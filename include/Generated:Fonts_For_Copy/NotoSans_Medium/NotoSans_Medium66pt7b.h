#ifndef _NOTOSANS_MEDIUM66PT7B_H_
#define _NOTOSANS_MEDIUM66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium66pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0xFC, 0x7F, 0x9F, 0xEF, 0xFF, 0xFF, 0x7F, 0x9F, 0xE7, 0xF0,
  0x78, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E,
  0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x03, 0xE7,
  0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFD, 0xE7, 0xFC, 0xFF, 0x87, 0x80, 0xE3, 0xF8,
  0x1E, 0x00, 0x8F, 0xE0, 0x78, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0xFE, 0x07,
  0x80, 0x03, 0xF8, 0x1E, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x3F, 0xC1, 0xE0,
  0x00, 0xFF, 0x87, 0x80, 0x01, 0xFF, 0xDE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7B, 0xFF, 0x80, 0x01, 0xE3, 0xFF, 0x00, 0x07,
  0x83, 0xFC, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x78, 0x1F, 0xC0, 0x01, 0xE0,
  0x3F, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x78, 0x1F,
  0xF8, 0x01, 0xE1, 0xFF, 0xFE, 0x07, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFC, 0x1F, 0xF8, 0x1F, 0x00, 0xFC, 0x3F,
  0x0F, 0xFF, 0x07, 0xE0, 0x7E, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x1F, 0x87,
  0xE3, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xFF, 0xF0,
  0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0xF8, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0xFC,
  0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xFF,
  0xE0, 0x01, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFE, 0x07, 0xF8, 0x01, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xFC,
  0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xFB, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E,
  0x3C, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xC0, 0x1F, 0x80, 0x3B, 0xF8, 0x1E, 0x07, 0xF7, 0xFE, 0x3C, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x0F, 0xC7, 0xF9, 0xFE, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0x7F,
  0x07, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xF7, 0xF7, 0xFC, 0x7F, 0xFF, 0x87, 0xF7, 0xF0, 0x7F, 0x3E, 0x07, 0xF1,
  0xC0, 0x7F, 0x10, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3E, 0x00, 0x07,
  0xF8, 0x1C, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0x80, 0x07, 0xFC, 0x3C, 0x00, 0x07, 0xF8,
  0x20, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x80, 0x00, 0x07, 0xFD, 0xE0, 0x00, 0x1F, 0xFB, 0xFC, 0x01, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xB0, 0x00, 0x03,
  0xFC, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x08, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E,
  0x0F, 0xFF, 0x80, 0x7E, 0x3F, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0xF0, 0xFE,
  0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFC, 0xFF,
  0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0x3F,
  0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xFE, 0x7E, 0x0F,
  0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xF8, 0x7E, 0x01, 0xFF, 0xF0, 0xFE, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x18,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFB, 0xFE, 0xFF, 0xFF, 0xE7, 0xF9,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xDF, 0xE7, 0xF9, 0xFC,
  0x1E, 0x00, 0x0F, 0xC3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8,
  0xFF, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0,
  0x3F, 0xF3, 0xE0, 0x01, 0xFE, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xFF, 0xFC,
  0x07, 0xC3, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x3E, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xF0, 0x1F, 0x80, 0x3E, 0x7E, 0x01, 0xFC,
  0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0xFC, 0x03,
  0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F,
  0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x3F, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0x3E, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x3E, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xEF, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x7C, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x00, 0x7F, 0x80, 0xF8, 0xFC, 0x03, 0xFC, 0x1F, 0xFC, 0x1F, 0x8F,
  0xC0, 0x1F, 0xFF, 0xF7, 0xFF, 0xF0, 0x7C, 0x00, 0xFF, 0xFE, 0x3F, 0xFE,
  0x07, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xF8, 0x0F,
  0xF8, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xE0, 0x00, 0xFF, 0xE3, 0xF8, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x07, 0xFF,
  0x8F, 0xE0, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x07, 0xFC,
  0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x7F, 0xC0, 0x7F, 0xF0, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x7F,
  0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xE0,
  0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x0F,
  0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x07, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x01, 0xFF, 0x8F,
  0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0x87,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0x00,
  0x01, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE,
  0x07, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xB0,
  0x7F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x0F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xE7, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFD, 0xF8, 0x00, 0x00,
  0x1F, 0xBF, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0xFD, 0xFC, 0x00, 0x00,
  0x1F, 0xBF, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0x3F, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0xFE, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0xFE, 0x3F, 0x00, 0x00,
  0xFC, 0x7F, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x00,
  0xFC, 0x7F, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0xFE, 0x1F, 0x80, 0x01,
  0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0xFE, 0x0F, 0xC0, 0x03,
  0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0xFE, 0x01, 0xF8, 0x1F,
  0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xF7, 0xFC, 0x00,
  0x03, 0xFF, 0xE7, 0xF8, 0x00, 0x07, 0xFF, 0xC7, 0xF8, 0x00, 0x0F, 0xFF,
  0x8F, 0xF0, 0x00, 0x1F, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x1F, 0xE0, 0x01, 0xFF,
  0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F,
  0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x07,
  0xFF, 0xE0, 0x01, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xFF, 0x80,
  0x03, 0xFC, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0xF0,
  0x00, 0x0F, 0xF3, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xFF, 0xC0, 0x00, 0x1F,
  0xEF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x2F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x0F, 0xFE, 0x7F, 0x00, 0x07, 0xFE, 0xFE,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x7F, 0xDF, 0xC0, 0x01, 0xFF, 0x3F, 0x80, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x2F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80,
  0x07, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07,
  0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF,
  0x0F, 0xF8, 0x00, 0x7C, 0x7F, 0x80, 0x00, 0x21, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x3F, 0xEF,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x5E,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0x78, 0x00, 0xFF, 0x80, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x01,
  0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF7, 0xFC,
  0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFC, 0xFF, 0xFF,
  0xE3, 0xF0, 0xFF, 0xFE, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0xFE, 0x1F, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF,
  0xF0, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x07,
  0xFC, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xFC, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F, 0xFF,
  0xE0, 0xFC, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFE, 0x00,
  0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x02, 0x3F, 0xE0, 0x01, 0xC3, 0xFF, 0x83, 0xF8, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x7F,
  0x03, 0xFF, 0xFE, 0x3F, 0x83, 0xFF, 0xFF, 0x9F, 0xC3, 0xFF, 0xFF, 0xEF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFE, 0x7F,
  0x01, 0xFF, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x1F, 0xF0, 0x00,
  0x1C, 0x0F, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x38,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x7F,
  0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xE7, 0xF0, 0xFF,
  0xFF, 0xFB, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F,
  0xC0, 0x03, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xE0,
  0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0xBF, 0x81, 0xFF,
  0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0x07, 0xF0, 0x00,
  0x70, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC2, 0x00, 0x00, 0x3F, 0xC1, 0xC0, 0x00, 0x3F, 0xE0,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0xFF, 0xC0, 0x7F, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xA0,
  0x7F, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFE, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x0F, 0xF8, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xF0, 0x00, 0xFF,
  0xC7, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x8F, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0x01, 0xF8, 0x3F, 0xFF, 0x83, 0xF0, 0xFF, 0xFF,
  0xC7, 0xF3, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFC, 0x01, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC,
  0x07, 0xFE, 0x00, 0xFC, 0x1F, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xE0, 0xFE,
  0x7F, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFC, 0xFF,
  0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF0, 0xFE,
  0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x00, 0xFE,
  0x00, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x7F, 0xFE, 0x0F, 0xC0,
  0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFB, 0xF8,
  0x7F, 0xFB, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F, 0xC0, 0x03, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFE, 0x1F,
  0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0xFF, 0x9F, 0xC0,
  0x7F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0x07, 0xF0, 0x00, 0x70, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x7F, 0xFB, 0xFB, 0xFF, 0xEF, 0xFF, 0xE0, 0xBF, 0xFE, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xF0, 0x1F,
  0xC7, 0xF0, 0x00, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x81, 0x81, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF,
  0xDF, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7E,
  0x3F, 0xFF, 0xF8, 0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x1F, 0xFF, 0x03, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0x9F, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xF0,
  0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xF8, 0x03, 0xF3, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF0, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0x1F, 0xFE, 0x00, 0x03, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0xC0, 0x01, 0xFF, 0xFC, 0x80, 0x00, 0x3F, 0xF0,
};

const GFXglyph NotoSans_Medium66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 10, 48, 18, 4, -47 },
  { 61, 20, 17, 28, 4, -47 },
  { 104, 39, 47, 43, 2, -47 },
  { 334, 30, 54, 38, 4, -50 },
  { 537, 50, 49, 56, 3, -48 },
  { 844, 46, 49, 49, 3, -48 },
  { 1126, 7, 17, 16, 4, -47 },
  { 1141, 16, 57, 21, 3, -47 },
  { 1255, 16, 57, 21, 2, -47 },
  { 1369, 31, 30, 36, 3, -50 },
  { 1486, 31, 32, 38, 3, -39 },
  { 1610, 10, 17, 18, 3, -8 },
  { 1632, 17, 6, 21, 2, -21 },
  { 1645, 10, 10, 18, 4, -9 },
  { 1658, 24, 47, 25, 1, -47 },
  { 1799, 32, 49, 38, 3, -48 },
  { 1995, 20, 47, 38, 5, -47 },
  { 2113, 32, 48, 38, 3, -48 },
  { 2305, 31, 49, 38, 3, -48 },
  { 2495, 36, 47, 38, 1, -47 },
  { 2707, 30, 48, 38, 4, -47 },
  { 2887, 32, 49, 38, 3, -48 },
  { 3083, 32, 47, 38, 3, -47 },
  { 3271, 32, 49, 38, 3, -48 },
  { 3467, 32, 49, 38, 3, -48 },
  { 3663, 10, 37, 18, 4, -36 },
  { 3710, 11, 45, 18, 2, -36 },
  { 3772, 32, 33, 38, 3, -40 },
  { 3904, 31, 18, 38, 3, -32 },
  { 3974, 32, 33, 38, 3, -40 },
  { 4106, 27, 49, 30, 1, -48 },
  { 4272, 52, 53, 59, 4, -47 },
  { 4617, 43, 47, 43, 0, -47 },
  { 4870, 34, 47, 43, 6, -47 },
  { 5070, 36, 49, 42, 4, -48 },
  { 5291, 38, 47, 48, 6, -47 },
  { 5515, 27, 47, 37, 6, -47 },
  { 5674, 27, 47, 35, 6, -47 },
  { 5833, 39, 49, 48, 4, -48 },
  { 6072, 37, 47, 49, 6, -47 },
  { 6290, 18, 47, 23, 3, -47 },
  { 6396, 18, 60, 19, -5, -47 },
  { 6531, 36, 47, 42, 6, -47 },
  { 6743, 27, 47, 35, 6, -47 },
  { 6902, 48, 47, 61, 6, -47 },
  { 7184, 39, 47, 51, 6, -47 },
  { 7414, 44, 49, 52, 4, -48 },
  { 7684, 31, 47, 40, 6, -47 },
  { 7867, 44, 59, 52, 4, -48 },
  { 8192, 35, 47, 42, 6, -47 },
  { 8398, 30, 49, 36, 3, -48 },
  { 8582, 35, 47, 37, 1, -47 },
  { 8788, 37, 48, 49, 6, -47 },
  { 9010, 41, 47, 41, 0, -47 },
  { 9251, 61, 47, 62, 1, -47 },
  { 9610, 40, 47, 40, 0, -47 },
  { 9845, 39, 47, 39, 0, -47 },
  { 10075, 34, 47, 38, 2, -47 },
  { 10275, 15, 57, 22, 5, -47 },
  { 10382, 24, 47, 25, 1, -47 },
  { 10523, 15, 57, 22, 2, -47 },
  { 10630, 34, 30, 38, 2, -47 },
  { 10758, 29, 4, 29, 0, 6 },
  { 10773, 15, 11, 20, 3, -51 },
  { 10794, 30, 37, 38, 3, -36 },
  { 10933, 32, 51, 41, 5, -50 },
  { 11137, 27, 37, 32, 3, -36 },
  { 11262, 33, 51, 41, 3, -50 },
  { 11473, 32, 37, 38, 3, -36 },
  { 11621, 25, 50, 24, 1, -50 },
  { 11778, 33, 52, 41, 3, -36 },
  { 11993, 31, 50, 41, 5, -50 },
  { 12187, 8, 49, 18, 5, -49 },
  { 12236, 17, 65, 18, -4, -49 },
  { 12375, 32, 50, 37, 5, -50 },
  { 12575, 7, 50, 18, 5, -50 },
  { 12619, 52, 36, 63, 5, -36 },
  { 12853, 31, 36, 41, 5, -36 },
  { 12993, 34, 37, 40, 3, -36 },
  { 13151, 32, 52, 41, 5, -36 },
  { 13359, 33, 52, 41, 3, -36 },
  { 13574, 22, 36, 28, 5, -36 },
  { 13673, 26, 37, 32, 3, -36 },
  { 13794, 23, 45, 25, 1, -44 },
  { 13924, 31, 37, 41, 5, -36 },
  { 14068, 35, 36, 35, 0, -36 },
  { 14226, 52, 36, 53, 1, -36 },
  { 14460, 34, 36, 36, 1, -36 },
  { 14613, 35, 52, 35, 0, -36 },
  { 14841, 27, 36, 31, 2, -36 },
  { 14963, 21, 57, 25, 2, -47 },
  { 15113, 6, 66, 36, 15, -50 },
  { 15163, 22, 57, 25, 2, -47 },
  { 15320, 32, 9, 38, 3, -28 },
};

const GFXfont NotoSans_Medium66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium66pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_MEDIUM66PT7B_H_
