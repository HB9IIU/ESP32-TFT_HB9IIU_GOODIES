#ifndef _NOTOSANS_MEDIUM6PT7B_H_
#define _NOTOSANS_MEDIUM6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0xFA, 0x55, 0x1E, 0xD7, 0x8E, 0xB0, 0xE4, 0xBF,
  0x80, 0xEA, 0x40, 0x95, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x5A, 0xF6, 0xB0, 0xD5, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xF8, 0xF0,
  0xFE, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xF0, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xE9, 0x20, 0x7F, 0xF7, 0x47, 0x00, 0x66, 0x69, 0xFA,
  0xE0, 0x78, 0x86, 0xF6, 0xE0, 0xFB, 0xFA, 0x7A, 0x97, 0xBE, 0xD0, 0xD7,
  0xF8, 0xF3, 0x50, 0xAB, 0x9B, 0xBD, 0xB7, 0xD0, 0x79, 0x97, 0xFA, 0x79,
  0x97, 0x10, 0xDB, 0x50, 0xE8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0x9A, 0x64,
  0xA6, 0xE5, 0x92, 0xB4, 0x6B, 0xB6, 0x44, 0xE9, 0x70, 0xEA, 0xC0, 0x95,
  0xD5, 0xC0, 0x54, 0xE0, 0xC0, 0x7F, 0x80, 0x93, 0xDE, 0xF1, 0x80, 0x27,
  0xD6, 0xFD, 0x80, 0x6E, 0x80, 0xF5, 0xB0, 0x93, 0xDA, 0xF0, 0xF8, 0x92,
  0xEA, 0xF8, 0xFD, 0x6A, 0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF5, 0x90,
  0xE8, 0xEB, 0x80, 0xB9, 0xB5, 0x80, 0xB5, 0x00, 0xAF, 0x94, 0xAA, 0x80,
  0xB5, 0x60, 0xEB, 0x80, 0x59, 0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_Medium6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 2, 0, -3 },
  { 45, 1, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 5, 5, 5, 0, -4 },
  { 57, 4, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 1, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 3, 4, 4, 1, -4 },
  { 65, 2, 4, 3, 1, -4 },
  { 66, 2, 4, 3, 1, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 3, 4, 4, 1, -4 },
  { 71, 2, 4, 2, 0, -4 },
  { 72, 1, 5, 2, 0, -4 },
  { 73, 3, 4, 4, 1, -4 },
  { 75, 2, 4, 3, 1, -4 },
  { 76, 4, 4, 6, 1, -4 },
  { 78, 3, 4, 5, 1, -4 },
  { 80, 4, 4, 5, 0, -4 },
  { 82, 2, 4, 4, 1, -4 },
  { 83, 4, 5, 5, 0, -4 },
  { 86, 3, 4, 4, 1, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 4, 1, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 6, 4, 6, 0, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 3, 4, 3, 0, -4 },
  { 105, 2, 5, 2, 0, -4 },
  { 107, 2, 4, 2, 0, -4 },
  { 108, 2, 5, 2, 0, -4 },
  { 110, 3, 2, 3, 0, -4 },
  { 111, 3, 1, 3, 0, 0 },
  { 112, 2, 1, 2, 0, -5 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 3, 5, 4, 0, -5 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 3, 5, 4, 0, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 2, 5, 2, 0, -5 },
  { 125, 3, 4, 4, 0, -3 },
  { 127, 3, 5, 4, 0, -5 },
  { 129, 1, 4, 2, 0, -4 },
  { 130, 1, 5, 2, 0, -4 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 1, 5, 2, 0, -5 },
  { 134, 5, 3, 6, 0, -3 },
  { 136, 3, 3, 4, 0, -3 },
  { 138, 3, 3, 4, 0, -3 },
  { 140, 3, 4, 4, 0, -3 },
  { 142, 3, 4, 4, 0, -3 },
  { 144, 2, 3, 3, 0, -3 },
  { 145, 3, 3, 3, 0, -3 },
  { 147, 2, 4, 2, 0, -4 },
  { 148, 3, 3, 4, 0, -3 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 5, 3, 5, 0, -3 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 3, 4, 3, 0, -3 },
  { 158, 3, 3, 3, 0, -3 },
  { 160, 2, 5, 2, 0, -4 },
  { 162, 1, 6, 3, 1, -5 },
  { 163, 2, 5, 2, 0, -4 },
  { 165, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Medium6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium6pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_MEDIUM6PT7B_H_
