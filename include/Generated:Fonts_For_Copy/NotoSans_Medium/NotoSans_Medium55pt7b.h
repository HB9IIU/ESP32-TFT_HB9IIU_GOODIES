#ifndef _NOTOSANS_MEDIUM55PT7B_H_
#define _NOTOSANS_MEDIUM55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0x78, 0x1E, 0x70, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xE0, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xF1, 0xC1, 0xE3, 0xF8, 0x70, 0x08,
  0xFC, 0x1C, 0x00, 0x3F, 0x07, 0x00, 0x0F, 0xC1, 0xC0, 0x03, 0xF0, 0x70,
  0x00, 0xFE, 0x1C, 0x00, 0x1F, 0xC7, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xC7,
  0xF8, 0x00, 0x70, 0x7E, 0x00, 0x1C, 0x0F, 0xC0, 0x07, 0x03, 0xF0, 0x01,
  0xC0, 0xFC, 0x00, 0x70, 0x3F, 0x80, 0x1C, 0x1F, 0xBC, 0x07, 0x0F, 0xEF,
  0xFD, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x20, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x3C, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x03, 0xE0, 0x1E,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x7C,
  0x00, 0x0F, 0x80, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x00,
  0x78, 0x0F, 0x87, 0xC1, 0xF8, 0x1F, 0x03, 0xE1, 0xE1, 0xFF, 0x87, 0xC0,
  0xF8, 0xF8, 0xFF, 0xF1, 0xF0, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0x3F, 0x1F,
  0x1F, 0x0F, 0x87, 0xFF, 0x8F, 0x8F, 0x81, 0xE1, 0xFF, 0xC3, 0xE3, 0xE0,
  0x7C, 0x3F, 0xE1, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x3C, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x3C, 0x00, 0x07,
  0xC1, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x7F,
  0xE0, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x00, 0x7E, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x7E, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0x3F, 0x80, 0x1F, 0x8F, 0xF0,
  0xFE, 0x01, 0xF8, 0x7F, 0x03, 0xFC, 0x0F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFC,
  0x3F, 0x00, 0x3F, 0xC7, 0xE1, 0xF8, 0x00, 0xFF, 0x7F, 0x0F, 0xC0, 0x03,
  0xFF, 0xF0, 0x7E, 0x00, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x1F,
  0x80, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xC0, 0x00, 0xFC, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x1E, 0x03, 0x9F, 0xC7, 0x87, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x01, 0xE0, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF0,
  0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9C,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x8F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x83, 0xF0,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x0F, 0xFF, 0x1F, 0xDF, 0x3F, 0x9F, 0xFF, 0x1F, 0x7E, 0x1F, 0x3C, 0x1F,
  0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xE0, 0x7F, 0x87, 0xE0, 0x07, 0xF0, 0xE0, 0x00, 0xFC, 0x10, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0x01, 0xFE, 0x0F, 0x00, 0x0F, 0xE0, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xD0, 0x00, 0x03,
  0xFB, 0xC0, 0x01, 0xFE, 0x7F, 0x83, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFB,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x78, 0x00, 0x7F, 0xBF, 0xC3, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x40,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x7F, 0xF8, 0x3F,
  0x3F, 0xFF, 0x0F, 0x9F, 0xFF, 0xE3, 0xEF, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F,
  0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7F, 0x87,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0x80, 0xFF, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0x80,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF9, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF0,
  0x00, 0x3F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x9F, 0x80, 0x1F, 0xF3, 0xFC, 0x0F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0x3E, 0x03, 0xFF,
  0x87, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0C,
  0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x00,
  0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xF8,
  0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xF8, 0x1F, 0xE7,
  0x00, 0x1F, 0xD0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0x0F,
  0x80, 0x3F, 0xFF, 0x03, 0xE3, 0xE0, 0x1F, 0xFF, 0xF0, 0x3C, 0x7C, 0x07,
  0xFF, 0xFE, 0x07, 0xDF, 0x01, 0xFC, 0x0F, 0x80, 0xFB, 0xE0, 0x3F, 0x00,
  0xF0, 0x0F, 0x78, 0x0F, 0xC0, 0x1E, 0x01, 0xEF, 0x01, 0xF0, 0x03, 0xC0,
  0x3F, 0xE0, 0x7E, 0x00, 0x78, 0x07, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0xFF,
  0x81, 0xF0, 0x03, 0xE0, 0x1F, 0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xFE, 0x07,
  0xC0, 0x0F, 0x80, 0x7F, 0xC0, 0xF8, 0x01, 0xF0, 0x0F, 0xF8, 0x1F, 0x00,
  0x3E, 0x03, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0x7B, 0xE0, 0x7C, 0x01, 0xF8,
  0x1F, 0x7C, 0x07, 0xC0, 0x7F, 0x03, 0xEF, 0x80, 0xFC, 0x1F, 0xF0, 0xF8,
  0xF0, 0x0F, 0xFF, 0xDF, 0xFE, 0x1F, 0x00, 0xFF, 0xF1, 0xFF, 0xC3, 0xE0,
  0x0F, 0xFC, 0x1F, 0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0,
  0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x07,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0x07, 0xFC, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xE0, 0x7F, 0x80, 0x03,
  0x03, 0xFC, 0x00, 0x02, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xE8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x38, 0x1F, 0xE0, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x7E,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x1F,
  0x87, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xEC, 0x7F, 0xDF, 0xFF, 0x3F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF7, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFB, 0xE0, 0x00, 0x07,
  0xDF, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0xF9,
  0xF0, 0x00, 0x0F, 0x9F, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0xFC, 0xF8, 0x00,
  0x1F, 0x9F, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0xFC, 0xFC, 0x00, 0x1F, 0x1F,
  0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0xFC, 0x7E,
  0x00, 0x3E, 0x3F, 0xFC, 0x3E, 0x00, 0x7C, 0x3F, 0xFC, 0x3E, 0x00, 0x7C,
  0x3F, 0xFC, 0x3F, 0x00, 0x7C, 0x3F, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0xFC,
  0x1F, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0x81,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0xFC, 0x07, 0xC3, 0xE0, 0x3F,
  0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0xFC, 0x03,
  0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xF0, 0x00,
  0x1F, 0xFB, 0xF8, 0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x1F, 0xF9, 0xFC, 0x00,
  0x1F, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x1F, 0xF8, 0x7F, 0x00,
  0x1F, 0xFC, 0x3F, 0x80, 0x1F, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xC0,
  0x1F, 0xFC, 0x0F, 0xE0, 0x1F, 0xFC, 0x0F, 0xE0, 0x1F, 0xFC, 0x07, 0xF0,
  0x1F, 0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x03, 0xF8, 0x1F, 0xFC, 0x01, 0xFC,
  0x1F, 0xFC, 0x00, 0xFC, 0x1F, 0xFC, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0x7F,
  0x1F, 0xFC, 0x00, 0x7F, 0x1F, 0xFC, 0x00, 0x3F, 0x9F, 0xFC, 0x00, 0x1F,
  0x9F, 0xFC, 0x00, 0x1F, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xA8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x3F, 0xEF, 0xC0,
  0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0xEF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xBF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0,
  0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xFE, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x7E,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF,
  0x0F, 0xF1, 0xFC, 0x00, 0x38, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x40, 0x00, 0x3F, 0xBC, 0x00, 0x3F, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0xCF, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xF8, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE7, 0xE0,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x3F,
  0x78, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x1E, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x07, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0x1F, 0xF0, 0x38, 0x01, 0xFC, 0x10, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x3F, 0xE0, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xBF, 0xC0, 0xFF, 0xCF, 0xFF, 0xFB, 0xE7,
  0xFF, 0xF9, 0xF1, 0xFF, 0xF8, 0x78, 0x3F, 0xF0, 0x3C, 0x01, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x3E, 0x3F, 0xFC, 0x0F, 0x9F, 0xFF,
  0xC3, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0,
  0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x7F,
  0x3F, 0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xEF, 0xFF, 0xF0, 0xF1, 0xFF,
  0xF8, 0x3C, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x00,
  0xE3, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x0C, 0x7F, 0xE7, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x50, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x7E, 0x07, 0xFF, 0x8F, 0xC3, 0xFF, 0xF9,
  0xF8, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0xFD, 0xFC,
  0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF3,
  0xF8, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0xC7, 0xFF, 0xFD, 0xF8, 0x7F, 0xFF,
  0xBF, 0x07, 0xFF, 0xC3, 0xE0, 0x3F, 0xF0, 0x7C, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xF1, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x03, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x07, 0xFC, 0x07,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xE0,
  0x7F, 0xF8, 0x7C, 0x3F, 0xFF, 0x9F, 0x8F, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0x80, 0xFF, 0xCF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7E,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xE7, 0xFC, 0x1F, 0xFC,
  0x7F, 0xFF, 0xDF, 0x87, 0xFF, 0xFB, 0xF0, 0x7F, 0xFE, 0x7E, 0x03, 0xFF,
  0x0F, 0xC0, 0x04, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE2, 0x00, 0x01,
  0xFC, 0x78, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x83, 0xFE, 0x07, 0xC7, 0xFF, 0xC3, 0xE7, 0xFF, 0xF9, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x38, 0xFB,
  0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x70,
  0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFB,
  0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFB, 0xE0, 0x03, 0xF9, 0xF0, 0x03, 0xF8, 0xF8,
  0x03, 0xF8, 0x7C, 0x03, 0xF8, 0x3E, 0x03, 0xF8, 0x1F, 0x03, 0xF8, 0x0F,
  0x83, 0xF8, 0x07, 0xC3, 0xF8, 0x03, 0xE3, 0xF8, 0x01, 0xF1, 0xF8, 0x00,
  0xF9, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFB, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xF0, 0x3F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xF0, 0x3E, 0x01, 0xFC, 0x1F, 0x00,
  0x7F, 0x0F, 0x80, 0x3F, 0x87, 0xC0, 0x0F, 0xE3, 0xE0, 0x03, 0xF9, 0xF0,
  0x00, 0xFE, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xE7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7D, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0x1F, 0xF0,
  0x03, 0xF7, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xF0, 0x3F, 0xE0, 0x78, 0x7F, 0xFC,
  0x3E, 0x7F, 0xFF, 0x9F, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFC, 0x03,
  0xFB, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x3E, 0x3F, 0xFE, 0x0F,
  0x9F, 0xFF, 0xC3, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFF,
  0x00, 0x7F, 0x3F, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xEF, 0xFF, 0xF0,
  0xF9, 0xFF, 0xF8, 0x3E, 0x1F, 0xF8, 0x0F, 0x80, 0x30, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x7C, 0x3F, 0xFF, 0x9F, 0x8F,
  0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xCF, 0xC0, 0x07,
  0xFB, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFE,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x3F, 0x80,
  0x3F, 0xE7, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0xDF, 0x87, 0xFF, 0xFB, 0xF0,
  0x7F, 0xFC, 0x7E, 0x03, 0xFF, 0x0F, 0xC0, 0x04, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0xF0, 0x1F, 0xFC, 0x1F, 0xEF, 0x0F, 0xFB, 0xE7, 0xFE,
  0xFB, 0xFF, 0xBF, 0xFC, 0x2F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F,
  0x7E, 0x00, 0x33, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x83, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x80, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xDF, 0xF0,
  0x7F, 0xF3, 0xFF, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F, 0x0F, 0xFF, 0xC7, 0xC1,
  0xFF, 0xC1, 0xF0, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC,
  0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0x1F, 0x80, 0x3F, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xDE,
  0x00, 0xFC, 0x3F, 0x00, 0xF3, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x7C, 0x07,
  0xE0, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x81,
  0xF8, 0x3E, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x03, 0xE0,
  0xF8, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xC0,
  0xF8, 0x7C, 0x01, 0xF8, 0xF8, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x01, 0xF3,
  0xF0, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x7E, 0xF8, 0x07, 0xCF, 0x80,
  0x0F, 0xDF, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0x78, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x03,
  0xF9, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x5F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE8, 0x00, 0x3F, 0xE0,
};

const GFXglyph NotoSans_Medium55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 40, 15, 4, -39 },
  { 36, 16, 14, 24, 4, -39 },
  { 64, 33, 39, 36, 1, -39 },
  { 225, 26, 45, 31, 3, -42 },
  { 372, 42, 41, 47, 2, -40 },
  { 588, 37, 41, 41, 3, -40 },
  { 778, 6, 14, 13, 4, -39 },
  { 789, 14, 48, 17, 2, -39 },
  { 873, 13, 48, 17, 2, -39 },
  { 951, 26, 25, 30, 2, -42 },
  { 1033, 26, 27, 31, 3, -33 },
  { 1121, 9, 13, 15, 2, -6 },
  { 1136, 14, 5, 18, 2, -17 },
  { 1145, 7, 8, 15, 4, -7 },
  { 1152, 21, 39, 21, 0, -39 },
  { 1255, 27, 41, 31, 2, -40 },
  { 1394, 16, 39, 31, 4, -39 },
  { 1472, 26, 40, 31, 3, -40 },
  { 1602, 27, 41, 31, 2, -40 },
  { 1741, 29, 39, 31, 1, -39 },
  { 1883, 25, 40, 31, 3, -39 },
  { 2008, 26, 41, 31, 3, -40 },
  { 2142, 27, 39, 31, 2, -39 },
  { 2274, 27, 41, 31, 2, -40 },
  { 2413, 27, 41, 31, 2, -40 },
  { 2552, 7, 31, 15, 4, -30 },
  { 2580, 9, 37, 15, 2, -30 },
  { 2622, 26, 28, 31, 3, -34 },
  { 2713, 25, 15, 31, 3, -27 },
  { 2760, 26, 28, 31, 3, -34 },
  { 2851, 22, 41, 25, 1, -40 },
  { 2964, 43, 44, 49, 3, -39 },
  { 3201, 36, 39, 36, 0, -39 },
  { 3377, 28, 39, 36, 5, -39 },
  { 3514, 30, 41, 35, 3, -40 },
  { 3668, 32, 39, 40, 5, -39 },
  { 3824, 22, 39, 31, 5, -39 },
  { 3932, 22, 39, 29, 5, -39 },
  { 4040, 33, 41, 40, 3, -40 },
  { 4210, 31, 39, 41, 5, -39 },
  { 4362, 15, 39, 19, 2, -39 },
  { 4436, 15, 50, 16, -4, -39 },
  { 4530, 30, 39, 35, 5, -39 },
  { 4677, 23, 39, 29, 5, -39 },
  { 4790, 40, 39, 50, 5, -39 },
  { 4985, 32, 39, 43, 5, -39 },
  { 5141, 37, 41, 43, 3, -40 },
  { 5331, 26, 39, 34, 5, -39 },
  { 5458, 37, 49, 43, 3, -40 },
  { 5685, 29, 39, 35, 5, -39 },
  { 5827, 25, 41, 30, 3, -40 },
  { 5956, 29, 39, 31, 1, -39 },
  { 6098, 31, 40, 41, 5, -39 },
  { 6253, 34, 39, 34, 0, -39 },
  { 6419, 51, 39, 52, 0, -39 },
  { 6668, 33, 39, 34, 0, -39 },
  { 6829, 32, 39, 32, 0, -39 },
  { 6985, 28, 39, 32, 2, -39 },
  { 7122, 13, 48, 18, 4, -39 },
  { 7200, 21, 39, 21, 0, -39 },
  { 7303, 13, 48, 18, 1, -39 },
  { 7381, 28, 26, 31, 2, -40 },
  { 7472, 24, 4, 24, 0, 5 },
  { 7484, 13, 9, 17, 2, -42 },
  { 7499, 25, 31, 31, 2, -30 },
  { 7596, 26, 43, 34, 5, -42 },
  { 7736, 22, 31, 27, 3, -30 },
  { 7822, 27, 43, 34, 3, -42 },
  { 7968, 26, 31, 32, 3, -30 },
  { 8069, 21, 42, 20, 1, -42 },
  { 8180, 27, 43, 34, 3, -30 },
  { 8326, 25, 42, 34, 5, -42 },
  { 8458, 7, 41, 15, 4, -41 },
  { 8494, 14, 54, 15, -3, -41 },
  { 8589, 25, 42, 31, 5, -42 },
  { 8721, 5, 42, 15, 5, -42 },
  { 8748, 43, 30, 52, 5, -30 },
  { 8910, 25, 30, 34, 5, -30 },
  { 9004, 28, 31, 34, 3, -30 },
  { 9113, 26, 43, 34, 5, -30 },
  { 9253, 27, 43, 34, 3, -30 },
  { 9399, 18, 30, 23, 5, -30 },
  { 9467, 21, 31, 27, 3, -30 },
  { 9549, 19, 37, 21, 1, -36 },
  { 9637, 26, 31, 34, 4, -30 },
  { 9738, 29, 30, 29, 0, -30 },
  { 9847, 43, 30, 44, 1, -30 },
  { 10009, 28, 30, 30, 1, -30 },
  { 10114, 29, 43, 29, 0, -30 },
  { 10270, 22, 30, 26, 2, -30 },
  { 10353, 18, 48, 21, 1, -39 },
  { 10461, 4, 55, 30, 13, -42 },
  { 10489, 18, 48, 21, 2, -39 },
  { 10597, 26, 7, 31, 3, -23 },
};

const GFXfont NotoSans_Medium55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium55pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_MEDIUM55PT7B_H_
