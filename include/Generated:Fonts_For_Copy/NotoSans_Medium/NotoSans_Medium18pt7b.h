#ifndef _NOTOSANS_MEDIUM18PT7B_H_
#define _NOTOSANS_MEDIUM18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x64, 0x92, 0x40, 0x7E, 0xCF, 0x2C, 0xB2, 0xC8, 0x0C, 0xC1,
  0x90, 0x22, 0x04, 0x47, 0xFE, 0x33, 0x06, 0x40, 0x88, 0xFF, 0xE2, 0x60,
  0xCC, 0x19, 0x03, 0x20, 0x08, 0x08, 0x7F, 0xEF, 0xC8, 0xC8, 0x78, 0x3E,
  0x0F, 0x0B, 0x0B, 0xEF, 0xFE, 0x08, 0x08, 0x70, 0x63, 0x61, 0x08, 0x8C,
  0x22, 0x20, 0x89, 0x82, 0x2D, 0xCD, 0xBD, 0x9D, 0xB2, 0x04, 0xCC, 0x33,
  0x30, 0x8C, 0x86, 0x32, 0x30, 0x78, 0x3E, 0x07, 0x70, 0x63, 0x06, 0x30,
  0x36, 0x03, 0xC0, 0x3C, 0x36, 0xE6, 0xC7, 0x6C, 0x3C, 0xC1, 0xCF, 0x7E,
  0x7E, 0x70, 0xFF, 0xC0, 0x36, 0x6C, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x63,
  0xCC, 0x66, 0x23, 0x33, 0x33, 0x32, 0x66, 0xCC, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x38, 0x2C, 0x66, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0xFB, 0x40, 0xFF, 0xFC, 0x06, 0x18, 0x30, 0x61, 0x83, 0x04,
  0x18, 0x30, 0xC1, 0x83, 0x0C, 0x00, 0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0xC1,
  0xC1, 0xC1, 0xC3, 0xC3, 0xC3, 0x76, 0x3E, 0x0C, 0xF7, 0xF3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0xFE, 0x43, 0x03, 0x03, 0x06, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x7C, 0xFF, 0x83, 0x03, 0x03, 0x0E,
  0x3C, 0x07, 0x03, 0x03, 0x03, 0xCF, 0xFE, 0x03, 0x01, 0xC0, 0x70, 0x3C,
  0x1B, 0x04, 0xC3, 0x31, 0x8C, 0xC3, 0x3F, 0xF0, 0x30, 0x0C, 0x03, 0x00,
  0x7E, 0x7E, 0x40, 0x40, 0xC0, 0xFC, 0x7F, 0x03, 0x03, 0x03, 0x03, 0xCF,
  0xFC, 0x1F, 0x1F, 0x98, 0x18, 0x0C, 0x06, 0xF3, 0x9D, 0x86, 0xC1, 0xE0,
  0xB0, 0xCE, 0xE3, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x00, 0x3E, 0x77, 0xC3, 0xC3, 0x63,
  0x7E, 0x3C, 0x67, 0xC3, 0xC1, 0xC3, 0xE7, 0x7E, 0x3C, 0x7E, 0xC3, 0xC3,
  0xC1, 0xC3, 0xE7, 0x7D, 0x03, 0x03, 0x06, 0x8E, 0x78, 0xDD, 0x00, 0x00,
  0xFC, 0xDD, 0x00, 0x00, 0xFB, 0x40, 0x01, 0x07, 0x1C, 0x70, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x0F, 0x3C, 0xE0, 0x80, 0x7C, 0xFE, 0x03, 0x03, 0x06, 0x0E, 0x1C,
  0x10, 0x10, 0x00, 0x00, 0x38, 0x38, 0x07, 0xC0, 0x79, 0xC3, 0x01, 0x98,
  0x03, 0x47, 0xCF, 0x31, 0x1C, 0x84, 0x62, 0x11, 0xC8, 0xCF, 0x33, 0x2C,
  0x73, 0x98, 0x00, 0x30, 0x20, 0x7F, 0x80, 0x30, 0x00, 0x06, 0x00, 0xE0,
  0x0F, 0x00, 0xB0, 0x19, 0x81, 0x98, 0x31, 0x83, 0x0C, 0x3F, 0xC6, 0x0C,
  0x60, 0x66, 0x06, 0xC0, 0x30, 0xFC, 0x7F, 0xB0, 0xD8, 0x6C, 0x36, 0x7B,
  0xF9, 0x86, 0xC1, 0xE0, 0xF0, 0xFF, 0xEF, 0xE0, 0x1F, 0x8F, 0xF7, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xFE, 0x1F,
  0x80, 0xFC, 0x3F, 0xCC, 0x3B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x3B, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xFF,
  0xE0, 0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F,
  0xFF, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x0F, 0xE7, 0xF9, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x30, 0xFE, 0x1F, 0xC0, 0x6C, 0x0D, 0x81, 0x9E, 0xF1, 0xFE,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xFF, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xCF, 0x80, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xDE,
  0xC0, 0xC1, 0xE1, 0xB1, 0x99, 0x8D, 0x87, 0xC3, 0xE1, 0xB8, 0xCC, 0x63,
  0x31, 0xD8, 0x6C, 0x18, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x07, 0xFF, 0xE0, 0xE0, 0x3F, 0x01, 0xE8, 0x1F, 0x60, 0xBB, 0x0D,
  0xC8, 0x6E, 0x62, 0x73, 0x33, 0x89, 0x9C, 0x68, 0xE3, 0xC7, 0x0E, 0x38,
  0x61, 0x80, 0xC0, 0xF8, 0x3F, 0x0E, 0xC3, 0x98, 0xE6, 0x38, 0xCE, 0x3B,
  0x86, 0x60, 0xD8, 0x3E, 0x07, 0x80, 0xC0, 0x1F, 0x83, 0xFC, 0x60, 0x66,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x60, 0x63,
  0xFC, 0x1F, 0x80, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0xFC, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x83, 0xFC, 0x60, 0x66, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x60, 0x63, 0xFC, 0x1F, 0x80,
  0x18, 0x00, 0xC0, 0x0F, 0xFC, 0x7F, 0x30, 0xD8, 0x6C, 0x36, 0x1B, 0xF9,
  0xF8, 0xCC, 0x63, 0x31, 0xD8, 0x6C, 0x18, 0x3E, 0x7F, 0xC0, 0xC0, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x03, 0x03, 0xEF, 0xFC, 0xFF, 0xFF, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x19, 0xDE, 0x3F, 0x00, 0xC0, 0x78, 0x0D, 0x83, 0x30, 0x62,
  0x0C, 0x63, 0x0C, 0x60, 0xC8, 0x1B, 0x03, 0x60, 0x28, 0x07, 0x00, 0xE0,
  0xC1, 0x81, 0xE0, 0xE1, 0x98, 0x70, 0xCC, 0x28, 0x66, 0x36, 0x31, 0x1B,
  0x30, 0xC9, 0x98, 0x6C, 0x6C, 0x36, 0x36, 0x0B, 0x1A, 0x07, 0x07, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xEC, 0x18, 0xC6, 0x0D, 0x81, 0xB0, 0x1C,
  0x03, 0x80, 0x70, 0x1B, 0x06, 0x30, 0xC6, 0x30, 0x6C, 0x0E, 0xC0, 0xEC,
  0x19, 0x86, 0x18, 0xC3, 0x30, 0x36, 0x07, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xFF, 0xC0, 0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10,
  0x30, 0x60, 0x60, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F,
  0xFF, 0x18, 0x0C, 0x0F, 0x04, 0x86, 0x62, 0x13, 0x0D, 0x83, 0xFF, 0xC6,
  0x30, 0x3C, 0x7E, 0x03, 0x03, 0x3F, 0xF3, 0xC3, 0xC3, 0xC7, 0x7B, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0xE7, 0xFB, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x7C,
  0x3F, 0x36, 0xF8, 0x1E, 0xFF, 0x86, 0x0C, 0x18, 0x30, 0x60, 0x76, 0x7C,
  0x01, 0x80, 0xC0, 0x60, 0x33, 0xDB, 0xFF, 0x8F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x77, 0x79, 0xEC, 0x3C, 0x7F, 0xC3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0,
  0x73, 0x3F, 0x0E, 0x7C, 0xC1, 0x87, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x00, 0x3D, 0xBF, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0x67, 0x9E, 0xC0, 0x60, 0x34, 0x33, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0xE7, 0xFB, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0xE8,
  0x6D, 0xB6, 0xDB, 0x6C, 0x38, 0x80, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x3E, 0x3B, 0x39, 0x98,
  0xD8, 0x7E, 0x3B, 0x18, 0xCC, 0x36, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0xCE,
  0x39, 0xFF, 0xFB, 0x8E, 0x3F, 0x0C, 0x3C, 0x18, 0x78, 0x30, 0xF0, 0x61,
  0xE0, 0xC3, 0xC1, 0x87, 0x83, 0x0C, 0xCE, 0x7F, 0xB8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xC0, 0x3C, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x77, 0x1F, 0x00, 0xCE, 0x7F, 0xB8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0xC3, 0xF3, 0x6F, 0xB0, 0x18, 0x0C, 0x06, 0x00, 0x3D, 0xBF,
  0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x77, 0x9E, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0xCF, 0x7E, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7D, 0xFF,
  0x06, 0x07, 0x87, 0x81, 0x83, 0xCF, 0xF8, 0x30, 0xC7, 0xFF, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x4F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0x67, 0xBE, 0xC0, 0xC1, 0xE0, 0xD8, 0x6C, 0x62, 0x31, 0x90, 0xD8,
  0x3C, 0x1C, 0x0E, 0x00, 0xC3, 0x0D, 0x0E, 0x36, 0x38, 0xD9, 0xA2, 0x66,
  0xD8, 0x93, 0x63, 0xCD, 0x8F, 0x14, 0x38, 0x70, 0x61, 0xC0, 0xE1, 0x98,
  0xE3, 0x30, 0x78, 0x1C, 0x07, 0x01, 0xE0, 0xCC, 0x63, 0x38, 0x70, 0xC1,
  0xF0, 0x66, 0x19, 0x8C, 0x33, 0x0C, 0xC1, 0x60, 0x78, 0x1C, 0x03, 0x00,
  0xC0, 0x60, 0x38, 0x3C, 0x00, 0xFF, 0xFC, 0x30, 0xC1, 0x86, 0x18, 0x30,
  0xC1, 0xFC, 0x0C, 0x71, 0x84, 0x10, 0x43, 0x3C, 0xF0, 0xC1, 0x04, 0x10,
  0x61, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6, 0x30, 0xC7,
  0x39, 0x18, 0xC6, 0x33, 0x98, 0x61, 0xFF, 0x8F,
};

const GFXglyph NotoSans_Medium18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 6, 5, 8, 1, -13 },
  { 10, 11, 13, 12, 0, -13 },
  { 28, 8, 15, 10, 1, -14 },
  { 43, 14, 13, 15, 1, -13 },
  { 66, 12, 13, 13, 1, -13 },
  { 86, 2, 5, 4, 1, -13 },
  { 88, 4, 16, 6, 1, -13 },
  { 96, 4, 16, 6, 1, -13 },
  { 104, 8, 9, 10, 1, -14 },
  { 113, 8, 9, 10, 1, -11 },
  { 122, 3, 4, 5, 1, -2 },
  { 124, 4, 2, 6, 1, -6 },
  { 125, 3, 2, 5, 1, -2 },
  { 126, 7, 13, 7, 0, -13 },
  { 138, 8, 13, 10, 1, -13 },
  { 151, 6, 13, 10, 1, -13 },
  { 161, 8, 13, 10, 1, -13 },
  { 174, 8, 13, 10, 1, -13 },
  { 187, 10, 13, 10, 0, -13 },
  { 204, 8, 13, 10, 1, -13 },
  { 217, 9, 13, 10, 1, -13 },
  { 232, 9, 13, 10, 1, -13 },
  { 247, 8, 13, 10, 1, -13 },
  { 260, 8, 13, 10, 1, -13 },
  { 273, 3, 10, 5, 1, -10 },
  { 277, 3, 12, 5, 1, -10 },
  { 282, 8, 9, 10, 1, -11 },
  { 291, 8, 5, 10, 1, -9 },
  { 296, 8, 9, 10, 1, -11 },
  { 305, 8, 13, 8, 0, -13 },
  { 318, 14, 15, 16, 1, -13 },
  { 345, 12, 13, 12, 0, -13 },
  { 365, 9, 13, 12, 2, -13 },
  { 380, 10, 13, 11, 1, -13 },
  { 397, 10, 13, 13, 2, -13 },
  { 414, 7, 13, 10, 2, -13 },
  { 426, 7, 13, 10, 2, -13 },
  { 438, 11, 13, 13, 1, -13 },
  { 456, 10, 13, 13, 2, -13 },
  { 473, 5, 13, 6, 1, -13 },
  { 482, 5, 17, 5, -1, -13 },
  { 493, 9, 13, 11, 2, -13 },
  { 508, 7, 13, 10, 2, -13 },
  { 520, 13, 13, 17, 2, -13 },
  { 542, 10, 13, 14, 2, -13 },
  { 559, 12, 13, 14, 1, -13 },
  { 579, 8, 13, 11, 2, -13 },
  { 592, 12, 16, 14, 1, -13 },
  { 616, 9, 13, 11, 2, -13 },
  { 631, 8, 13, 10, 1, -13 },
  { 644, 10, 13, 10, 0, -13 },
  { 661, 10, 13, 13, 2, -13 },
  { 678, 11, 13, 11, 0, -13 },
  { 696, 17, 13, 17, 0, -13 },
  { 724, 11, 13, 11, 0, -13 },
  { 742, 11, 13, 11, 0, -13 },
  { 760, 9, 13, 10, 1, -13 },
  { 775, 4, 16, 6, 1, -13 },
  { 783, 7, 13, 7, 0, -13 },
  { 795, 5, 16, 6, 0, -13 },
  { 805, 9, 8, 10, 1, -13 },
  { 814, 8, 1, 8, 0, 2 },
  { 815, 4, 3, 6, 1, -14 },
  { 817, 8, 10, 10, 1, -10 },
  { 827, 9, 14, 11, 1, -14 },
  { 843, 7, 10, 9, 1, -10 },
  { 852, 9, 14, 11, 1, -14 },
  { 868, 8, 10, 10, 1, -10 },
  { 878, 7, 14, 6, 0, -14 },
  { 891, 9, 14, 11, 1, -10 },
  { 907, 9, 14, 11, 1, -14 },
  { 923, 3, 13, 5, 1, -13 },
  { 928, 5, 17, 5, -1, -13 },
  { 939, 9, 14, 10, 1, -14 },
  { 955, 2, 14, 5, 1, -14 },
  { 959, 15, 10, 17, 1, -10 },
  { 978, 9, 10, 11, 1, -10 },
  { 990, 9, 10, 11, 1, -10 },
  { 1002, 9, 14, 11, 1, -10 },
  { 1018, 9, 14, 11, 1, -10 },
  { 1034, 6, 10, 8, 1, -10 },
  { 1042, 7, 10, 9, 1, -10 },
  { 1051, 6, 12, 7, 0, -12 },
  { 1060, 9, 10, 11, 1, -10 },
  { 1072, 9, 10, 9, 0, -10 },
  { 1084, 14, 10, 15, 0, -10 },
  { 1102, 10, 10, 10, 0, -10 },
  { 1115, 10, 14, 10, 0, -10 },
  { 1133, 7, 10, 9, 1, -10 },
  { 1142, 6, 16, 7, 0, -13 },
  { 1154, 2, 18, 10, 4, -14 },
  { 1159, 5, 16, 7, 1, -13 },
  { 1169, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_Medium18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium18pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_MEDIUM18PT7B_H_
