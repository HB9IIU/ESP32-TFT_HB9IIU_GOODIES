#ifndef _NOTOSANS_MEDIUM39PT7B_H_
#define _NOTOSANS_MEDIUM39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x39, 0xCE, 0x73,
  0x9C, 0xE0, 0x00, 0x1E, 0xFF, 0xFF, 0xF2, 0x00, 0xF8, 0xF7, 0x8F, 0x78,
  0xF7, 0x8F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x07, 0x70, 0x77, 0x07, 0x00,
  0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xF0, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x1E, 0x0E, 0x00, 0x38, 0x3C,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x81,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x01,
  0xE0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0xF9,
  0xF3, 0x1E, 0xF8, 0xC0, 0xBC, 0x30, 0x0F, 0x0C, 0x03, 0xE3, 0x00, 0x7C,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x0D, 0xFC, 0x03, 0x1F, 0x00, 0xC3, 0xC0, 0x30, 0xF0, 0x0C, 0x3F,
  0x03, 0x1F, 0xF8, 0xDF, 0xBF, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x0F, 0x00,
  0xFF, 0x00, 0x38, 0x07, 0xFC, 0x01, 0xE0, 0x3C, 0x78, 0x07, 0x00, 0xF0,
  0xE0, 0x3C, 0x03, 0x83, 0x80, 0xE0, 0x0E, 0x0F, 0x07, 0x80, 0x38, 0x3C,
  0x3C, 0x00, 0xE0, 0xF0, 0xE0, 0x03, 0x83, 0xC7, 0x80, 0x0E, 0x0F, 0x1C,
  0x00, 0x38, 0x38, 0xF1, 0xF0, 0xF0, 0xE3, 0x9F, 0xE3, 0xC7, 0x9E, 0x7F,
  0xC7, 0xFC, 0x73, 0xC7, 0x8F, 0xF3, 0xCE, 0x0E, 0x1F, 0x8E, 0x38, 0x38,
  0x00, 0x70, 0xE0, 0xE0, 0x03, 0xC7, 0x83, 0x80, 0x0E, 0x1E, 0x0F, 0x00,
  0x78, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0xE0, 0x0F, 0x03, 0x83, 0x80, 0x38,
  0x0E, 0x0E, 0x01, 0xE0, 0x3C, 0x78, 0x07, 0x00, 0x7B, 0xC0, 0x38, 0x01,
  0xFF, 0x01, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x01, 0xE1, 0xF3, 0xE0, 0x7C, 0x7C,
  0x3E, 0x0F, 0x1F, 0x03, 0xE1, 0xE3, 0xE0, 0x3E, 0x7C, 0x78, 0x03, 0xEF,
  0x0F, 0x00, 0x3F, 0xC1, 0xE0, 0x03, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xE0,
  0x1F, 0xE0, 0x7E, 0x0F, 0xFE, 0x0F, 0xFF, 0xFB, 0xE0, 0x7F, 0xFC, 0x3E,
  0x07, 0xFE, 0x03, 0xF0, 0xFB, 0xDE, 0xF7, 0x39, 0xCE, 0x73, 0x80, 0x07,
  0x87, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x1C,
  0x38, 0x73, 0xFF, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0x3B, 0xC0, 0x0F, 0x38, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x0E,
  0x0F, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3E,
  0x7C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0x71, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF7, 0xFF, 0xFF, 0x90, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0x0F, 0x87, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E,
  0x01, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3C, 0xF0,
  0x0F, 0x9E, 0x01, 0xE3, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF7,
  0xFF, 0xF9, 0xF7, 0x1F, 0x21, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xF8,
  0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0x00, 0xF8, 0x40, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xF0, 0x7E, 0x60, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3B, 0xC0,
  0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1,
  0xE0, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07,
  0x80, 0xF0, 0x78, 0x07, 0x83, 0x80, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7E, 0x00, 0x3E, 0xF0, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x41, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0xC0, 0x79, 0xFF, 0x0F, 0x7F, 0xF1, 0xFF, 0xFF, 0x3F, 0x01,
  0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xE0, 0x3E, 0x3E, 0x0F,
  0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0x07,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07,
  0x8F, 0x80, 0xF0, 0xF8, 0x7C, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x03, 0xFF, 0x81, 0xFB, 0xF8, 0x7C, 0x1F, 0x8F, 0x00, 0xFB, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x1E,
  0x7C, 0x0F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF8, 0xFC, 0x78, 0x0F, 0xBE, 0x01, 0xEF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x07, 0xDE, 0x03, 0xF7, 0xF7, 0xFC, 0xFF, 0xEF, 0x1F, 0xF3,
  0xC1, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0x80, 0x27, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBF, 0xFF, 0xFC, 0x80, 0x08, 0x7C, 0xF9, 0xF3, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF9, 0xE3, 0xCF, 0x1E,
  0x3C, 0x70, 0xE3, 0x80, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x0C, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7E, 0x3F, 0x20, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x1E, 0x3C, 0x0F, 0xFE, 0x1C, 0x70, 0x3F, 0xF8, 0x39,
  0xE0, 0xF8, 0xF0, 0x7B, 0x83, 0xC0, 0xE0, 0x77, 0x07, 0x01, 0xC0, 0xFE,
  0x1E, 0x03, 0x81, 0xFC, 0x3C, 0x07, 0x03, 0xF0, 0x70, 0x0E, 0x07, 0xE0,
  0xE0, 0x1C, 0x0F, 0xC1, 0xC0, 0x38, 0x3F, 0x83, 0xC0, 0xF0, 0x77, 0x87,
  0x81, 0xE0, 0xEF, 0x07, 0x87, 0xE3, 0x8E, 0x0F, 0xFD, 0xFF, 0x1C, 0x0F,
  0xF1, 0xFC, 0x3C, 0x03, 0x80, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x0F, 0xCF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE7, 0x80, 0xFE, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFC, 0xFE, 0x1F,
  0x80, 0x10, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0xE3, 0xC0, 0x0F, 0xCF, 0x00, 0x0F,
  0xBC, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E,
  0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xEF, 0x00, 0x3F, 0x3C, 0x03, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xE7, 0xE1, 0xFC, 0x00, 0xC3, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFE, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xCF,
  0xC0, 0x07, 0x8F, 0xC0, 0x0F, 0x0F, 0xF0, 0x3E, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0xFF, 0xDF, 0xF3, 0xFC, 0x38, 0x00,
  0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF8, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07,
  0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x3C,
  0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3E,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x7D, 0xE0,
  0x03, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0xFF, 0xEF, 0x00, 0x0E, 0xFE, 0x70,
  0x01, 0xEF, 0xE7, 0x80, 0x1E, 0xFE, 0x78, 0x01, 0xCF, 0xF3, 0x80, 0x3C,
  0xFF, 0x3C, 0x03, 0xCF, 0xF3, 0xC0, 0x38, 0xFF, 0x1C, 0x07, 0x8F, 0xF1,
  0xE0, 0x70, 0xFF, 0x1E, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E,
  0x0F, 0xF0, 0xF1, 0xE0, 0xFF, 0x07, 0x9E, 0x0F, 0xF0, 0x79, 0xC0, 0xFF,
  0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0x80, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0x00, 0xFF, 0x00, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFB, 0xE0, 0x07, 0xF3, 0xC0, 0x0F, 0xE7,
  0xC0, 0x1F, 0xC7, 0xC0, 0x3F, 0x87, 0x80, 0x7F, 0x8F, 0x80, 0xFF, 0x0F,
  0x81, 0xFE, 0x1F, 0x03, 0xFC, 0x1F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3E,
  0x1F, 0xE0, 0x3E, 0x3F, 0xC0, 0x7C, 0x7F, 0x80, 0x7C, 0xFF, 0x00, 0x7D,
  0xFE, 0x00, 0xFB, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xC7, 0xF8, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x7C,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0,
  0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0xF0, 0x1F, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x0F, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xC7, 0xF8, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0,
  0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x1F, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00,
  0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x07,
  0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFE, 0xFC, 0x7C, 0x01, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7A, 0x00, 0x3E, 0xF8, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x3F, 0x83,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80,
  0x00, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0x80, 0x0F, 0x78, 0x01, 0xF8, 0x01, 0xF7, 0x80,
  0x1F, 0x80, 0x1E, 0x7C, 0x01, 0xFC, 0x01, 0xE3, 0xC0, 0x1F, 0xC0, 0x1E,
  0x3C, 0x03, 0xDC, 0x03, 0xE3, 0xC0, 0x3D, 0xC0, 0x3C, 0x3E, 0x03, 0xDE,
  0x03, 0xC1, 0xE0, 0x79, 0xE0, 0x3C, 0x1E, 0x07, 0x8E, 0x07, 0xC1, 0xE0,
  0x78, 0xF0, 0x78, 0x0F, 0x07, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0xF0, 0x78,
  0x0F, 0x0F, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x78, 0xF0, 0x07, 0x8E, 0x07,
  0x8F, 0x00, 0x79, 0xE0, 0x38, 0xF0, 0x07, 0x9E, 0x03, 0xDF, 0x00, 0x79,
  0xE0, 0x3D, 0xE0, 0x03, 0xDC, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x1D, 0xE0,
  0x03, 0xFC, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x83, 0xE0,
  0x07, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xE7, 0xC0,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF1,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x78, 0x07,
  0x81, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x1E, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3B, 0xC0,
  0x03, 0x9C, 0x00, 0x71, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x07,
  0x01, 0xE0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x80,
  0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0x0F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0x81, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF,
  0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F, 0xDF, 0xFE, 0xEF, 0xFE, 0x73,
  0xFE, 0x38, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x3F, 0x83, 0xDF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE,
  0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xDF, 0x80, 0xFB, 0xF8, 0x3F, 0x7F, 0xFF, 0xCF, 0x7F, 0xF1, 0xC3,
  0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x06, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3F, 0x06, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0xFE, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF,
  0xF3, 0xE0, 0xFE, 0xF8, 0x0F, 0xDE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x3F,
  0x9F, 0xFF, 0xF1, 0xFF, 0xDE, 0x0F, 0xE1, 0xC0, 0x07, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x7C, 0x07, 0xDE, 0x00, 0xF7, 0x80, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x61, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7F, 0xF3, 0xFF, 0xE7, 0xFF, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xF1, 0xE3, 0xFF, 0xBC, 0xFF, 0xFF,
  0x9F, 0x07, 0xF7, 0xC0, 0x7E, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC1, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFE, 0xF0, 0x7F, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE8, 0x00, 0xF8, 0xE0, 0x3F, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x7F, 0x8F, 0x7F, 0xF3, 0xDF, 0xFE, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xF0, 0x77, 0xFF, 0xE6, 0x00, 0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x03, 0x81, 0xF0, 0x7C,
  0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFB, 0xC0, 0x3E, 0x78, 0x0F,
  0x8F, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0x8F, 0x80, 0xF3, 0xE0,
  0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFB, 0xE0,
  0x3C, 0x3E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0xC3, 0xC0, 0x7C,
  0x78, 0x07, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFE, 0x0F, 0xF1, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xF7, 0xF0,
  0x7F, 0x83, 0xEF, 0xC0, 0x7E, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01,
  0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F,
  0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7C,
  0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xE0,
  0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00,
  0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0xF1, 0xFE, 0x3D,
  0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x3E,
  0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80,
  0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0xF1, 0xFE, 0x1E, 0xFF, 0xE3, 0xDF, 0xFE, 0x7F, 0x07, 0xEF,
  0xC0, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1E, 0xFC, 0x07, 0xDF, 0xC1, 0xFB, 0xFF, 0xFE, 0x7B,
  0xFF, 0x8F, 0x1F, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xF1, 0xE3, 0xFF, 0xBC, 0xFF, 0xFF, 0x9F, 0x07, 0xF7,
  0xC0, 0x7E, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7B, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC1, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFE, 0xF0, 0x7F, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0xF1, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xAF, 0xE0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x1F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF7, 0xC0, 0x6F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0xFF,
  0xF7, 0xFF, 0xC7, 0xFF, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xDF, 0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xE7, 0x1F, 0xF1, 0xC0,
  0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03, 0xC3, 0xC0,
  0x1E, 0x1E, 0x01, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0xF0, 0x0F, 0x80, 0x7D, 0xE0, 0x1F, 0x80, 0xF3, 0xE0, 0x7F, 0x01, 0xE3,
  0xC0, 0xEE, 0x03, 0xC7, 0x81, 0xDE, 0x0F, 0x8F, 0x03, 0xBC, 0x1E, 0x0F,
  0x0F, 0x38, 0x3C, 0x1E, 0x1E, 0x70, 0x78, 0x3C, 0x38, 0xF1, 0xE0, 0x78,
  0xF1, 0xE3, 0xC0, 0x79, 0xE1, 0xC7, 0x80, 0xF3, 0x83, 0xCF, 0x01, 0xE7,
  0x07, 0xBC, 0x03, 0xDE, 0x07, 0x78, 0x03, 0xB8, 0x0E, 0xF0, 0x07, 0xF0,
  0x1D, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE7, 0xC0, 0x3C, 0x3C,
  0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0xBE, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x9E, 0x01, 0xF1, 0xF0, 0x1E, 0x0F,
  0x03, 0xE0, 0x78, 0x7C, 0x07, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x01, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0xC3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x1F, 0xE0, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xFF, 0x01, 0xF8, 0x07, 0xC0, 0xFE, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x08, 0x00, 0x5F, 0xE0, 0x1F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xC0,
};

const GFXglyph NotoSans_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 29, 11, 3, -28 },
  { 20, 12, 10, 17, 2, -28 },
  { 35, 23, 28, 25, 1, -28 },
  { 116, 18, 32, 22, 2, -30 },
  { 188, 30, 28, 33, 2, -28 },
  { 293, 27, 28, 29, 2, -28 },
  { 388, 5, 10, 9, 2, -28 },
  { 395, 9, 34, 12, 2, -28 },
  { 434, 10, 34, 12, 1, -28 },
  { 477, 19, 18, 21, 1, -30 },
  { 520, 18, 19, 22, 2, -23 },
  { 563, 7, 10, 11, 1, -5 },
  { 572, 10, 3, 13, 1, -12 },
  { 576, 5, 6, 11, 3, -5 },
  { 580, 15, 28, 15, 0, -28 },
  { 633, 19, 28, 22, 2, -28 },
  { 700, 12, 28, 22, 3, -28 },
  { 742, 19, 28, 22, 2, -28 },
  { 809, 18, 28, 22, 2, -28 },
  { 872, 21, 28, 22, 1, -28 },
  { 946, 18, 28, 22, 2, -28 },
  { 1009, 19, 28, 22, 2, -28 },
  { 1076, 19, 28, 22, 2, -28 },
  { 1143, 19, 28, 22, 2, -28 },
  { 1210, 18, 28, 22, 2, -28 },
  { 1273, 5, 23, 11, 3, -22 },
  { 1288, 7, 27, 11, 1, -22 },
  { 1312, 18, 20, 22, 2, -24 },
  { 1357, 18, 11, 22, 2, -19 },
  { 1382, 18, 20, 22, 2, -24 },
  { 1427, 16, 29, 17, 0, -28 },
  { 1485, 31, 31, 35, 2, -28 },
  { 1606, 26, 28, 26, 0, -28 },
  { 1697, 19, 28, 26, 4, -28 },
  { 1764, 22, 28, 25, 2, -28 },
  { 1841, 22, 28, 29, 4, -28 },
  { 1918, 15, 28, 22, 4, -28 },
  { 1971, 15, 28, 21, 4, -28 },
  { 2024, 23, 28, 28, 2, -28 },
  { 2105, 21, 28, 29, 4, -28 },
  { 2179, 11, 28, 14, 1, -28 },
  { 2218, 11, 36, 11, -3, -28 },
  { 2268, 21, 28, 25, 4, -28 },
  { 2342, 16, 28, 21, 4, -28 },
  { 2398, 28, 28, 36, 4, -28 },
  { 2496, 23, 28, 30, 4, -28 },
  { 2577, 26, 28, 31, 2, -28 },
  { 2668, 18, 28, 24, 4, -28 },
  { 2731, 26, 35, 31, 2, -28 },
  { 2845, 20, 28, 25, 4, -28 },
  { 2915, 18, 28, 21, 2, -28 },
  { 2978, 21, 28, 22, 0, -28 },
  { 3052, 22, 28, 29, 3, -28 },
  { 3129, 24, 28, 24, 0, -28 },
  { 3213, 36, 28, 37, 0, -28 },
  { 3339, 24, 28, 24, 0, -28 },
  { 3423, 23, 28, 23, 0, -28 },
  { 3504, 20, 28, 22, 1, -28 },
  { 3574, 9, 34, 13, 3, -28 },
  { 3613, 15, 28, 15, 0, -28 },
  { 3666, 9, 34, 13, 1, -28 },
  { 3705, 20, 18, 22, 1, -28 },
  { 3750, 17, 2, 17, 0, 4 },
  { 3755, 8, 6, 12, 2, -30 },
  { 3761, 17, 21, 22, 2, -21 },
  { 3806, 19, 30, 24, 3, -30 },
  { 3878, 16, 21, 19, 2, -21 },
  { 3920, 19, 30, 24, 2, -30 },
  { 3992, 18, 21, 22, 2, -21 },
  { 4040, 15, 30, 14, 1, -30 },
  { 4097, 19, 30, 24, 2, -21 },
  { 4169, 18, 30, 24, 3, -30 },
  { 4237, 5, 29, 11, 3, -29 },
  { 4256, 10, 38, 11, -2, -29 },
  { 4304, 19, 30, 22, 3, -30 },
  { 4376, 4, 30, 11, 3, -30 },
  { 4391, 31, 21, 37, 3, -21 },
  { 4473, 18, 21, 24, 3, -21 },
  { 4521, 20, 21, 24, 2, -21 },
  { 4574, 19, 30, 24, 3, -21 },
  { 4646, 19, 30, 24, 2, -21 },
  { 4718, 13, 21, 17, 3, -21 },
  { 4753, 15, 21, 19, 2, -21 },
  { 4793, 13, 26, 15, 1, -26 },
  { 4836, 18, 21, 24, 3, -21 },
  { 4884, 21, 21, 21, 0, -21 },
  { 4940, 31, 21, 31, 0, -21 },
  { 5022, 20, 21, 21, 1, -21 },
  { 5075, 21, 30, 21, 0, -21 },
  { 5154, 16, 21, 19, 1, -21 },
  { 5196, 13, 34, 15, 1, -28 },
  { 5252, 3, 39, 21, 9, -30 },
  { 5267, 13, 34, 15, 1, -28 },
  { 5323, 18, 6, 22, 2, -17 },
};

const GFXfont NotoSans_Medium39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium39pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_MEDIUM39PT7B_H_
