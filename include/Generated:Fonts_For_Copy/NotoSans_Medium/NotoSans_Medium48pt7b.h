#ifndef _NOTOSANS_MEDIUM48PT7B_H_
#define _NOTOSANS_MEDIUM48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Medium.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Medium48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xDF, 0xFF, 0xFF, 0xFE, 0xF8, 0xE0, 0xF8, 0x7F, 0xF0, 0xFB,
  0xE1, 0xF7, 0xC1, 0xEF, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFE, 0x70, 0xF3,
  0xE1, 0xC0, 0x4F, 0x87, 0x00, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xE1,
  0xC0, 0x0F, 0xC7, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0x1F, 0x80, 0x1C, 0x3F, 0x00, 0x70, 0x7C, 0x01, 0xC1, 0xF0, 0x07,
  0x07, 0xE0, 0x1C, 0x3F, 0xE0, 0x71, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0x1E,
  0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x78, 0x00,
  0xF0, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x83,
  0xE0, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x0F, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0xF0, 0xFC, 0x0F, 0x07, 0x87, 0x8F,
  0xF8, 0x78, 0x3C, 0x78, 0xFF, 0xE3, 0xE3, 0xE7, 0xCF, 0xFF, 0x0F, 0xFE,
  0x3C, 0x78, 0x7C, 0x7F, 0xF3, 0xE3, 0xC1, 0xE1, 0xFF, 0x1E, 0x3C, 0x0F,
  0x03, 0xE1, 0xF1, 0xE0, 0x7C, 0x00, 0x0F, 0x0F, 0x01, 0xE0, 0x00, 0xF0,
  0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x03, 0xC0,
  0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x3C,
  0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x07, 0x83, 0xC0, 0x0F,
  0x00, 0x3E, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0x03, 0xFE,
  0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x03, 0xFF, 0xC0, 0x0F, 0x83,
  0xFB, 0xF0, 0x07, 0xC3, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0xF8, 0x03, 0xF9, 0xF0, 0xFC, 0x00, 0xFF, 0xF8,
  0x7E, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x03, 0xFC,
  0x07, 0xC0, 0x01, 0xFE, 0x03, 0xF0, 0x01, 0xFF, 0x81, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B,
  0xDC, 0xE0, 0x03, 0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0xFC, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x0C, 0x07, 0x80, 0xFF, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3C,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x3E,
  0x03, 0xC0, 0xF0, 0x03, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFF, 0xFF,
  0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x07,
  0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF,
  0xF7, 0xF7, 0xFF, 0x1F, 0x78, 0x7C, 0xC1, 0xF2, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xC0, 0x3F, 0x0E, 0x00, 0x3F, 0x08, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x80, 0x3F,
  0x0C, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xD0, 0x00, 0x1F, 0xBC, 0x00, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x40, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x80, 0x01, 0xFB, 0xC0,
  0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xE3, 0x81, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x1F, 0x3F, 0xF8, 0x3C, 0xFF, 0xF8, 0x7B,
  0xFF, 0xF9, 0xFF, 0x87, 0xFB, 0xFC, 0x03, 0xF7, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0x87, 0xE0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0x87, 0xE0,
  0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0x83, 0xF0, 0x7E,
  0x03, 0xF9, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0xFE, 0x7F, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x9F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80,
  0x3F, 0x1F, 0xF7, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFE, 0xFF, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C,
  0x00, 0xFE, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFD, 0xF0, 0xFF,
  0xF3, 0xE0, 0xFF, 0xC7, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF1, 0xC0, 0x04, 0x0F, 0x8F, 0xE7, 0xF3,
  0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F,
  0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0x80, 0x3F, 0x20,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x03, 0xFE,
  0x03, 0xC3, 0xC0, 0x3F, 0xFE, 0x0F, 0x9F, 0x03, 0xFF, 0xF8, 0x1E, 0x78,
  0x1F, 0xC3, 0xE0, 0x79, 0xE0, 0x7C, 0x07, 0x81, 0xEF, 0x03, 0xE0, 0x1E,
  0x07, 0xBC, 0x0F, 0x00, 0x78, 0x0E, 0xF0, 0x3C, 0x01, 0xE0, 0x3F, 0xC1,
  0xF0, 0x07, 0x80, 0xFF, 0x07, 0x80, 0x1E, 0x03, 0xBC, 0x1E, 0x00, 0x78,
  0x1E, 0xF0, 0x78, 0x03, 0xE0, 0x7B, 0xC1, 0xF0, 0x0F, 0x81, 0xEF, 0x07,
  0xC0, 0x3E, 0x07, 0xBC, 0x0F, 0x01, 0xF8, 0x3C, 0xF0, 0x3E, 0x0F, 0xE1,
  0xF3, 0xC0, 0x7F, 0xFB, 0xFF, 0x8F, 0x81, 0xFF, 0xC7, 0xFC, 0x1E, 0x01,
  0xFE, 0x0F, 0xE0, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xC0, 0x1F, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x3F,
  0x00, 0x7F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x1F,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x01, 0xE1, 0xFC, 0x00,
  0x10, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x78, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFC, 0x01,
  0xFF, 0x0F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0xFF, 0x8F, 0xC1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x1E, 0x1F, 0xE0,
  0x00, 0x41, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x1F, 0x3F, 0x80, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x0F, 0xF8,
  0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE8, 0x3F, 0xBF,
  0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0,
  0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C,
  0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07,
  0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0x80,
  0x1F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xF7, 0xFD, 0xE0, 0x00,
  0x1E, 0xFF, 0xBE, 0x00, 0x07, 0xDF, 0xF7, 0xC0, 0x00, 0xF3, 0xFE, 0x78,
  0x00, 0x3E, 0x7F, 0xCF, 0x80, 0x07, 0xCF, 0xF9, 0xF0, 0x00, 0xF3, 0xFF,
  0x1F, 0x00, 0x3E, 0x7F, 0xE3, 0xE0, 0x07, 0x8F, 0xFC, 0x3C, 0x00, 0xF1,
  0xFF, 0x87, 0xC0, 0x3E, 0x3F, 0xF0, 0xF8, 0x07, 0x87, 0xFE, 0x0F, 0x00,
  0xF0, 0xFF, 0xC1, 0xF0, 0x3E, 0x1F, 0xF8, 0x3E, 0x07, 0x83, 0xFF, 0x03,
  0xC1, 0xF0, 0x7F, 0xE0, 0x7C, 0x3E, 0x0F, 0xFC, 0x0F, 0x87, 0x81, 0xFF,
  0x80, 0xF1, 0xF0, 0x3F, 0xF0, 0x1F, 0x3C, 0x07, 0xFE, 0x03, 0xE7, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x3F, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0x7E, 0x00, 0x1F, 0xF7, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x1F, 0xF1,
  0xF8, 0x01, 0xFF, 0x1F, 0x80, 0x1F, 0xF0, 0xFC, 0x01, 0xFF, 0x07, 0xC0,
  0x1F, 0xF0, 0x7E, 0x01, 0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0x01, 0xFF,
  0x01, 0xF8, 0x1F, 0xF0, 0x0F, 0xC1, 0xFF, 0x00, 0xFC, 0x1F, 0xF0, 0x07,
  0xE1, 0xFF, 0x00, 0x3E, 0x1F, 0xF0, 0x03, 0xF1, 0xFF, 0x00, 0x1F, 0x9F,
  0xF0, 0x01, 0xF9, 0xFF, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xDF, 0x80, 0x3F,
  0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x1F, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFC, 0x01, 0xC7, 0xE0, 0x01, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xFB, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x87, 0xE0,
  0x07, 0xBC, 0x00, 0x7C, 0x1F, 0x00, 0x7D, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0xF1,
  0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xC1, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x01, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x00,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x0F, 0x1F, 0x00, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0x80, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xE0,
  0x03, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xEF, 0x00, 0x01, 0xCF, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x07,
  0x83, 0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0E, 0x01, 0xF8, 0x20, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF0, 0x07, 0xDF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xDF,
  0x3F, 0xFE, 0x3C, 0x3F, 0xE0, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE1,
  0xFE, 0x07, 0xCF, 0xFF, 0x0F, 0xBF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC0,
  0x7E, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x80, 0x3F, 0x7F,
  0x80, 0xFC, 0xFF, 0xFF, 0xF9, 0xE7, 0xFF, 0xE3, 0xC7, 0xFF, 0x87, 0x87,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3,
  0xF8, 0x1C, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0x01, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0xF0, 0xF8,
  0x7F, 0xF9, 0xF1, 0xFF, 0xFB, 0xE7, 0xFF, 0xFF, 0xDF, 0xC0, 0xFF, 0xBF,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0xFF,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0x7C, 0x3F, 0xFC, 0xF8, 0x3F, 0xE0, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0x01, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFB, 0x81,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFC, 0x1E, 0x1F, 0xFE, 0x7C, 0x7F, 0xFE, 0xF9, 0xFF, 0xFF, 0xF7,
  0xF0, 0x3F, 0xEF, 0xC0, 0x1F, 0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F,
  0xEF, 0xE0, 0x3F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0x0F, 0xFF, 0x3E,
  0x0F, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x20, 0x00, 0x7E, 0x70, 0x01, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x04,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x87, 0xFC, 0x3E, 0x7F, 0xF8, 0xFB,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0x77, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFC, 0xFF, 0x80, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xF7,
  0xC0, 0x0F, 0xCF, 0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xCF,
  0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF0,
  0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xC7, 0xFF, 0x87, 0xFF, 0x8F, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0x83, 0xFB, 0xF8,
  0x07, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x07,
  0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0xF0, 0x7F, 0xC3, 0xC7, 0xFF, 0xCF, 0x3F, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xF0, 0x7F, 0x81,
  0xE3, 0xFF, 0xC3, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0x9F,
  0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xE0, 0x0F, 0xDF, 0xE0, 0x3F,
  0x3F, 0xFF, 0xFE, 0x7D, 0xFF, 0xF8, 0xF9, 0xFF, 0xE1, 0xF1, 0xFF, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x1E, 0x1F, 0xFE, 0x7C, 0x7F, 0xFE, 0xF9, 0xFF, 0xFF, 0xF7, 0xF0,
  0x1F, 0xEF, 0xC0, 0x1F, 0xDF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xE0, 0x3F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0x0F, 0xFF, 0x3E, 0x0F,
  0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF0, 0x7F, 0xF0, 0xFE, 0xF3, 0xFE, 0xF3, 0xFE, 0xFF, 0xE2, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xC0, 0x19, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0x3F, 0xFF, 0x3C, 0x3F, 0xF0, 0xF0, 0xFC,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xE3,
  0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xF8,
  0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x1F, 0x3E, 0x01, 0xEF, 0x00,
  0xF9, 0xF0, 0x0F, 0x78, 0x0F, 0x87, 0xC0, 0xFB, 0xC0, 0x7C, 0x3E, 0x07,
  0x9F, 0x03, 0xE1, 0xF0, 0x3C, 0x78, 0x1F, 0x0F, 0x81, 0xE3, 0xC1, 0xF0,
  0x3E, 0x1F, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0xF8, 0x7C, 0x0F, 0x87, 0x83,
  0xC3, 0xC0, 0x3C, 0x7C, 0x1E, 0x3E, 0x01, 0xF3, 0xC0, 0xF9, 0xF0, 0x0F,
  0x9E, 0x07, 0xCF, 0x80, 0x7C, 0xF0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0xF7,
  0xC0, 0x0F, 0x78, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xE7,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00,
  0x07, 0xCF, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0xFF,
  0x83, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0x00, 0x00,
  0x1F, 0xE0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xD0, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_Medium48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 35, 13, 3, -34 },
  { 32, 15, 12, 21, 3, -34 },
  { 55, 29, 34, 31, 1, -34 },
  { 179, 22, 39, 27, 3, -36 },
  { 287, 37, 35, 41, 2, -35 },
  { 449, 33, 35, 35, 2, -35 },
  { 594, 5, 12, 11, 3, -34 },
  { 602, 12, 42, 15, 2, -34 },
  { 665, 12, 42, 15, 1, -34 },
  { 728, 22, 21, 26, 2, -36 },
  { 786, 23, 24, 27, 2, -29 },
  { 855, 8, 12, 13, 2, -6 },
  { 867, 12, 4, 15, 2, -15 },
  { 873, 7, 7, 13, 3, -6 },
  { 880, 18, 34, 18, 0, -34 },
  { 957, 23, 35, 27, 2, -35 },
  { 1058, 14, 34, 27, 4, -34 },
  { 1118, 23, 35, 27, 2, -35 },
  { 1219, 23, 35, 27, 2, -35 },
  { 1320, 26, 34, 27, 1, -34 },
  { 1431, 22, 34, 27, 3, -34 },
  { 1525, 23, 35, 27, 2, -35 },
  { 1626, 23, 34, 27, 2, -34 },
  { 1724, 23, 35, 27, 2, -35 },
  { 1825, 23, 35, 27, 2, -35 },
  { 1926, 7, 28, 13, 3, -27 },
  { 1951, 9, 33, 13, 1, -27 },
  { 1989, 23, 24, 27, 2, -29 },
  { 2058, 23, 14, 27, 2, -24 },
  { 2099, 23, 24, 27, 2, -29 },
  { 2168, 20, 36, 21, 0, -35 },
  { 2258, 38, 38, 43, 3, -34 },
  { 2439, 31, 34, 31, 0, -34 },
  { 2571, 25, 34, 31, 4, -34 },
  { 2678, 26, 35, 30, 3, -35 },
  { 2792, 28, 34, 35, 4, -34 },
  { 2911, 19, 34, 27, 5, -34 },
  { 2992, 19, 34, 25, 5, -34 },
  { 3073, 28, 35, 35, 3, -35 },
  { 3196, 26, 34, 36, 5, -34 },
  { 3307, 13, 34, 17, 2, -34 },
  { 3363, 14, 43, 14, -4, -34 },
  { 3439, 25, 34, 30, 5, -34 },
  { 3546, 20, 34, 26, 4, -34 },
  { 3631, 35, 34, 44, 5, -34 },
  { 3780, 28, 34, 37, 5, -34 },
  { 3899, 32, 35, 38, 3, -35 },
  { 4039, 23, 34, 29, 4, -34 },
  { 4137, 32, 43, 38, 3, -35 },
  { 4309, 26, 34, 30, 4, -34 },
  { 4420, 22, 35, 26, 2, -35 },
  { 4517, 25, 34, 27, 1, -34 },
  { 4624, 27, 34, 35, 4, -34 },
  { 4739, 30, 34, 30, 0, -34 },
  { 4867, 45, 34, 45, 0, -34 },
  { 5059, 29, 34, 29, 0, -34 },
  { 5183, 28, 34, 28, 0, -34 },
  { 5302, 24, 34, 28, 2, -34 },
  { 5404, 11, 42, 16, 4, -34 },
  { 5462, 18, 34, 18, 0, -34 },
  { 5539, 11, 42, 16, 1, -34 },
  { 5597, 24, 22, 27, 2, -35 },
  { 5663, 21, 3, 21, 0, 4 },
  { 5671, 11, 8, 15, 2, -37 },
  { 5682, 22, 26, 27, 2, -26 },
  { 5754, 23, 36, 30, 4, -36 },
  { 5858, 19, 26, 24, 3, -26 },
  { 5920, 23, 36, 30, 3, -36 },
  { 6024, 22, 26, 28, 3, -26 },
  { 6096, 18, 37, 17, 1, -37 },
  { 6180, 23, 38, 30, 3, -26 },
  { 6290, 22, 36, 30, 4, -36 },
  { 6389, 5, 36, 13, 4, -36 },
  { 6412, 12, 48, 13, -3, -36 },
  { 6484, 23, 36, 27, 4, -36 },
  { 6588, 5, 36, 13, 4, -36 },
  { 6611, 38, 26, 45, 4, -26 },
  { 6735, 22, 26, 30, 4, -26 },
  { 6807, 24, 26, 29, 3, -26 },
  { 6885, 23, 38, 30, 4, -26 },
  { 6995, 23, 38, 30, 3, -26 },
  { 7105, 16, 26, 20, 4, -26 },
  { 7157, 19, 26, 23, 2, -26 },
  { 7219, 16, 32, 18, 1, -32 },
  { 7283, 22, 26, 30, 4, -26 },
  { 7355, 25, 26, 25, 0, -26 },
  { 7437, 37, 26, 39, 1, -26 },
  { 7558, 24, 26, 26, 1, -26 },
  { 7636, 25, 38, 25, 0, -26 },
  { 7755, 19, 26, 23, 2, -26 },
  { 7817, 16, 42, 18, 1, -34 },
  { 7901, 4, 47, 26, 11, -36 },
  { 7925, 15, 42, 18, 2, -34 },
  { 8004, 23, 6, 27, 2, -20 },
};

const GFXfont NotoSans_Medium48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Medium48pt7bBitmaps,
  (GFXglyph *)NotoSans_Medium48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_MEDIUM48PT7B_H_
