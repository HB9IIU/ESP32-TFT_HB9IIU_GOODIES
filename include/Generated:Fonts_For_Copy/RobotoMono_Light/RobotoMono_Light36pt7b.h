#ifndef _ROBOTOMONO_LIGHT36PT7B_H_
#define _ROBOTOMONO_LIGHT36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0xFC, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00,
  0x81, 0x80, 0x18, 0x10, 0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00,
  0x10, 0x30, 0x7F, 0xFF, 0xF0, 0x30, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0x80, 0x0C, 0x08, 0x00, 0xC1,
  0x80, 0x0C, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x03, 0xE0, 0x0F, 0xF8, 0x3C,
  0x1C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x60, 0x03, 0x70, 0x06, 0x38, 0x0E, 0x1F, 0xFC, 0x0F, 0xF0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0xC3, 0x00, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x08, 0x18, 0x60, 0x81, 0x84,
  0x0C, 0x18, 0xC0, 0xC1, 0x18, 0x06, 0x31, 0x80, 0x7E, 0x30, 0x00, 0x83,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x7C, 0x01,
  0x8E, 0xE0, 0x11, 0x86, 0x03, 0x18, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x01, 0x82, 0x00, 0x0C, 0x60, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xFE, 0x00, 0x30, 0xE0, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x01, 0x9C, 0x00,
  0x3F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x06, 0x70, 0x01,
  0x87, 0x06, 0x70, 0x60, 0xCC, 0x06, 0x1B, 0x80, 0xE6, 0x60, 0x0E, 0xCE,
  0x00, 0xF8, 0xC0, 0x0E, 0x18, 0x01, 0xC1, 0x80, 0xFC, 0x3E, 0xF9, 0xC1,
  0xFE, 0x1C, 0xFF, 0xFF, 0x01, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x41, 0x83, 0xF8, 0x8F, 0x3E, 0xFE, 0x07, 0xF0,
  0x01, 0xC0, 0x03, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x1C, 0x18, 0x38, 0x1C,
  0x10, 0x08, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x77, 0x76, 0x66, 0xCC, 0xFF,
  0xF8, 0xFF, 0x80, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x38, 0x18, 0x70, 0x0C, 0x60, 0x06, 0x60,
  0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1B, 0xC0, 0x33, 0xC0,
  0x63, 0xC0, 0xC3, 0xC3, 0x83, 0xC7, 0x03, 0xCE, 0x03, 0xDC, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x38,
  0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x81, 0xC3, 0xEF, 0xBF, 0x1C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x07,
  0xC0, 0x1F, 0xF0, 0x38, 0x3C, 0x60, 0x0C, 0xE0, 0x0E, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0C, 0x60,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60,
  0x06, 0x70, 0x0C, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x81, 0xC0, 0x30, 0x30, 0x06, 0x0C,
  0x00, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0xFE, 0x7F,
  0xFC, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xBF, 0x83, 0xFF, 0xC6, 0x07, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xD8, 0x07, 0x3C, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0, 0x00, 0x70,
  0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC3, 0xC0, 0xCF, 0xF0, 0xD8, 0x38, 0xF0, 0x0C,
  0xE0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x38, 0x1C, 0x1E, 0xF8,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x07, 0x70, 0x06, 0x30, 0x0E, 0x1C, 0x1C, 0x0F, 0xF0,
  0x0F, 0xF8, 0x38, 0x1C, 0x70, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x0E, 0x3F, 0x7C,
  0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x38, 0x38, 0x70, 0x1C, 0x60, 0x0C,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0x60, 0x0F, 0x70, 0x1E, 0x3C, 0x76, 0x1F, 0xE6,
  0x03, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF7, 0x3B, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x31, 0x8C, 0x66, 0x33, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x0F,
  0xC0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0xC0, 0x1F, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x3F, 0xE0, 0x07, 0x03, 0x80, 0xC0, 0x1C, 0x18, 0x00, 0xC3, 0x00, 0x06,
  0x30, 0xFC, 0x66, 0x1C, 0xC2, 0x61, 0x04, 0x24, 0x30, 0x42, 0xC2, 0x0C,
  0x2C, 0x60, 0xC2, 0xC6, 0x0C, 0x3C, 0x60, 0xC2, 0xC6, 0x08, 0x2C, 0x60,
  0x82, 0xC6, 0x18, 0x6C, 0x61, 0x86, 0xC2, 0x3C, 0xC4, 0x3E, 0x78, 0x61,
  0x83, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x20, 0x0F, 0x9E, 0x00,
  0x3F, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x60,
  0x60, 0x18, 0x18, 0x06, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xC0, 0x0C, 0x30,
  0x03, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xF0, 0x00,
  0x30, 0xFF, 0x80, 0xFF, 0xF0, 0xE0, 0x7C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0C, 0xE0,
  0x38, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x06, 0xE0,
  0x1E, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87,
  0x00, 0xE3, 0x00, 0x33, 0x80, 0x1D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x19, 0x80, 0x18, 0xE0, 0x0C, 0x38, 0x1C, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x30, 0x3E, 0x18, 0x03, 0x8C, 0x00, 0xC6,
  0x00, 0x33, 0x00, 0x1D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x73,
  0x00, 0x71, 0x80, 0x70, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x9F, 0xFF,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00, 0xE3, 0x00, 0x33, 0x00, 0x1D,
  0x80, 0x06, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x19, 0x80, 0x0C, 0xE0, 0x06,
  0x38, 0x07, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x38, 0x1C,
  0x1F, 0xF8, 0x0F, 0xF0, 0xC0, 0x07, 0x60, 0x07, 0x30, 0x03, 0x18, 0x03,
  0x0C, 0x03, 0x86, 0x03, 0x83, 0x03, 0x81, 0x83, 0x80, 0xC3, 0x80, 0x61,
  0x80, 0x31, 0x80, 0x19, 0xC0, 0x0D, 0xE0, 0x07, 0xF8, 0x03, 0xCC, 0x01,
  0xC3, 0x00, 0xC1, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0E, 0x0C, 0x03,
  0x86, 0x00, 0xE3, 0x00, 0x31, 0x80, 0x1C, 0xC0, 0x07, 0x60, 0x01, 0xC0,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1B, 0xD8, 0x1B, 0xD8, 0x1B, 0xCC, 0x33, 0xCC, 0x33, 0xCC, 0x63, 0xC6,
  0x63, 0xC6, 0x63, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0xC1,
  0x83, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC, 0x03, 0xC6,
  0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x83, 0xC1, 0x83, 0xC1, 0xC3, 0xC0,
  0xC3, 0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x33, 0xC0, 0x1B, 0xC0,
  0x1B, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0x07, 0x07, 0x00, 0xC3, 0x00, 0x73, 0x80, 0x19, 0x80, 0x0E,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x31, 0x80, 0x18, 0xE0, 0x18, 0x38, 0x1C,
  0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xC0, 0x7C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x7C, 0xFF, 0xF0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xFE, 0x01, 0xC1, 0xE0, 0xE0, 0x18, 0x30, 0x03, 0x18, 0x00, 0xE6, 0x00,
  0x1B, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x9C, 0x00, 0xC3, 0x00,
  0x70, 0x70, 0x38, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0xFF, 0x00, 0xFF, 0xE0, 0xC0, 0xF8, 0xC0,
  0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0xE0, 0xC0,
  0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0,
  0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x98, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x06, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1B, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x67, 0x00,
  0x38, 0xE0, 0x1C, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x0F, 0xE0, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00,
  0xC7, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x0E, 0x01, 0x81, 0x80, 0x60,
  0x60, 0x30, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x38, 0x60, 0x06,
  0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x60,
  0x36, 0x06, 0x03, 0x60, 0x60, 0x66, 0x07, 0x06, 0x60, 0xF0, 0x66, 0x0F,
  0x06, 0x60, 0xF0, 0x66, 0x0D, 0x06, 0x30, 0x98, 0x63, 0x19, 0x84, 0x31,
  0x98, 0xC3, 0x19, 0x8C, 0x31, 0x88, 0xC3, 0x18, 0xCC, 0x31, 0x0C, 0xC1,
  0xB0, 0xCC, 0x1B, 0x0C, 0x81, 0xB0, 0xD8, 0x1B, 0x05, 0x81, 0xA0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xE0, 0x01, 0xD8, 0x00, 0x67, 0x00, 0x38, 0xC0, 0x0C,
  0x18, 0x07, 0x07, 0x01, 0x80, 0xC0, 0xC0, 0x38, 0x70, 0x06, 0x18, 0x00,
  0xCC, 0x00, 0x3B, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0E, 0xC0, 0x03, 0x30, 0x01, 0x86, 0x00, 0xE1, 0xC0, 0x30, 0x30,
  0x1C, 0x06, 0x06, 0x01, 0xC3, 0x00, 0x31, 0xC0, 0x0E, 0x60, 0x01, 0xB8,
  0x00, 0x30, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x07, 0x18, 0x00, 0xC3,
  0x80, 0x38, 0x30, 0x06, 0x07, 0x01, 0xC0, 0x60, 0x30, 0x0E, 0x0E, 0x00,
  0xC1, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x1B, 0x80, 0x03, 0x60, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xFF, 0xF0, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xF0, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0F, 0x00, 0xD8, 0x06, 0x60, 0x23, 0x03, 0x1C, 0x18,
  0x61, 0x83, 0x0C, 0x0C, 0xC0, 0x66, 0x01, 0xF0, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xC3, 0x07, 0x0F, 0xF0, 0x3E, 0xF8, 0x70, 0x1C, 0x60, 0x0E,
  0x60, 0x06, 0x80, 0x06, 0x00, 0x06, 0x00, 0x06, 0x07, 0xFE, 0x3F, 0xFE,
  0x70, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x0E,
  0x60, 0x3E, 0x7F, 0xF6, 0x1F, 0xC7, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xCF, 0xE1, 0xBF,
  0xE3, 0xC0, 0xE7, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xB0,
  0x03, 0x70, 0x0E, 0xF0, 0x39, 0xFF, 0xE3, 0x3F, 0x80, 0x0F, 0xF0, 0x1F,
  0xF8, 0x38, 0x1C, 0x70, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x03, 0x60, 0x06, 0x70, 0x06, 0x38, 0x0C, 0x1F, 0x78, 0x0F, 0xF0, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x0F, 0xE6, 0x3D, 0xEC, 0xE0, 0x7B, 0x80, 0x76, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xD8, 0x01, 0xB8, 0x07, 0x38, 0x1E, 0x3F, 0xEC,
  0x3F, 0x98, 0x07, 0xF0, 0x1F, 0x78, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x03, 0x38, 0x0E,
  0x1F, 0x7C, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x7F, 0xC0, 0x78, 0x40, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x7F,
  0xFF, 0x3F, 0xFF, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xE6, 0x3F, 0xEC, 0xE0, 0x7B, 0x80, 0x76,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xD8, 0x01, 0xB8, 0x07, 0x38, 0x1E,
  0x3F, 0xEC, 0x3F, 0x98, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC8, 0x03, 0x38,
  0x0E, 0x3C, 0x78, 0x3F, 0xE0, 0x04, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE3, 0xF9,
  0xDE, 0xFB, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x18, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x38, 0xFF,
  0x07, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0x80, 0x73, 0x01, 0xC6, 0x07,
  0x0C, 0x1C, 0x18, 0x70, 0x31, 0xC0, 0x67, 0x00, 0xDE, 0x01, 0xFC, 0x03,
  0x8C, 0x06, 0x1C, 0x0C, 0x1C, 0x18, 0x1C, 0x30, 0x1C, 0x60, 0x1C, 0xC0,
  0x19, 0x80, 0x3B, 0x00, 0x38, 0xFF, 0x81, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0xDF, 0x1F, 0x3F, 0xEE,
  0xEE, 0x1E, 0x1F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F,
  0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0,
  0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30,
  0x3C, 0x0C, 0x0C, 0xC7, 0xF9, 0x9E, 0xFB, 0x60, 0x36, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x18, 0x07, 0xF8, 0x0F, 0xBE, 0x06, 0x03, 0x86, 0x00, 0xE7,
  0x00, 0x33, 0x00, 0x1D, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1D, 0xC0, 0x0C, 0x60,
  0x0E, 0x18, 0x0E, 0x07, 0xBE, 0x01, 0xFE, 0x00, 0xC7, 0xF0, 0xDF, 0xF8,
  0xF8, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x0C, 0xF0, 0x1C, 0xFE, 0xF8, 0xE7, 0xF0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x0F, 0xE6, 0x7D, 0xEC, 0xE0, 0x7B, 0x80, 0x76, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xD8, 0x01, 0xB8, 0x07, 0x38, 0x1E, 0x3D, 0xEC, 0x3F, 0x98,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0xC3, 0xFE, 0x7F, 0xF7, 0x01, 0xA0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x1F, 0x7C,
  0x30, 0x0E, 0x60, 0x06, 0x60, 0x07, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x03, 0x60, 0x07, 0x70, 0x0E, 0x3F, 0x7C, 0x0F, 0xF8, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1F, 0xFF, 0xBF, 0xFF, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0,
  0x07, 0x30, 0x1E, 0x7F, 0xEC, 0x3F, 0x98, 0xC0, 0x01, 0xD8, 0x00, 0x66,
  0x00, 0x39, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60,
  0x30, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x06, 0x30,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0xC0, 0x60, 0x3C, 0x06, 0x06, 0x60, 0x60, 0x66, 0x0F, 0x06,
  0x60, 0xF0, 0x66, 0x0B, 0x06, 0x20, 0x90, 0xC3, 0x19, 0x8C, 0x31, 0x98,
  0xC3, 0x11, 0x8C, 0x31, 0x08, 0x81, 0x30, 0xD8, 0x1B, 0x0D, 0x81, 0xA0,
  0xD8, 0x1A, 0x05, 0x80, 0xE0, 0x50, 0x0E, 0x07, 0x00, 0xC0, 0x70, 0x0C,
  0x03, 0x00, 0x60, 0x03, 0x8C, 0x00, 0xC1, 0x80, 0x60, 0x70, 0x38, 0x0E,
  0x1C, 0x01, 0x86, 0x00, 0x33, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x01, 0x86, 0x00, 0xC0, 0xC0,
  0x60, 0x18, 0x38, 0x07, 0x1C, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x00, 0x6C,
  0x00, 0x1D, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x80, 0x18, 0x30, 0x07, 0x07,
  0x00, 0xC0, 0x60, 0x18, 0x0E, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x01,
  0x86, 0x00, 0x31, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x3C, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0xF8, 0x1C, 0x03, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0xE0, 0x1C, 0x07, 0x81, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x38, 0x1E, 0x03,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x03, 0x61, 0xC0, 0x2C, 0x0F, 0x06,
  0xC0, 0x39, 0xCC, 0x01, 0xFC, 0x00, 0x03, 0x00,
};

const GFXglyph RobotoMono_Light36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 3, 26, 22, 9, -26 },
  { 11, 7, 8, 22, 7, -27 },
  { 18, 20, 26, 22, 1, -26 },
  { 83, 16, 34, 22, 3, -30 },
  { 151, 20, 26, 22, 1, -26 },
  { 216, 19, 26, 22, 2, -26 },
  { 278, 2, 8, 22, 9, -27 },
  { 280, 8, 37, 22, 7, -29 },
  { 317, 8, 37, 22, 6, -29 },
  { 354, 16, 16, 22, 3, -26 },
  { 386, 18, 18, 22, 2, -21 },
  { 427, 4, 8, 22, 7, -3 },
  { 431, 13, 1, 22, 4, -12 },
  { 433, 3, 3, 22, 10, -3 },
  { 435, 13, 28, 22, 5, -26 },
  { 481, 16, 26, 22, 3, -26 },
  { 533, 9, 26, 22, 4, -26 },
  { 563, 16, 26, 22, 2, -26 },
  { 615, 16, 26, 22, 2, -26 },
  { 667, 19, 26, 22, 1, -26 },
  { 729, 15, 26, 22, 4, -26 },
  { 778, 16, 26, 22, 3, -26 },
  { 830, 17, 26, 22, 2, -26 },
  { 886, 16, 26, 22, 3, -26 },
  { 938, 16, 26, 22, 3, -26 },
  { 990, 4, 18, 22, 10, -18 },
  { 999, 5, 23, 22, 9, -18 },
  { 1014, 15, 15, 22, 3, -19 },
  { 1043, 16, 9, 22, 3, -16 },
  { 1061, 16, 15, 22, 3, -19 },
  { 1091, 14, 26, 22, 4, -26 },
  { 1137, 20, 26, 22, 1, -26 },
  { 1202, 18, 26, 22, 2, -26 },
  { 1261, 16, 26, 22, 3, -26 },
  { 1313, 17, 26, 22, 2, -26 },
  { 1369, 17, 26, 22, 3, -26 },
  { 1425, 15, 26, 22, 4, -26 },
  { 1474, 15, 26, 22, 4, -26 },
  { 1523, 17, 26, 22, 2, -26 },
  { 1579, 16, 26, 22, 3, -26 },
  { 1631, 15, 26, 22, 3, -26 },
  { 1680, 16, 26, 22, 2, -26 },
  { 1732, 17, 26, 22, 4, -26 },
  { 1788, 15, 26, 22, 4, -26 },
  { 1837, 16, 26, 22, 3, -26 },
  { 1889, 16, 26, 22, 3, -26 },
  { 1941, 17, 26, 22, 2, -26 },
  { 1997, 16, 26, 22, 4, -26 },
  { 2049, 18, 30, 22, 2, -26 },
  { 2117, 16, 26, 22, 4, -26 },
  { 2169, 18, 26, 22, 2, -26 },
  { 2228, 18, 26, 22, 2, -26 },
  { 2287, 16, 26, 22, 3, -26 },
  { 2339, 18, 26, 22, 2, -26 },
  { 2398, 20, 26, 22, 1, -26 },
  { 2463, 18, 26, 22, 2, -26 },
  { 2522, 19, 26, 22, 1, -26 },
  { 2584, 17, 26, 22, 2, -26 },
  { 2640, 6, 34, 22, 8, -29 },
  { 2666, 12, 28, 22, 5, -26 },
  { 2708, 6, 34, 22, 8, -29 },
  { 2734, 13, 14, 22, 4, -26 },
  { 2757, 16, 2, 22, 3, 0 },
  { 2761, 6, 4, 22, 8, -26 },
  { 2764, 16, 19, 22, 3, -19 },
  { 2802, 15, 27, 22, 4, -27 },
  { 2853, 16, 19, 22, 3, -19 },
  { 2891, 15, 27, 22, 3, -27 },
  { 2942, 16, 19, 22, 3, -19 },
  { 2980, 17, 28, 22, 3, -28 },
  { 3040, 15, 27, 22, 3, -19 },
  { 3091, 15, 27, 22, 3, -27 },
  { 3142, 15, 26, 22, 4, -26 },
  { 3191, 12, 34, 22, 3, -26 },
  { 3242, 15, 27, 22, 4, -27 },
  { 3293, 15, 27, 22, 4, -27 },
  { 3344, 18, 19, 22, 2, -19 },
  { 3387, 15, 19, 22, 3, -19 },
  { 3423, 17, 19, 22, 2, -19 },
  { 3464, 16, 26, 22, 3, -19 },
  { 3516, 15, 26, 22, 3, -19 },
  { 3565, 13, 19, 22, 6, -19 },
  { 3596, 16, 19, 22, 3, -19 },
  { 3634, 15, 24, 22, 3, -24 },
  { 3679, 15, 19, 22, 3, -19 },
  { 3715, 18, 19, 22, 2, -19 },
  { 3758, 20, 19, 22, 1, -19 },
  { 3806, 18, 19, 22, 2, -19 },
  { 3849, 19, 27, 22, 1, -19 },
  { 3914, 16, 19, 22, 3, -19 },
  { 3952, 11, 35, 22, 6, -28 },
  { 4001, 2, 32, 22, 10, -26 },
  { 4009, 11, 35, 22, 6, -28 },
  { 4058, 20, 7, 22, 1, -14 },
};

const GFXfont RobotoMono_Light36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light36pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_LIGHT36PT7B_H_
