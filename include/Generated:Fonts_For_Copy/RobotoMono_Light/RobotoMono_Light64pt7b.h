#ifndef _ROBOTOMONO_LIGHT64PT7B_H_
#define _ROBOTOMONO_LIGHT64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light64pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xBF, 0xFF, 0xBC, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x30, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x07,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x38, 0x00, 0x70, 0x07, 0x07, 0x80, 0x07,
  0x80, 0xE0, 0x70, 0x00, 0x38, 0x1E, 0x0F, 0x00, 0x03, 0xE3, 0xC0, 0xE0,
  0x00, 0x1F, 0xF8, 0x1C, 0x00, 0x00, 0x7F, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x03,
  0x83, 0xFF, 0xC0, 0x00, 0x70, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x70, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0xE0,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x78,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x40, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x03, 0xC3, 0xC0, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x00, 0xE3,
  0xE0, 0x0F, 0x80, 0x71, 0xE0, 0x03, 0xE0, 0x78, 0xF0, 0x00, 0xF8, 0x3C,
  0xF0, 0x00, 0x3C, 0x1E, 0x78, 0x00, 0x0F, 0x0E, 0x3C, 0x00, 0x07, 0xCF,
  0x1E, 0x00, 0x01, 0xF7, 0x0F, 0x00, 0x00, 0x7F, 0x83, 0x80, 0x00, 0x1F,
  0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x07,
  0xF8, 0x1F, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x0F, 0xCF, 0x01, 0xFF, 0xFF,
  0xC3, 0xC0, 0x7F, 0xFF, 0x81, 0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0x00, 0x04, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x08, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x70, 0x06, 0xFC, 0x07, 0x01, 0xFF, 0xF0, 0x70, 0xFF, 0xFF,
  0xE7, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x78,
  0xF3, 0xC7, 0x9E, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0xFE, 0xF0,
  0x00, 0x0F, 0x7F, 0x80, 0x00, 0xF3, 0xFC, 0x00, 0x0F, 0x1F, 0xE0, 0x00,
  0xF0, 0xFF, 0x00, 0x1F, 0x07, 0xF8, 0x01, 0xF0, 0x3F, 0xC0, 0x1F, 0x01,
  0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0x1E, 0x00, 0x7F, 0x81, 0xE0, 0x03, 0xFC,
  0x1E, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0xFF, 0x1E, 0x00, 0x07, 0xFB, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0xFC, 0x00, 0x00,
  0x77, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0xFF,
  0x03, 0xFF, 0x0F, 0xFF, 0x7F, 0xCF, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x0F, 0xF8,
  0x00, 0xEF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFC,
  0x01, 0xFE, 0x1E, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x7F, 0x87,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x0F, 0xC0, 0x07, 0x07, 0xFF, 0x80, 0xF1, 0xFF, 0xFC, 0x0F, 0x3F, 0x9F,
  0xF0, 0xF7, 0x80, 0x1F, 0x0F, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xF1,
  0xE0, 0x00, 0xFF, 0x1F, 0x80, 0x1E, 0xF0, 0xFE, 0x0F, 0xCF, 0x07, 0xFF,
  0xF8, 0xF0, 0x1F, 0xFE, 0x0E, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x73, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0x78, 0x0E, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0xF0, 0xF0,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03,
  0xF8, 0x3F, 0x83, 0xE0, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x78, 0x03,
  0xF8, 0x0E, 0x0E, 0x01, 0xFF, 0x80, 0xC3, 0x80, 0x7E, 0xF8, 0x1C, 0x70,
  0x1E, 0x07, 0x03, 0x8E, 0x03, 0x80, 0xE0, 0x73, 0x80, 0xE0, 0x1C, 0x06,
  0x70, 0x1C, 0x03, 0x80, 0xCE, 0x07, 0x00, 0x70, 0x19, 0x80, 0xE0, 0x0C,
  0x03, 0x70, 0x18, 0x01, 0x80, 0x6E, 0x07, 0x00, 0x30, 0x0D, 0xC0, 0xE0,
  0x06, 0x01, 0xB8, 0x1C, 0x00, 0xC0, 0x37, 0x03, 0x80, 0x38, 0x06, 0xE0,
  0x70, 0x07, 0x00, 0xDC, 0x0C, 0x00, 0xE0, 0x1B, 0x81, 0x80, 0x1C, 0x07,
  0x70, 0x38, 0x03, 0x80, 0xEE, 0x07, 0x00, 0xF0, 0x1D, 0xC0, 0xE0, 0x1C,
  0x03, 0x38, 0x1C, 0x07, 0xC0, 0xE7, 0x03, 0x80, 0xF8, 0x1C, 0xE0, 0x38,
  0x3F, 0x07, 0x0E, 0x07, 0x9E, 0x71, 0xC1, 0xC0, 0x7F, 0x8F, 0xF8, 0x38,
  0x0F, 0xE0, 0xFE, 0x03, 0x80, 0x20, 0x03, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3C, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x7F, 0x07, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x1F, 0xC0,
  0x70, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x7C, 0x1C, 0x00, 0x01, 0xF0, 0xE0,
  0x00, 0x07, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3F, 0x07, 0x00,
  0x03, 0xF0, 0x38, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x01, 0xC7, 0xC0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x3C,
  0xFF, 0x00, 0x00, 0x7B, 0xFF, 0x00, 0x00, 0xFF, 0x9E, 0x00, 0x01, 0xFE,
  0x3E, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0x7F, 0xB8, 0x00, 0x3B, 0xFD, 0xE0, 0x03,
  0xDF, 0xEF, 0x00, 0x1C, 0xFF, 0x38, 0x01, 0xE7, 0xF9, 0xE0, 0x0F, 0x3F,
  0xC7, 0x00, 0x71, 0xFE, 0x38, 0x07, 0x8F, 0xF1, 0xE0, 0x38, 0x7F, 0x87,
  0x03, 0xC3, 0xFC, 0x38, 0x1E, 0x1F, 0xE1, 0xE0, 0xE0, 0xFF, 0x07, 0x0F,
  0x07, 0xF8, 0x3C, 0x70, 0x3F, 0xC1, 0xE3, 0x81, 0xFE, 0x07, 0x3C, 0x0F,
  0xF0, 0x3D, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x3C,
  0x01, 0xFE, 0x00, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x7F, 0x3C,
  0x00, 0x07, 0xF3, 0xC0, 0x00, 0x7F, 0x1E, 0x00, 0x07, 0xF1, 0xE0, 0x00,
  0x7F, 0x0F, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x7F, 0x07, 0x80, 0x07, 0xF0,
  0x3C, 0x00, 0x7F, 0x03, 0xC0, 0x07, 0xF0, 0x1E, 0x00, 0x7F, 0x01, 0xE0,
  0x07, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x7F,
  0x00, 0x78, 0x07, 0xF0, 0x03, 0xC0, 0x7F, 0x00, 0x1E, 0x07, 0xF0, 0x01,
  0xE0, 0x7F, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0xF0, 0x7F, 0x00, 0x07, 0x87,
  0xF0, 0x00, 0x78, 0x7F, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x3C, 0x7F, 0x00,
  0x01, 0xE7, 0xF0, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x3F, 0x8F, 0x00, 0x00,
  0xFC, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F,
  0x8F, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0x00, 0x03, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0xFC, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0xFE, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0E, 0xF0, 0x03, 0xE0,
  0x03, 0xBC, 0x00, 0xF8, 0x00, 0xEF, 0x00, 0x3F, 0x00, 0x39, 0xC0, 0x0F,
  0xC0, 0x1E, 0x70, 0x03, 0xF0, 0x07, 0x9C, 0x01, 0xFC, 0x01, 0xE7, 0x80,
  0x77, 0x00, 0x71, 0xE0, 0x1D, 0xC0, 0x1C, 0x78, 0x07, 0x38, 0x07, 0x1E,
  0x01, 0xCE, 0x01, 0xC3, 0x80, 0xF3, 0x80, 0xF0, 0xE0, 0x38, 0xE0, 0x3C,
  0x38, 0x0E, 0x38, 0x0F, 0x0F, 0x03, 0x8F, 0x03, 0x83, 0xC0, 0xE1, 0xC0,
  0xE0, 0xF0, 0x38, 0x70, 0x38, 0x3C, 0x1E, 0x1C, 0x0E, 0x07, 0x07, 0x07,
  0x07, 0x81, 0xC1, 0xC1, 0xE1, 0xE0, 0x70, 0x70, 0x38, 0x78, 0x1C, 0x1C,
  0x0E, 0x1C, 0x07, 0x8F, 0x03, 0x87, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0x78,
  0xE0, 0x38, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x00,
  0xE7, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0F, 0x70, 0x07, 0x38,
  0x03, 0xDC, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03,
  0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7B, 0x80, 0x00, 0xE7, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x8E, 0x00,
  0x0E, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0xF0,
  0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x1E, 0x1F, 0x80, 0x01, 0xE3, 0xE0,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x7E, 0x78, 0x00, 0x0F, 0xE7, 0xC0, 0x01,
  0xEE, 0x3F, 0x00, 0x7C, 0xF1, 0xFF, 0xFF, 0x8F, 0x0F, 0xFF, 0xF0, 0xF0,
  0x3F, 0xFC, 0x0F, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x7F, 0xE0, 0x0F,
  0x1F, 0xFF, 0x80, 0xF3, 0xFF, 0xFC, 0x0F, 0x7C, 0x07, 0xE0, 0xFF, 0x00,
  0x1F, 0x0F, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x78, 0xFC, 0x00,
  0x0F, 0x8F, 0xF0, 0x01, 0xF0, 0xF7, 0x80, 0x7E, 0x0F, 0x3F, 0xFF, 0xC0,
  0xF1, 0xFF, 0xF8, 0x0F, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7E, 0x01,
  0xF8, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xE3, 0xE0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x3F, 0xF0, 0x78, 0x0F, 0xFF, 0x8F, 0x07, 0xFF, 0xF9, 0xE1,
  0xF8, 0x07, 0xBC, 0x7E, 0x00, 0x3F, 0x8F, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7C,
  0x78, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xF0, 0xFC, 0x03, 0xEE, 0x0F, 0xFF,
  0xF9, 0xC0, 0xFF, 0xFE, 0x38, 0x07, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xC1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x70, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xE0, 0x3F, 0xFE, 0x1C,
  0x1F, 0xFF, 0xF3, 0x87, 0xE0, 0x1E, 0x71, 0xF8, 0x00, 0xEE, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xC3, 0xF0,
  0x0F, 0xF8, 0x3F, 0xFF, 0xEF, 0x03, 0xFF, 0xF9, 0xE0, 0x1F, 0xFC, 0x3C,
  0x00, 0x30, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x80, 0x00, 0x1E, 0x18, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0xFC, 0x07, 0x83,
  0xFF, 0xE0, 0xF1, 0xFF, 0xFE, 0x1E, 0x7C, 0x07, 0xE3, 0xDE, 0x00, 0x3E,
  0x7B, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3D, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x0F, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xC0, 0x00,
  0xFE, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0x73, 0xFF, 0x8F, 0xFE, 0x3B, 0xFF,
  0xEF, 0xFF, 0x9D, 0xC1, 0xF7, 0x03, 0xEF, 0x80, 0x7F, 0x00, 0xF7, 0x80,
  0x1F, 0x00, 0x3B, 0xC0, 0x0F, 0x00, 0x1F, 0xE0, 0x07, 0x80, 0x0F, 0xE0,
  0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xFC,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x07,
  0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x78, 0x00,
  0xFE, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x0F, 0x00,
  0x1F, 0xC0, 0x07, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0,
  0x03, 0xF8, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x7F, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x07,
  0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xF0,
  0x3F, 0xF0, 0x1E, 0x1F, 0xFF, 0x83, 0xC7, 0xFF, 0xF8, 0x79, 0xF0, 0x1F,
  0x8F, 0x78, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0xF7, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x7F, 0xE0, 0x1E, 0x3F, 0xFF,
  0x03, 0xCF, 0xFF, 0xF0, 0x7B, 0xE0, 0x3F, 0x0F, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x7C, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x3E, 0x3F,
  0xE0, 0x1F, 0x87, 0xBF, 0xFF, 0xE0, 0xF1, 0xFF, 0xF8, 0x1E, 0x0F, 0xFC,
  0x03, 0xC0, 0x18, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0xE0, 0x3F, 0xFE, 0x1C, 0x1F, 0xFF, 0xF3, 0x87, 0xE0, 0x1F, 0x71, 0xF8,
  0x00, 0xEE, 0x3C, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0xC3, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xEF, 0x03, 0xFF, 0xF9,
  0xE0, 0x1F, 0xFC, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFB, 0xC3, 0xFF, 0xF7, 0x8F, 0xE0, 0x6F,
  0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x3C, 0x00,
  0x0F, 0xCF, 0x80, 0x07, 0x71, 0xF0, 0x07, 0x9C, 0x3F, 0xFF, 0xE7, 0x07,
  0xFF, 0xE1, 0xC0, 0xFF, 0xF0, 0x70, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x03,
  0x80, 0x07, 0x38, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x00, 0x1C, 0xF0,
  0x03, 0xE0, 0x07, 0x9E, 0x00, 0x6C, 0x00, 0xE1, 0xC0, 0x1D, 0xC0, 0x1C,
  0x38, 0x03, 0xB8, 0x03, 0x87, 0x00, 0x77, 0x00, 0x70, 0xF0, 0x1C, 0xE0,
  0x1E, 0x1E, 0x03, 0x8E, 0x03, 0x81, 0xC0, 0x71, 0xC0, 0x70, 0x38, 0x0E,
  0x38, 0x0E, 0x07, 0x01, 0x87, 0x01, 0xC0, 0xF0, 0x70, 0x70, 0x70, 0x0E,
  0x0E, 0x0E, 0x0E, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0x38, 0x70, 0x38, 0x38,
  0x07, 0x0E, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x71, 0xC0, 0x0E, 0x38, 0x0E,
  0x38, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x07, 0x38,
  0x03, 0x9C, 0x00, 0x77, 0x00, 0x77, 0x00, 0x0E, 0xC0, 0x0E, 0xE0, 0x01,
  0xF8, 0x00, 0xDC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x14,
  0x7F, 0xF8, 0x00, 0x07, 0x1F, 0xFF, 0xC0, 0x00, 0xE7, 0xC0, 0xFC, 0x00,
  0x1C, 0xF0, 0x07, 0xC0, 0x07, 0x9C, 0x00, 0x7C, 0x00, 0xE7, 0x00, 0x07,
  0xE0, 0x3C, 0xE0, 0x00, 0x7F, 0xFF, 0x1C, 0x00, 0x03, 0xFF, 0xC1, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_Light64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 5, 46, 38, 16, -46 },
  { 30, 12, 14, 38, 13, -48 },
  { 51, 35, 46, 38, 2, -46 },
  { 253, 28, 59, 38, 6, -52 },
  { 460, 36, 47, 38, 1, -46 },
  { 672, 33, 47, 38, 4, -46 },
  { 866, 4, 14, 38, 16, -48 },
  { 873, 15, 66, 38, 12, -51 },
  { 997, 15, 66, 38, 11, -51 },
  { 1121, 28, 28, 38, 6, -46 },
  { 1219, 31, 33, 38, 4, -38 },
  { 1347, 7, 15, 38, 12, -6 },
  { 1361, 24, 3, 38, 7, -22 },
  { 1370, 6, 6, 38, 17, -6 },
  { 1375, 22, 50, 38, 9, -46 },
  { 1513, 29, 47, 38, 5, -46 },
  { 1684, 16, 46, 38, 7, -46 },
  { 1776, 30, 46, 38, 3, -46 },
  { 1949, 29, 47, 38, 3, -46 },
  { 2120, 32, 46, 38, 3, -46 },
  { 2304, 27, 47, 38, 7, -46 },
  { 2463, 28, 47, 38, 5, -46 },
  { 2628, 30, 46, 38, 4, -46 },
  { 2801, 29, 47, 38, 6, -46 },
  { 2972, 28, 46, 38, 5, -46 },
  { 3133, 6, 33, 38, 19, -33 },
  { 3158, 9, 42, 38, 16, -33 },
  { 3206, 27, 27, 38, 5, -34 },
  { 3298, 28, 16, 38, 5, -29 },
  { 3354, 27, 27, 38, 6, -34 },
  { 3446, 25, 46, 38, 7, -46 },
  { 3590, 35, 46, 38, 2, -46 },
  { 3792, 33, 46, 38, 3, -46 },
  { 3982, 29, 46, 38, 6, -46 },
  { 4149, 30, 47, 38, 4, -46 },
  { 4326, 29, 46, 38, 6, -46 },
  { 4493, 27, 46, 38, 6, -46 },
  { 4649, 26, 46, 38, 7, -46 },
  { 4799, 30, 47, 38, 4, -46 },
  { 4976, 28, 46, 38, 5, -46 },
  { 5137, 26, 46, 38, 6, -46 },
  { 5287, 29, 47, 38, 3, -46 },
  { 5458, 31, 46, 38, 6, -46 },
  { 5637, 27, 46, 38, 7, -46 },
  { 5793, 29, 46, 38, 5, -46 },
  { 5960, 28, 46, 38, 5, -46 },
  { 6121, 31, 47, 38, 4, -46 },
  { 6304, 28, 46, 38, 7, -46 },
  { 6465, 32, 54, 38, 3, -46 },
  { 6681, 29, 46, 38, 6, -46 },
  { 6848, 31, 47, 38, 4, -46 },
  { 7031, 33, 46, 38, 3, -46 },
  { 7221, 29, 47, 38, 5, -46 },
  { 7392, 32, 46, 38, 3, -46 },
  { 7576, 34, 46, 38, 3, -46 },
  { 7772, 33, 46, 38, 3, -46 },
  { 7962, 33, 46, 38, 2, -46 },
  { 8152, 29, 46, 38, 4, -46 },
  { 8319, 11, 62, 38, 14, -52 },
  { 8405, 23, 50, 38, 8, -46 },
  { 8549, 11, 62, 38, 13, -52 },
  { 8635, 23, 25, 38, 8, -46 },
  { 8707, 28, 3, 38, 5, 0 },
  { 8718, 10, 8, 38, 14, -47 },
  { 8728, 28, 35, 38, 5, -34 },
  { 8851, 28, 49, 38, 6, -48 },
  { 9023, 28, 35, 38, 5, -34 },
  { 9146, 27, 49, 38, 5, -48 },
  { 9312, 29, 35, 38, 5, -34 },
  { 9439, 29, 49, 38, 6, -49 },
  { 9617, 27, 47, 38, 5, -34 },
  { 9776, 27, 48, 38, 6, -48 },
  { 9938, 27, 46, 38, 7, -46 },
  { 10094, 20, 60, 38, 6, -46 },
  { 10244, 28, 48, 38, 7, -48 },
  { 10412, 27, 48, 38, 7, -48 },
  { 10574, 33, 34, 38, 3, -34 },
  { 10715, 27, 34, 38, 6, -34 },
  { 10830, 30, 35, 38, 4, -34 },
  { 10962, 27, 47, 38, 6, -34 },
  { 11121, 27, 47, 38, 5, -34 },
  { 11280, 23, 34, 38, 11, -34 },
  { 11378, 27, 35, 38, 6, -34 },
  { 11497, 27, 43, 38, 5, -42 },
  { 11643, 26, 35, 38, 6, -34 },
  { 11757, 32, 34, 38, 3, -34 },
  { 11893, 35, 34, 38, 2, -34 },
  { 12042, 31, 34, 38, 4, -34 },
  { 12174, 34, 48, 38, 2, -34 },
  { 12378, 29, 34, 38, 5, -34 },
  { 12502, 21, 63, 38, 10, -50 },
  { 12668, 3, 56, 38, 18, -46 },
  { 12689, 21, 63, 38, 10, -50 },
  { 12855, 35, 12, 38, 2, -25 },
};

const GFXfont RobotoMono_Light64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light64pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_LIGHT64PT7B_H_
