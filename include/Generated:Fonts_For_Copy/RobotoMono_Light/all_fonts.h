#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoMono_Light
// Headers: 67

#include "RobotoMono_Light6pt7b.h"
#include "RobotoMono_Light7pt7b.h"
#include "RobotoMono_Light8pt7b.h"
#include "RobotoMono_Light9pt7b.h"
#include "RobotoMono_Light10pt7b.h"
#include "RobotoMono_Light11pt7b.h"
#include "RobotoMono_Light12pt7b.h"
#include "RobotoMono_Light13pt7b.h"
#include "RobotoMono_Light14pt7b.h"
#include "RobotoMono_Light15pt7b.h"
#include "RobotoMono_Light16pt7b.h"
#include "RobotoMono_Light17pt7b.h"
#include "RobotoMono_Light18pt7b.h"
#include "RobotoMono_Light19pt7b.h"
#include "RobotoMono_Light20pt7b.h"
#include "RobotoMono_Light21pt7b.h"
#include "RobotoMono_Light22pt7b.h"
#include "RobotoMono_Light23pt7b.h"
#include "RobotoMono_Light24pt7b.h"
#include "RobotoMono_Light25pt7b.h"
#include "RobotoMono_Light26pt7b.h"
#include "RobotoMono_Light27pt7b.h"
#include "RobotoMono_Light28pt7b.h"
#include "RobotoMono_Light29pt7b.h"
#include "RobotoMono_Light30pt7b.h"
#include "RobotoMono_Light31pt7b.h"
#include "RobotoMono_Light32pt7b.h"
#include "RobotoMono_Light33pt7b.h"
#include "RobotoMono_Light34pt7b.h"
#include "RobotoMono_Light35pt7b.h"
#include "RobotoMono_Light36pt7b.h"
#include "RobotoMono_Light37pt7b.h"
#include "RobotoMono_Light38pt7b.h"
#include "RobotoMono_Light39pt7b.h"
#include "RobotoMono_Light40pt7b.h"
#include "RobotoMono_Light41pt7b.h"
#include "RobotoMono_Light42pt7b.h"
#include "RobotoMono_Light43pt7b.h"
#include "RobotoMono_Light44pt7b.h"
#include "RobotoMono_Light45pt7b.h"
#include "RobotoMono_Light46pt7b.h"
#include "RobotoMono_Light47pt7b.h"
#include "RobotoMono_Light48pt7b.h"
#include "RobotoMono_Light49pt7b.h"
#include "RobotoMono_Light50pt7b.h"
#include "RobotoMono_Light51pt7b.h"
#include "RobotoMono_Light52pt7b.h"
#include "RobotoMono_Light53pt7b.h"
#include "RobotoMono_Light54pt7b.h"
#include "RobotoMono_Light55pt7b.h"
#include "RobotoMono_Light56pt7b.h"
#include "RobotoMono_Light57pt7b.h"
#include "RobotoMono_Light58pt7b.h"
#include "RobotoMono_Light59pt7b.h"
#include "RobotoMono_Light60pt7b.h"
#include "RobotoMono_Light61pt7b.h"
#include "RobotoMono_Light62pt7b.h"
#include "RobotoMono_Light63pt7b.h"
#include "RobotoMono_Light64pt7b.h"
#include "RobotoMono_Light65pt7b.h"
#include "RobotoMono_Light66pt7b.h"
#include "RobotoMono_Light67pt7b.h"
#include "RobotoMono_Light68pt7b.h"
#include "RobotoMono_Light69pt7b.h"
#include "RobotoMono_Light70pt7b.h"
#include "RobotoMono_Light71pt7b.h"
#include "RobotoMono_Light72pt7b.h"
