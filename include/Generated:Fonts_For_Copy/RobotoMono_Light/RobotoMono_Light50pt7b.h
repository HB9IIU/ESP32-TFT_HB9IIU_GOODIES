#ifndef _ROBOTOMONO_LIGHT50PT7B_H_
#define _ROBOTOMONO_LIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light50pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xE0, 0x00, 0x00, 0x00, 0x6F, 0xFE, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1C, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x03,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x06, 0x01, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0x00, 0xF0, 0x70, 0x01, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xDE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xF8, 0x01, 0xE1,
  0xF8, 0x3F, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00,
  0xE0, 0x30, 0x08, 0x0E, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x1C, 0x0C, 0x03,
  0x01, 0x80, 0xC0, 0x30, 0x38, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0x30, 0x70,
  0x0E, 0x03, 0x0E, 0x00, 0x70, 0x70, 0xC0, 0x07, 0x8E, 0x1C, 0x00, 0x3F,
  0xC1, 0x80, 0x00, 0xF8, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0xC3, 0xF8, 0x00, 0x38, 0x7F, 0xC0, 0x03, 0x0E, 0x0E, 0x00, 0x70,
  0xC0, 0x60, 0x06, 0x0C, 0x07, 0x00, 0xE0, 0xC0, 0x70, 0x0C, 0x1C, 0x07,
  0x01, 0xC1, 0xC0, 0x70, 0x18, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x10,
  0x0C, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x0F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0x3C, 0x03, 0x8F, 0x07, 0x00, 0xE3, 0x80, 0xE0, 0x39, 0xC0,
  0x1C, 0x0C, 0x70, 0x07, 0x87, 0x38, 0x00, 0xF1, 0xCE, 0x00, 0x1C, 0x73,
  0x80, 0x03, 0xB8, 0xE0, 0x00, 0xFE, 0x1C, 0x00, 0x1F, 0x07, 0x00, 0x03,
  0xC1, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0xFE, 0x07, 0xC0, 0xFB, 0xC0, 0xFF,
  0xF8, 0x78, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x07, 0x00,
  0xF0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x38, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x0C, 0x06, 0x7C, 0x18, 0x3D, 0xFE, 0x33, 0xFC, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0xE3, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x1C, 0x07,
  0x00, 0x78, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0x80, 0x08, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0xF3, 0x8E, 0x39, 0xC7, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFE, 0xFC, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x00,
  0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0x7E, 0x00, 0x39, 0xF8,
  0x01, 0xC7, 0xE0, 0x1E, 0x1F, 0x80, 0xF0, 0x7E, 0x07, 0x81, 0xF8, 0x3C,
  0x07, 0xE1, 0xC0, 0x1F, 0x8E, 0x00, 0x7E, 0x70, 0x01, 0xFB, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x3C, 0x0F, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x01,
  0xC0, 0x3E, 0x0F, 0xF1, 0xFF, 0xBF, 0x1F, 0xE0, 0xF8, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF0, 0x0F, 0x83, 0xC0, 0x07, 0x07, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x0F,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x77, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x1E, 0x00, 0x78, 0x3F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE3, 0xF0, 0x03, 0x7F, 0xF0, 0x0F, 0xFF,
  0xF0, 0x7E, 0x0F, 0xE1, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x39, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x8E, 0x00, 0x3C, 0x3E, 0x03, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x87, 0xFC, 0x0E, 0x7F,
  0xF8, 0x3B, 0xE1, 0xF0, 0xFC, 0x01, 0xE3, 0xE0, 0x03, 0xCF, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0E, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x0E, 0x00, 0x3C,
  0x1E, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x07, 0x81, 0xC0, 0x07, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x07, 0x80, 0x78, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7C, 0x0F, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0x80, 0xF8, 0x3C, 0x00, 0xE1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0xCE, 0x00, 0x3F, 0x3C, 0x01,
  0xDC, 0x7C, 0x3E, 0x70, 0xFF, 0xF1, 0x80, 0xFF, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x67, 0xBF, 0xEF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0xDF, 0xF7, 0x80, 0x10,
  0xF7, 0xCF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x39, 0xC7, 0x38, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xC0, 0x3C, 0x38, 0x01,
  0xE7, 0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x80,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x1C, 0x0F,
  0xE0, 0xC1, 0x81, 0xFF, 0x06, 0x30, 0x38, 0x30, 0x63, 0x03, 0x03, 0x06,
  0x30, 0x60, 0x30, 0x66, 0x06, 0x03, 0x06, 0x60, 0xE0, 0x30, 0x66, 0x0C,
  0x03, 0x06, 0x60, 0xC0, 0x60, 0x66, 0x0C, 0x06, 0x06, 0x61, 0xC0, 0x60,
  0x66, 0x1C, 0x06, 0x06, 0xE1, 0xC0, 0x60, 0x6E, 0x1C, 0x06, 0x06, 0x61,
  0xC0, 0xE0, 0x66, 0x0C, 0x0E, 0x0C, 0x60, 0xC1, 0xE0, 0xC6, 0x0E, 0x3E,
  0x1C, 0x60, 0xFF, 0x3B, 0x87, 0x07, 0xE3, 0xF0, 0x30, 0x18, 0x0C, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x08, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x06, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x38, 0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x38, 0x00, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x1C, 0xE0, 0x01, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x0E, 0x00, 0x78, 0x07, 0x81, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0x00, 0x7E, 0x0E,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C,
  0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00, 0xF0, 0xE0, 0x03, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x3C, 0x00, 0x07, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x1C, 0x3C, 0x01, 0xE0, 0x7C, 0x1F,
  0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00,
  0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0xE7, 0xC0, 0x00,
  0xEF, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x38, 0x00,
  0xF0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xBF, 0xC0, 0x0E,
  0xFB, 0x00, 0x3B, 0xEE, 0x00, 0xCF, 0xB8, 0x07, 0x3E, 0x60, 0x1C, 0xF9,
  0xC0, 0xE3, 0xE7, 0x03, 0x8F, 0x8E, 0x0C, 0x3E, 0x38, 0x70, 0xF8, 0xE1,
  0xC3, 0xE1, 0xC6, 0x0F, 0x87, 0x38, 0x3E, 0x0C, 0xE0, 0xF8, 0x3F, 0x03,
  0xE0, 0xFC, 0x0F, 0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xE0,
  0x30, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFB, 0x80, 0x07, 0xEE, 0x00, 0x1F, 0x9C, 0x00, 0x7E,
  0x70, 0x01, 0xF8, 0xE0, 0x07, 0xE3, 0x80, 0x1F, 0x87, 0x00, 0x7E, 0x1E,
  0x01, 0xF8, 0x38, 0x07, 0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x03, 0x81,
  0xF8, 0x0E, 0x07, 0xE0, 0x1C, 0x1F, 0x80, 0x70, 0x7E, 0x00, 0xE1, 0xF8,
  0x03, 0x87, 0xE0, 0x07, 0x1F, 0x80, 0x1E, 0x7E, 0x00, 0x39, 0xF8, 0x00,
  0x77, 0xE0, 0x01, 0xDF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x0F,
  0x00, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0x00, 0x0F, 0x8E, 0x00,
  0x07, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x39,
  0xC0, 0x01, 0xE3, 0x80, 0x0F, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x70, 0x0F,
  0x00, 0x78, 0x07, 0xE1, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E,
  0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x80,
  0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0F,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x0F, 0xC0, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x80,
  0x07, 0x8E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x7C, 0x0F, 0x80, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0x70, 0x07,
  0x00, 0x66, 0x01, 0xE0, 0x1C, 0xE0, 0x3E, 0x03, 0x9C, 0x07, 0xC0, 0x73,
  0x80, 0xD8, 0x0E, 0x70, 0x1B, 0x01, 0xCE, 0x07, 0x60, 0x31, 0xC0, 0xEE,
  0x06, 0x18, 0x1D, 0xC0, 0xC3, 0x03, 0x18, 0x38, 0x70, 0x63, 0x07, 0x0E,
  0x1C, 0x60, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0C, 0x38,
  0x60, 0x61, 0x83, 0x0C, 0x0C, 0x30, 0x63, 0x81, 0xCE, 0x0E, 0x70, 0x39,
  0xC1, 0xCE, 0x07, 0x38, 0x39, 0xC0, 0xE6, 0x03, 0x38, 0x1C, 0xC0, 0x66,
  0x01, 0xB8, 0x0C, 0xC0, 0x37, 0x01, 0xD8, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xC7,
  0x00, 0x01, 0xC3, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x78,
  0x00, 0x38, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xF0, 0x01,
  0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x01, 0xC0,
  0x70, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07,
  0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x06, 0x18, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x06, 0x01, 0x83, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x03, 0x9C,
  0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFE, 0x07, 0x80, 0x78, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF0, 0x03,
  0x8E, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xE7, 0x00, 0x0F, 0x9E, 0x00,
  0x7E, 0x3E, 0x0F, 0xB8, 0x7F, 0xFC, 0x70, 0xFF, 0xC1, 0xC0, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC1, 0xF8, 0x0E, 0x3F, 0xF0, 0x77, 0xFF, 0xC3, 0xF8,
  0x0F, 0x1F, 0x00, 0x3C, 0xF0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0x3F, 0x00, 0x79, 0xFE, 0x0F, 0x8E, 0x7F, 0xF8, 0x71,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0,
  0x7C, 0x3C, 0x00, 0x70, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x07,
  0x70, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0x03, 0xE0, 0x1F,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xF0,
  0x70, 0x7F, 0xE3, 0x87, 0xFF, 0xDC, 0x78, 0x0F, 0xE7, 0x80, 0x1F, 0x38,
  0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x07, 0x78, 0x00, 0x39, 0xC0, 0x03, 0xC7, 0x00,
  0x3E, 0x3E, 0x0F, 0xF0, 0xFF, 0xF3, 0x81, 0xFF, 0x1C, 0x00, 0x7E, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xC0, 0x78, 0x1C, 0x00, 0x70, 0xE0,
  0x01, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x43, 0xC0, 0x01,
  0xC7, 0x80, 0x0E, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x18, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF1, 0xC3, 0xFF, 0xEE, 0x3C, 0x07,
  0xF3, 0xC0, 0x0F, 0x9C, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xBC, 0x00, 0x1C,
  0xE0, 0x01, 0xE3, 0x80, 0x1F, 0x1F, 0x03, 0xF8, 0x7F, 0xFD, 0xC0, 0xFF,
  0x8E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE4,
  0x00, 0x0E, 0x30, 0x00, 0xF3, 0xC0, 0x0F, 0x07, 0x81, 0xF0, 0x1F, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0xFC, 0x0E, 0x1F, 0xF8, 0x73, 0xFF, 0xE3, 0xB8, 0x07, 0x9F, 0x80, 0x1E,
  0xF8, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x8F,
  0xFE, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x02, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8E, 0x00, 0x3C, 0x38,
  0x01, 0xE0, 0xE0, 0x0F, 0x03, 0x80, 0x78, 0x0E, 0x03, 0x80, 0x38, 0x1C,
  0x00, 0xE1, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x3B, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xF3, 0x80, 0x0F, 0x87, 0x00, 0x3C, 0x1E, 0x00, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0xE0, 0x03,
  0x83, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x7B,
  0x80, 0x00, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x7C, 0x3B, 0xFE, 0x3F, 0xCE, 0xFF, 0x9F, 0xFB, 0xE0, 0xFC,
  0x0E, 0xF0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x00, 0xC0, 0x1F, 0x80,
  0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00, 0xC0, 0x1F,
  0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00, 0xC0,
  0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00,
  0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E,
  0x00, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00,
  0x7E, 0x00, 0xC0, 0x1C, 0x00, 0x7E, 0x06, 0x1F, 0xFC, 0x31, 0xFF, 0xF1,
  0xDC, 0x03, 0xCF, 0xC0, 0x0E, 0x7C, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0xFC, 0x07, 0x3F, 0xF8, 0x3B, 0xFF, 0xE1, 0xF8, 0x07, 0x8F, 0x80,
  0x1E, 0x78, 0x00, 0x73, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0xC0, 0x03,
  0x9F, 0x00, 0x78, 0xFE, 0x07, 0xC7, 0x7F, 0xFC, 0x38, 0xFF, 0x81, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF9, 0xC3, 0xFF, 0xEE, 0x3C, 0x03,
  0xF3, 0xC0, 0x0F, 0x9C, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xBC, 0x00, 0x1C,
  0xE0, 0x01, 0xE3, 0x80, 0x1F, 0x1F, 0x03, 0xF8, 0x7F, 0xFD, 0xC0, 0xFF,
  0x8E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xF8, 0xFF, 0xFD, 0xF0,
  0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x78, 0x03,
  0xC7, 0x80, 0x0F, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x3E, 0x03, 0xE0, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x20, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78,
  0x03, 0xF3, 0xE0, 0xF3, 0x1F, 0xFE, 0x30, 0xFF, 0xC3, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC3, 0x80,
  0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x01, 0xC0, 0x1B, 0x80, 0x78,
  0x03, 0x70, 0x0F, 0x00, 0xE6, 0x01, 0xE0, 0x1C, 0xC0, 0x3E, 0x03, 0x9C,
  0x0E, 0xC0, 0x63, 0x81, 0x98, 0x0C, 0x70, 0x33, 0x03, 0x86, 0x06, 0x70,
  0x70, 0xC1, 0xC6, 0x0C, 0x1C, 0x30, 0xC1, 0x83, 0x86, 0x18, 0x30, 0x30,
  0xC3, 0x8E, 0x06, 0x38, 0x31, 0xC0, 0xE6, 0x06, 0x30, 0x1C, 0xC0, 0xC6,
  0x03, 0x98, 0x1D, 0xC0, 0x37, 0x01, 0xB8, 0x06, 0xC0, 0x36, 0x00, 0xD8,
  0x06, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0xE0, 0x03, 0x81, 0xE0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x00, 0xF7,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xC3,
  0xC0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0x70, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0x3E, 0xFC, 0x00, 0x67, 0x01, 0xE0, 0x06, 0x70, 0x0F,
  0x00, 0xE6, 0x00, 0x7C, 0x1C, 0x60, 0x01, 0xFF, 0x8E, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1C, 0x00,
};

const GFXglyph RobotoMono_Light50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 4, 36, 30, 13, -36 },
  { 19, 10, 11, 30, 10, -38 },
  { 33, 28, 36, 30, 1, -36 },
  { 159, 22, 46, 30, 4, -41 },
  { 286, 28, 37, 30, 1, -36 },
  { 416, 26, 36, 30, 3, -36 },
  { 533, 2, 11, 30, 13, -38 },
  { 536, 12, 51, 30, 9, -40 },
  { 613, 12, 51, 30, 8, -40 },
  { 690, 23, 22, 30, 4, -36 },
  { 754, 24, 25, 30, 3, -29 },
  { 829, 6, 12, 30, 9, -5 },
  { 838, 18, 2, 30, 6, -17 },
  { 843, 5, 5, 30, 13, -5 },
  { 847, 17, 39, 30, 7, -36 },
  { 930, 22, 36, 30, 4, -36 },
  { 1029, 13, 36, 30, 5, -36 },
  { 1088, 23, 36, 30, 2, -36 },
  { 1192, 23, 36, 30, 2, -36 },
  { 1296, 25, 36, 30, 2, -36 },
  { 1409, 22, 36, 30, 5, -36 },
  { 1508, 22, 36, 30, 4, -36 },
  { 1607, 23, 36, 30, 3, -36 },
  { 1711, 23, 36, 30, 4, -36 },
  { 1815, 22, 36, 30, 4, -36 },
  { 1914, 5, 26, 30, 15, -26 },
  { 1931, 6, 33, 30, 13, -26 },
  { 1956, 21, 20, 30, 4, -26 },
  { 2009, 22, 12, 30, 4, -22 },
  { 2042, 22, 21, 30, 4, -27 },
  { 2100, 20, 36, 30, 5, -36 },
  { 2190, 28, 36, 30, 1, -36 },
  { 2316, 26, 36, 30, 2, -36 },
  { 2433, 22, 36, 30, 5, -36 },
  { 2532, 24, 36, 30, 3, -36 },
  { 2640, 23, 36, 30, 4, -36 },
  { 2744, 21, 36, 30, 5, -36 },
  { 2839, 21, 36, 30, 5, -36 },
  { 2934, 24, 36, 30, 3, -36 },
  { 3042, 22, 36, 30, 4, -36 },
  { 3141, 20, 36, 30, 5, -36 },
  { 3231, 22, 36, 30, 3, -36 },
  { 3330, 24, 36, 30, 5, -36 },
  { 3438, 21, 36, 30, 5, -36 },
  { 3533, 22, 36, 30, 4, -36 },
  { 3632, 22, 36, 30, 4, -36 },
  { 3731, 24, 36, 30, 3, -36 },
  { 3839, 23, 36, 30, 5, -36 },
  { 3943, 25, 42, 30, 3, -36 },
  { 4075, 23, 36, 30, 5, -36 },
  { 4179, 24, 36, 30, 3, -36 },
  { 4287, 26, 36, 30, 2, -36 },
  { 4404, 22, 36, 30, 4, -36 },
  { 4503, 26, 36, 30, 2, -36 },
  { 4620, 27, 36, 30, 2, -36 },
  { 4742, 25, 36, 30, 3, -36 },
  { 4855, 25, 36, 30, 2, -36 },
  { 4968, 23, 36, 30, 3, -36 },
  { 5072, 8, 49, 30, 11, -41 },
  { 5121, 18, 39, 30, 6, -36 },
  { 5209, 9, 49, 30, 10, -41 },
  { 5265, 18, 20, 30, 6, -36 },
  { 5310, 22, 2, 30, 4, 0 },
  { 5316, 8, 7, 30, 11, -37 },
  { 5323, 22, 27, 30, 4, -27 },
  { 5398, 21, 38, 30, 5, -38 },
  { 5498, 22, 27, 30, 4, -27 },
  { 5573, 21, 38, 30, 4, -38 },
  { 5673, 22, 27, 30, 4, -27 },
  { 5748, 23, 38, 30, 4, -38 },
  { 5858, 21, 38, 30, 4, -27 },
  { 5958, 21, 38, 30, 5, -38 },
  { 6058, 22, 36, 30, 5, -36 },
  { 6157, 15, 47, 30, 5, -36 },
  { 6246, 22, 38, 30, 5, -38 },
  { 6351, 22, 38, 30, 5, -38 },
  { 6456, 26, 27, 30, 2, -27 },
  { 6544, 21, 27, 30, 5, -27 },
  { 6615, 24, 27, 30, 3, -27 },
  { 6696, 21, 37, 30, 5, -27 },
  { 6794, 21, 37, 30, 4, -27 },
  { 6892, 17, 27, 30, 9, -27 },
  { 6950, 21, 27, 30, 5, -27 },
  { 7021, 21, 33, 30, 4, -33 },
  { 7108, 20, 26, 30, 5, -26 },
  { 7173, 24, 26, 30, 3, -26 },
  { 7251, 27, 26, 30, 2, -26 },
  { 7339, 24, 26, 30, 3, -26 },
  { 7417, 26, 37, 30, 2, -26 },
  { 7538, 23, 26, 30, 4, -26 },
  { 7613, 16, 49, 30, 8, -39 },
  { 7711, 2, 44, 30, 14, -36 },
  { 7722, 16, 49, 30, 8, -39 },
  { 7820, 28, 9, 30, 1, -19 },
};

const GFXfont RobotoMono_Light50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light50pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_LIGHT50PT7B_H_
