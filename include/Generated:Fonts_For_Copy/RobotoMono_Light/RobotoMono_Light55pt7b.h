#ifndef _ROBOTOMONO_LIGHT55PT7B_H_
#define _ROBOTOMONO_LIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0x60, 0x60, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x03,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x1F,
  0xC3, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x40, 0x38, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x06,
  0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0x70, 0x30, 0x07, 0x00, 0xE0, 0xE0,
  0x0E, 0x01, 0xC1, 0x80, 0x0E, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x1C, 0x00,
  0x1E, 0x78, 0x38, 0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x1F, 0x81, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x03, 0xF0, 0x00,
  0x0E, 0x0F, 0xF0, 0x00, 0x38, 0x3C, 0xF0, 0x00, 0x70, 0xE0, 0x70, 0x01,
  0xC1, 0x80, 0xE0, 0x03, 0x87, 0x00, 0xC0, 0x0E, 0x0E, 0x01, 0xC0, 0x18,
  0x1C, 0x03, 0x80, 0x70, 0x38, 0x07, 0x00, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x1C, 0x06, 0x01, 0xC0, 0x38, 0x04, 0x03, 0x80, 0x60, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0xE3, 0xC1, 0xE0, 0x0E, 0x78, 0x0F, 0x01, 0xC7, 0x00, 0x70, 0x1C,
  0xF0, 0x07, 0x81, 0xCE, 0x00, 0x3C, 0x1C, 0xE0, 0x01, 0xE1, 0xCE, 0x00,
  0x0F, 0x38, 0xE0, 0x00, 0xF3, 0x8E, 0x00, 0x07, 0xF8, 0xE0, 0x00, 0x3F,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xF0, 0x3C,
  0x00, 0xFF, 0x81, 0xF8, 0x7E, 0x3C, 0x0F, 0xFF, 0xC1, 0xE0, 0x3F, 0xF0,
  0x0F, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x08,
  0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x08, 0x40, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x80, 0x38, 0x06, 0xF8, 0x1C, 0x0F, 0x7F, 0x8E, 0x3F, 0x9F,
  0xF7, 0x7F, 0xA0, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xE0,
  0x00, 0xE0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x38, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCF,
  0x38, 0xE7, 0x3C, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xF8,
  0x3F, 0x00, 0xF0, 0x07, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x70,
  0x00, 0x1C, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xE7, 0xF0, 0x01, 0xE3, 0xF8, 0x01, 0xE1, 0xFC, 0x01, 0xE0,
  0xFE, 0x01, 0xE0, 0x7F, 0x01, 0xE0, 0x3F, 0x81, 0xC0, 0x1F, 0xC1, 0xC0,
  0x0F, 0xE1, 0xC0, 0x07, 0xF3, 0xC0, 0x03, 0xFB, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x77, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3E, 0x0F, 0xC0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x3F, 0xDF, 0xF8, 0x7F, 0x81, 0xF8, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x0F, 0x81, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x81, 0xF8,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1C,
  0x3E, 0x00, 0x7C, 0x1F, 0xC1, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x3F, 0xC0, 0x3B, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFE, 0x1F, 0xE1,
  0xE0, 0x07, 0xE0, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0xF8, 0xF0, 0x03,
  0xE1, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x70, 0xFF, 0xC0,
  0x73, 0xFF, 0xF0, 0xE7, 0xC1, 0xF8, 0xEF, 0x00, 0x7C, 0xFC, 0x00, 0x3C,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0x01, 0xE0,
  0x07, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x3C, 0x0F, 0x80, 0x7C, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x78, 0x01, 0xE0, 0x78, 0x00,
  0x38, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xC3, 0xE0, 0x07, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xC1, 0xF0, 0x1F, 0x00, 0x78, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x1F, 0x1E, 0x00, 0x7F, 0x1F, 0x00, 0xF7, 0x0F, 0xFF, 0xE7, 0x03, 0xFF,
  0xC7, 0x00, 0xFE, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x73, 0xEF, 0xFE, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x73, 0xEF, 0xFE, 0x78, 0x1C, 0x7C, 0xF9, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xC7,
  0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8, 0x3C, 0x01, 0xF1,
  0xE0, 0x01, 0xC7, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x00, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x0E, 0x18, 0x07, 0xE0, 0x31, 0xC0, 0x7F, 0xC1,
  0x8C, 0x07, 0x8E, 0x0E, 0xE0, 0x70, 0x30, 0x36, 0x07, 0x01, 0x81, 0xB0,
  0x30, 0x0C, 0x0F, 0x83, 0x80, 0x60, 0x7C, 0x1C, 0x03, 0x03, 0xC0, 0xC0,
  0x38, 0x1E, 0x06, 0x01, 0xC0, 0xF0, 0x70, 0x0C, 0x07, 0x83, 0x80, 0x60,
  0x3C, 0x1C, 0x03, 0x01, 0xE0, 0xE0, 0x18, 0x0F, 0x07, 0x00, 0xC0, 0x78,
  0x38, 0x0E, 0x07, 0xC1, 0xC0, 0x70, 0x36, 0x0E, 0x03, 0x81, 0xB0, 0x30,
  0x3C, 0x1D, 0xC1, 0xC3, 0x60, 0xCE, 0x0F, 0xFB, 0xDE, 0x30, 0x3F, 0x8F,
  0xE1, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x70, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x07, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0E, 0x00, 0x1F, 0x87, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0x9C, 0x00, 0x1F, 0x8F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x07, 0xC1,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1C, 0x00, 0x7C,
  0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0x83, 0xF0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x07, 0xC0, 0x07, 0x80, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x7B, 0xFC,
  0x00, 0x0F, 0xF7, 0x80, 0x01, 0xFC, 0x78, 0x00, 0x3F, 0x07, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x70, 0x00, 0xFF, 0xB8, 0x00, 0xEF, 0xDC, 0x00, 0x77,
  0xE7, 0x00, 0x3B, 0xF3, 0x80, 0x39, 0xF9, 0xC0, 0x1C, 0xFE, 0x70, 0x1E,
  0x7F, 0x38, 0x0E, 0x3F, 0x9C, 0x07, 0x1F, 0xC7, 0x07, 0x0F, 0xE3, 0x83,
  0x87, 0xF0, 0xE1, 0xC3, 0xF8, 0x71, 0xC1, 0xFC, 0x38, 0xE0, 0xFE, 0x0E,
  0xE0, 0x7F, 0x07, 0x70, 0x3F, 0x83, 0xB8, 0x1F, 0xC0, 0xF8, 0x0F, 0xE0,
  0x7C, 0x07, 0xF0, 0x3E, 0x03, 0xF8, 0x0E, 0x01, 0xFC, 0x07, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF7, 0x00, 0x07, 0xFB, 0xC0, 0x03, 0xFC, 0xE0, 0x01, 0xFE,
  0x78, 0x00, 0xFF, 0x1C, 0x00, 0x7F, 0x87, 0x00, 0x3F, 0xC3, 0xC0, 0x1F,
  0xE0, 0xE0, 0x0F, 0xF0, 0x78, 0x07, 0xF8, 0x1C, 0x03, 0xFC, 0x0F, 0x01,
  0xFE, 0x03, 0x80, 0xFF, 0x01, 0xE0, 0x7F, 0x80, 0x70, 0x3F, 0xC0, 0x3C,
  0x1F, 0xE0, 0x0E, 0x0F, 0xF0, 0x03, 0x87, 0xF8, 0x01, 0xE3, 0xFC, 0x00,
  0x71, 0xFE, 0x00, 0x3C, 0xFF, 0x00, 0x0E, 0x7F, 0x80, 0x07, 0xBF, 0xC0,
  0x01, 0xDF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x07,
  0x80, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0C,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1C,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3E,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xE0, 0x07,
  0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x1C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0x70, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x9E,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x83,
  0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x1F,
  0x03, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x38,
  0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x0F, 0x80,
  0xFE, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x70, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00,
  0xE7, 0x00, 0x78, 0x03, 0x9C, 0x01, 0xE0, 0x0E, 0x70, 0x07, 0x80, 0x39,
  0xC0, 0x1E, 0x00, 0xE7, 0x00, 0xFC, 0x03, 0x9C, 0x03, 0xF0, 0x0E, 0x70,
  0x0F, 0xC0, 0x70, 0xE0, 0x33, 0x01, 0xC3, 0x80, 0xCC, 0x07, 0x0E, 0x07,
  0x38, 0x1C, 0x38, 0x1C, 0xE0, 0x70, 0xE0, 0x73, 0x81, 0xC3, 0x81, 0xCE,
  0x07, 0x0E, 0x06, 0x18, 0x18, 0x1C, 0x38, 0x70, 0xE0, 0x70, 0xE1, 0xC3,
  0x81, 0xC3, 0x87, 0x0E, 0x07, 0x0E, 0x1C, 0x38, 0x1C, 0x30, 0x30, 0xE0,
  0x71, 0xC0, 0xC3, 0x81, 0xC7, 0x03, 0x8C, 0x03, 0x9C, 0x0E, 0x70, 0x0E,
  0x70, 0x39, 0xC0, 0x39, 0xC0, 0xE7, 0x00, 0xE6, 0x01, 0x9C, 0x03, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x76, 0x00, 0x6E, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xE0,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xF8, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC1, 0xC0,
  0x38, 0x38, 0x07, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x78, 0x03, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x70, 0x00, 0x7E,
  0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7F,
  0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3E, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3E, 0xF0, 0x00,
  0x7E, 0x78, 0x01, 0xEE, 0x3F, 0x9F, 0xCE, 0x1F, 0xFF, 0x0E, 0x0F, 0xFE,
  0x0F, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x0C, 0x00, 0xF1, 0xFF, 0x80, 0xF3, 0xFF, 0xE0, 0xF7, 0xC7,
  0xF0, 0xFE, 0x00, 0xF8, 0xFC, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1C, 0xF8, 0x00, 0x3C, 0xFC, 0x00, 0x78, 0xEE, 0x00, 0xF8, 0xE7, 0xC7,
  0xF0, 0xE3, 0xFF, 0xE0, 0xE1, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xC1, 0xF8, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x38, 0x00, 0x07, 0x3C, 0x00,
  0x0E, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x07, 0xC1, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x18, 0x0F, 0x01, 0xFF, 0x8F, 0x07, 0xFF,
  0xCF, 0x0F, 0xC3, 0xEF, 0x1F, 0x00, 0x7F, 0x1E, 0x00, 0x3F, 0x3C, 0x00,
  0x1F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x1F, 0x00,
  0x77, 0x0F, 0xE3, 0xE7, 0x03, 0xFF, 0xC7, 0x01, 0xFF, 0x87, 0x00, 0x10,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x02, 0x0F, 0x00, 0x03, 0x83, 0xE0,
  0x07, 0x80, 0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x87, 0x07, 0xFF, 0xC7, 0x0F,
  0xC3, 0xE7, 0x1F, 0x00, 0x77, 0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x38,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x0F,
  0xE3, 0xFF, 0x07, 0xFF, 0xCF, 0x01, 0xFF, 0x8F, 0x00, 0x10, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x10,
  0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x83, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x0E, 0x07, 0xFC, 0x1C, 0x3F, 0xFE,
  0x38, 0xF0, 0x7E, 0x73, 0x80, 0x3E, 0xEE, 0x00, 0x3D, 0xF8, 0x00, 0x3B,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x01, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE0,
  0xE0, 0x07, 0xC0, 0xE0, 0x0F, 0x80, 0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00,
  0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00,
  0xE7, 0xC0, 0x00, 0xEF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x0F, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xC0, 0x06, 0x07, 0x1F, 0xE1, 0xFE, 0x39, 0xFF, 0x9F, 0xF9,
  0xDC, 0x7D, 0xE3, 0xEF, 0x80, 0xFC, 0x0F, 0x78, 0x03, 0xC0, 0x3B, 0xC0,
  0x1C, 0x01, 0xFE, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38,
  0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03,
  0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0,
  0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E,
  0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00,
  0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8,
  0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0x0C, 0x01, 0xC1, 0xFF, 0x83, 0x87, 0xFF, 0xC7, 0x1E,
  0x0F, 0xCE, 0x70, 0x07, 0xDD, 0x80, 0x07, 0xBE, 0x00, 0x07, 0x7C, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xF0, 0x07, 0xC1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3D, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xE1, 0xFF, 0x80,
  0xE3, 0xFF, 0xE0, 0xE7, 0xC3, 0xF0, 0xEE, 0x00, 0xF8, 0xFC, 0x00, 0x78,
  0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x78,
  0xFE, 0x00, 0xF8, 0xEF, 0xC3, 0xF0, 0xE3, 0xFF, 0xE0, 0xE1, 0xFF, 0x80,
  0xE0, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xFF, 0x87, 0x07, 0xFF, 0xC7, 0x0F, 0xC1, 0xE7, 0x1F, 0x00, 0x77,
  0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x1F,
  0x1E, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x0F, 0xC1, 0xFF, 0x07, 0xFF, 0xCF,
  0x01, 0xFF, 0x8F, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x1C, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x01,
  0xDC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8,
  0x3E, 0x00, 0x7C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1F, 0x81, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x30, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0xDC, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x38, 0x00, 0x7E, 0x78,
  0x01, 0xDC, 0x7E, 0x3F, 0x38, 0x7F, 0xFC, 0x70, 0x7F, 0xE0, 0xE0, 0x06,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x3C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0xEE,
  0x00, 0x70, 0x03, 0xB8, 0x01, 0xE0, 0x0E, 0x70, 0x0F, 0x80, 0x39, 0xC0,
  0x36, 0x00, 0xC7, 0x00, 0xD8, 0x07, 0x1C, 0x03, 0x70, 0x1C, 0x30, 0x1D,
  0xC0, 0x70, 0xE0, 0x73, 0x01, 0xC3, 0x81, 0x8C, 0x06, 0x0E, 0x06, 0x38,
  0x38, 0x38, 0x38, 0xE0, 0xE0, 0x60, 0xE1, 0x83, 0x81, 0xC3, 0x06, 0x0C,
  0x07, 0x0C, 0x1C, 0x30, 0x1C, 0x70, 0x71, 0xC0, 0x31, 0xC0, 0xC7, 0x00,
  0xE6, 0x03, 0x1C, 0x03, 0x98, 0x0E, 0x60, 0x0E, 0xE0, 0x39, 0x80, 0x3B,
  0x80, 0x6E, 0x00, 0x6C, 0x01, 0xB8, 0x01, 0xB0, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70,
  0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xCF, 0xFF, 0x00, 0x06, 0xF0, 0x7C, 0x00, 0x7F, 0x00, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x3B, 0x00, 0x0F, 0xC7, 0xD8, 0x00, 0x1F, 0xFC, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x30, 0x00,
};

const GFXglyph RobotoMono_Light55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 4, 39, 33, 14, -39 },
  { 21, 11, 12, 33, 11, -41 },
  { 38, 30, 39, 33, 2, -39 },
  { 185, 24, 51, 33, 5, -45 },
  { 338, 31, 41, 33, 1, -40 },
  { 497, 28, 41, 33, 4, -40 },
  { 641, 3, 12, 33, 14, -41 },
  { 646, 13, 57, 33, 10, -44 },
  { 739, 13, 57, 33, 9, -44 },
  { 832, 25, 24, 33, 5, -39 },
  { 907, 27, 28, 33, 3, -32 },
  { 1002, 6, 13, 33, 10, -5 },
  { 1012, 20, 3, 33, 6, -19 },
  { 1020, 5, 5, 33, 15, -5 },
  { 1024, 20, 42, 33, 7, -39 },
  { 1129, 25, 41, 33, 4, -40 },
  { 1258, 14, 39, 33, 6, -39 },
  { 1327, 25, 40, 33, 3, -40 },
  { 1452, 24, 41, 33, 3, -40 },
  { 1575, 28, 39, 33, 2, -39 },
  { 1712, 23, 40, 33, 6, -39 },
  { 1827, 24, 40, 33, 4, -39 },
  { 1947, 26, 39, 33, 3, -39 },
  { 2074, 25, 41, 33, 5, -40 },
  { 2203, 24, 40, 33, 4, -40 },
  { 2323, 6, 29, 33, 16, -29 },
  { 2345, 7, 37, 33, 14, -29 },
  { 2378, 23, 23, 33, 4, -29 },
  { 2445, 24, 14, 33, 5, -25 },
  { 2487, 23, 23, 33, 5, -29 },
  { 2554, 22, 40, 33, 6, -40 },
  { 2664, 29, 39, 33, 2, -39 },
  { 2806, 28, 39, 33, 3, -39 },
  { 2943, 25, 39, 33, 5, -39 },
  { 3065, 27, 41, 33, 3, -40 },
  { 3204, 25, 39, 33, 5, -39 },
  { 3326, 24, 39, 33, 5, -39 },
  { 3443, 23, 39, 33, 6, -39 },
  { 3556, 26, 41, 33, 3, -40 },
  { 3690, 25, 39, 33, 4, -39 },
  { 3812, 23, 39, 33, 5, -39 },
  { 3925, 25, 40, 33, 3, -39 },
  { 4050, 27, 39, 33, 5, -39 },
  { 4182, 23, 39, 33, 6, -39 },
  { 4295, 25, 39, 33, 4, -39 },
  { 4417, 25, 39, 33, 4, -39 },
  { 4539, 27, 41, 33, 3, -40 },
  { 4678, 24, 39, 33, 6, -39 },
  { 4795, 27, 47, 33, 3, -40 },
  { 4954, 25, 39, 33, 5, -39 },
  { 5076, 26, 41, 33, 4, -40 },
  { 5210, 28, 39, 33, 3, -39 },
  { 5347, 25, 40, 33, 4, -39 },
  { 5472, 28, 39, 33, 2, -39 },
  { 5609, 30, 39, 33, 2, -39 },
  { 5756, 28, 39, 33, 3, -39 },
  { 5893, 28, 39, 33, 2, -39 },
  { 6030, 25, 39, 33, 3, -39 },
  { 6152, 9, 53, 33, 12, -45 },
  { 6212, 19, 42, 33, 7, -39 },
  { 6312, 9, 53, 33, 12, -45 },
  { 6372, 19, 21, 33, 7, -39 },
  { 6422, 23, 3, 33, 5, 0 },
  { 6431, 9, 7, 33, 12, -40 },
  { 6439, 24, 31, 33, 5, -30 },
  { 6532, 24, 42, 33, 5, -41 },
  { 6658, 24, 31, 33, 4, -30 },
  { 6751, 24, 42, 33, 4, -41 },
  { 6877, 25, 31, 33, 4, -30 },
  { 6974, 25, 42, 33, 5, -42 },
  { 7106, 24, 42, 33, 4, -30 },
  { 7232, 23, 41, 33, 5, -41 },
  { 7350, 23, 39, 33, 6, -39 },
  { 7463, 17, 51, 33, 5, -39 },
  { 7572, 24, 41, 33, 6, -41 },
  { 7695, 23, 41, 33, 6, -41 },
  { 7813, 29, 30, 33, 2, -30 },
  { 7922, 23, 30, 33, 5, -30 },
  { 8009, 25, 31, 33, 4, -30 },
  { 8106, 24, 41, 33, 5, -30 },
  { 8229, 24, 41, 33, 4, -30 },
  { 8352, 19, 30, 33, 10, -30 },
  { 8424, 24, 31, 33, 5, -30 },
  { 8517, 23, 38, 33, 5, -37 },
  { 8627, 23, 30, 33, 5, -29 },
  { 8714, 27, 29, 33, 3, -29 },
  { 8812, 30, 29, 33, 2, -29 },
  { 8921, 27, 29, 33, 3, -29 },
  { 9019, 29, 41, 33, 2, -29 },
  { 9168, 25, 29, 33, 4, -29 },
  { 9259, 18, 54, 33, 9, -43 },
  { 9381, 3, 48, 33, 15, -39 },
  { 9399, 18, 54, 33, 9, -43 },
  { 9521, 29, 10, 33, 2, -21 },
};

const GFXfont RobotoMono_Light55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light55pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_LIGHT55PT7B_H_
