#ifndef _ROBOTOMONO_LIGHT34PT7B_H_
#define _ROBOTOMONO_LIGHT34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x2F, 0x87, 0x0E, 0x1C, 0x28, 0x50,
  0xA1, 0x42, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x00,
  0x10, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x83, 0xFF, 0xFF, 0x03, 0x04, 0x00,
  0x40, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x01,
  0x02, 0x00, 0x20, 0xC0, 0xFF, 0xFF, 0x81, 0x83, 0x00, 0x30, 0x60, 0x04,
  0x08, 0x00, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFF, 0x07, 0x8F, 0x0C, 0x07,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x0C, 0xE0, 0x38,
  0xFB, 0xE0, 0x7F, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0F, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x80, 0x08, 0x30, 0x61, 0x02, 0x18,
  0x20, 0x43, 0x04, 0x18, 0xC0, 0xC3, 0x18, 0x0C, 0xC6, 0x01, 0xF8, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x80, 0x0C, 0x7C,
  0x03, 0x18, 0xC0, 0x66, 0x08, 0x18, 0xC1, 0x82, 0x18, 0x30, 0xC3, 0x06,
  0x10, 0x60, 0xC0, 0x04, 0x10, 0x00, 0xC6, 0x00, 0x0F, 0x80, 0x01, 0x00,
  0x03, 0xF8, 0x01, 0xC7, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C, 0x06, 0x03,
  0x03, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x07, 0x30, 0x00, 0xD8, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0x18, 0x19, 0xC3, 0x06, 0x60, 0x61,
  0xB8, 0x1C, 0x4C, 0x03, 0xB3, 0x00, 0x6C, 0xC0, 0x0E, 0x18, 0x03, 0x87,
  0x01, 0xF0, 0xF3, 0xCC, 0x1F, 0xE1, 0xC0, 0xFF, 0x01, 0x03, 0x06, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0x60, 0xC0, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x08, 0x18, 0x3E, 0x23, 0xDF, 0xDF, 0x03, 0xF0, 0x03, 0x80, 0x0D,
  0x80, 0x39, 0x80, 0x63, 0x81, 0x83, 0x86, 0x03, 0x04, 0x04, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x33, 0x33, 0x36, 0x6C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0x01, 0x00, 0x3F, 0xC0, 0xE1, 0xC3, 0x80, 0xC6, 0x00, 0xD8,
  0x01, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x1F, 0x80, 0x6F, 0x01, 0x9E, 0x06,
  0x3C, 0x18, 0x78, 0x60, 0xF3, 0x81, 0xEE, 0x03, 0xF8, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x6E, 0x00, 0xCC, 0x03, 0x8C, 0x06, 0x1E, 0x78, 0x0F,
  0xE0, 0x03, 0x0F, 0x3F, 0xF3, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x01, 0x00, 0x3F, 0xC0, 0xE1, 0xC3, 0x00, 0xCE, 0x01, 0xD8, 0x01,
  0xB0, 0x03, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0x00, 0x3F, 0xC0, 0xF1, 0xE3, 0x80, 0xC6, 0x00, 0xD8, 0x01, 0xB0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x7C,
  0x00, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xDC, 0x01, 0x9C, 0x07, 0x1F, 0x7C, 0x1F, 0xE0, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x33,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x3F, 0xFE, 0x7F, 0xFC, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x31, 0x00, 0x5F, 0xE1,
  0xFF, 0xE3, 0x81, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0D, 0x80, 0x3B, 0x00, 0x77, 0x00, 0xC7, 0x07, 0x87, 0xFE,
  0x07, 0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x63, 0xE0, 0xDF, 0xF1, 0xF0, 0x73, 0x80,
  0x6E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x33, 0x00, 0xC7, 0x03, 0x87, 0x9E, 0x03, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x1F, 0xE0, 0xF1, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xD8, 0x01,
  0xB0, 0x03, 0x60, 0x0E, 0xC0, 0x18, 0xC0, 0x70, 0xE3, 0xC0, 0xFE, 0x03,
  0xDE, 0x0C, 0x07, 0x30, 0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x6C, 0x01, 0xDC, 0x07, 0x1F, 0x7C, 0x0F, 0xF0, 0x02, 0x00,
  0x3F, 0xC0, 0xE1, 0xC3, 0x81, 0xC6, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60,
  0x06, 0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xEC, 0x03,
  0xDC, 0x0D, 0x1F, 0xF6, 0x0F, 0x8C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x0F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x66, 0x66, 0x6C, 0x80, 0x00, 0x04, 0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F,
  0x01, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0xFE, 0x1E, 0x3C, 0xC0, 0x6C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0xFC, 0x01, 0xC3, 0x80, 0xC0, 0x30, 0x60,
  0x06, 0x30, 0x00, 0x88, 0x3E, 0x36, 0x19, 0x85, 0x0C, 0x21, 0x42, 0x08,
  0x71, 0x82, 0x1C, 0x60, 0x87, 0x10, 0x61, 0x84, 0x18, 0x61, 0x06, 0x1C,
  0x41, 0x87, 0x10, 0x63, 0xC6, 0x38, 0xB1, 0xF3, 0xE4, 0x38, 0xF1, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x01, 0x01, 0xE1, 0xC0, 0x1F, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x08, 0x03, 0x06, 0x01, 0x83, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x7F, 0xF8, 0x3F, 0xFE, 0x18, 0x03,
  0x18, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xE1, 0xFF, 0xE3, 0x00, 0xE6, 0x00, 0x6C, 0x00, 0xD8, 0x01,
  0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x03, 0xC7, 0xFF, 0x0C,
  0x07, 0x98, 0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xBF, 0xFE, 0x7F, 0xF0, 0x00, 0x80,
  0x07, 0xF0, 0x1E, 0x3C, 0x38, 0x0E, 0x30, 0x06, 0x60, 0x07, 0x60, 0x03,
  0x60, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x07, 0x30, 0x06, 0x38, 0x0C, 0x1F, 0x78, 0x07, 0xF0,
  0xFF, 0x80, 0xFF, 0xE0, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF, 0xCC, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x98, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x80, 0x07, 0xF0, 0x1E, 0x3C,
  0x38, 0x0E, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x03,
  0x30, 0x03, 0x18, 0x07, 0x0F, 0x3E, 0x07, 0xF8, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x66, 0x00, 0xCE, 0x03, 0x0F, 0x3C, 0x07, 0xF0, 0xC0, 0x07, 0x60, 0x07,
  0x30, 0x07, 0x18, 0x07, 0x0C, 0x07, 0x06, 0x03, 0x03, 0x03, 0x01, 0x83,
  0x00, 0xC3, 0x80, 0x63, 0x80, 0x33, 0x80, 0x1B, 0xE0, 0x0F, 0xB0, 0x07,
  0x9C, 0x03, 0x87, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x38, 0x30, 0x0E,
  0x18, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x73, 0x00, 0x1D, 0x80, 0x07, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80,
  0xFF, 0x01, 0x7E, 0x06, 0xF6, 0x0D, 0xEC, 0x33, 0xC8, 0x67, 0x98, 0xCF,
  0x33, 0x1E, 0x36, 0x3C, 0x68, 0x78, 0xF0, 0xF0, 0xE1, 0xE1, 0x83, 0xC3,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7B,
  0x00, 0xF6, 0x01, 0xE6, 0x03, 0xCC, 0x07, 0x8C, 0x0F, 0x1C, 0x1E, 0x18,
  0x3C, 0x38, 0x78, 0x30, 0xF0, 0x31, 0xE0, 0x63, 0xC0, 0x67, 0x80, 0xCF,
  0x00, 0xDE, 0x01, 0xBC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x00,
  0x80, 0x0F, 0xF0, 0x1E, 0x78, 0x38, 0x0C, 0x30, 0x0E, 0x60, 0x06, 0x60,
  0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07,
  0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x01, 0xCF,
  0xFF, 0x1F, 0xF8, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x07, 0xF8, 0x07, 0x9E, 0x07, 0x01, 0x83, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xB0, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x61, 0x80, 0x30, 0xE0, 0x30, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x10,
  0xFF, 0xE0, 0xFF, 0xF0, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x38,
  0xFF, 0xF0, 0xFF, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x07,
  0x00, 0x80, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC7, 0x00, 0x73, 0x00,
  0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xB0, 0x00, 0xDC, 0x00, 0x76, 0x00, 0x33, 0x80, 0x18, 0xE0,
  0x18, 0x3E, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x66, 0x01,
  0xCE, 0x07, 0x0F, 0x3C, 0x07, 0xF0, 0xE0, 0x01, 0xD8, 0x00, 0x66, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18,
  0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0xC0, 0xE0, 0x6C, 0x1C, 0x19, 0x83, 0x83, 0x30, 0x70, 0x66, 0x0A, 0x0C,
  0xC1, 0x41, 0x98, 0x6C, 0x33, 0x0D, 0x84, 0x21, 0xB0, 0x86, 0x22, 0x30,
  0xC4, 0x46, 0x19, 0x8C, 0xC3, 0x31, 0x98, 0x66, 0x33, 0x0C, 0xC6, 0x60,
  0x90, 0x48, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0xE0, 0x03, 0xB0,
  0x01, 0x8C, 0x01, 0x87, 0x01, 0xC1, 0x80, 0xC0, 0xE0, 0xC0, 0x30, 0x60,
  0x0C, 0x60, 0x06, 0x70, 0x01, 0xB0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0C, 0x60, 0x0E, 0x38, 0x06, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x83, 0x00, 0x63, 0x80, 0x39, 0x80, 0x0D, 0x80, 0x03,
  0xE0, 0x01, 0xD8, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x06, 0x06,
  0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0x06,
  0x00, 0x70, 0x0F, 0x00, 0xD0, 0x09, 0x81, 0x98, 0x18, 0xC3, 0x0C, 0x30,
  0x66, 0x06, 0x60, 0x66, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3,
  0x1C, 0x61, 0x80, 0x0F, 0xE0, 0x79, 0xE1, 0xC0, 0x63, 0x00, 0x6C, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x1F, 0xFC, 0xF0, 0x19, 0x80, 0x36,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x07, 0x70, 0x1E, 0x7D, 0xEC, 0x7F,
  0x9C, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xCF, 0xE1, 0xBD, 0xE3, 0xC0, 0xE7, 0x00, 0xEE,
  0x00, 0xD8, 0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0xB8, 0x07, 0x78, 0x1C, 0xDE, 0xF1,
  0x9F, 0xC0, 0x0F, 0xE0, 0x7D, 0xE0, 0xC0, 0x63, 0x00, 0x6E, 0x00, 0xD8,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x7C, 0x01, 0x98, 0x03, 0x18, 0x0C, 0x3C, 0xF8, 0x1F, 0xC0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x0F, 0xCC, 0xFF, 0xB7, 0x03, 0xD8, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x36, 0x01, 0xDC, 0x0F, 0x3C, 0xEC, 0x3F, 0x30, 0x07, 0xF0,
  0x0F, 0x78, 0x18, 0x0C, 0x30, 0x06, 0x70, 0x06, 0x60, 0x03, 0x60, 0x03,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x02, 0x18, 0x07, 0x0F, 0x3C, 0x07, 0xF8, 0x00, 0x7F,
  0x01, 0xFE, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0F, 0xCC, 0xFF, 0xB7, 0x03, 0xD8, 0x07, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x36, 0x01, 0xDC, 0x0F, 0x3C, 0xEC, 0x7F, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0D, 0x00, 0x67, 0x03, 0x8F, 0xFC, 0x0F, 0xC0, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC7, 0xF3, 0x3D, 0xED, 0x81, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x19, 0xDF, 0x3F, 0x80, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x1F, 0x01, 0xCC, 0x0E, 0x30, 0x70, 0xC3, 0x83, 0x1C, 0x0C, 0xE0, 0x37,
  0x00, 0xFC, 0x03, 0xD8, 0x0C, 0x70, 0x30, 0xE0, 0xC1, 0xC3, 0x03, 0x8C,
  0x06, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x70, 0xFF, 0x03, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xCF, 0x9F, 0x36, 0xFE, 0xEE, 0x0E, 0x0F,
  0x83, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0,
  0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30,
  0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x30, 0xC7, 0xF3,
  0x3F, 0xED, 0x81, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x07, 0xF0, 0x1F, 0x78, 0x38, 0x1C,
  0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x06,
  0x38, 0x0C, 0x1E, 0x78, 0x07, 0xF0, 0xCF, 0xE1, 0xBD, 0xE3, 0xC0, 0xE7,
  0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xD8, 0x01, 0xB8, 0x07, 0x78, 0x1C,
  0xDC, 0xF1, 0x9F, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x0F, 0xCC, 0xFB, 0xB7, 0x03, 0xD8, 0x07,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0xDC, 0x07, 0x3C, 0xFC, 0x7F,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0xC7, 0xFC, 0xFF, 0xD8, 0x0F, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xE0, 0x7D, 0xF1, 0xC0, 0x73, 0x00, 0x66,
  0x00, 0x6C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x60, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xB8, 0x06, 0x3C, 0x78,
  0x1F, 0xE0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x03, 0xFF,
  0xEF, 0xFF, 0x81, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0F, 0x30, 0x1F, 0xC0, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x36, 0x01, 0xDC, 0x0F, 0x3D,
  0xEC, 0x7F, 0x30, 0xC0, 0x03, 0xE0, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x60, 0xE0, 0x30, 0x30, 0x30, 0x18, 0x18, 0x06, 0x0C,
  0x03, 0x0C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0D, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x78, 0x18, 0x19, 0x03,
  0x83, 0x30, 0x70, 0x66, 0x1A, 0x0C, 0xC3, 0x41, 0x18, 0x6C, 0x61, 0x09,
  0x8C, 0x33, 0x11, 0x86, 0x62, 0x30, 0xCC, 0x64, 0x09, 0x0D, 0x81, 0x60,
  0xB0, 0x3C, 0x16, 0x07, 0x83, 0x80, 0xE0, 0x70, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0xE0, 0x03, 0x18, 0x03, 0x0E, 0x03, 0x03, 0x03, 0x80, 0xC1, 0x80,
  0x31, 0x80, 0x1D, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xEE, 0x00, 0xE3, 0x00, 0x60, 0xC0, 0x60, 0x30, 0x60, 0x1C, 0x70,
  0x06, 0x70, 0x01, 0xC0, 0xE0, 0x00, 0xD8, 0x00, 0x67, 0x00, 0x18, 0xC0,
  0x0E, 0x38, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x01, 0x83, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xEC, 0x00,
  0x1B, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x0E, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0xF8, 0x0F, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x1C, 0x00, 0xF0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xF0, 0x0F, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x80,
  0xF0, 0x04, 0x00, 0x3E, 0x00, 0x5F, 0xE0, 0x16, 0x1C, 0x0F, 0x03, 0x83,
  0xC0, 0x3F, 0x80, 0x07, 0xC0,
};

const GFXglyph RobotoMono_Light34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 2, 24, 20, 9, -24 },
  { 7, 7, 8, 20, 7, -26 },
  { 14, 19, 24, 20, 1, -24 },
  { 71, 15, 31, 20, 3, -28 },
  { 130, 19, 25, 20, 1, -25 },
  { 190, 18, 25, 20, 2, -25 },
  { 247, 1, 8, 20, 9, -26 },
  { 248, 8, 35, 20, 6, -27 },
  { 283, 8, 35, 20, 6, -27 },
  { 318, 15, 15, 20, 3, -24 },
  { 347, 17, 18, 20, 2, -20 },
  { 386, 4, 8, 20, 6, -3 },
  { 390, 12, 2, 20, 4, -12 },
  { 393, 3, 3, 20, 9, -3 },
  { 395, 12, 26, 20, 5, -24 },
  { 434, 15, 25, 20, 3, -25 },
  { 481, 8, 24, 20, 4, -24 },
  { 505, 15, 25, 20, 2, -25 },
  { 552, 15, 25, 20, 2, -25 },
  { 599, 18, 24, 20, 1, -24 },
  { 653, 15, 24, 20, 3, -24 },
  { 698, 15, 24, 20, 2, -24 },
  { 743, 16, 24, 20, 2, -24 },
  { 791, 15, 25, 20, 3, -25 },
  { 838, 15, 25, 20, 3, -25 },
  { 885, 3, 18, 20, 10, -18 },
  { 892, 4, 23, 20, 9, -18 },
  { 904, 14, 14, 20, 3, -18 },
  { 929, 15, 8, 20, 3, -15 },
  { 944, 15, 14, 20, 3, -18 },
  { 971, 13, 25, 20, 4, -25 },
  { 1012, 18, 24, 20, 1, -24 },
  { 1066, 17, 24, 20, 2, -24 },
  { 1117, 15, 24, 20, 3, -24 },
  { 1162, 16, 25, 20, 2, -25 },
  { 1212, 16, 24, 20, 3, -24 },
  { 1260, 15, 24, 20, 3, -24 },
  { 1305, 15, 24, 20, 3, -24 },
  { 1350, 16, 25, 20, 2, -25 },
  { 1400, 15, 24, 20, 3, -24 },
  { 1445, 14, 24, 20, 3, -24 },
  { 1487, 15, 24, 20, 2, -24 },
  { 1532, 17, 24, 20, 3, -24 },
  { 1583, 14, 24, 20, 4, -24 },
  { 1625, 15, 24, 20, 3, -24 },
  { 1670, 15, 24, 20, 3, -24 },
  { 1715, 16, 25, 20, 2, -25 },
  { 1765, 15, 24, 20, 4, -24 },
  { 1810, 17, 29, 20, 2, -25 },
  { 1872, 16, 24, 20, 3, -24 },
  { 1920, 17, 25, 20, 2, -25 },
  { 1974, 17, 24, 20, 2, -24 },
  { 2025, 15, 24, 20, 3, -24 },
  { 2070, 18, 24, 20, 1, -24 },
  { 2124, 19, 24, 20, 1, -24 },
  { 2181, 17, 24, 20, 2, -24 },
  { 2232, 18, 24, 20, 1, -24 },
  { 2286, 16, 24, 20, 2, -24 },
  { 2334, 6, 33, 20, 7, -28 },
  { 2359, 12, 26, 20, 4, -24 },
  { 2398, 6, 33, 20, 7, -28 },
  { 2423, 12, 13, 20, 4, -24 },
  { 2443, 15, 2, 20, 3, 0 },
  { 2447, 5, 5, 20, 8, -25 },
  { 2451, 15, 18, 20, 3, -18 },
  { 2485, 15, 26, 20, 3, -26 },
  { 2534, 15, 18, 20, 3, -18 },
  { 2568, 14, 26, 20, 3, -26 },
  { 2614, 16, 18, 20, 2, -18 },
  { 2650, 16, 26, 20, 3, -26 },
  { 2702, 14, 25, 20, 3, -18 },
  { 2746, 14, 26, 20, 3, -26 },
  { 2792, 14, 24, 20, 4, -24 },
  { 2834, 11, 31, 20, 3, -24 },
  { 2877, 14, 26, 20, 4, -26 },
  { 2923, 14, 26, 20, 4, -26 },
  { 2969, 18, 18, 20, 1, -18 },
  { 3010, 14, 18, 20, 3, -18 },
  { 3042, 16, 18, 20, 2, -18 },
  { 3078, 15, 25, 20, 3, -18 },
  { 3125, 14, 25, 20, 3, -18 },
  { 3169, 12, 18, 20, 6, -18 },
  { 3196, 15, 18, 20, 3, -18 },
  { 3230, 14, 23, 20, 3, -23 },
  { 3271, 14, 18, 20, 3, -18 },
  { 3303, 17, 18, 20, 2, -18 },
  { 3342, 19, 18, 20, 1, -18 },
  { 3385, 17, 18, 20, 2, -18 },
  { 3424, 18, 25, 20, 1, -18 },
  { 3481, 16, 18, 20, 2, -18 },
  { 3517, 12, 34, 20, 5, -27 },
  { 3568, 2, 30, 20, 9, -24 },
  { 3576, 12, 34, 20, 5, -27 },
  { 3627, 18, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_Light34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light34pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_LIGHT34PT7B_H_
