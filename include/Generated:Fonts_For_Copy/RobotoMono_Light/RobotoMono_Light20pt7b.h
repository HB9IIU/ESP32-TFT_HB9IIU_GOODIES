#ifndef _ROBOTOMONO_LIGHT20PT7B_H_
#define _ROBOTOMONO_LIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light20pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0xB0, 0x99, 0x99, 0x08, 0x81, 0x10, 0x42, 0x08,
  0x8F, 0xFE, 0x22, 0x04, 0x40, 0x88, 0x22, 0x1F, 0xF8, 0x88, 0x11, 0x02,
  0x20, 0x88, 0x00, 0x08, 0x04, 0x0F, 0x88, 0x6C, 0x14, 0x0B, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x28, 0x1C, 0x0B, 0x0C, 0x7C, 0x08, 0x04, 0x00,
  0x78, 0x04, 0x88, 0x88, 0x88, 0x90, 0x49, 0x07, 0x20, 0x02, 0x00, 0x40,
  0x05, 0xE0, 0x92, 0x09, 0x11, 0x11, 0x01, 0x20, 0x1E, 0x3E, 0x04, 0x40,
  0x8C, 0x11, 0x02, 0x60, 0x30, 0x06, 0x01, 0x40, 0x44, 0x58, 0x4A, 0x0F,
  0x60, 0xC4, 0x18, 0x7C, 0xC0, 0xF0, 0x11, 0x24, 0x4C, 0x88, 0x88, 0x88,
  0x88, 0x84, 0x44, 0x21, 0x10, 0x82, 0x08, 0x61, 0x08, 0x61, 0x08, 0x42,
  0x10, 0x84, 0x62, 0x11, 0x08, 0x88, 0x00, 0x08, 0x04, 0x22, 0x3D, 0xF1,
  0x80, 0xA0, 0x98, 0xC6, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x56, 0x80, 0xFF, 0x70, 0x06, 0x08,
  0x10, 0x40, 0x83, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x00,
  0x7E, 0x21, 0xA0, 0x50, 0x28, 0x34, 0x2E, 0x27, 0x23, 0xA1, 0xE0, 0xA0,
  0x50, 0x24, 0x21, 0xE0, 0x1B, 0xE2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x3E, 0x20, 0xA0, 0x50, 0x20, 0x10, 0x08, 0x08, 0x0C, 0x0C, 0x0C,
  0x04, 0x04, 0x04, 0x07, 0xFC, 0x3E, 0x20, 0xB0, 0x70, 0x30, 0x10, 0x18,
  0x78, 0x06, 0x01, 0x80, 0x60, 0x30, 0x34, 0x11, 0xF0, 0x03, 0x01, 0x40,
  0x50, 0x24, 0x11, 0x04, 0x42, 0x11, 0x04, 0x41, 0x3F, 0xF0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x03, 0xF1, 0x1C, 0x02,
  0x01, 0x80, 0xE0, 0x78, 0x26, 0x31, 0xF0, 0x0E, 0x08, 0x08, 0x08, 0x04,
  0x02, 0xF9, 0x87, 0x81, 0xC0, 0xE0, 0x50, 0x28, 0x12, 0x10, 0xF0, 0xFF,
  0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x00, 0x7E, 0x21, 0xA0, 0x50, 0x28, 0x12, 0x18,
  0xF0, 0xC4, 0x81, 0x40, 0x60, 0x30, 0x3C, 0x11, 0xF0, 0x7E, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC3, 0x7D, 0x01, 0x03, 0x02, 0x0C, 0x78, 0xF0,
  0x00, 0x3C, 0x6C, 0x00, 0x00, 0x09, 0x25, 0x00, 0x01, 0x03, 0x1C, 0x70,
  0x80, 0x60, 0x1C, 0x07, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0,
  0x38, 0x0E, 0x01, 0x06, 0x38, 0xE0, 0x80, 0x7E, 0x43, 0x81, 0x01, 0x01,
  0x02, 0x06, 0x08, 0x18, 0x10, 0x00, 0x00, 0x10, 0x18, 0x1F, 0x08, 0x24,
  0x06, 0x39, 0x92, 0x64, 0x9A, 0x26, 0x89, 0xA2, 0x69, 0x99, 0x9A, 0x00,
  0x41, 0x0F, 0x80, 0x0C, 0x03, 0x00, 0xE0, 0x68, 0x12, 0x04, 0xC3, 0x10,
  0x84, 0x21, 0x1F, 0xE4, 0x09, 0x02, 0xC0, 0x60, 0x10, 0xFE, 0x41, 0xA0,
  0x50, 0x28, 0x14, 0x1B, 0xF1, 0x06, 0x81, 0x40, 0x60, 0x30, 0x38, 0x37,
  0xF0, 0x3F, 0x18, 0x64, 0x09, 0x03, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x30, 0x04, 0x0D, 0x02, 0x21, 0x87, 0xC0, 0xFC, 0x41, 0x20, 0x50, 0x28,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x68, 0x67, 0xE0, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x3F, 0x18, 0x64, 0x0B, 0x03, 0x80, 0x20, 0x08, 0x02,
  0x1F, 0x80, 0x70, 0x14, 0x05, 0x01, 0x20, 0xC7, 0xC0, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x38, 0x34, 0x11, 0xF0, 0x81, 0xA0, 0xC8, 0x62, 0x30, 0x88, 0x24,
  0x0B, 0x03, 0x60, 0xCC, 0x21, 0x08, 0x22, 0x0C, 0x81, 0x20, 0x30, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x07, 0xFC, 0x81, 0xE1, 0x70, 0xB8, 0x7A, 0x5D, 0x2E, 0xF7, 0x33,
  0x99, 0xC8, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x81, 0xC1, 0xC1, 0xA1, 0xA1,
  0x91, 0x91, 0x89, 0x8D, 0x85, 0x87, 0x83, 0x83, 0x81, 0x3F, 0x18, 0x64,
  0x09, 0x02, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x34, 0x09, 0x02,
  0x21, 0x07, 0x80, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x05, 0xFC,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x3F, 0x18, 0x64, 0x0B, 0x03,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x0D, 0x02, 0x21, 0x87,
  0xC0, 0x18, 0x03, 0xFE, 0x41, 0xA0, 0x50, 0x38, 0x1C, 0x0A, 0x0D, 0xF8,
  0x84, 0x43, 0x20, 0x90, 0x68, 0x14, 0x04, 0x3F, 0x18, 0x24, 0x0D, 0x01,
  0x40, 0x0C, 0x01, 0xC0, 0x0C, 0x00, 0x80, 0x3C, 0x05, 0x03, 0x60, 0x87,
  0xC0, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x80, 0x70, 0x34,
  0x09, 0x02, 0x61, 0x88, 0x42, 0x10, 0xCC, 0x12, 0x04, 0x81, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0x84, 0x71, 0x8A, 0x31, 0x46, 0x2C, 0xA4, 0x94, 0x94,
  0x92, 0x94, 0x52, 0x8A, 0x31, 0x46, 0x30, 0xC2, 0x18, 0x43, 0x00, 0xC0,
  0xD8, 0x22, 0x10, 0xC4, 0x12, 0x03, 0x80, 0xC0, 0x30, 0x1A, 0x04, 0xC3,
  0x10, 0x86, 0x40, 0xB0, 0x10, 0x80, 0xD0, 0x24, 0x18, 0x84, 0x23, 0x04,
  0x81, 0x60, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x18, 0x08, 0x0C,
  0x04, 0x07, 0xFC, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xF0, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40,
  0xC0, 0x81, 0x80, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xF0, 0x18, 0x18, 0x3C, 0x24, 0x24, 0x42, 0xC3, 0xFF, 0xC6, 0x30, 0x3C,
  0x66, 0x81, 0x01, 0x01, 0x7F, 0xC1, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x80,
  0x80, 0x80, 0x9C, 0xE6, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2,
  0xBE, 0x1C, 0x66, 0xC1, 0x81, 0x80, 0x80, 0x80, 0x80, 0x81, 0x43, 0x3E,
  0x01, 0x01, 0x01, 0x01, 0x39, 0x67, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x43, 0x3D, 0x0E, 0x0C, 0xC6, 0x09, 0x02, 0x40, 0xFF, 0xFC, 0x01,
  0x00, 0x40, 0x08, 0x21, 0xF0, 0x0F, 0x8C, 0x04, 0x02, 0x0F, 0xF0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x39, 0x67,
  0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0xC2,
  0x7C, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xA3, 0xC1, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x08, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x0C, 0x00, 0x1F, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0B, 0xC0, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x14, 0x12, 0x11, 0x10, 0xB0, 0x78, 0x32, 0x11, 0x88,
  0x64, 0x1A, 0x06, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0xB1, 0xB3, 0xB8, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC4, 0x9C, 0xA2,
  0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x0C, 0xC4,
  0x09, 0x02, 0xC0, 0xE0, 0x18, 0x07, 0x03, 0x40, 0x98, 0x61, 0xE0, 0x9C,
  0xE6, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBE, 0x80, 0x80,
  0x80, 0x80, 0x39, 0x67, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43,
  0x3D, 0x01, 0x01, 0x01, 0x01, 0x9F, 0xE7, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x3C, 0x63, 0xC1, 0x80, 0x40, 0x3C, 0x03, 0x01, 0x81,
  0xC1, 0x7E, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x0F, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC3, 0x7D, 0x80, 0x70, 0x24, 0x09, 0x86, 0x21, 0x08, 0x41, 0x20, 0x48,
  0x1E, 0x03, 0x00, 0xC0, 0x84, 0x71, 0x8A, 0x31, 0x46, 0x24, 0xA4, 0xA5,
  0x14, 0xA2, 0x94, 0x51, 0x84, 0x30, 0x84, 0x00, 0xC0, 0xD8, 0x22, 0x10,
  0x48, 0x0E, 0x03, 0x00, 0xC0, 0x48, 0x31, 0x18, 0x6C, 0x0C, 0x80, 0x70,
  0x34, 0x09, 0x02, 0x21, 0x08, 0x41, 0x30, 0x48, 0x1E, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x04, 0x0F, 0x00, 0x7F, 0x80, 0x20, 0x10, 0x08, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC, 0x02, 0x18, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x10, 0xC3, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20,
  0x30, 0xFF, 0xFF, 0x80, 0x80, 0xC0, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x18, 0x38, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0x86, 0x00, 0x70, 0x36,
  0x18, 0x46, 0x0E,
};

const GFXglyph RobotoMono_Light20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 14, 12, 5, -14 },
  { 5, 4, 4, 12, 4, -15 },
  { 7, 11, 14, 12, 1, -14 },
  { 27, 9, 18, 12, 2, -16 },
  { 48, 12, 14, 12, 0, -14 },
  { 69, 11, 14, 12, 1, -14 },
  { 89, 1, 4, 12, 5, -15 },
  { 90, 4, 21, 12, 4, -16 },
  { 101, 5, 21, 12, 3, -16 },
  { 115, 9, 8, 12, 2, -14 },
  { 124, 10, 11, 12, 1, -12 },
  { 138, 2, 5, 12, 4, -2 },
  { 140, 8, 1, 12, 2, -7 },
  { 141, 2, 2, 12, 5, -2 },
  { 142, 7, 15, 12, 3, -14 },
  { 156, 9, 14, 12, 2, -14 },
  { 172, 5, 14, 12, 2, -14 },
  { 181, 9, 14, 12, 1, -14 },
  { 197, 9, 14, 12, 1, -14 },
  { 213, 10, 14, 12, 1, -14 },
  { 231, 9, 14, 12, 2, -14 },
  { 247, 9, 14, 12, 1, -14 },
  { 263, 10, 14, 12, 1, -14 },
  { 281, 9, 14, 12, 2, -14 },
  { 297, 8, 14, 12, 2, -14 },
  { 311, 2, 11, 12, 6, -11 },
  { 314, 3, 14, 12, 5, -11 },
  { 320, 8, 9, 12, 2, -11 },
  { 329, 8, 5, 12, 2, -9 },
  { 334, 8, 9, 12, 2, -11 },
  { 343, 8, 14, 12, 2, -14 },
  { 357, 10, 14, 12, 1, -14 },
  { 375, 10, 14, 12, 1, -14 },
  { 393, 9, 14, 12, 2, -14 },
  { 409, 10, 14, 12, 1, -14 },
  { 427, 9, 14, 12, 2, -14 },
  { 443, 8, 14, 12, 2, -14 },
  { 457, 8, 14, 12, 2, -14 },
  { 471, 10, 14, 12, 1, -14 },
  { 489, 8, 14, 12, 2, -14 },
  { 503, 8, 14, 12, 2, -14 },
  { 517, 9, 14, 12, 1, -14 },
  { 533, 10, 14, 12, 2, -14 },
  { 551, 9, 14, 12, 2, -14 },
  { 567, 9, 14, 12, 2, -14 },
  { 583, 8, 14, 12, 2, -14 },
  { 597, 10, 14, 12, 1, -14 },
  { 615, 9, 14, 12, 2, -14 },
  { 631, 10, 16, 12, 1, -14 },
  { 651, 9, 14, 12, 2, -14 },
  { 667, 10, 14, 12, 1, -14 },
  { 685, 10, 14, 12, 1, -14 },
  { 703, 8, 14, 12, 2, -14 },
  { 717, 10, 14, 12, 1, -14 },
  { 735, 11, 14, 12, 1, -14 },
  { 755, 10, 14, 12, 1, -14 },
  { 773, 10, 14, 12, 1, -14 },
  { 791, 9, 14, 12, 1, -14 },
  { 807, 4, 19, 12, 4, -16 },
  { 817, 7, 15, 12, 3, -14 },
  { 831, 4, 19, 12, 4, -16 },
  { 841, 8, 7, 12, 2, -14 },
  { 848, 8, 1, 12, 2, 0 },
  { 849, 4, 3, 12, 4, -15 },
  { 851, 8, 11, 12, 2, -11 },
  { 862, 8, 15, 12, 2, -15 },
  { 877, 8, 11, 12, 2, -11 },
  { 888, 8, 15, 12, 2, -15 },
  { 903, 10, 11, 12, 1, -11 },
  { 917, 9, 15, 12, 2, -15 },
  { 934, 8, 15, 12, 2, -11 },
  { 949, 8, 15, 12, 2, -15 },
  { 964, 9, 14, 12, 2, -14 },
  { 980, 6, 18, 12, 2, -14 },
  { 994, 9, 15, 12, 2, -15 },
  { 1011, 9, 15, 12, 2, -15 },
  { 1028, 10, 11, 12, 1, -11 },
  { 1042, 8, 11, 12, 2, -11 },
  { 1053, 10, 11, 12, 1, -11 },
  { 1067, 8, 15, 12, 2, -11 },
  { 1082, 8, 15, 12, 2, -11 },
  { 1097, 7, 11, 12, 4, -11 },
  { 1107, 8, 11, 12, 2, -11 },
  { 1118, 8, 13, 12, 2, -13 },
  { 1131, 8, 11, 12, 2, -11 },
  { 1142, 10, 11, 12, 1, -11 },
  { 1156, 11, 11, 12, 1, -11 },
  { 1172, 10, 11, 12, 1, -11 },
  { 1186, 10, 15, 12, 1, -11 },
  { 1205, 10, 11, 12, 1, -11 },
  { 1219, 7, 20, 12, 3, -16 },
  { 1237, 1, 17, 12, 6, -14 },
  { 1240, 7, 20, 12, 3, -16 },
  { 1258, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoMono_Light20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light20pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_LIGHT20PT7B_H_
