#ifndef _ROBOTOMONO_LIGHT43PT7B_H_
#define _ROBOTOMONO_LIGHT43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x61, 0xB0, 0xD8, 0x6C, 0x36, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0x80,
  0x00, 0x30, 0x38, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60,
  0x00, 0xC0, 0x60, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0xC0, 0xC0,
  0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07,
  0xC7, 0xC1, 0xC0, 0x3C, 0x30, 0x03, 0x8E, 0x00, 0x39, 0x80, 0x07, 0x30,
  0x00, 0x66, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0x9C, 0x00, 0x73, 0x80,
  0x1E, 0x3C, 0x07, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x61, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x40, 0xC0, 0x60, 0xE0,
  0xC0, 0x60, 0xC0, 0xC0, 0x61, 0xC0, 0xC0, 0xE1, 0x80, 0xC0, 0xC3, 0x00,
  0xE0, 0xC3, 0x00, 0x71, 0xC6, 0x00, 0x3F, 0x86, 0x00, 0x1E, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0xF8, 0x00, 0x61, 0xDC, 0x00, 0xC3, 0x06, 0x00, 0xC7, 0x06,
  0x01, 0x86, 0x03, 0x01, 0x86, 0x03, 0x03, 0x06, 0x03, 0x03, 0x06, 0x03,
  0x06, 0x06, 0x03, 0x02, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF1, 0xC0, 0x07,
  0x03, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01,
  0x80, 0x18, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x03, 0x9C, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xE3, 0x80, 0x67, 0x07, 0x03, 0x9C, 0x0E, 0x0E, 0xE0, 0x1C,
  0x3B, 0x80, 0x70, 0xCC, 0x00, 0xE3, 0x30, 0x01, 0xDC, 0xC0, 0x03, 0xE3,
  0x80, 0x07, 0x8E, 0x00, 0x1C, 0x1C, 0x00, 0xF8, 0x38, 0x0F, 0x70, 0x7F,
  0xF8, 0xE0, 0xFF, 0x83, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x70, 0x38,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x40, 0x38, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x02, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x30, 0x18, 0x17, 0xC3, 0x1F, 0xFE, 0x6F, 0xE1, 0xFF, 0xC0, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x01, 0xC7, 0x00, 0x70, 0x70,
  0x1C, 0x07, 0x07, 0x80, 0xF0, 0x20, 0x08, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x39, 0xCE, 0x73, 0x99, 0xCE, 0x66,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xFE, 0xE0, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0, 0x38, 0x38, 0x01,
  0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00,
  0x0E, 0xE0, 0x03, 0xEE, 0x00, 0x77, 0xE0, 0x0E, 0x7E, 0x01, 0xC7, 0xE0,
  0x38, 0x7E, 0x07, 0x07, 0xE0, 0xE0, 0x7E, 0x1C, 0x07, 0xE3, 0x00, 0x7E,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x06, 0x70, 0x00, 0x66, 0x00, 0x06,
  0x70, 0x00, 0xE7, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0x80, 0x38, 0x1E, 0x07,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xFF,
  0xCF, 0xE1, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x1F, 0x03, 0x80, 0x38, 0x70,
  0x01, 0xC6, 0x00, 0x1C, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x7C, 0x3C, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1D, 0xC0, 0x03, 0x1C,
  0x00, 0xE3, 0xC0, 0x78, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0D,
  0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x80, 0x06, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x07, 0x00, 0x30, 0x38, 0x03, 0x81, 0xC0, 0x18, 0x0E,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0,
  0x07, 0x06, 0x00, 0x38, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x30, 0x03,
  0x7F, 0xC0, 0x7F, 0xFE, 0x0F, 0x07, 0xE3, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0x00, 0x07, 0x60, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x1C,
  0x03, 0xC1, 0xF1, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0xFE, 0x06, 0x7F, 0xE1, 0xDE, 0x1E, 0x3F, 0x00, 0xE7, 0x80, 0x0E, 0xF0,
  0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xEE, 0x00, 0x18, 0xE0,
  0x07, 0x1E, 0x01, 0xC1, 0xE0, 0x78, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x7C,
  0x1C, 0x03, 0xC7, 0x00, 0x1C, 0xE0, 0x03, 0x98, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x80, 0x38,
  0x38, 0x0E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xBF, 0x07, 0x00, 0x71,
  0xC0, 0x07, 0x70, 0x00, 0x6E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x38, 0x00, 0xE3,
  0xC0, 0x78, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x7C, 0x3C, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x33,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x80, 0x07, 0x38, 0x01, 0xE7,
  0x80, 0xEC, 0x78, 0x79, 0x87, 0xFE, 0x70, 0x3F, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0xEF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x38, 0xF7, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x38,
  0xE3, 0x8C, 0x71, 0xC6, 0x30, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x8F, 0x8E, 0x01,
  0xCE, 0x00, 0x77, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0xF0, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38, 0x3F, 0x06, 0x30, 0x7B,
  0x86, 0x30, 0xE1, 0x86, 0x60, 0xC1, 0x86, 0x61, 0x81, 0x82, 0x61, 0x81,
  0x82, 0x41, 0x81, 0x82, 0xC3, 0x01, 0x82, 0xC3, 0x01, 0x02, 0xC3, 0x01,
  0x02, 0xC3, 0x01, 0x02, 0xC3, 0x03, 0x06, 0xC3, 0x03, 0x06, 0xC3, 0x07,
  0x04, 0x61, 0x85, 0x0C, 0x61, 0xDD, 0x9C, 0x60, 0xF9, 0xF8, 0x60, 0x60,
  0x60, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xB0, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x18,
  0x70, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0x60, 0x06, 0x01, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x0C, 0x03,
  0x00, 0x38, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x9C, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x70, 0x07, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x07, 0x70,
  0x00, 0xCE, 0x00, 0x39, 0xC0, 0x1E, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xE0,
  0x1F, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0x70, 0x01, 0xEE, 0x01, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC7,
  0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60,
  0x00, 0x67, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x1E, 0x07, 0x80,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0C, 0x01, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00,
  0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E,
  0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x07,
  0x8C, 0x00, 0xF0, 0xC0, 0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC,
  0x01, 0xF1, 0xF0, 0x1C, 0x03, 0xC1, 0xC0, 0x0F, 0x1C, 0x00, 0x38, 0xE0,
  0x00, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x38, 0x00,
  0x19, 0xC0, 0x00, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x70, 0xF0, 0x0F, 0x01,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x6E, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01,
  0xC3, 0x80, 0x3C, 0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xE0,
  0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x78,
  0x70, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x03,
  0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x03,
  0x9E, 0x00, 0x1D, 0xF8, 0x00, 0xFD, 0xC0, 0x07, 0xC7, 0x00, 0x3C, 0x1C,
  0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xF1, 0xC0, 0x03,
  0x8E, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xE0, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xEC, 0x03,
  0xFE, 0xC0, 0x37, 0xEE, 0x07, 0x7E, 0x60, 0x67, 0xE6, 0x06, 0x7E, 0x70,
  0xE7, 0xE3, 0x0C, 0x7E, 0x31, 0xC7, 0xE3, 0x98, 0x7E, 0x19, 0x87, 0xE1,
  0xB8, 0x7E, 0x1F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0x60, 0x7E,
  0x06, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFB, 0x00, 0x1F, 0x70, 0x03, 0xE6, 0x00, 0x7C, 0xE0,
  0x0F, 0x8C, 0x01, 0xF1, 0xC0, 0x3E, 0x1C, 0x07, 0xC3, 0x80, 0xF8, 0x38,
  0x1F, 0x07, 0x03, 0xE0, 0x70, 0x7C, 0x06, 0x0F, 0x80, 0xE1, 0xF0, 0x0C,
  0x3E, 0x01, 0xC7, 0xC0, 0x18, 0xF8, 0x03, 0x9F, 0x00, 0x3B, 0xE0, 0x07,
  0x7C, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x18, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0,
  0x38, 0x38, 0x01, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0xE0,
  0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x76, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC3, 0xC0,
  0x38, 0x1E, 0x07, 0x80, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x60, 0x03, 0xCC, 0x00, 0x39, 0x80, 0x03, 0xB0,
  0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0xE6, 0x00, 0x3C, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x78, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0x80, 0x00, 0x66, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xC1, 0x80,
  0x06, 0x07, 0x00, 0x38, 0x0F, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0E, 0x00, 0x78,
  0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xCE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x03, 0x8E, 0x00, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x06, 0x0E,
  0x00, 0x70, 0xE0, 0x03, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0x8E, 0x00, 0x1C,
  0xE0, 0x00, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0x0F, 0x83, 0xC0, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x06, 0x70,
  0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x37, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0x70, 0x00, 0x73, 0x80, 0x0E, 0x1E, 0x03, 0xC0, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x01, 0xC3,
  0x80, 0x3C, 0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x66, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x31,
  0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0x60,
  0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x30, 0x0C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0C, 0x00,
  0x30, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18,
  0xE0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x30, 0x0F, 0x80, 0x70, 0x1F, 0x00, 0xE0, 0x37, 0x01, 0xC0, 0x6E,
  0x07, 0x80, 0xDC, 0x0F, 0x01, 0x98, 0x1F, 0x03, 0x30, 0x36, 0x0E, 0x60,
  0x6C, 0x1C, 0xC1, 0xD8, 0x31, 0xC3, 0x30, 0x63, 0x86, 0x60, 0xC7, 0x0C,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0x31, 0x8E, 0x18, 0xC3, 0x1C, 0x31, 0x86,
  0x30, 0x63, 0x0E, 0x60, 0xE6, 0x0C, 0xC1, 0xCC, 0x19, 0x81, 0xB8, 0x33,
  0x03, 0x60, 0x66, 0x06, 0xC0, 0xFC, 0x0D, 0x80, 0xF0, 0x1B, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x00, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0xE3,
  0x80, 0x03, 0x8E, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x38, 0x03, 0x80, 0xE0,
  0x1C, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x70,
  0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0x87, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x03, 0x81, 0xC0, 0x06, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x39, 0xC0, 0x00, 0xEF, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03,
  0x81, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x38, 0x0E, 0x00,
  0x60, 0x30, 0x01, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0E, 0x38, 0x00, 0x18,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x18,
  0x18, 0x38, 0x18, 0x30, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x86, 0x0C, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xC0, 0xF1, 0xC0, 0x0E, 0x60, 0x03, 0xB8, 0x00, 0x6E,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x7F, 0xFC, 0x7F,
  0xFF, 0x78, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0x70, 0x1D, 0xCF, 0xFE, 0x71,
  0xFE, 0x0C, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x7F, 0x03, 0xBF, 0xF8, 0x7F, 0x0F, 0x8F, 0x80, 0x71, 0xE0, 0x07, 0x38,
  0x00, 0x67, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0x70,
  0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x37, 0x00, 0x06, 0xE0,
  0x00, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xF8,
  0x1E, 0x3B, 0xFF, 0x87, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3C,
  0x1E, 0x0E, 0x00, 0xE3, 0x80, 0x0C, 0x60, 0x01, 0xDC, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x6E, 0x00,
  0x1C, 0xE0, 0x03, 0x8E, 0x00, 0xE1, 0xE0, 0x38, 0x1F, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x7F,
  0x1C, 0x3F, 0xF3, 0x8F, 0x07, 0x73, 0xC0, 0x3E, 0x70, 0x03, 0xDC, 0x00,
  0x3B, 0x80, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x3E, 0x3C, 0x0F,
  0xC3, 0xFF, 0xB8, 0x3F, 0xC7, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x07,
  0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x41, 0xC0, 0x0E, 0x1E, 0x01, 0xC0, 0x7F, 0xF8,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x20, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xF8, 0xE1, 0xFF, 0x9C, 0x78, 0x3B, 0x9E, 0x01, 0xF3,
  0x80, 0x1E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xD8,
  0x00, 0x3B, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x07, 0x9C,
  0x01, 0xF1, 0xE0, 0x7E, 0x1F, 0xFD, 0xC1, 0xFE, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x18, 0x00, 0xE3, 0x80, 0x38, 0x3C,
  0x1E, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x7F, 0x0E, 0x7F, 0xE3, 0xB8, 0x3C, 0xF8, 0x03, 0xBC,
  0x00, 0x6F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x8F, 0xFC,
  0x3F, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0xEC, 0x00, 0x73, 0x00, 0x38, 0xC0, 0x3C, 0x30, 0x1E, 0x0C, 0x0F, 0x03,
  0x07, 0x80, 0xC3, 0xC0, 0x31, 0xE0, 0x0C, 0xE0, 0x03, 0x7C, 0x00, 0xFF,
  0x80, 0x3C, 0xE0, 0x0E, 0x1C, 0x03, 0x03, 0x80, 0xC0, 0x70, 0x30, 0x0E,
  0x0C, 0x03, 0xC3, 0x00, 0x70, 0xC0, 0x0E, 0x30, 0x01, 0xCC, 0x00, 0x3B,
  0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xC3, 0xE3, 0x7F, 0x9F, 0xEF, 0x0F, 0xC3, 0xB8, 0x1E,
  0x07, 0xE0, 0x30, 0x1F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03,
  0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30,
  0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x3C, 0x03, 0x00, 0xC0, 0xC1, 0xFC, 0x31, 0xFF, 0x8C, 0xE0,
  0xF3, 0xE0, 0x0E, 0xF0, 0x01, 0xBC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1C, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x1E, 0x0F, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x00,
  0x0E, 0x60, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xC3, 0x80, 0x1C,
  0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xC3, 0xF8, 0x3B, 0xFF,
  0x8F, 0xE1, 0xF3, 0xE0, 0x1C, 0xF0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x6E, 0x00, 0x3B, 0xC0, 0x1C, 0xFC, 0x0F, 0x3B, 0xFF, 0x8E, 0x7F, 0x83,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0xE1, 0xFF,
  0x9C, 0x78, 0x3F, 0x9E, 0x01, 0xF3, 0x80, 0x1E, 0xE0, 0x01, 0xDC, 0x00,
  0x3B, 0x00, 0x07, 0x60, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xF1, 0xE0, 0x7E, 0x1F, 0xFD,
  0xC1, 0xFE, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xC1, 0xFF, 0x8F, 0xFB, 0x3E, 0x16, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xC0, 0xF9, 0xE0, 0x0E, 0x70, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x0D,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0D, 0xC0, 0x07, 0x38, 0x07, 0x87, 0xFF, 0xC0, 0x7F, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00,
  0x3D, 0xC0, 0x1F, 0x38, 0x0F, 0xC7, 0xFF, 0x70, 0xFF, 0x1C, 0xE0, 0x00,
  0x1B, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x60, 0x00, 0x63, 0x80, 0x07, 0x1C,
  0x00, 0x30, 0x60, 0x03, 0x83, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x70, 0x30, 0x01, 0x83, 0x80, 0x0E,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x37, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x18, 0x07, 0x60, 0x18, 0x07, 0x60, 0x18, 0x06, 0x60, 0x3C, 0x06, 0x70,
  0x3C, 0x06, 0x70, 0x3C, 0x0E, 0x30, 0x3C, 0x0C, 0x30, 0x66, 0x0C, 0x30,
  0x66, 0x0C, 0x38, 0x66, 0x0C, 0x18, 0x66, 0x1C, 0x18, 0xC3, 0x18, 0x18,
  0xC3, 0x18, 0x18, 0xC3, 0x18, 0x1C, 0xC3, 0x18, 0x0D, 0x81, 0xB0, 0x0D,
  0x81, 0xB0, 0x0D, 0x81, 0xB0, 0x0D, 0x80, 0xB0, 0x07, 0x00, 0xF0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x60, 0xE0, 0x00, 0x73, 0x80,
  0x07, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x03, 0x80,
  0x1C, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x70, 0x00,
  0x61, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x38, 0x07, 0x00, 0xE0, 0x70, 0x03,
  0x83, 0x80, 0x0E, 0x38, 0x00, 0x73, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x76, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0x06, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0C, 0x0C, 0x00,
  0x38, 0x70, 0x00, 0x61, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x04, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x80, 0xF8, 0x03,
  0x80, 0x0F, 0x80, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0xF0, 0x0F, 0xC0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x3F, 0xF0, 0x06, 0x70, 0x78,
  0x06, 0x60, 0x3C, 0x0E, 0xE0, 0x0F, 0x1C, 0xC0, 0x07, 0xFC, 0x00, 0x01,
  0xF0,
};

const GFXglyph RobotoMono_Light43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 3, 31, 26, 11, -31 },
  { 13, 9, 9, 26, 8, -32 },
  { 24, 24, 31, 26, 1, -31 },
  { 117, 19, 39, 26, 4, -35 },
  { 210, 24, 31, 26, 1, -31 },
  { 303, 22, 31, 26, 3, -31 },
  { 389, 2, 9, 26, 11, -32 },
  { 392, 10, 44, 26, 8, -34 },
  { 447, 10, 44, 26, 7, -34 },
  { 502, 19, 19, 26, 4, -31 },
  { 548, 21, 22, 26, 2, -25 },
  { 606, 5, 10, 26, 8, -4 },
  { 613, 16, 2, 26, 5, -15 },
  { 617, 5, 4, 26, 11, -4 },
  { 620, 15, 34, 26, 6, -31 },
  { 684, 20, 31, 26, 3, -31 },
  { 762, 11, 31, 26, 5, -31 },
  { 805, 20, 31, 26, 2, -31 },
  { 883, 19, 31, 26, 2, -31 },
  { 957, 21, 31, 26, 2, -31 },
  { 1039, 19, 31, 26, 4, -31 },
  { 1113, 19, 31, 26, 3, -31 },
  { 1187, 20, 31, 26, 3, -31 },
  { 1265, 19, 31, 26, 4, -31 },
  { 1339, 19, 31, 26, 3, -31 },
  { 1413, 4, 22, 26, 13, -22 },
  { 1424, 6, 28, 26, 11, -22 },
  { 1445, 18, 18, 26, 3, -23 },
  { 1486, 18, 11, 26, 4, -19 },
  { 1511, 18, 18, 26, 4, -23 },
  { 1552, 17, 31, 26, 5, -31 },
  { 1618, 24, 31, 26, 1, -31 },
  { 1711, 22, 31, 26, 2, -31 },
  { 1797, 19, 31, 26, 4, -31 },
  { 1871, 20, 31, 26, 3, -31 },
  { 1949, 20, 31, 26, 4, -31 },
  { 2027, 18, 31, 26, 4, -31 },
  { 2097, 18, 31, 26, 4, -31 },
  { 2167, 21, 31, 26, 2, -31 },
  { 2249, 19, 31, 26, 3, -31 },
  { 2323, 18, 31, 26, 4, -31 },
  { 2393, 20, 31, 26, 2, -31 },
  { 2471, 21, 31, 26, 4, -31 },
  { 2553, 18, 31, 26, 5, -31 },
  { 2623, 20, 31, 26, 3, -31 },
  { 2701, 19, 31, 26, 3, -31 },
  { 2775, 20, 31, 26, 3, -31 },
  { 2853, 19, 31, 26, 5, -31 },
  { 2927, 22, 36, 26, 2, -31 },
  { 3026, 20, 31, 26, 4, -31 },
  { 3104, 20, 31, 26, 3, -31 },
  { 3182, 22, 31, 26, 2, -31 },
  { 3268, 20, 31, 26, 3, -31 },
  { 3346, 22, 31, 26, 2, -31 },
  { 3432, 23, 31, 26, 2, -31 },
  { 3522, 22, 31, 26, 2, -31 },
  { 3608, 22, 31, 26, 2, -31 },
  { 3694, 19, 31, 26, 3, -31 },
  { 3768, 8, 42, 26, 9, -35 },
  { 3810, 16, 34, 26, 5, -31 },
  { 3878, 7, 42, 26, 9, -35 },
  { 3915, 16, 17, 26, 5, -31 },
  { 3949, 18, 2, 26, 4, 0 },
  { 3954, 6, 5, 26, 10, -31 },
  { 3958, 18, 23, 26, 4, -23 },
  { 4010, 19, 32, 26, 4, -32 },
  { 4086, 19, 23, 26, 3, -23 },
  { 4141, 19, 32, 26, 3, -32 },
  { 4217, 20, 23, 26, 3, -23 },
  { 4275, 20, 33, 26, 4, -33 },
  { 4358, 19, 32, 26, 3, -23 },
  { 4434, 18, 32, 26, 4, -32 },
  { 4506, 18, 31, 26, 5, -31 },
  { 4576, 14, 40, 26, 4, -31 },
  { 4646, 18, 32, 26, 5, -32 },
  { 4718, 18, 32, 26, 5, -32 },
  { 4790, 22, 23, 26, 2, -23 },
  { 4854, 18, 23, 26, 4, -23 },
  { 4906, 20, 23, 26, 3, -23 },
  { 4964, 18, 32, 26, 4, -23 },
  { 5036, 19, 32, 26, 3, -23 },
  { 5112, 15, 23, 26, 8, -23 },
  { 5156, 18, 23, 26, 4, -23 },
  { 5208, 18, 29, 26, 4, -29 },
  { 5274, 18, 23, 26, 4, -23 },
  { 5326, 21, 23, 26, 2, -23 },
  { 5387, 24, 23, 26, 1, -23 },
  { 5456, 21, 23, 26, 3, -23 },
  { 5517, 22, 32, 26, 2, -23 },
  { 5605, 20, 23, 26, 3, -23 },
  { 5663, 14, 42, 26, 7, -34 },
  { 5737, 2, 38, 26, 12, -31 },
  { 5747, 14, 42, 26, 7, -34 },
  { 5821, 24, 8, 26, 1, -17 },
};

const GFXfont RobotoMono_Light43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light43pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_LIGHT43PT7B_H_
