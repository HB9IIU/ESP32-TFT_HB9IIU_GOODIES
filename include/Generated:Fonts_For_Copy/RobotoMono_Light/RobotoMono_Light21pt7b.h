#ifndef _ROBOTOMONO_LIGHT21PT7B_H_
#define _ROBOTOMONO_LIGHT21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFC, 0x1C, 0x99, 0x99, 0x90, 0x08, 0xC1, 0x10, 0x22,
  0x04, 0x4F, 0xFE, 0x22, 0x04, 0x40, 0x88, 0x11, 0x06, 0x23, 0xFF, 0x11,
  0x02, 0x20, 0x44, 0x18, 0x80, 0x08, 0x04, 0x0F, 0x8C, 0x64, 0x1E, 0x07,
  0x00, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x02, 0x82, 0x3E,
  0x04, 0x02, 0x00, 0x78, 0x04, 0x80, 0x84, 0x48, 0x48, 0x45, 0x84, 0x90,
  0x32, 0x00, 0x20, 0x04, 0x40, 0x5B, 0x09, 0x10, 0x91, 0x11, 0x10, 0x11,
  0x00, 0xE0, 0x1E, 0x06, 0x60, 0x84, 0x10, 0x82, 0x20, 0x68, 0x06, 0x01,
  0xC0, 0x64, 0x28, 0xCF, 0x0D, 0x60, 0xA4, 0x08, 0xC3, 0x8F, 0x98, 0xF8,
  0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x18, 0x42, 0x08,
  0x41, 0x04, 0x88, 0x42, 0x23, 0x11, 0x11, 0x11, 0x11, 0x11, 0x32, 0x24,
  0x88, 0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0x60, 0x50, 0x44, 0x61, 0x00,
  0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xFF, 0xF0, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x55, 0x80, 0xFF, 0xB0, 0x02, 0x04, 0x10, 0x20, 0xC1, 0x02,
  0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x10, 0x40, 0x3E, 0x21, 0xB0, 0x50,
  0x38, 0x1C, 0x16, 0x13, 0x11, 0x90, 0xD0, 0x70, 0x30, 0x1C, 0x12, 0x18,
  0xF8, 0x0C, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x3E, 0x18, 0x4C, 0x1A, 0x02, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC, 0x3E, 0x30, 0x90, 0x30,
  0x10, 0x08, 0x0C, 0x0C, 0x3C, 0x01, 0x00, 0x40, 0x30, 0x1C, 0x0B, 0x0C,
  0xF8, 0x03, 0x00, 0xC0, 0x50, 0x34, 0x09, 0x04, 0x41, 0x10, 0x84, 0x41,
  0x10, 0x4F, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x10, 0x7F, 0xA0, 0x10, 0x08,
  0x04, 0x02, 0x61, 0xFC, 0x86, 0x01, 0x80, 0x40, 0x30, 0x1C, 0x1B, 0x18,
  0xF8, 0x0E, 0x18, 0x18, 0x08, 0x08, 0x04, 0xE3, 0x8D, 0x02, 0x81, 0xC0,
  0x60, 0x30, 0x38, 0x12, 0x18, 0xF8, 0xFF, 0xC0, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x03,
  0x00, 0x3E, 0x31, 0xB0, 0x70, 0x18, 0x0A, 0x0D, 0x8C, 0x7C, 0x41, 0x40,
  0x60, 0x30, 0x18, 0x0A, 0x0C, 0xF8, 0x3E, 0x21, 0xA0, 0x50, 0x38, 0x0C,
  0x06, 0x03, 0x03, 0x42, 0x9E, 0xC0, 0x40, 0x20, 0x20, 0x30, 0xE0, 0xF0,
  0x00, 0x3C, 0x6C, 0x00, 0x00, 0x0D, 0xB5, 0x80, 0x01, 0x07, 0x18, 0xE0,
  0xC0, 0x70, 0x0C, 0x03, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x18, 0x70, 0xE1, 0x80, 0x80, 0x00, 0x3E, 0x31,
  0xB0, 0x50, 0x30, 0x10, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x60, 0x0F, 0x06, 0x19, 0x01, 0x23, 0x18, 0x93, 0x22, 0x64,
  0x4C, 0x89, 0xA1, 0x32, 0x46, 0x55, 0x4E, 0xCC, 0x00, 0xC2, 0x0F, 0xC0,
  0x04, 0x01, 0x80, 0x28, 0x05, 0x01, 0xA0, 0x22, 0x04, 0x41, 0x88, 0x20,
  0x84, 0x10, 0xFE, 0x20, 0x64, 0x04, 0x80, 0xA0, 0x18, 0xFC, 0x41, 0xA0,
  0x70, 0x18, 0x0C, 0x0A, 0x0D, 0xFC, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x1B, 0xF8, 0x1F, 0x08, 0x66, 0x0D, 0x01, 0x40, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x05, 0x01, 0x40, 0xC8, 0x21, 0xF0, 0xFC, 0x21, 0x88,
  0x12, 0x06, 0x80, 0xA0, 0x28, 0x0E, 0x03, 0x80, 0xE0, 0x28, 0x0A, 0x02,
  0x81, 0x21, 0x8F, 0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x1F, 0x0C, 0x66, 0x0D, 0x01, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x83, 0xF0, 0x1C, 0x05, 0x01, 0x60, 0x4C, 0x31, 0xF8, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0A, 0x02, 0x40, 0x98,
  0x43, 0xE0, 0x80, 0xE0, 0x48, 0x32, 0x18, 0x8C, 0x22, 0x09, 0x02, 0xE0,
  0xC8, 0x21, 0x08, 0x62, 0x0C, 0x81, 0x20, 0x28, 0x0C, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0xFE, 0x81, 0xE0, 0xF0, 0x7C, 0x5A, 0x2D, 0x36, 0xD3, 0x29, 0x98,
  0xC4, 0x62, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x80, 0xE0, 0x70, 0x3C, 0x1A,
  0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0xB0, 0x58, 0x3C, 0x0E, 0x06,
  0x1F, 0x0C, 0x66, 0x09, 0x01, 0x40, 0x70, 0x18, 0x06, 0x01, 0x80, 0x70,
  0x1C, 0x05, 0x01, 0x60, 0x88, 0x61, 0xF0, 0xFE, 0x20, 0x68, 0x0A, 0x03,
  0x80, 0xE0, 0x38, 0x0A, 0x0C, 0xFE, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x1F, 0x04, 0x31, 0x03, 0x20, 0x2C, 0x05, 0x00, 0xA0, 0x1C,
  0x03, 0x80, 0x70, 0x0B, 0x01, 0x20, 0x24, 0x0C, 0x43, 0x07, 0xC0, 0x0C,
  0x00, 0x60, 0x08, 0xFC, 0x20, 0xC8, 0x1A, 0x02, 0x80, 0xA0, 0x28, 0x1A,
  0x0C, 0xFC, 0x21, 0x88, 0x22, 0x0C, 0x81, 0x20, 0x68, 0x0C, 0x1F, 0x08,
  0x24, 0x05, 0x01, 0x40, 0x18, 0x03, 0x80, 0x3C, 0x01, 0x80, 0x30, 0x07,
  0x01, 0x40, 0x58, 0x31, 0xF0, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x12, 0x18, 0xF8, 0x80, 0x78, 0x09, 0x01, 0x20,
  0x66, 0x08, 0x41, 0x08, 0x61, 0x88, 0x11, 0x02, 0x60, 0x48, 0x05, 0x00,
  0xE0, 0x18, 0x01, 0x00, 0x84, 0x30, 0x86, 0x30, 0xC5, 0x3C, 0xA4, 0x94,
  0x92, 0x92, 0x52, 0x51, 0x4A, 0x29, 0x45, 0x38, 0xC3, 0x18, 0x43, 0x08,
  0x20, 0xC0, 0x6C, 0x18, 0x82, 0x18, 0xC1, 0x10, 0x14, 0x03, 0x80, 0x20,
  0x0A, 0x03, 0x40, 0x44, 0x18, 0xC2, 0x08, 0x81, 0xB0, 0x18, 0x80, 0x68,
  0x19, 0x02, 0x10, 0xC2, 0x10, 0x26, 0x04, 0x80, 0x70, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x7F, 0xC0, 0x20, 0x18, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0F, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x70, 0x81, 0x01,
  0x02, 0x04, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x81, 0x01,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x60,
  0xA3, 0x44, 0xC8, 0xA1, 0x41, 0xFF, 0x80, 0xCC, 0x3E, 0x60, 0xA0, 0x40,
  0x30, 0x1B, 0xFF, 0x07, 0x03, 0x81, 0xE1, 0xDF, 0x60, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x05, 0xF3, 0x0D, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0B, 0x0D, 0x7C, 0x3E, 0x20, 0xB0, 0x70, 0x18, 0x04, 0x02, 0x01, 0x00,
  0xC1, 0xA0, 0x8F, 0x80, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x19, 0xED, 0x0F,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0D, 0x0E, 0x7B, 0x3E, 0x20,
  0xA0, 0x70, 0x1F, 0xFF, 0xFE, 0x01, 0x00, 0xC0, 0x30, 0xCF, 0x80, 0x07,
  0xC2, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xE1, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x3D, 0xA1, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xA1, 0xCF, 0x60, 0x30, 0x16, 0x19, 0xF8,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xFA, 0x85, 0x83, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x0C, 0x04, 0x00, 0x00, 0x0F, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x06,
  0x08, 0x00, 0x07, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x1B, 0xE0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x0E, 0x09,
  0x18, 0x98, 0x58, 0x3E, 0x19, 0x88, 0x44, 0x12, 0x05, 0x03, 0xF8, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x21, 0xFF, 0xBB, 0xD9, 0x8E, 0x10, 0xC2, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0x80, 0xBE, 0x50, 0xB0, 0x70,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x1F, 0x08, 0x64,
  0x0D, 0x01, 0xC0, 0x70, 0x1C, 0x05, 0x01, 0x40, 0xC8, 0x61, 0xF0, 0xBE,
  0x61, 0xA0, 0x50, 0x38, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x61, 0xAF, 0x90,
  0x08, 0x04, 0x02, 0x00, 0x3F, 0xA1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xC1, 0xA1, 0xCF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xBF, 0xC3, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x3E, 0x20, 0xB0, 0x38, 0x06,
  0x00, 0xF0, 0x04, 0x01, 0x80, 0xA0, 0xCF, 0xC0, 0x10, 0x08, 0x04, 0x1F,
  0xE1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x7C,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xA1, 0xCF,
  0x60, 0xC0, 0x50, 0x14, 0x08, 0x82, 0x21, 0x8C, 0x41, 0x10, 0x48, 0x0A,
  0x03, 0x00, 0x40, 0x84, 0x30, 0x86, 0x31, 0xE5, 0x24, 0xA4, 0x94, 0x94,
  0x92, 0x8C, 0x31, 0x84, 0x30, 0x82, 0x00, 0xC0, 0xC4, 0x10, 0x44, 0x0D,
  0x80, 0xE0, 0x08, 0x02, 0x80, 0x98, 0x31, 0x8C, 0x13, 0x01, 0x80, 0x80,
  0x68, 0x09, 0x03, 0x30, 0x42, 0x18, 0x62, 0x04, 0x40, 0xD0, 0x0A, 0x01,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x1C, 0x00, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x3F, 0xE0, 0x06, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0x11, 0xC1, 0x80, 0x81, 0x02, 0x04, 0x08, 0x18,
  0x10, 0x30, 0x30, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x08, 0x0C, 0x30, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x00,
  0x78, 0x31, 0x86, 0x1D, 0x00, 0xC0,
};

const GFXglyph RobotoMono_Light21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 2, 15, 13, 5, -15 },
  { 5, 4, 5, 13, 4, -16 },
  { 8, 11, 15, 13, 1, -15 },
  { 29, 9, 19, 13, 2, -17 },
  { 51, 12, 15, 13, 0, -15 },
  { 74, 11, 15, 13, 1, -15 },
  { 95, 1, 5, 13, 5, -16 },
  { 96, 5, 22, 13, 4, -17 },
  { 110, 4, 22, 13, 4, -17 },
  { 121, 9, 9, 13, 2, -15 },
  { 132, 10, 11, 13, 1, -12 },
  { 146, 2, 5, 13, 4, -2 },
  { 148, 8, 1, 13, 2, -7 },
  { 149, 2, 2, 13, 6, -2 },
  { 150, 7, 16, 13, 3, -15 },
  { 164, 9, 15, 13, 2, -15 },
  { 181, 6, 15, 13, 2, -15 },
  { 193, 10, 15, 13, 1, -15 },
  { 212, 9, 15, 13, 1, -15 },
  { 229, 10, 15, 13, 1, -15 },
  { 248, 9, 15, 13, 2, -15 },
  { 265, 9, 15, 13, 2, -15 },
  { 282, 10, 15, 13, 1, -15 },
  { 301, 9, 15, 13, 2, -15 },
  { 318, 9, 15, 13, 2, -15 },
  { 335, 2, 11, 13, 6, -11 },
  { 338, 3, 14, 13, 5, -11 },
  { 344, 8, 9, 13, 2, -11 },
  { 353, 9, 5, 13, 2, -9 },
  { 359, 9, 9, 13, 2, -11 },
  { 370, 9, 15, 13, 2, -15 },
  { 387, 11, 15, 13, 1, -15 },
  { 408, 11, 15, 13, 1, -15 },
  { 429, 9, 15, 13, 2, -15 },
  { 446, 10, 15, 13, 1, -15 },
  { 465, 10, 15, 13, 2, -15 },
  { 484, 9, 15, 13, 2, -15 },
  { 501, 9, 15, 13, 2, -15 },
  { 518, 10, 15, 13, 1, -15 },
  { 537, 9, 15, 13, 2, -15 },
  { 554, 9, 15, 13, 2, -15 },
  { 571, 10, 15, 13, 1, -15 },
  { 590, 10, 15, 13, 2, -15 },
  { 609, 9, 15, 13, 2, -15 },
  { 626, 9, 15, 13, 2, -15 },
  { 643, 9, 15, 13, 2, -15 },
  { 660, 10, 15, 13, 1, -15 },
  { 679, 10, 15, 13, 2, -15 },
  { 698, 11, 18, 13, 1, -15 },
  { 723, 10, 15, 13, 2, -15 },
  { 742, 10, 15, 13, 1, -15 },
  { 761, 11, 15, 13, 1, -15 },
  { 782, 9, 15, 13, 2, -15 },
  { 799, 11, 15, 13, 1, -15 },
  { 820, 11, 15, 13, 1, -15 },
  { 841, 11, 15, 13, 1, -15 },
  { 862, 11, 15, 13, 1, -15 },
  { 883, 10, 15, 13, 1, -15 },
  { 902, 3, 20, 13, 5, -17 },
  { 910, 7, 16, 13, 3, -15 },
  { 924, 4, 20, 13, 4, -17 },
  { 934, 7, 8, 13, 3, -15 },
  { 941, 9, 1, 13, 2, 0 },
  { 943, 3, 2, 13, 5, -15 },
  { 944, 9, 11, 13, 2, -11 },
  { 957, 9, 16, 13, 2, -16 },
  { 975, 9, 11, 13, 2, -11 },
  { 988, 9, 16, 13, 2, -16 },
  { 1006, 9, 11, 13, 2, -11 },
  { 1019, 10, 16, 13, 2, -16 },
  { 1039, 9, 15, 13, 2, -11 },
  { 1056, 9, 16, 13, 2, -16 },
  { 1074, 9, 15, 13, 2, -15 },
  { 1091, 7, 19, 13, 2, -15 },
  { 1108, 9, 16, 13, 2, -16 },
  { 1126, 9, 16, 13, 2, -16 },
  { 1144, 11, 11, 13, 1, -11 },
  { 1160, 9, 11, 13, 2, -11 },
  { 1173, 10, 11, 13, 1, -11 },
  { 1187, 9, 15, 13, 2, -11 },
  { 1204, 9, 15, 13, 2, -11 },
  { 1221, 7, 11, 13, 4, -11 },
  { 1231, 9, 11, 13, 2, -11 },
  { 1244, 9, 14, 13, 2, -14 },
  { 1260, 9, 11, 13, 2, -11 },
  { 1273, 10, 11, 13, 1, -11 },
  { 1287, 11, 11, 13, 1, -11 },
  { 1303, 11, 11, 13, 1, -11 },
  { 1319, 11, 15, 13, 1, -11 },
  { 1340, 9, 11, 13, 2, -11 },
  { 1353, 7, 20, 13, 3, -16 },
  { 1371, 1, 18, 13, 6, -15 },
  { 1374, 7, 20, 13, 3, -16 },
  { 1392, 11, 4, 13, 1, -8 },
};

const GFXfont RobotoMono_Light21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light21pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_LIGHT21PT7B_H_
