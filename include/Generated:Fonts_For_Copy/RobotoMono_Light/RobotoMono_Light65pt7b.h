#ifndef _ROBOTOMONO_LIGHT65PT7B_H_
#define _ROBOTOMONO_LIGHT65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light65pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xFF, 0xFD, 0xE0,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x38, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x81,
  0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x3C, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC1, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x03,
  0x80, 0x38, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xF0,
  0x78, 0x00, 0x07, 0xFF, 0x03, 0x80, 0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFE,
  0x00, 0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0xFF, 0xE0, 0x00, 0x1E,
  0x0F, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x38, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x3C, 0x01,
  0xC0, 0x38, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x01, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x70, 0x7C, 0x0F, 0x00, 0x1C, 0x1E, 0x03, 0xE0, 0x0F,
  0x0F, 0x00, 0x7C, 0x03, 0xC7, 0xC0, 0x0F, 0x80, 0xF1, 0xE0, 0x01, 0xE0,
  0x3C, 0x78, 0x00, 0x3C, 0x0E, 0x3C, 0x00, 0x0F, 0x87, 0x8F, 0x00, 0x01,
  0xF1, 0xE3, 0xC0, 0x00, 0x3E, 0xF0, 0xF0, 0x00, 0x07, 0xBC, 0x3C, 0x00,
  0x00, 0xFE, 0x07, 0x80, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0xFF, 0xC0,
  0x7E, 0x00, 0xFC, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0x03,
  0xC0, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x77, 0x77, 0x77,
  0x77, 0xFF, 0xFF, 0xEE, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x08, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x40, 0x07, 0x00,
  0x13, 0xC0, 0x38, 0x07, 0xBF, 0x81, 0xC0, 0xFD, 0xFF, 0x8E, 0x3F, 0xF3,
  0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0x7C, 0x01, 0xC0, 0x01, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x78, 0xF1, 0xC7, 0x9E, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF9,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7B, 0xFC, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0xF8, 0xFF,
  0x00, 0x0F, 0x87, 0xF8, 0x00, 0xF8, 0x3F, 0xC0, 0x0F, 0x81, 0xFE, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0xF0, 0x03, 0xFC, 0x0F, 0x00,
  0x1F, 0xE0, 0xF0, 0x00, 0xFF, 0x0F, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0x3F,
  0xDF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF9, 0xFF, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x8F, 0xFF, 0x00, 0x3B, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xE0, 0x07, 0xF8, 0x38, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x03,
  0xFF, 0x00, 0x70, 0xFF, 0xFC, 0x0F, 0x1F, 0xFF, 0xE0, 0xF7, 0xE0, 0x3F,
  0x0F, 0xF8, 0x00, 0xF8, 0xFE, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3C, 0xF8,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0xF0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3F, 0x3C, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xDC,
  0x1F, 0x00, 0x7C, 0xE0, 0x7F, 0xBF, 0xC7, 0x01, 0xFF, 0xFC, 0x78, 0x07,
  0xFF, 0x83, 0xC0, 0x07, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xF0, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x0F, 0x80, 0x70, 0x70, 0x07, 0xFC, 0x07, 0x0E, 0x01,
  0xFF, 0xC0, 0xE3, 0x80, 0x78, 0x38, 0x0C, 0x70, 0x1E, 0x03, 0x01, 0x8C,
  0x03, 0x80, 0x60, 0x3B, 0x80, 0xE0, 0x0C, 0x07, 0x70, 0x1C, 0x03, 0x80,
  0xEE, 0x07, 0x00, 0x70, 0x1D, 0x80, 0xE0, 0x0E, 0x03, 0xF0, 0x1C, 0x01,
  0xC0, 0x7E, 0x07, 0x00, 0x38, 0x0F, 0xC0, 0xE0, 0x07, 0x01, 0xF8, 0x1C,
  0x00, 0xC0, 0x3F, 0x03, 0x80, 0x18, 0x07, 0xE0, 0x70, 0x03, 0x00, 0xFC,
  0x0E, 0x00, 0x60, 0x1F, 0x81, 0xC0, 0x1C, 0x03, 0x70, 0x38, 0x03, 0x80,
  0x6E, 0x07, 0x00, 0x70, 0x1D, 0xC0, 0xE0, 0x1E, 0x03, 0xB8, 0x1C, 0x03,
  0xC0, 0x67, 0x03, 0xC0, 0xF8, 0x1C, 0x60, 0x38, 0x3B, 0x83, 0x0E, 0x07,
  0xFE, 0x79, 0xE1, 0xC0, 0x7F, 0x87, 0xF8, 0x38, 0x07, 0xE0, 0x7E, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x08, 0x00, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF0,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0,
  0x01, 0xFE, 0x0F, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7E,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7E, 0x3C, 0x00, 0x3F, 0xE1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x7E, 0x03,
  0x80, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x01, 0xF0, 0xE0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x1F, 0x03, 0x80, 0x01, 0xF8, 0x0E, 0x00, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x7E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF1,
  0xFC, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x00, 0xF7, 0xFE, 0x00, 0x00, 0xFF,
  0x9F, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0E, 0xFF, 0xE0, 0x00, 0xF7, 0xF7, 0x00, 0x07, 0xBF,
  0xBC, 0x00, 0x39, 0xFD, 0xE0, 0x03, 0xCF, 0xE7, 0x00, 0x1E, 0x7F, 0x3C,
  0x00, 0xE3, 0xF8, 0xE0, 0x0F, 0x1F, 0xC7, 0x00, 0x70, 0xFE, 0x3C, 0x07,
  0x87, 0xF0, 0xE0, 0x3C, 0x3F, 0x87, 0x81, 0xC1, 0xFC, 0x3C, 0x1E, 0x0F,
  0xE0, 0xE0, 0xE0, 0x7F, 0x07, 0x87, 0x03, 0xF8, 0x3C, 0x78, 0x1F, 0xC0,
  0xE3, 0x80, 0xFE, 0x07, 0xBC, 0x07, 0xF0, 0x3D, 0xE0, 0x3F, 0x80, 0xEE,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x03,
  0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x1C, 0x00, 0xFE, 0x00, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x7F, 0xBC,
  0x00, 0x03, 0xFC, 0xF0, 0x00, 0x1F, 0xE7, 0x80, 0x00, 0xFF, 0x1E, 0x00,
  0x07, 0xF8, 0xF0, 0x00, 0x3F, 0xC3, 0xC0, 0x01, 0xFE, 0x1F, 0x00, 0x0F,
  0xF0, 0x78, 0x00, 0x7F, 0x81, 0xE0, 0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xE0,
  0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x07, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x3C,
  0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x1E, 0x03,
  0xFC, 0x00, 0xF8, 0x1F, 0xE0, 0x03, 0xC0, 0xFF, 0x00, 0x0F, 0x07, 0xF8,
  0x00, 0x78, 0x3F, 0xC0, 0x01, 0xE1, 0xFE, 0x00, 0x0F, 0x0F, 0xF0, 0x00,
  0x3C, 0x7F, 0x80, 0x01, 0xE3, 0xFC, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0x3C,
  0xFF, 0x00, 0x00, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x7F, 0x0F, 0x00, 0x00,
  0xFC, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0x87, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x1F, 0x83,
  0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x7F,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xF0, 0x03,
  0xFC, 0x00, 0xFC, 0x00, 0xF7, 0x00, 0x3F, 0x00, 0x39, 0xC0, 0x0F, 0xC0,
  0x0E, 0x70, 0x03, 0xF0, 0x03, 0x9E, 0x00, 0xFE, 0x00, 0xE7, 0x80, 0x7B,
  0x80, 0x79, 0xE0, 0x1C, 0xE0, 0x1E, 0x78, 0x07, 0x38, 0x07, 0x8E, 0x01,
  0xCE, 0x01, 0xC3, 0x80, 0x73, 0xC0, 0x70, 0xE0, 0x3C, 0xF0, 0x1C, 0x3C,
  0x0E, 0x1C, 0x07, 0x0F, 0x03, 0x87, 0x03, 0xC3, 0xC0, 0xE1, 0xC0, 0xF0,
  0xF0, 0x38, 0x70, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x83,
  0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x78, 0x70, 0x38, 0x38, 0x1E, 0x1C, 0x0E,
  0x0E, 0x07, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0x71, 0xE0, 0x38, 0xE0,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x79, 0xC0, 0x3D, 0xE0, 0x1E, 0x70, 0x0F, 0x78, 0x03, 0xBC, 0x03,
  0xDC, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xE7,
  0x80, 0x01, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1E,
  0x00, 0x70, 0x1C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x70,
  0x1E, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0x80, 0x03, 0x8F, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x00, 0xF8, 0x00, 0xFC, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3F, 0x3E,
  0x00, 0x03, 0xF8, 0xF8, 0x00, 0x7F, 0xC7, 0xE0, 0x0F, 0xDE, 0x1F, 0xFF,
  0xF8, 0xF0, 0x7F, 0xFF, 0x87, 0xC0, 0xFF, 0xF0, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x0F, 0x0F, 0xFF, 0x80, 0xF1, 0xFF, 0xFC,
  0x0F, 0x3F, 0x1F, 0xE0, 0xF7, 0x80, 0x3F, 0x0F, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0x07, 0x8F, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x78, 0xFF,
  0x00, 0x1F, 0x8F, 0x7C, 0x03, 0xF0, 0xF3, 0xFF, 0xFE, 0x0F, 0x1F, 0xFF,
  0xC0, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0xFC,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0xF0,
  0x0F, 0xFF, 0x0F, 0x03, 0xFF, 0xF8, 0xF0, 0x7F, 0x9F, 0xCF, 0x0F, 0xC0,
  0x1E, 0xF1, 0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F,
  0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xF0, 0xFC, 0x03, 0xEF,
  0x07, 0xFF, 0xFC, 0xF0, 0x1F, 0xFF, 0x8F, 0x00, 0xFF, 0xE0, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xF0, 0xFF, 0x00, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x0F,
  0x80, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0x0F, 0x03, 0xFF, 0xF8, 0xF0, 0x7F, 0x8F, 0xCF, 0x0F,
  0xC0, 0x1E, 0xF1, 0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x03, 0xF3, 0xC0, 0x00,
  0x3F, 0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xF0, 0xFC, 0x03,
  0xEF, 0x07, 0xFF, 0xFC, 0xF0, 0x1F, 0xFF, 0x8F, 0x00, 0xFF, 0xE0, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x08, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x03, 0xF8, 0x07, 0x81, 0xFF, 0xE0, 0xF0, 0xFF, 0xFE, 0x1E, 0x3F,
  0x0F, 0xE3, 0xCF, 0x00, 0x3E, 0x7B, 0x80, 0x03, 0xEF, 0xE0, 0x00, 0x3D,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x8F, 0x9F, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2F, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x3F,
  0x00, 0x00, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x7C, 0x00,
  0x0F, 0xE3, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x71, 0xFF, 0x87, 0xFE, 0x39, 0xFF, 0xE7,
  0xFF, 0x9D, 0xE3, 0xF7, 0xC7, 0xEF, 0xC0, 0x7F, 0x80, 0xF7, 0xC0, 0x1F,
  0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x1F, 0xE0, 0x03, 0xC0, 0x0F, 0xF0, 0x01,
  0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80,
  0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x0F,
  0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01,
  0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80,
  0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x1E, 0x07, 0xFF, 0x83, 0xC3, 0xFF, 0xF8,
  0x78, 0xFC, 0x3F, 0x8F, 0x3C, 0x00, 0xF9, 0xEE, 0x00, 0x0F, 0xBF, 0x80,
  0x00, 0xF7, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0x0F, 0xFF, 0x00, 0xF1, 0xFF, 0xFC, 0x0F, 0x7F, 0x9F, 0xE0, 0xF7,
  0x80, 0x3F, 0x0F, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0xF8,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF8, 0xFE, 0x00, 0x1F, 0x0F, 0x78, 0x03,
  0xF0, 0xF3, 0xFF, 0xFE, 0x0F, 0x1F, 0xFF, 0xC0, 0xF0, 0x7F, 0xF0, 0x0F,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0x0F, 0x03, 0xFF, 0xF8, 0xF0, 0x7F, 0x8F, 0xEF, 0x0F,
  0xC0, 0x1E, 0xF1, 0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x1F, 0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xF0, 0xFC, 0x01,
  0xEF, 0x07, 0xFF, 0xFC, 0xF0, 0x1F, 0xFF, 0x8F, 0x00, 0xFF, 0xE0, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFD,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0x00, 0x1E,
  0x78, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0x0F, 0xF8, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0x3E,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0xBC, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0xFE, 0x7C, 0x00, 0x3F, 0xC7,
  0xC0, 0x1F, 0x78, 0x7F, 0xFF, 0xCF, 0x07, 0xFF, 0xF1, 0xE0, 0x3F, 0xF8,
  0x3C, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1D, 0xC0, 0x03, 0xC0, 0x07, 0xB8, 0x00,
  0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x00, 0x1C, 0xF0, 0x03, 0xF0, 0x03, 0x9E,
  0x00, 0x6E, 0x00, 0x71, 0xC0, 0x1D, 0xC0, 0x1E, 0x38, 0x03, 0xB8, 0x03,
  0xC7, 0x80, 0x77, 0x80, 0x70, 0xF0, 0x0E, 0x70, 0x0E, 0x0E, 0x03, 0x8E,
  0x01, 0xC1, 0xC0, 0x71, 0xC0, 0x78, 0x38, 0x0E, 0x3C, 0x0E, 0x07, 0x81,
  0xC3, 0x81, 0xC0, 0xF0, 0x70, 0x70, 0x38, 0x0E, 0x0E, 0x0E, 0x07, 0x01,
  0xC1, 0xC1, 0xE1, 0xE0, 0x38, 0x38, 0x1C, 0x38, 0x07, 0x8E, 0x03, 0x87,
  0x00, 0x71, 0xC0, 0x70, 0xE0, 0x0E, 0x38, 0x0F, 0x1C, 0x01, 0xC7, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x07, 0xB8, 0x03, 0x9C, 0x00, 0x77,
  0x00, 0x33, 0x80, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xD8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1C, 0x7F, 0xFC, 0x00, 0x03, 0x9F, 0x9F, 0xC0, 0x00, 0x77, 0xC0, 0x7E,
  0x00, 0x1E, 0xE0, 0x07, 0xE0, 0x03, 0xBC, 0x00, 0x3E, 0x00, 0xF7, 0x00,
  0x03, 0xF0, 0x3C, 0xE0, 0x00, 0x3F, 0xFF, 0x9C, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00,
};

const GFXglyph RobotoMono_Light65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 6, 46, 39, 16, -46 },
  { 36, 13, 14, 39, 13, -49 },
  { 59, 35, 46, 39, 2, -46 },
  { 261, 28, 60, 39, 6, -53 },
  { 471, 37, 48, 39, 1, -47 },
  { 693, 34, 48, 39, 4, -47 },
  { 897, 4, 14, 39, 16, -49 },
  { 904, 15, 67, 39, 12, -52 },
  { 1030, 15, 67, 39, 11, -52 },
  { 1156, 29, 28, 39, 6, -46 },
  { 1258, 31, 33, 39, 4, -38 },
  { 1386, 7, 15, 39, 12, -6 },
  { 1400, 23, 3, 39, 8, -22 },
  { 1409, 7, 6, 39, 17, -6 },
  { 1415, 23, 50, 39, 9, -46 },
  { 1559, 29, 48, 39, 5, -47 },
  { 1733, 17, 46, 39, 7, -46 },
  { 1831, 30, 47, 39, 3, -47 },
  { 2008, 29, 48, 39, 3, -47 },
  { 2182, 32, 46, 39, 3, -46 },
  { 2366, 28, 47, 39, 7, -46 },
  { 2531, 28, 48, 39, 5, -47 },
  { 2699, 30, 46, 39, 4, -46 },
  { 2872, 29, 48, 39, 6, -47 },
  { 3046, 29, 47, 39, 5, -47 },
  { 3217, 6, 34, 39, 19, -34 },
  { 3243, 8, 43, 39, 17, -34 },
  { 3286, 27, 27, 39, 5, -34 },
  { 3378, 28, 16, 39, 6, -29 },
  { 3434, 28, 27, 39, 6, -34 },
  { 3529, 26, 47, 39, 7, -47 },
  { 3682, 35, 46, 39, 2, -46 },
  { 3884, 34, 46, 39, 3, -46 },
  { 4080, 29, 46, 39, 6, -46 },
  { 4247, 31, 48, 39, 4, -47 },
  { 4433, 30, 46, 39, 6, -46 },
  { 4606, 28, 46, 39, 6, -46 },
  { 4767, 27, 46, 39, 7, -46 },
  { 4923, 31, 48, 39, 4, -47 },
  { 5109, 29, 46, 39, 5, -46 },
  { 5276, 27, 46, 39, 6, -46 },
  { 5432, 29, 47, 39, 4, -46 },
  { 5603, 32, 46, 39, 6, -46 },
  { 5787, 27, 46, 39, 7, -46 },
  { 5943, 29, 46, 39, 5, -46 },
  { 6110, 29, 46, 39, 5, -46 },
  { 6277, 31, 48, 39, 4, -47 },
  { 6463, 29, 46, 39, 7, -46 },
  { 6630, 33, 55, 39, 3, -47 },
  { 6857, 30, 46, 39, 6, -46 },
  { 7030, 31, 48, 39, 4, -47 },
  { 7216, 33, 46, 39, 3, -46 },
  { 7406, 29, 47, 39, 5, -46 },
  { 7577, 33, 46, 39, 3, -46 },
  { 7767, 34, 46, 39, 3, -46 },
  { 7963, 34, 46, 39, 3, -46 },
  { 8159, 34, 46, 39, 2, -46 },
  { 8355, 30, 46, 39, 4, -46 },
  { 8528, 11, 63, 39, 14, -53 },
  { 8615, 23, 50, 39, 8, -46 },
  { 8759, 11, 63, 39, 14, -53 },
  { 8846, 23, 25, 39, 8, -46 },
  { 8918, 28, 3, 39, 5, 0 },
  { 8929, 11, 9, 39, 14, -48 },
  { 8942, 29, 36, 39, 5, -35 },
  { 9073, 28, 50, 39, 6, -49 },
  { 9248, 29, 36, 39, 5, -35 },
  { 9379, 28, 50, 39, 5, -49 },
  { 9554, 29, 36, 39, 5, -35 },
  { 9685, 30, 50, 39, 6, -50 },
  { 9873, 28, 49, 39, 5, -35 },
  { 10045, 27, 49, 39, 6, -49 },
  { 10211, 28, 47, 39, 7, -47 },
  { 10376, 20, 61, 39, 6, -47 },
  { 10529, 28, 49, 39, 7, -49 },
  { 10701, 28, 49, 39, 7, -49 },
  { 10873, 33, 35, 39, 3, -35 },
  { 11018, 27, 35, 39, 6, -35 },
  { 11137, 31, 36, 39, 4, -35 },
  { 11277, 28, 48, 39, 6, -35 },
  { 11445, 28, 48, 39, 5, -35 },
  { 11613, 23, 35, 39, 11, -35 },
  { 11714, 28, 36, 39, 6, -35 },
  { 11840, 28, 44, 39, 5, -43 },
  { 11994, 27, 35, 39, 6, -34 },
  { 12113, 32, 34, 39, 3, -34 },
  { 12249, 35, 34, 39, 2, -34 },
  { 12398, 32, 34, 39, 4, -34 },
  { 12534, 34, 48, 39, 2, -34 },
  { 12738, 30, 34, 39, 5, -34 },
  { 12866, 22, 64, 39, 10, -51 },
  { 13042, 3, 57, 39, 18, -46 },
  { 13064, 22, 64, 39, 10, -51 },
  { 13240, 35, 12, 39, 2, -25 },
};

const GFXfont RobotoMono_Light65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light65pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_LIGHT65PT7B_H_
