#ifndef _ROBOTOCONDENSED_BOLD65PT7B_H_
#define _ROBOTOCONDENSED_BOLD65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x87, 0xF3, 0xFE, 0xFF, 0xBF, 0xFF, 0xFB, 0xFE, 0x7F, 0x9F, 0xC1, 0xC0,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF,
  0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x87, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xBF, 0xE0,
  0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x04, 0x00, 0xFE,
  0x1F, 0x80, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0x80, 0xFC, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0xF8,
  0x3E, 0x00, 0xFC, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x7C, 0x00, 0xFC,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0x80,
  0x03, 0xFF, 0xF1, 0xF0, 0x00, 0x3F, 0xFE, 0x3F, 0x00, 0x01, 0xFF, 0xC3,
  0xE0, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0xE0, 0x00, 0x07, 0xC3, 0xFF, 0x00, 0x00, 0xFC, 0x7F, 0xF8, 0x00,
  0x0F, 0x8F, 0xFF, 0xC0, 0x01, 0xF9, 0xFF, 0xFE, 0x00, 0x1F, 0x1F, 0xCF,
  0xE0, 0x03, 0xF1, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x03, 0xF0, 0x07, 0xE3,
  0xF0, 0x3F, 0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x00,
  0xF8, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x83,
  0xE0, 0x1F, 0x01, 0xF8, 0x7E, 0x00, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0xFC, 0x7F, 0x83, 0xFF,
  0xFF, 0x8F, 0xF0, 0xFF, 0x9F, 0xF9, 0xFE, 0x1F, 0xF1, 0xFF, 0xBF, 0xC3,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xFE, 0x0F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF3, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x04, 0x40, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x01, 0xF8, 0x00, 0x78, 0x1F, 0x81,
  0xE7, 0xF0, 0xF8, 0x7E, 0x7F, 0xCF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xBF, 0x80, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x78, 0x03, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x07, 0x80,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0x3F, 0x83, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x3F, 0xE7, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x0F,
  0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07,
  0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0x7F, 0xE7, 0xFE, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFB, 0xFE, 0x00, 0x1F, 0xDF, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x0F,
  0xE7, 0xFC, 0x00, 0xFE, 0x3F, 0xE0, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x0F,
  0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0x3F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFE, 0x0F, 0xFE, 0x0F, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x07, 0xFD,
  0xFF, 0xC0, 0x7F, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE0, 0xFF, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x07, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF9, 0xFF,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF,
  0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x83,
  0xFF, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFC,
  0x03, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0x3F, 0x83, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF1, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3, 0xF8,
  0x38, 0x0F, 0x81, 0xFE, 0x3F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3,
  0xFE, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE0, 0x3C, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xFF, 0xC0,
  0x7E, 0x1F, 0x80, 0x1F, 0xFF, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xFC, 0x0F,
  0x8F, 0xE0, 0x1F, 0xFF, 0xE0, 0x7C, 0x7E, 0x01, 0xFF, 0xFF, 0x03, 0xF3,
  0xF0, 0x1F, 0xE1, 0xF8, 0x1F, 0x9F, 0x80, 0xFE, 0x0F, 0xC0, 0xFD, 0xF8,
  0x0F, 0xE0, 0x7E, 0x03, 0xEF, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFB, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xDF, 0x81, 0xFC,
  0x0F, 0xE0, 0x3E, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF7, 0xE0, 0x7E, 0x03,
  0xF0, 0x0F, 0xBF, 0x07, 0xF0, 0x1F, 0x80, 0x7D, 0xF8, 0x3F, 0x80, 0xFC,
  0x03, 0xEF, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x7E, 0x0F, 0xE0, 0x3F, 0x01,
  0xFB, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0x9F, 0x83, 0xF8, 0x0F, 0xC0, 0x7C,
  0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xE7, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x3F,
  0x07, 0xF0, 0x3F, 0x81, 0xF1, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0x8F, 0xC0,
  0xFF, 0x3F, 0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xFF, 0x9F, 0xC1, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xF7, 0xFF, 0xE0, 0x7E, 0x03, 0xFF,
  0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xC0, 0x1E, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xF7, 0xFC, 0x01, 0xFF,
  0xBF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0,
  0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xE3, 0xFE, 0x00, 0xFF,
  0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0,
  0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0,
  0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0,
  0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xFC,
  0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFE, 0xFF,
  0xC0, 0xFF, 0x9F, 0xFC, 0x3F, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x1F,
  0xFC, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F,
  0xF0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xBF, 0xFF, 0xDF, 0xE0,
  0x3F, 0xDF, 0xFF, 0xEF, 0xF0, 0x1F, 0xEF, 0xFF, 0xF7, 0xF8, 0x0F, 0xE7,
  0xFF, 0xF9, 0xFE, 0x07, 0xF3, 0xFF, 0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0xFE,
  0x7F, 0x83, 0xFC, 0xFF, 0xFF, 0x9F, 0xE1, 0xFC, 0x7F, 0xFF, 0xCF, 0xF1,
  0xFE, 0x3F, 0xFF, 0xE7, 0xF8, 0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0x7F, 0x0F,
  0xFF, 0xF8, 0xFF, 0x3F, 0x87, 0xFF, 0xFC, 0x7F, 0xBF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xDF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x9F, 0xE1,
  0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF9,
  0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0xFF, 0x83, 0xFD,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00,
  0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x83, 0xFE,
  0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80,
  0x3F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0xFF, 0x9F,
  0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xBF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFE,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFB, 0xF8, 0xFF, 0x80, 0x7F, 0x9F, 0xEF,
  0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x7F,
  0x7F, 0xC0, 0x1F, 0xF7, 0xF1, 0xFD, 0xFF, 0x00, 0x7F, 0xDF, 0xC7, 0xF7,
  0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0,
  0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xC7, 0xFF,
  0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0x78,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0xBF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFC, 0x1F, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFD, 0xFF, 0xF0, 0xFF, 0x9F, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF7,
  0xFC, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x83, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x1E, 0x0F, 0xF8, 0x1F, 0xF9, 0xFF, 0x07, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFB,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFD, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0x03, 0xFF, 0x1F, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xF9, 0xFF,
  0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xDF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x0C, 0x1F, 0xF8, 0x07, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xF3, 0xFC, 0x1F, 0xFF, 0x7F, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x7F, 0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x80, 0xFF, 0xBF, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0x3E, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC1, 0x00, 0x0F, 0xF8, 0x38, 0x03, 0xFF, 0x0F,
  0xC1, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x3E, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFC, 0x1F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFD, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD,
  0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x1F,
  0xF8, 0xFF, 0x83, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x9F,
  0xF0, 0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xCF,
  0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x03, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x0F, 0xFB, 0xFF, 0xE3,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xBF, 0xF0, 0x3F,
  0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x01, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F, 0xFB, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC,
  0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xF3, 0xFF, 0x03, 0xFE, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x0F, 0xFB,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xF7, 0xFF, 0x83, 0xFE, 0x7F, 0xE0,
  0x7F, 0xC1, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xE3, 0xFC, 0x1F, 0xFE, 0x7F, 0x87, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xE0, 0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF7, 0xFC, 0x0F, 0xFC, 0xFF, 0x80, 0x3C, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0x7F,
  0xDF, 0xE0, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFE, 0x1F, 0xFB,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xC0, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0xC1, 0xFF, 0x9F, 0xF0, 0x1F,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x01, 0xFF,
  0xBF, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF9, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xBF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xF8, 0x0F, 0xF3,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x3F,
  0xE0, 0x7F, 0x9F, 0xF0, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0xF9, 0xFE, 0x07, 0xF9, 0xFF, 0xF3, 0xFC, 0x0F, 0xF3,
  0xF7, 0xE7, 0xF8, 0x0F, 0xEF, 0xEF, 0xEF, 0xF0, 0x1F, 0xFF, 0xDF, 0xDF,
  0xC0, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0xFF,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x9F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xDF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0x01, 0xFF, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF,
  0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x7F,
  0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF,
  0x80, 0xFF, 0x9F, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xDF, 0xF0,
  0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xF0, 0xFF, 0xE0, 0x1F, 0xC7, 0xFF, 0xC0,
  0x7F, 0x3F, 0xFF, 0x81, 0xFC, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xCF,
  0xE0, 0x3F, 0xFE, 0x3F, 0x80, 0x7F, 0xF8, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_Bold65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 47, 17, 4, -46 },
  { 60, 17, 17, 21, 2, -49 },
  { 97, 30, 46, 34, 2, -46 },
  { 270, 27, 61, 33, 3, -54 },
  { 476, 36, 48, 41, 3, -47 },
  { 692, 35, 48, 38, 2, -47 },
  { 902, 7, 17, 11, 2, -49 },
  { 917, 15, 65, 21, 4, -51 },
  { 1039, 16, 65, 21, 2, -51 },
  { 1169, 28, 28, 29, 1, -46 },
  { 1267, 27, 33, 31, 2, -38 },
  { 1379, 11, 19, 16, 1, -8 },
  { 1406, 15, 7, 23, 4, -23 },
  { 1420, 10, 10, 19, 4, -9 },
  { 1433, 20, 50, 22, 0, -46 },
  { 1558, 27, 48, 33, 3, -47 },
  { 1720, 18, 46, 33, 5, -46 },
  { 1824, 28, 47, 33, 2, -47 },
  { 1989, 28, 48, 33, 2, -47 },
  { 2157, 29, 46, 33, 2, -46 },
  { 2324, 27, 47, 33, 3, -46 },
  { 2483, 28, 47, 33, 3, -46 },
  { 2648, 28, 46, 33, 2, -46 },
  { 2809, 27, 48, 33, 3, -47 },
  { 2971, 26, 47, 33, 3, -47 },
  { 3124, 10, 36, 18, 4, -35 },
  { 3169, 12, 46, 16, 2, -35 },
  { 3238, 23, 31, 29, 2, -35 },
  { 3328, 24, 21, 33, 4, -31 },
  { 3391, 23, 31, 30, 4, -35 },
  { 3481, 25, 48, 29, 2, -47 },
  { 3631, 45, 59, 50, 2, -45 },
  { 3963, 37, 46, 39, 1, -46 },
  { 4176, 29, 46, 36, 4, -46 },
  { 4343, 32, 48, 37, 3, -47 },
  { 4535, 30, 46, 37, 4, -46 },
  { 4708, 26, 46, 32, 4, -46 },
  { 4858, 25, 46, 31, 4, -46 },
  { 5002, 32, 48, 38, 3, -47 },
  { 5194, 32, 46, 40, 4, -46 },
  { 5378, 9, 46, 18, 4, -46 },
  { 5430, 27, 47, 32, 1, -46 },
  { 5589, 32, 46, 36, 4, -46 },
  { 5773, 25, 46, 31, 4, -46 },
  { 5917, 41, 46, 49, 4, -46 },
  { 6153, 32, 46, 40, 4, -46 },
  { 6337, 33, 48, 39, 3, -47 },
  { 6535, 30, 46, 37, 4, -46 },
  { 6708, 33, 55, 39, 3, -47 },
  { 6935, 31, 46, 36, 4, -46 },
  { 7114, 31, 48, 35, 2, -47 },
  { 7300, 32, 46, 35, 2, -46 },
  { 7484, 31, 47, 37, 3, -46 },
  { 7667, 36, 46, 38, 1, -46 },
  { 7874, 46, 46, 49, 1, -46 },
  { 8139, 34, 46, 36, 1, -46 },
  { 8335, 34, 46, 35, 1, -46 },
  { 8531, 30, 46, 34, 2, -46 },
  { 8704, 12, 65, 17, 4, -54 },
  { 8802, 26, 50, 25, 0, -46 },
  { 8965, 12, 65, 17, 1, -54 },
  { 9063, 22, 23, 25, 2, -46 },
  { 9127, 24, 7, 26, 1, 0 },
  { 9148, 16, 10, 22, 2, -49 },
  { 9168, 27, 36, 31, 2, -35 },
  { 9290, 27, 50, 32, 3, -49 },
  { 9459, 26, 36, 30, 2, -35 },
  { 9576, 27, 50, 32, 2, -49 },
  { 9745, 27, 36, 31, 2, -35 },
  { 9867, 20, 50, 21, 1, -50 },
  { 9992, 27, 48, 33, 2, -35 },
  { 10154, 26, 49, 32, 3, -49 },
  { 10314, 10, 47, 16, 3, -47 },
  { 10373, 15, 60, 16, -2, -47 },
  { 10486, 28, 49, 31, 3, -49 },
  { 10658, 9, 49, 16, 4, -49 },
  { 10714, 42, 35, 48, 3, -35 },
  { 10898, 26, 35, 32, 3, -35 },
  { 11012, 28, 36, 32, 2, -35 },
  { 11138, 27, 48, 32, 3, -35 },
  { 11300, 27, 48, 32, 2, -35 },
  { 11462, 17, 35, 22, 3, -35 },
  { 11537, 25, 36, 30, 2, -35 },
  { 11650, 17, 44, 20, 1, -43 },
  { 11744, 26, 35, 32, 3, -34 },
  { 11858, 27, 34, 29, 1, -34 },
  { 11973, 39, 34, 41, 1, -34 },
  { 12139, 28, 34, 29, 1, -34 },
  { 12258, 27, 47, 29, 1, -34 },
  { 12417, 24, 34, 29, 3, -34 },
  { 12519, 16, 62, 19, 2, -51 },
  { 12643, 5, 55, 16, 6, -46 },
  { 12678, 16, 62, 19, 2, -51 },
  { 12802, 30, 14, 36, 3, -26 },
};

const GFXfont RobotoCondensed_Bold65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_BOLD65PT7B_H_
