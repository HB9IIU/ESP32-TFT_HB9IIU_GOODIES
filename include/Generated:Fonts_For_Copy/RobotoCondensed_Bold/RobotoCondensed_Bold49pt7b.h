#ifndef _ROBOTOCONDENSED_BOLD49PT7B_H_
#define _ROBOTOCONDENSED_BOLD49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xEF, 0x1E, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E,
  0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0xF8, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x0F,
  0xE7, 0xF0, 0x7F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x7F, 0x01, 0xFB,
  0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xCF, 0x81, 0x81, 0xF0, 0xF0, 0x78,
  0x3E, 0x1E, 0x0F, 0x07, 0xC3, 0xC3, 0xC0, 0xF8, 0x78, 0x78, 0x1F, 0x0F,
  0x1E, 0x03, 0xE1, 0xE7, 0xC0, 0x3E, 0x7C, 0xF0, 0x07, 0xFF, 0xBE, 0x00,
  0x7F, 0xE7, 0x80, 0x07, 0xF9, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xCF, 0xF8, 0x00, 0x7B, 0xFF, 0x80, 0x1E, 0x7F, 0xF0, 0x07, 0xDF,
  0x1F, 0x00, 0xF3, 0xE3, 0xE0, 0x3E, 0x7C, 0x3C, 0x07, 0x8F, 0x07, 0x81,
  0xE1, 0xE0, 0xF0, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xE0, 0xF8,
  0xF8, 0x08, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x7F, 0xFE, 0x3F, 0x1F,
  0xBF, 0xCF, 0x8F, 0xE7, 0xFF, 0xE3, 0xF8, 0xFF, 0xF8, 0xFE, 0x3F, 0xFE,
  0x3F, 0x07, 0xFF, 0x8F, 0xE0, 0xFF, 0xC3, 0xF8, 0x1F, 0xF0, 0xFE, 0x07,
  0xF8, 0x3F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xC3, 0xF8, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x40, 0x1C,
  0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x08, 0x40, 0x07, 0x00, 0x78, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xC0, 0xFC, 0x07, 0x80, 0x70, 0x04, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x20, 0x78,
  0x09, 0xC3, 0xC1, 0xDF, 0xDE, 0x3E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC7,
  0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xF3, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x1C,
  0x07, 0x00, 0x40, 0x20, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0xFC, 0x78, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7F, 0x7F,
  0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE,
  0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0xDF, 0xC0,
  0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7C, 0xFE, 0x03, 0xF3, 0xF8,
  0x0F, 0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xE1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF7, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xF8, 0xFF, 0x83, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x3F,
  0x7F, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0, 0x7F,
  0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0x0F, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x9F, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3E, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3C, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x07, 0xC1, 0xE0, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0xF8, 0x3C, 0x3E,
  0x07, 0xFF, 0x07, 0x8F, 0x03, 0xFF, 0xC1, 0xE7, 0xC1, 0xF8, 0xF0, 0x79,
  0xF0, 0x7C, 0x3C, 0x1E, 0x78, 0x3E, 0x0F, 0x07, 0x9E, 0x0F, 0x83, 0xC1,
  0xEF, 0x83, 0xE1, 0xF0, 0x7F, 0xE1, 0xF0, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F,
  0x07, 0xFE, 0x1F, 0x07, 0xC1, 0xEF, 0x87, 0xC1, 0xF0, 0x7B, 0xC1, 0xF0,
  0x7C, 0x1E, 0xF0, 0x7C, 0x1F, 0x07, 0xBC, 0x1F, 0x07, 0xC1, 0xEF, 0x87,
  0xC1, 0xF0, 0x7B, 0xE1, 0xF0, 0x78, 0x3C, 0xF8, 0x7C, 0x3E, 0x0F, 0x3E,
  0x1F, 0x9F, 0xC7, 0xCF, 0x87, 0xFF, 0xFB, 0xE1, 0xE0, 0xFF, 0xBF, 0xF0,
  0x7C, 0x1F, 0xEF, 0xFC, 0x1F, 0x03, 0xF1, 0xFC, 0x07, 0xC0, 0x20, 0x1C,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x08, 0x00, 0x07, 0xF8,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0xBF, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF,
  0x3F, 0x80, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xCF, 0xE0, 0xFF, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xBF,
  0x80, 0xFE, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F,
  0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFE, 0xFE, 0x03, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x0F,
  0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xBF, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xEF, 0xFF, 0x7E,
  0x0F, 0xDF, 0xFE, 0xFC, 0x1F, 0xBF, 0xFD, 0xF8, 0x3E, 0x7F, 0xF9, 0xF8,
  0xFC, 0xFF, 0xF3, 0xF1, 0xF9, 0xFF, 0xE7, 0xE3, 0xF3, 0xFF, 0xC7, 0xE7,
  0xC7, 0xFF, 0xCF, 0xDF, 0x8F, 0xFF, 0x9F, 0xBF, 0x1F, 0xFF, 0x3F, 0x7C,
  0x3F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xF0, 0xFF, 0xF8, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xC3, 0xFE, 0x0F,
  0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0x07, 0xF0, 0x3F, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFC, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD,
  0xF8, 0x3F, 0xFD, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC,
  0x7E, 0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x3F, 0xBF, 0xFC,
  0x1F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0xFF, 0x07, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x1F, 0xF1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xBF, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFC, 0xFF, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F,
  0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x80, 0xFF, 0x7F, 0x03, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0xFE, 0x7F, 0x80,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xE7, 0xF8,
  0x3F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00,
  0x7F, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0x01,
  0xF9, 0xF8, 0x0F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0x81, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0x9F, 0xC1, 0xFF, 0x07, 0xF3, 0xF8,
  0x3F, 0xE0, 0xFC, 0x3F, 0x07, 0xFC, 0x1F, 0x87, 0xE0, 0xFF, 0x87, 0xF0,
  0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xC7, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0xE3,
  0xF0, 0x7F, 0x1F, 0xFC, 0x7E, 0x07, 0xE3, 0xFF, 0x8F, 0xC0, 0xFC, 0x7D,
  0xF3, 0xF8, 0x1F, 0xDF, 0xBE, 0x7F, 0x03, 0xFB, 0xF7, 0xEF, 0xE0, 0x7F,
  0x7E, 0xFD, 0xF8, 0x07, 0xEF, 0x9F, 0xBF, 0x00, 0xFD, 0xF1, 0xF7, 0xE0,
  0x1F, 0xFE, 0x3E, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF0,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x03,
  0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x1F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xDF,
  0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x9E, 0x0F,
  0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E,
  0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x1F, 0xEF, 0xE0, 0xFC, 0x7F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC7, 0xC0, 0xFD, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xDF, 0xF0, 0xFC, 0x7C, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7E,
  0x7F, 0x1F, 0xF7, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0x7F, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x07, 0xEF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1C, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x10, 0x03,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE3, 0xF1,
  0xFF, 0xBF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xF7, 0xF0,
  0x7E, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF1, 0x80, 0xFF,
  0x1F, 0x3F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xE0, 0xFE, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0,
  0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F,
  0xCF, 0xF1, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0,
  0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFE, 0xFE, 0x03, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x7E, 0x07, 0xE1, 0xFB,
  0xFE, 0x3F, 0xE3, 0xFF, 0xFE, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0x87, 0xF8, 0x7F, 0xFE, 0x07,
  0xF0, 0x7F, 0xFC, 0x0F, 0xE0, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xF0, 0x3F,
  0x83, 0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x81, 0xFC,
  0x1F, 0xFF, 0x03, 0xF8, 0x3F, 0xFE, 0x07, 0xF0, 0x7F, 0xFC, 0x0F, 0xE0,
  0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xE0, 0x7F, 0x07,
  0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0x03, 0xF8, 0x3F,
  0xFE, 0x07, 0xF0, 0x7F, 0xFC, 0x0F, 0xE0, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC,
  0xFE, 0x3F, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x81, 0xFC, 0xFE, 0x0F, 0xE7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x7C, 0x0F, 0xDF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x07,
  0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xEF, 0xE0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFD, 0xFF, 0x0F, 0xC7, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF1, 0xFF,
  0x3F, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF0, 0x7E,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0xFF, 0x1F, 0xDF,
  0xC3, 0xFB, 0xF8, 0x3F, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xF0, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xFC,
  0x1F, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xF7, 0xF0, 0x7C, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0x81,
  0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x0F, 0x81, 0xFF, 0xF0, 0x7C, 0x1F, 0xFF, 0x87, 0xE0, 0xFE,
  0xFC, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x3F, 0x3F, 0x0F, 0xE1, 0xF9, 0xF8,
  0x7F, 0x0F, 0xCF, 0xC7, 0xFC, 0xFE, 0x3F, 0x3F, 0xE7, 0xE1, 0xF9, 0xFF,
  0x3F, 0x0F, 0xCF, 0xF9, 0xF8, 0x7E, 0xFB, 0xEF, 0xC3, 0xF7, 0xDF, 0x7E,
  0x0F, 0xBE, 0xFB, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0x83, 0xF9,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFD, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xFB,
  0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0x7F, 0x07,
  0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x0F, 0x01, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x60, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7C, 0x07, 0x80,
  0x60, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x7C, 0xFF, 0xC0, 0xF9, 0xFF,
  0xC1, 0xF7, 0xFF, 0xC7, 0xEF, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0x3E, 0x1F,
  0xFC, 0xF8, 0x1F, 0xF9, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Bold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 35, 13, 3, -35 },
  { 32, 12, 13, 16, 2, -37 },
  { 52, 22, 35, 26, 2, -35 },
  { 149, 21, 45, 25, 2, -40 },
  { 268, 27, 35, 31, 2, -35 },
  { 387, 26, 36, 28, 2, -35 },
  { 504, 5, 13, 8, 2, -37 },
  { 513, 11, 50, 16, 3, -39 },
  { 582, 12, 50, 16, 1, -39 },
  { 657, 21, 21, 22, 1, -35 },
  { 713, 20, 25, 23, 2, -28 },
  { 776, 8, 15, 12, 1, -6 },
  { 791, 12, 6, 18, 3, -18 },
  { 800, 8, 7, 14, 3, -7 },
  { 807, 15, 38, 16, 0, -35 },
  { 879, 20, 35, 25, 2, -35 },
  { 967, 13, 35, 25, 4, -35 },
  { 1024, 21, 35, 25, 2, -35 },
  { 1116, 20, 35, 25, 2, -35 },
  { 1204, 22, 35, 25, 1, -35 },
  { 1301, 21, 35, 25, 2, -35 },
  { 1393, 21, 35, 25, 2, -35 },
  { 1485, 21, 35, 25, 2, -35 },
  { 1577, 20, 35, 25, 2, -35 },
  { 1665, 20, 35, 25, 2, -35 },
  { 1753, 8, 27, 13, 3, -27 },
  { 1780, 9, 36, 12, 1, -27 },
  { 1821, 18, 23, 22, 1, -26 },
  { 1873, 18, 17, 25, 3, -24 },
  { 1912, 18, 23, 22, 3, -26 },
  { 1964, 19, 35, 22, 1, -35 },
  { 2048, 34, 45, 38, 2, -34 },
  { 2240, 28, 35, 29, 1, -35 },
  { 2363, 22, 35, 27, 3, -35 },
  { 2460, 24, 35, 28, 2, -35 },
  { 2565, 22, 35, 28, 3, -35 },
  { 2662, 20, 35, 24, 3, -35 },
  { 2750, 19, 35, 23, 3, -35 },
  { 2834, 24, 35, 29, 2, -35 },
  { 2939, 24, 35, 30, 3, -35 },
  { 3044, 7, 35, 13, 3, -35 },
  { 3075, 20, 35, 24, 1, -35 },
  { 3163, 24, 35, 27, 3, -35 },
  { 3268, 19, 35, 23, 3, -35 },
  { 3352, 31, 35, 37, 3, -35 },
  { 3488, 24, 35, 30, 3, -35 },
  { 3593, 25, 35, 30, 2, -35 },
  { 3703, 23, 35, 28, 3, -35 },
  { 3804, 25, 41, 30, 2, -35 },
  { 3933, 23, 35, 27, 3, -35 },
  { 4034, 23, 35, 26, 2, -35 },
  { 4135, 24, 35, 27, 1, -35 },
  { 4240, 22, 35, 28, 3, -35 },
  { 4337, 27, 35, 28, 1, -35 },
  { 4456, 35, 35, 37, 1, -35 },
  { 4610, 26, 35, 27, 1, -35 },
  { 4724, 26, 35, 27, 0, -35 },
  { 4838, 22, 35, 26, 2, -35 },
  { 4935, 9, 49, 13, 3, -41 },
  { 4991, 19, 38, 19, 0, -35 },
  { 5082, 9, 49, 13, 1, -41 },
  { 5138, 17, 17, 19, 1, -35 },
  { 5175, 19, 5, 20, 0, 0 },
  { 5187, 13, 7, 16, 1, -36 },
  { 5199, 20, 26, 23, 2, -26 },
  { 5264, 20, 37, 24, 3, -37 },
  { 5357, 19, 26, 23, 2, -26 },
  { 5419, 20, 37, 24, 2, -37 },
  { 5512, 20, 26, 23, 2, -26 },
  { 5577, 15, 38, 16, 1, -38 },
  { 5649, 20, 36, 25, 2, -26 },
  { 5739, 20, 37, 24, 2, -37 },
  { 5832, 8, 36, 12, 2, -36 },
  { 5868, 11, 46, 12, -1, -36 },
  { 5932, 22, 37, 23, 2, -37 },
  { 6034, 7, 37, 12, 3, -37 },
  { 6067, 31, 26, 36, 3, -26 },
  { 6168, 20, 26, 24, 2, -26 },
  { 6233, 21, 26, 24, 2, -26 },
  { 6302, 20, 36, 24, 3, -26 },
  { 6392, 20, 36, 24, 2, -26 },
  { 6482, 13, 26, 16, 2, -26 },
  { 6525, 19, 26, 22, 1, -26 },
  { 6587, 13, 32, 15, 1, -32 },
  { 6639, 20, 26, 24, 2, -26 },
  { 6704, 20, 26, 22, 1, -26 },
  { 6769, 29, 26, 31, 1, -26 },
  { 6864, 21, 26, 22, 1, -26 },
  { 6933, 21, 36, 22, 0, -26 },
  { 7028, 18, 26, 22, 2, -26 },
  { 7087, 12, 47, 15, 1, -38 },
  { 7158, 4, 41, 12, 4, -35 },
  { 7179, 12, 47, 15, 1, -38 },
  { 7250, 23, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_Bold49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_BOLD49PT7B_H_
