#ifndef _ROBOTOCONDENSED_BOLD10PT7B_H_
#define _ROBOTOCONDENSED_BOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xF6, 0xB6, 0x80, 0x31, 0x9E, 0xAF, 0xA9, 0x80, 0x23, 0x96, 0x87,
  0x0F, 0x6E, 0x20, 0x62, 0xA7, 0x04, 0x2C, 0xD0, 0xC0, 0x71, 0x45, 0x1A,
  0xFB, 0x67, 0x80, 0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x36, 0xDA, 0x50, 0x2F,
  0x65, 0x22, 0xF2, 0x20, 0x58, 0xC0, 0x40, 0x25, 0x24, 0xA4, 0x72, 0xB7,
  0xBD, 0xA9, 0xC0, 0x7D, 0xB6, 0xD8, 0x76, 0x84, 0x22, 0x23, 0xE0, 0x76,
  0x84, 0x61, 0xED, 0xC0, 0x31, 0x94, 0xAF, 0x88, 0x40, 0x72, 0x1C, 0x31,
  0xA9, 0xC0, 0x33, 0x1C, 0xB5, 0xAD, 0xC0, 0xF8, 0x84, 0x62, 0x11, 0x80,
  0x72, 0x94, 0xE5, 0x2D, 0xC0, 0x72, 0xB6, 0xB7, 0x09, 0x80, 0x44, 0x10,
  0x16, 0x1E, 0xE1, 0xE3, 0x80, 0x8D, 0xC0, 0x7D, 0x12, 0x20, 0x60, 0x3C,
  0x85, 0x6D, 0x5A, 0xB5, 0x57, 0xA0, 0x38, 0x30, 0xC3, 0x1E, 0x49, 0xEC,
  0xC0, 0xEB, 0x9E, 0x99, 0xF0, 0x72, 0x73, 0x8C, 0x25, 0xE0, 0xEB, 0x99,
  0x9B, 0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8E, 0x88, 0x80, 0x7A, 0x71,
  0xBC, 0xA5, 0xE0, 0x9C, 0xE7, 0xF9, 0xCE, 0x60, 0xFE, 0x11, 0x11, 0x1D,
  0x70, 0x95, 0xB9, 0xCA, 0x5A, 0x40, 0x88, 0x88, 0x88, 0xF0, 0x8F, 0x3D,
  0xF5, 0xF6, 0xDA, 0x40, 0x9E, 0xF7, 0xFB, 0xDE, 0x60, 0x79, 0x2C, 0xF3,
  0xCD, 0x27, 0x80, 0xE9, 0x99, 0xF8, 0x80, 0x79, 0x2C, 0xF3, 0xCD, 0x27,
  0x82, 0xF9, 0x9E, 0xAB, 0x90, 0x72, 0xD0, 0x61, 0xED, 0xC0, 0xF9, 0x08,
  0x42, 0x10, 0x80, 0x99, 0x99, 0x99, 0xF0, 0xCD, 0x24, 0x96, 0x70, 0xC3,
  0x00, 0xD3, 0xB5, 0x7A, 0xF6, 0xCD, 0x9B, 0x00, 0xCA, 0xDC, 0x67, 0x2F,
  0x20, 0xCA, 0xD4, 0x62, 0x10, 0x80, 0xF8, 0xC4, 0x46, 0x23, 0xE0, 0xFF,
  0xC0, 0xC4, 0x46, 0x62, 0x23, 0xD5, 0x55, 0x70, 0x66, 0x6B, 0xF0, 0x4C,
  0x7D, 0x7D, 0x70, 0x88, 0x8E, 0xBB, 0xBE, 0x7D, 0xCD, 0x70, 0x11, 0x17,
  0xDD, 0xD7, 0x76, 0xBF, 0x87, 0x00, 0x69, 0x74, 0x92, 0x7E, 0xF7, 0xB7,
  0x89, 0xC0, 0xCC, 0xCF, 0xDD, 0xDD, 0xBE, 0x45, 0x55, 0xC0, 0x88, 0x8A,
  0xEC, 0xEB, 0xFF, 0xFE, 0xBA, 0x69, 0xA4, 0xFD, 0xDD, 0xD0, 0x76, 0xF7,
  0xB7, 0x00, 0xEB, 0xBB, 0xE8, 0x80, 0x7D, 0xDD, 0x71, 0x10, 0xEA, 0x80,
  0x7D, 0x7D, 0x70, 0x4B, 0xA4, 0x98, 0xDD, 0xDD, 0x70, 0xD5, 0x76, 0x60,
  0xD7, 0xD7, 0xDA, 0x68, 0xD7, 0x67, 0xD0, 0xD5, 0x76, 0x66, 0x40, 0xF3,
  0x64, 0xF0, 0x29, 0x25, 0x12, 0x44, 0xFF, 0x89, 0x24, 0x52, 0x50, 0x6A,
  0xC0,
};

const GFXglyph RobotoCondensed_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 3, 3, 0, -8 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 3, 2, 0, -8 },
  { 28, 2, 10, 3, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 4, 4, 5, 0, -7 },
  { 37, 4, 5, 5, 0, -6 },
  { 40, 2, 3, 2, 0, -1 },
  { 41, 2, 1, 4, 1, -3 },
  { 42, 1, 2, 3, 1, -2 },
  { 43, 3, 8, 3, 0, -7 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 3, 7, 5, 1, -7 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 7, 5, 0, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 5, 7, 5, 0, -7 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 1, 6, 3, 1, -6 },
  { 95, 2, 8, 3, 0, -6 },
  { 97, 4, 4, 4, 0, -5 },
  { 99, 3, 3, 5, 1, -5 },
  { 101, 3, 4, 5, 1, -5 },
  { 103, 4, 7, 4, 0, -7 },
  { 107, 7, 9, 8, 0, -7 },
  { 115, 6, 7, 6, 0, -7 },
  { 121, 4, 7, 6, 1, -7 },
  { 125, 5, 7, 6, 0, -7 },
  { 130, 4, 7, 6, 1, -7 },
  { 134, 4, 7, 5, 1, -7 },
  { 138, 4, 7, 5, 1, -7 },
  { 142, 5, 7, 6, 0, -7 },
  { 147, 5, 7, 6, 1, -7 },
  { 152, 1, 7, 3, 1, -7 },
  { 153, 4, 7, 5, 0, -7 },
  { 157, 5, 7, 6, 1, -7 },
  { 162, 4, 7, 5, 1, -7 },
  { 166, 6, 7, 8, 1, -7 },
  { 172, 5, 7, 6, 1, -7 },
  { 177, 6, 7, 6, 0, -7 },
  { 183, 4, 7, 6, 1, -7 },
  { 187, 6, 8, 6, 0, -7 },
  { 193, 4, 7, 6, 1, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 4, 7, 6, 1, -7 },
  { 211, 6, 7, 6, 0, -7 },
  { 217, 7, 7, 8, 0, -7 },
  { 224, 5, 7, 6, 0, -7 },
  { 229, 5, 7, 5, 0, -7 },
  { 234, 5, 7, 5, 0, -7 },
  { 239, 1, 10, 3, 1, -8 },
  { 241, 4, 8, 4, 0, -7 },
  { 245, 2, 10, 3, 0, -8 },
  { 248, 4, 4, 4, 0, -7 },
  { 250, 4, 1, 4, 0, 0 },
  { 251, 3, 2, 3, 0, -8 },
  { 252, 4, 5, 5, 0, -5 },
  { 255, 4, 8, 5, 1, -8 },
  { 259, 4, 5, 5, 0, -5 },
  { 262, 4, 8, 5, 0, -8 },
  { 266, 5, 5, 5, 0, -5 },
  { 270, 3, 8, 3, 0, -8 },
  { 273, 5, 7, 5, 0, -5 },
  { 278, 4, 8, 5, 0, -8 },
  { 282, 1, 7, 3, 1, -7 },
  { 283, 2, 9, 2, 0, -7 },
  { 286, 4, 8, 5, 1, -8 },
  { 290, 1, 8, 3, 1, -8 },
  { 291, 6, 5, 7, 1, -5 },
  { 295, 4, 5, 5, 0, -5 },
  { 298, 5, 5, 5, 0, -5 },
  { 302, 4, 7, 5, 1, -5 },
  { 306, 4, 7, 5, 0, -5 },
  { 310, 2, 5, 3, 1, -5 },
  { 312, 4, 5, 5, 0, -5 },
  { 315, 3, 7, 3, 0, -7 },
  { 318, 4, 5, 5, 0, -5 },
  { 321, 4, 5, 4, 0, -5 },
  { 324, 6, 5, 6, 0, -5 },
  { 328, 4, 5, 5, 0, -5 },
  { 331, 4, 7, 4, 0, -5 },
  { 335, 4, 5, 5, 0, -5 },
  { 338, 3, 10, 3, 0, -8 },
  { 342, 1, 8, 3, 1, -7 },
  { 343, 3, 10, 3, 0, -8 },
  { 347, 5, 2, 6, 0, -4 },
};

const GFXfont RobotoCondensed_Bold10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_BOLD10PT7B_H_
