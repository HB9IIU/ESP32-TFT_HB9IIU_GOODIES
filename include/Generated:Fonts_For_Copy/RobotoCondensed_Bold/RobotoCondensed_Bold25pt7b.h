#ifndef _ROBOTOCONDENSED_BOLD25PT7B_H_
#define _ROBOTOCONDENSED_BOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x00, 0x77, 0x77, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x0C, 0xC1, 0x98, 0x37, 0x06, 0xC1, 0xD8, 0xFF,
  0xDF, 0xF8, 0xCC, 0x19, 0x83, 0x70, 0x6C, 0x7F, 0xFF, 0xFE, 0x66, 0x0C,
  0xC1, 0x98, 0x37, 0x0E, 0xC0, 0x06, 0x01, 0x80, 0x60, 0x7C, 0x3F, 0x9F,
  0xF7, 0x1D, 0xC7, 0x71, 0xDE, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F,
  0xC7, 0xF1, 0xFC, 0x77, 0xFC, 0xFE, 0x1F, 0x01, 0x00, 0x40, 0x38, 0x01,
  0xF0, 0x0E, 0xE6, 0x31, 0x98, 0xC6, 0xE3, 0xBB, 0x07, 0xD8, 0x0E, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x67, 0x01, 0xBE, 0x0D, 0xDC, 0x36, 0x31, 0x98,
  0xC6, 0x77, 0x00, 0xF8, 0x01, 0xC0, 0x1E, 0x01, 0xFC, 0x0F, 0xE0, 0xE7,
  0x07, 0x18, 0x39, 0xC0, 0xFE, 0x07, 0xE0, 0x1E, 0x03, 0xF3, 0x9F, 0xDD,
  0xEE, 0xEE, 0x7F, 0x71, 0xF3, 0xC7, 0x9F, 0xFC, 0x7F, 0xF0, 0xF3, 0xC0,
  0xFF, 0xFC, 0x04, 0x31, 0xC6, 0x38, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3,
  0x86, 0x18, 0x71, 0xC7, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x10, 0x83, 0x0E,
  0x18, 0x70, 0xC3, 0x8E, 0x38, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xE3,
  0x8E, 0x31, 0xC7, 0x38, 0xC2, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x33, 0x3F,
  0xFE, 0x7F, 0x83, 0x80, 0xF8, 0x3B, 0x86, 0x38, 0x42, 0x00, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x00, 0x39, 0xCE, 0x77, 0x39, 0x80, 0xFF, 0xFF, 0xC0, 0xEE,
  0xEE, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0x1F, 0x0F, 0xE7,
  0xFD, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x77, 0x3D, 0xFE, 0x3F, 0x87, 0xC0, 0x06, 0x3F, 0xFF, 0xFF,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x1F, 0x07, 0xF1, 0xFF, 0x79, 0xEF, 0x1D, 0xC3, 0x80, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0xE1, 0xC0, 0x70, 0x3C, 0x7E, 0x1F,
  0x07, 0xE0, 0x3C, 0x07, 0x01, 0xF8, 0x7F, 0x3F, 0xFF, 0x7F, 0x87, 0x80,
  0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDC, 0x73,
  0x8E, 0x73, 0x8E, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC3, 0xFC,
  0x7F, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1F, 0xE3, 0xBC, 0x73, 0xFE, 0x3F,
  0x83, 0xE0, 0x07, 0x03, 0xE0, 0xFC, 0x1E, 0x07, 0x80, 0xE0, 0x1D, 0xC7,
  0xFC, 0xFF, 0xDE, 0x3B, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xDC, 0x73, 0xFE,
  0x3F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xCF, 0x71, 0xDC, 0x77,
  0x3D, 0xFE, 0x3F, 0x1F, 0xE7, 0x3F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1D, 0xFF,
  0x7F, 0x87, 0xC0, 0x1E, 0x0F, 0xE7, 0xF9, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xDF, 0xF7, 0xFC, 0xF7, 0x01, 0xC0, 0xE0, 0x78, 0xFC, 0x3E,
  0x0F, 0x00, 0xEE, 0xEE, 0x00, 0x00, 0x00, 0x6E, 0xFE, 0x6F, 0xF7, 0x00,
  0x00, 0x00, 0x07, 0x77, 0x76, 0xE4, 0x00, 0x83, 0xC7, 0xEF, 0xEF, 0x87,
  0x03, 0xE0, 0xFE, 0x1F, 0x83, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xF0,
  0xFD, 0xFC, 0xFC, 0x3C, 0x0C, 0x00, 0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x38,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00, 0x60, 0x78,
  0x3C, 0x0E, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x83, 0x87, 0x00, 0xE3,
  0x00, 0x33, 0x87, 0x19, 0x8F, 0xE6, 0xC6, 0x63, 0xE7, 0x31, 0xF3, 0x18,
  0xF1, 0x8C, 0x79, 0xC6, 0x3C, 0xE3, 0x1E, 0x73, 0x9F, 0x1D, 0xCD, 0xCF,
  0xFE, 0xE3, 0x9E, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC1, 0x00,
  0xFF, 0x80, 0x1F, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1E, 0xF0, 0x38, 0xE0, 0x71,
  0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x1E, 0x0F, 0x3C, 0x1E, 0x70, 0x1D,
  0xE0, 0x3C, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0,
  0xEF, 0xFE, 0xFF, 0xCF, 0xFE, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1, 0xEF,
  0x07, 0x78, 0x3B, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x07, 0x78, 0x39, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xFF,
  0x0F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0xFE, 0xFF, 0xDF, 0xFB, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0x78, 0x3B,
  0xC0, 0x1E, 0x00, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0xFF, 0x07, 0xB8,
  0x3D, 0xE1, 0xEF, 0xFF, 0x3F, 0xF0, 0x7E, 0x00, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xE3, 0xF8, 0xFF, 0x3F, 0xFE, 0x7F, 0x0F, 0x80, 0xF0, 0xFF, 0x87, 0xBC,
  0x79, 0xE3, 0xCF, 0x3C, 0x7B, 0xC3, 0xDE, 0x1F, 0xE0, 0xFF, 0x07, 0xFC,
  0x3F, 0xE1, 0xF7, 0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x1E, 0xF0, 0xF7,
  0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x37, 0xFB, 0xBB, 0xFD, 0xDD,
  0xFE, 0xEE, 0xFF, 0x7E, 0x7F, 0x9F, 0x3F, 0xCF, 0x9F, 0xE7, 0xCF, 0xF1,
  0xC7, 0xF8, 0xE3, 0xC0, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFF, 0x3F, 0xF9, 0xFF, 0xEF, 0xF7, 0x7F, 0xBF, 0xFC, 0xFF, 0xE7, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xC0, 0x0F, 0x81,
  0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xE3, 0xCF, 0xFE,
  0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC,
  0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xB8, 0x3D, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0x7F,
  0x00, 0x3E, 0x00, 0xE0, 0x02, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x3C,
  0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0x1F, 0x03, 0xFC,
  0x7F, 0xEF, 0x1E, 0xF0, 0xEF, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xE0, 0x1E, 0xE0, 0xEF, 0x0F, 0xF0, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x70, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xF0, 0x3D, 0xC0, 0xF7, 0x83, 0xDE,
  0x1E, 0x38, 0x78, 0xE1, 0xE3, 0xC7, 0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0x81,
  0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xE1, 0xC3, 0xF0, 0xE3, 0xF8, 0xF1, 0xFE, 0x7C, 0xFF, 0x3E,
  0x73, 0x9F, 0x39, 0xCF, 0x9C, 0xE7, 0xCE, 0x77, 0x6F, 0x3F, 0xBF, 0x9F,
  0xDF, 0x87, 0xEF, 0xC3, 0xE7, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78,
  0x3E, 0x3C, 0x0E, 0x1E, 0x00, 0x78, 0x79, 0xE1, 0xE3, 0xC7, 0x0F, 0x3C,
  0x1C, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0xE0, 0x73, 0x83, 0xCF, 0x0E, 0x3C, 0x78, 0x79, 0xE1,
  0xE0, 0xF0, 0x7B, 0xC3, 0xDE, 0x1C, 0x71, 0xE3, 0xCF, 0x0E, 0x70, 0x77,
  0x83, 0xF8, 0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xFF, 0xF8,
  0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38,
  0x0F, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9F, 0xFF, 0xF8, 0x38, 0x3C, 0x3C, 0x7C, 0x7E, 0x66, 0xE6,
  0xE7, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3, 0x87, 0x1E, 0x1F, 0xEF,
  0xFB, 0xCE, 0x03, 0xCF, 0xF7, 0xFF, 0xCF, 0xE3, 0xF8, 0xFF, 0xFD, 0xFF,
  0x3B, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xC7,
  0xFE, 0xFF, 0xDE, 0x3B, 0xC7, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x77, 0x8E,
  0xFF, 0xDF, 0xFB, 0x9C, 0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0xCF, 0xE1, 0xF8,
  0x0E, 0x03, 0x80, 0xE1, 0xFC, 0xF7, 0xF9, 0xFE, 0x1E, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x73, 0xDD, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0xFF, 0xDF, 0xF3, 0xDC, 0x1F, 0x1F,
  0xE7, 0xFF, 0xC7, 0xF1, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x3C, 0x27, 0xFD,
  0xFF, 0x1F, 0x00, 0x0F, 0x1F, 0x3F, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3D, 0xDF,
  0xFF, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0xFD,
  0xFF, 0x3D, 0xC0, 0x70, 0x3D, 0xFF, 0x7F, 0x8F, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x73, 0xFE, 0xFF, 0xFC, 0xFF, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1C, 0x6F, 0xF6, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xC6, 0x00, 0x03,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF,
  0xBC, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0xF7, 0x9E,
  0xF7, 0x9F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3D, 0xE7, 0xBC, 0xF3,
  0xDE, 0x7B, 0xC7, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF7, 0x1E, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xC7, 0xF3, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xE7, 0x3F, 0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xC0, 0x1F, 0x0F, 0xF1,
  0xFF, 0x79, 0xEE, 0x1D, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDE, 0x39, 0xFF,
  0x3F, 0xC1, 0xF0, 0xEF, 0x1F, 0xFB, 0xFF, 0x78, 0xEF, 0x1D, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xDE, 0x3B, 0xFF, 0x7F, 0xCF, 0xF1, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x00, 0x3D, 0xDF, 0xFF, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0xFD, 0xFF, 0x3D, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x00, 0x3E, 0x3F, 0xBF, 0xFC, 0x7F, 0x03, 0xE0, 0xFC, 0x3F,
  0x07, 0xF1, 0xFF, 0xEF, 0xF3, 0xE0, 0x38, 0x70, 0xE7, 0xFF, 0xFF, 0xCE,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xCF, 0x8F, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFF, 0xFD, 0xFF, 0x3D,
  0xC0, 0xF1, 0xEE, 0x39, 0xC7, 0x3C, 0xE3, 0xBC, 0x77, 0x0E, 0xE1, 0xDC,
  0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x80, 0xE0, 0x71, 0x8E, 0xE7, 0x1D, 0xCF,
  0x3B, 0x9E, 0xF7, 0x3D, 0xC7, 0xFB, 0x8F, 0xFF, 0x1F, 0x7E, 0x3E, 0x7C,
  0x7C, 0xF0, 0x79, 0xE0, 0xE3, 0xC1, 0xC3, 0x80, 0x71, 0xEF, 0x38, 0xEF,
  0x1F, 0xC1, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0x87, 0xF0, 0xEF, 0x3C,
  0xE7, 0x1E, 0xF1, 0xEE, 0x39, 0xC7, 0x3D, 0xE3, 0xBC, 0x77, 0x0E, 0xE1,
  0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x83, 0xE0,
  0x7C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78,
  0x78, 0x3C, 0x3F, 0xFF, 0xFF, 0xF8, 0x08, 0x73, 0x8E, 0x79, 0xC7, 0x1C,
  0x71, 0xCF, 0x38, 0xE1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x38, 0xE1, 0xC2,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x8E, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC3, 0xC7, 0x3D, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x20,
  0x38, 0x77, 0xC7, 0x7E, 0x6E, 0x7E, 0xE3, 0xEE, 0x1C,
};

const GFXglyph RobotoCondensed_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 18, 7, 1, -18 },
  { 10, 6, 7, 8, 1, -19 },
  { 16, 11, 18, 13, 1, -18 },
  { 41, 10, 23, 13, 1, -21 },
  { 70, 14, 18, 16, 1, -18 },
  { 102, 13, 18, 14, 1, -18 },
  { 132, 2, 7, 4, 1, -19 },
  { 134, 6, 26, 8, 1, -20 },
  { 154, 6, 26, 8, 1, -20 },
  { 174, 11, 11, 11, 0, -18 },
  { 190, 10, 13, 12, 1, -15 },
  { 207, 5, 7, 6, 0, -3 },
  { 212, 6, 3, 9, 1, -9 },
  { 215, 4, 4, 7, 2, -4 },
  { 217, 8, 20, 8, 0, -18 },
  { 237, 10, 18, 13, 1, -18 },
  { 260, 7, 18, 13, 2, -18 },
  { 276, 11, 18, 13, 1, -18 },
  { 301, 10, 18, 13, 1, -18 },
  { 324, 11, 18, 13, 1, -18 },
  { 349, 11, 18, 13, 1, -18 },
  { 374, 11, 18, 13, 1, -18 },
  { 399, 11, 18, 13, 1, -18 },
  { 424, 10, 18, 13, 1, -18 },
  { 447, 10, 18, 13, 1, -18 },
  { 470, 4, 14, 7, 2, -14 },
  { 477, 4, 18, 6, 1, -14 },
  { 486, 9, 11, 11, 1, -13 },
  { 499, 9, 8, 13, 2, -12 },
  { 508, 10, 11, 11, 1, -13 },
  { 522, 9, 18, 11, 1, -18 },
  { 543, 17, 23, 19, 1, -17 },
  { 592, 15, 18, 15, 0, -18 },
  { 626, 12, 18, 14, 1, -18 },
  { 653, 13, 18, 14, 1, -18 },
  { 683, 12, 18, 14, 1, -18 },
  { 710, 11, 18, 12, 1, -18 },
  { 735, 10, 18, 12, 1, -18 },
  { 758, 13, 18, 15, 1, -18 },
  { 788, 13, 18, 15, 1, -18 },
  { 818, 3, 18, 7, 2, -18 },
  { 825, 10, 18, 12, 1, -18 },
  { 848, 13, 18, 14, 1, -18 },
  { 878, 10, 18, 12, 1, -18 },
  { 901, 17, 18, 19, 1, -18 },
  { 940, 13, 18, 15, 1, -18 },
  { 970, 13, 18, 15, 1, -18 },
  { 1000, 12, 18, 14, 1, -18 },
  { 1027, 13, 21, 15, 1, -18 },
  { 1062, 12, 18, 14, 1, -18 },
  { 1089, 12, 18, 13, 1, -18 },
  { 1116, 12, 18, 14, 1, -18 },
  { 1143, 12, 18, 14, 1, -18 },
  { 1170, 14, 18, 14, 0, -18 },
  { 1202, 17, 18, 19, 1, -18 },
  { 1241, 14, 18, 14, 0, -18 },
  { 1273, 13, 18, 14, 0, -18 },
  { 1303, 11, 18, 13, 1, -18 },
  { 1328, 5, 25, 7, 1, -21 },
  { 1344, 10, 20, 10, 0, -18 },
  { 1369, 5, 25, 7, 0, -21 },
  { 1385, 8, 9, 10, 1, -18 },
  { 1394, 10, 3, 10, 0, 0 },
  { 1398, 6, 4, 8, 1, -19 },
  { 1401, 10, 13, 12, 1, -13 },
  { 1418, 11, 19, 12, 1, -19 },
  { 1445, 10, 13, 12, 1, -13 },
  { 1462, 10, 19, 12, 1, -19 },
  { 1486, 10, 13, 12, 1, -13 },
  { 1503, 8, 19, 8, 0, -19 },
  { 1522, 10, 18, 13, 1, -13 },
  { 1545, 10, 19, 12, 1, -19 },
  { 1569, 4, 19, 6, 1, -19 },
  { 1579, 6, 24, 6, -1, -19 },
  { 1597, 11, 19, 12, 1, -19 },
  { 1624, 4, 19, 6, 1, -19 },
  { 1634, 16, 13, 19, 1, -13 },
  { 1660, 10, 13, 12, 1, -13 },
  { 1677, 11, 13, 12, 1, -13 },
  { 1695, 11, 18, 12, 1, -13 },
  { 1720, 10, 18, 12, 1, -13 },
  { 1743, 7, 13, 8, 1, -13 },
  { 1755, 9, 13, 11, 1, -13 },
  { 1770, 7, 16, 8, 0, -16 },
  { 1784, 10, 13, 12, 1, -13 },
  { 1801, 11, 13, 11, 0, -13 },
  { 1819, 15, 13, 16, 0, -13 },
  { 1844, 11, 13, 11, 0, -13 },
  { 1862, 11, 18, 11, 0, -13 },
  { 1887, 9, 13, 11, 1, -13 },
  { 1902, 6, 24, 7, 1, -20 },
  { 1920, 2, 21, 6, 2, -18 },
  { 1926, 6, 24, 7, 1, -20 },
  { 1944, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_Bold25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_BOLD25PT7B_H_
