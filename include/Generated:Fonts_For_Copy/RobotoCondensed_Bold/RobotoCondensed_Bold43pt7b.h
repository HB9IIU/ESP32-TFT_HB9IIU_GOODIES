#ifndef _ROBOTOCONDENSED_BOLD43PT7B_H_
#define _ROBOTOCONDENSED_BOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7,
  0x80, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF0, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1C, 0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x1C,
  0x78, 0x07, 0x8F, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xE3,
  0x80, 0x3C, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF0, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x0E, 0x3C,
  0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x3F, 0x7E,
  0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xDF, 0x87, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x80,
  0xF1, 0xE0, 0xE0, 0xF0, 0xE1, 0xE0, 0xF0, 0xE1, 0xC0, 0xF0, 0xE3, 0xC0,
  0xF0, 0xE3, 0x80, 0xF1, 0xE7, 0x80, 0x7F, 0xE7, 0x00, 0x7F, 0xEF, 0x00,
  0x3F, 0xCE, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xFC, 0x00, 0xF7, 0xFE,
  0x01, 0xE7, 0xFE, 0x01, 0xCF, 0x1E, 0x03, 0xCF, 0x0F, 0x03, 0x8F, 0x0F,
  0x07, 0x8F, 0x0F, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x06, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFC,
  0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78,
  0x03, 0xF3, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0xF9, 0xFF, 0xE7, 0xC7, 0xDF,
  0x9F, 0x3F, 0x3F, 0x7C, 0xFC, 0xFF, 0xF3, 0xE1, 0xFF, 0xCF, 0x83, 0xFF,
  0x3F, 0x0F, 0xF8, 0xFC, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xE0, 0x00, 0x80, 0x60, 0x38, 0x1F,
  0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xE0,
  0x18, 0x02, 0x40, 0x0C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x01,
  0x80, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x10, 0x78, 0x2F, 0x9E, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xDF, 0x01, 0xF3,
  0xC0, 0xF8, 0xF8, 0x3C, 0x1F, 0x07, 0x03, 0x80, 0x00, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xFB, 0xE7, 0x82, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFB, 0xFF, 0xEF, 0xCF,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x1F, 0x8F, 0xE7, 0xE1, 0xF9, 0xF0, 0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xF9, 0xF0, 0x7E, 0x7E, 0x1F, 0x9F, 0x8F, 0xE3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x30, 0x0F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x8F, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBE, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xE3, 0xF9, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7B, 0xF0, 0x1F, 0x7E,
  0x03, 0xCF, 0xC0, 0xF9, 0xF8, 0x1F, 0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0xFC,
  0x3E, 0x1F, 0x87, 0xC3, 0xF1, 0xF0, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xCF,
  0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF0, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0x9F, 0x87, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xEF, 0x81, 0xF7,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x8F, 0xE7,
  0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8,
  0x7E, 0x7E, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE,
  0x0F, 0xFF, 0xC7, 0xE3, 0xF9, 0xF8, 0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0x87, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x8F, 0xC7, 0xE1, 0xFB,
  0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFD, 0xF8, 0x7E, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xDF, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x7D, 0xFB, 0xFF, 0xEF, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xF7, 0xFF,
  0xDF, 0x9E, 0x00, 0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x30, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFD, 0xFE, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF1, 0xE0,
  0x3F, 0x07, 0x8F, 0x03, 0xFC, 0x1C, 0xF0, 0x3F, 0xF0, 0xF7, 0x83, 0xFF,
  0x87, 0xBC, 0x3E, 0x3C, 0x3F, 0xC1, 0xE1, 0xE1, 0xFE, 0x1F, 0x0F, 0x07,
  0xF0, 0xF0, 0x78, 0x3F, 0x87, 0x83, 0xC1, 0xFC, 0x3C, 0x1E, 0x0F, 0xE1,
  0xE0, 0xF0, 0x7F, 0x1F, 0x07, 0x87, 0xF8, 0xF8, 0x7C, 0x3F, 0xC7, 0xC3,
  0xC1, 0xFE, 0x3E, 0x1E, 0x0E, 0xF0, 0xF0, 0xF0, 0xF7, 0x87, 0xCF, 0x87,
  0xBC, 0x3F, 0xFE, 0x79, 0xE0, 0xFF, 0xFF, 0x8F, 0x07, 0xF3, 0xFC, 0x3C,
  0x1F, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x20,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7D,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0x80, 0x3F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01,
  0xFD, 0xF8, 0x00, 0x7E, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x3F,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0,
  0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xC3, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0,
  0x3F, 0x7E, 0x03, 0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xE1, 0xFE, 0xFE,
  0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE1,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xC3, 0xF9, 0xFC, 0x0F,
  0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x01, 0xFB,
  0xFC, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7E,
  0xFE, 0x1F, 0xBF, 0x8F, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F,
  0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7D, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0x07,
  0xFF, 0xFD, 0xF0, 0xFB, 0xFF, 0xDF, 0x8F, 0xBF, 0xFC, 0xF8, 0xFB, 0xFF,
  0xCF, 0x9F, 0x3F, 0xFC, 0xF9, 0xF3, 0xFF, 0xC7, 0xDF, 0x3F, 0xFC, 0x7F,
  0xF3, 0xFF, 0xC7, 0xFE, 0x3F, 0xFC, 0x7F, 0xE3, 0xFF, 0xC3, 0xFE, 0x3F,
  0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x1F, 0xC3, 0xFF, 0xC1,
  0xFC, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC0, 0xF8, 0x3F, 0xFC, 0x0F, 0x83,
  0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFD, 0xF8,
  0xFF, 0xF7, 0xE3, 0xFF, 0xCF, 0xCF, 0xFF, 0x3F, 0x3F, 0xFC, 0x7C, 0xFF,
  0xF1, 0xFB, 0xFF, 0xC3, 0xEF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80,
  0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7F, 0x03, 0xF9,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xDF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFB, 0xF8, 0x1F, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80,
  0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF9,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x1F,
  0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC,
  0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE3,
  0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xC7,
  0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x01,
  0xFB, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xEF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0,
  0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xC3, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03,
  0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC,
  0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xDF, 0x83,
  0xF0, 0x3F, 0x7E, 0x0F, 0xE0, 0xFD, 0xF8, 0x3F, 0x87, 0xE7, 0xE1, 0xFE,
  0x1F, 0x9F, 0x87, 0xF8, 0x7E, 0x7E, 0x1F, 0xE1, 0xF8, 0xF8, 0x7F, 0x87,
  0xE3, 0xF1, 0xFF, 0x1F, 0x0F, 0xCF, 0xFC, 0x7C, 0x3F, 0x3F, 0xF3, 0xF0,
  0xFC, 0xFF, 0xCF, 0xC1, 0xF3, 0xEF, 0x3F, 0x07, 0xCF, 0xBE, 0xFC, 0x1F,
  0xBC, 0xFB, 0xE0, 0x7F, 0xF3, 0xEF, 0x81, 0xFF, 0xCF, 0xBE, 0x07, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFD, 0xFC,
  0x07, 0xF7, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x1F,
  0xC1, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFC, 0xFC, 0x07,
  0xF3, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x7F, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x7E, 0x00,
  0xFE, 0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F,
  0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x78,
  0x3E, 0xF8, 0x78, 0xF0, 0xF1, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0xBE,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x1F,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xFC, 0x7E, 0x7E, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x3E, 0x0F, 0xDF, 0xE3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xDF, 0xE3, 0xF3, 0xE0, 0x03,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xC7,
  0xE7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x7E,
  0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1,
  0xF3, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xF1,
  0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xDF,
  0x83, 0xF7, 0xF1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE,
  0x7C, 0x1F, 0x1F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF7, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x02, 0x7F, 0x03, 0x9F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFF, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0xE7, 0xC3, 0xFD,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC3, 0xF7, 0xE0, 0x7D,
  0xF8, 0x1F, 0x7E, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0xC3,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFD, 0xF0, 0x7E, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF1, 0xC1, 0xFC, 0x7F, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x7C, 0x3F, 0x7F, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0x7D, 0xFB, 0xFF, 0xF7, 0xCF, 0x00, 0x00, 0x01,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x0F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xFB,
  0xF0, 0xFE, 0x7E, 0x3F, 0x8F, 0xC7, 0xF1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07,
  0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0xFC, 0xFE, 0x1F,
  0x8F, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xF7, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x1F, 0x0F, 0xDF, 0xE7, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xFC,
  0x7E, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xF0, 0xFC, 0xFC, 0x7E, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7E, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xBF, 0x8F, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0x8F, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xFC, 0xF8, 0x3F, 0x7F, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0x87, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x7F, 0x8F, 0xCF, 0x83, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF,
  0x7C, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC7, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC7, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7C, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF,
  0xF3, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x1F, 0xBE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x1F, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0x3E, 0x7E, 0xFC, 0x1F,
  0xFF, 0x07, 0xEF, 0xC1, 0xF9, 0xF0, 0x7E, 0x7E, 0x1F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0xCF, 0x83, 0xF7, 0xE0, 0x7D,
  0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0xF8, 0x3E, 0x0F, 0xFE, 0x1F, 0x07, 0xFF, 0x0F, 0x87, 0xFF,
  0x87, 0xE3, 0xF7, 0xC7, 0xF1, 0xFB, 0xE3, 0xF8, 0xF9, 0xF1, 0xFC, 0x7C,
  0xFC, 0xFE, 0x3E, 0x7E, 0xFF, 0xBF, 0x1F, 0x7F, 0xDF, 0x8F, 0xBD, 0xEF,
  0x87, 0xDE, 0xF7, 0xC3, 0xEF, 0x7F, 0xE1, 0xFF, 0x9F, 0xF0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF0,
  0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x03, 0xE0, 0xFC, 0x1F, 0x9F, 0x87, 0xE7, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x3E, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xF1, 0xFC, 0xFC, 0x7E,
  0x3F, 0xBF, 0x87, 0xEF, 0xC1, 0xFC, 0x7E, 0x07, 0xEF, 0xC1, 0xF9, 0xF8,
  0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE0, 0xF8,
  0xFC, 0x1F, 0x9F, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFB,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x38, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F,
  0x01, 0xF8, 0x1E, 0x01, 0xC0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x0E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x3F, 0x07, 0xC0, 0x70, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x0F, 0x3F,
  0xE1, 0xF7, 0xFF, 0x1F, 0x7F, 0xFF, 0xEF, 0x8F, 0xFE, 0xF8, 0x7F, 0xCF,
  0x83, 0xFC, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 31, 11, 3, -31 },
  { 25, 11, 12, 14, 1, -32 },
  { 42, 19, 31, 23, 2, -31 },
  { 116, 18, 39, 22, 2, -35 },
  { 204, 24, 31, 27, 2, -31 },
  { 297, 22, 31, 25, 2, -31 },
  { 383, 5, 12, 7, 1, -32 },
  { 391, 10, 44, 14, 3, -34 },
  { 446, 11, 44, 14, 1, -34 },
  { 507, 18, 19, 20, 1, -31 },
  { 550, 18, 22, 20, 1, -25 },
  { 600, 7, 13, 11, 1, -5 },
  { 612, 10, 5, 16, 3, -16 },
  { 619, 7, 6, 13, 3, -6 },
  { 625, 14, 34, 14, 0, -31 },
  { 685, 18, 31, 22, 2, -31 },
  { 755, 12, 31, 22, 3, -31 },
  { 802, 18, 31, 22, 2, -31 },
  { 872, 19, 31, 22, 1, -31 },
  { 946, 19, 31, 22, 1, -31 },
  { 1020, 18, 31, 22, 2, -31 },
  { 1090, 18, 31, 22, 2, -31 },
  { 1160, 19, 31, 22, 1, -31 },
  { 1234, 18, 31, 22, 2, -31 },
  { 1304, 18, 31, 22, 2, -31 },
  { 1374, 7, 23, 12, 3, -23 },
  { 1395, 8, 31, 11, 1, -23 },
  { 1426, 16, 20, 19, 1, -23 },
  { 1466, 16, 14, 22, 3, -21 },
  { 1494, 15, 20, 20, 3, -23 },
  { 1532, 17, 31, 19, 1, -31 },
  { 1598, 29, 40, 33, 2, -30 },
  { 1743, 25, 31, 26, 0, -31 },
  { 1840, 20, 31, 24, 2, -31 },
  { 1918, 21, 31, 25, 2, -31 },
  { 2000, 20, 31, 24, 2, -31 },
  { 2078, 18, 31, 21, 2, -31 },
  { 2148, 17, 31, 20, 2, -31 },
  { 2214, 21, 31, 25, 2, -31 },
  { 2296, 22, 31, 26, 2, -31 },
  { 2382, 6, 31, 12, 3, -31 },
  { 2406, 18, 31, 21, 1, -31 },
  { 2476, 22, 31, 24, 2, -31 },
  { 2562, 17, 31, 21, 2, -31 },
  { 2628, 28, 31, 33, 2, -31 },
  { 2737, 22, 31, 26, 2, -31 },
  { 2823, 22, 31, 26, 2, -31 },
  { 2909, 21, 31, 24, 2, -31 },
  { 2991, 22, 36, 26, 2, -31 },
  { 3090, 21, 31, 24, 2, -31 },
  { 3172, 20, 31, 23, 2, -31 },
  { 3250, 21, 31, 23, 1, -31 },
  { 3332, 20, 31, 25, 2, -31 },
  { 3410, 24, 31, 25, 0, -31 },
  { 3503, 30, 31, 32, 1, -31 },
  { 3620, 22, 31, 24, 1, -31 },
  { 3706, 23, 31, 23, 0, -31 },
  { 3796, 19, 31, 23, 2, -31 },
  { 3870, 8, 43, 11, 2, -36 },
  { 3913, 17, 34, 16, 0, -31 },
  { 3986, 8, 43, 11, 1, -36 },
  { 4029, 15, 15, 17, 1, -31 },
  { 4058, 17, 5, 17, 0, 0 },
  { 4069, 11, 6, 14, 1, -32 },
  { 4078, 17, 23, 20, 2, -23 },
  { 4127, 18, 32, 21, 2, -32 },
  { 4199, 18, 23, 20, 1, -23 },
  { 4251, 18, 32, 21, 1, -32 },
  { 4323, 17, 23, 21, 2, -23 },
  { 4372, 13, 32, 14, 1, -32 },
  { 4424, 18, 32, 22, 1, -23 },
  { 4496, 17, 32, 21, 2, -32 },
  { 4564, 7, 32, 11, 2, -32 },
  { 4592, 10, 41, 11, -1, -32 },
  { 4644, 19, 32, 21, 2, -32 },
  { 4720, 6, 32, 11, 2, -32 },
  { 4744, 28, 23, 32, 2, -23 },
  { 4825, 17, 23, 21, 2, -23 },
  { 4874, 18, 23, 21, 2, -23 },
  { 4926, 18, 32, 21, 2, -23 },
  { 4998, 18, 32, 21, 1, -23 },
  { 5070, 11, 23, 14, 2, -23 },
  { 5102, 17, 23, 20, 1, -23 },
  { 5151, 12, 28, 13, 0, -28 },
  { 5193, 17, 23, 21, 2, -23 },
  { 5242, 18, 23, 19, 1, -23 },
  { 5294, 25, 23, 27, 1, -23 },
  { 5366, 18, 23, 19, 1, -23 },
  { 5418, 19, 32, 19, 0, -23 },
  { 5494, 16, 23, 19, 2, -23 },
  { 5540, 11, 42, 13, 1, -34 },
  { 5598, 3, 37, 11, 4, -31 },
  { 5612, 11, 42, 13, 1, -34 },
  { 5670, 20, 9, 24, 2, -17 },
};

const GFXfont RobotoCondensed_Bold43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_BOLD43PT7B_H_
