#ifndef _ROBOTOCONDENSED_BOLD56PT7B_H_
#define _ROBOTOCONDENSED_BOLD56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0xF0, 0x7B, 0xC1,
  0xEF, 0x07, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F,
  0x81, 0xFE, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x7F, 0x87, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x18, 0x0F, 0x87, 0xC0, 0xF0,
  0x3E, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x78, 0x0F,
  0x83, 0xE3, 0xE0, 0x3E, 0x0F, 0x8F, 0x00, 0xF8, 0x7C, 0x7C, 0x03, 0xE1,
  0xF1, 0xE0, 0x0F, 0xCF, 0xCF, 0x80, 0x1F, 0xFF, 0x3C, 0x00, 0x7F, 0xF9,
  0xF0, 0x00, 0xFF, 0xCF, 0x80, 0x01, 0xFE, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC7, 0xF8, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0xF9, 0xFF, 0xE0,
  0x03, 0xEF, 0xFF, 0x80, 0x1F, 0x3F, 0x3F, 0x00, 0x7C, 0xF8, 0x7C, 0x03,
  0xE7, 0xE1, 0xF0, 0x0F, 0x1F, 0x07, 0xC0, 0x7C, 0x7C, 0x1F, 0x01, 0xE1,
  0xF0, 0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x3C, 0x1F, 0x87, 0xC1, 0xF0, 0x3E,
  0x1F, 0x03, 0x80, 0xFC, 0xFC, 0x02, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x83, 0xF0, 0x7F, 0xFC, 0x1F, 0x87,
  0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0xC7, 0xE3, 0xFD, 0xFE, 0x7F, 0x1F, 0xC7,
  0xFB, 0xF9, 0xFE, 0x3F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFC, 0x7F, 0x83, 0xFF,
  0xE3, 0xFC, 0x1F, 0xFF, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0x01, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF9,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x00, 0x10, 0x00,
  0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x04, 0x40,
  0x07, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0x78, 0x03, 0x80, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x60, 0x3C, 0x02, 0x78, 0x3C, 0x1E, 0x7E, 0x3C, 0x7E, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0,
  0x0F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x07, 0x00, 0xE0, 0x02, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F,
  0xC1, 0xF0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x3F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E,
  0x08, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8,
  0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x81, 0xFE, 0x7F,
  0x03, 0xFC, 0xFF, 0x07, 0xF1, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF,
  0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xC3, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0xC3, 0xFE,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x03, 0xF7, 0xF8, 0x03, 0xF7, 0xF8, 0x07, 0xE7, 0xF8, 0x07, 0xE7, 0xF8,
  0x0F, 0xC7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0x87, 0xF8,
  0x3F, 0x87, 0xF8, 0x3F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0xFE, 0x07, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xCF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xC1, 0xC0, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFE, 0xFF, 0x03, 0xFD, 0xFF, 0x0F, 0xF9, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC7, 0xE0, 0x7F, 0xBF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xBF, 0x80, 0xFF, 0x7F, 0x83, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0xFE, 0x07, 0xFB, 0xFC, 0x0F,
  0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFF,
  0x3F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x7F, 0x87, 0xF8, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8,
  0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xE3, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x03, 0xF9, 0xFE,
  0x07, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFE, 0x03,
  0xFB, 0xFC, 0x0F, 0xF7, 0xFC, 0x1F, 0xE7, 0xFC, 0x7F, 0xCF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xF7, 0xF8,
  0x0F, 0xCF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x3F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD, 0xFE,
  0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7E, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xF9, 0xF8, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF3, 0xF8,
  0xFE, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8,
  0xFE, 0x3F, 0x07, 0x80, 0x40, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xF1, 0xFE,
  0x7F, 0x83, 0xFD, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x03, 0xF0,
  0x0F, 0x83, 0xE0, 0x0F, 0xF8, 0x0F, 0x0F, 0xC0, 0x7F, 0xFC, 0x1F, 0x1F,
  0x01, 0xFF, 0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0xF0, 0x7C, 0xFC, 0x0F, 0xC3,
  0xE0, 0x79, 0xF0, 0x1F, 0x07, 0xC0, 0xF3, 0xE0, 0x7E, 0x0F, 0x81, 0xE7,
  0xC0, 0xF8, 0x1F, 0x03, 0xEF, 0x83, 0xF0, 0x3E, 0x07, 0xDF, 0x07, 0xE0,
  0xFC, 0x0F, 0xFE, 0x0F, 0x81, 0xF8, 0x1F, 0xFC, 0x1F, 0x03, 0xF0, 0x3F,
  0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xE0, 0xFC, 0x0F, 0x80, 0xF7, 0xC1, 0xF8,
  0x1F, 0x01, 0xEF, 0x83, 0xF0, 0x3E, 0x03, 0xDF, 0x07, 0xE0, 0x7C, 0x0F,
  0xBE, 0x0F, 0xC0, 0xF8, 0x1F, 0x7E, 0x1F, 0x81, 0xF0, 0x3C, 0xFC, 0x3F,
  0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x1F, 0xC1, 0xF1, 0xF0, 0x7F, 0xFF, 0xC7,
  0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFF, 0xDF, 0xFE, 0x0F, 0xC0,
  0xFF, 0x1F, 0xF8, 0x0F, 0x80, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0x40, 0x0E,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFC, 0x03,
  0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF3, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFE,
  0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xCF, 0xF0, 0x07, 0xF9, 0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0xC1, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0xFF,
  0x8F, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xFC,
  0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFE, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF,
  0x8F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xF7, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xFE, 0x07, 0xF7,
  0xFF, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0x7F, 0x07, 0xE7, 0xFF, 0xF7, 0xF0,
  0x7E, 0x7F, 0xFF, 0x7F, 0x0F, 0xE7, 0xFF, 0xF3, 0xF0, 0xFC, 0x7F, 0xFF,
  0x3F, 0x8F, 0xC7, 0xFF, 0xF3, 0xF9, 0xFC, 0x7F, 0xFF, 0x1F, 0x9F, 0xC7,
  0xFF, 0xF1, 0xFD, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0x07, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xF7, 0xF8, 0xFF, 0xFF,
  0x3F, 0x8F, 0xFF, 0xF3, 0xFC, 0xFF, 0xFF, 0x1F, 0xCF, 0xFF, 0xF1, 0xFE,
  0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7,
  0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xFE, 0xFF, 0x00,
  0x7F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x9F, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00,
  0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x13, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF,
  0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFE, 0x7F, 0xC0, 0xFF,
  0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x1F, 0xF7, 0xFE, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xF8, 0x7F, 0xE7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x3F, 0x81, 0xFF, 0x81,
  0xFC, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F,
  0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0xC3, 0xFC, 0x3F, 0xC3, 0xFF,
  0xC3, 0xFC, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8,
  0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x1F, 0xE3, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7,
  0xFF, 0xE7, 0xF8, 0x0F, 0xE7, 0xFF, 0xE7, 0xF8, 0x0F, 0xE7, 0xE7, 0xE7,
  0xF0, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x0F,
  0xFF, 0xE7, 0xF7, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F,
  0xDF, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFF, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF9, 0xF8, 0x1F,
  0x9F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x07, 0xC7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0,
  0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x07,
  0xFD, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x80, 0x40, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x20, 0x0F, 0xF3, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFB, 0xFE, 0x1F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFB, 0xFC,
  0x0F, 0xF7, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0x7F, 0xF8, 0xFE, 0xFF, 0xE1, 0xFC, 0x7F, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xE1, 0xFF, 0x7F,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x02, 0x0F, 0xF0, 0x7F, 0x9F, 0xE1, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFB, 0xFE, 0x1F,
  0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0x7F,
  0x0F, 0xFC, 0xFE, 0x0F, 0xF1, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0x81, 0xFC, 0xFE,
  0x03, 0xFD, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x18, 0x7F, 0xC0, 0x78, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC1, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x3F, 0xFB, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF,
  0x7F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0xC0, 0xFF, 0x7F, 0xC3,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xDF, 0xC0, 0xFF, 0x3F, 0x80, 0x20, 0x7F, 0x00, 0x01, 0xFE,
  0x10, 0x03, 0xFC, 0x30, 0x07, 0xF8, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0xC3, 0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8,
  0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x7F, 0xC0,
  0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xC0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFE, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xE1, 0xFE,
  0xFF, 0x07, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x01, 0xFC, 0x7F, 0x83, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x03, 0xFD,
  0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0x7F, 0x81, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xCF, 0xF0, 0x7F, 0x82, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x0F, 0xF1, 0xFC, 0x3F, 0xF3, 0xF8, 0xFF, 0xF7, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xBF, 0xC1, 0xFE, 0x7F, 0x80, 0x20, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0B, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0x7F, 0xEF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07,
  0xFF, 0xFE, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x04, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xF9, 0xFC, 0x3F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC, 0x0F,
  0xEF, 0xE0, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xC3,
  0xF9, 0xFC, 0x3F, 0xE1, 0xFC, 0xFF, 0x1F, 0xF0, 0xFE, 0x3F, 0x8F, 0xF8,
  0x7F, 0x1F, 0xC7, 0xFE, 0x3F, 0x8F, 0xE7, 0xFF, 0x3F, 0x87, 0xF3, 0xFF,
  0x9F, 0xC1, 0xF9, 0xFF, 0xCF, 0xE0, 0xFC, 0xFF, 0xF7, 0xF0, 0x7F, 0x7D,
  0xFB, 0xF8, 0x3F, 0xFE, 0xFD, 0xF8, 0x1F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF,
  0x9F, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF,
  0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF0, 0x1F, 0xEF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3,
  0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xE3,
  0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7,
  0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xF7,
  0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x03, 0x80,
  0x7E, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0xFF,
  0x87, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0x00, 0x78, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x03, 0xE3,
  0xFF, 0x80, 0xF8, 0xFF, 0xF0, 0x7E, 0x7F, 0xFE, 0x1F, 0x9F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xF0, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0x3F, 0x03,
  0xFF, 0x8F, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Bold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 41, 15, 3, -40 },
  { 48, 14, 15, 18, 2, -42 },
  { 75, 26, 40, 30, 2, -40 },
  { 205, 23, 53, 28, 3, -47 },
  { 358, 30, 42, 36, 3, -41 },
  { 516, 29, 42, 32, 2, -41 },
  { 669, 6, 15, 9, 2, -42 },
  { 681, 14, 56, 18, 3, -44 },
  { 779, 13, 56, 18, 2, -44 },
  { 870, 24, 24, 25, 1, -40 },
  { 942, 23, 29, 27, 2, -33 },
  { 1026, 10, 17, 14, 1, -7 },
  { 1048, 14, 6, 20, 3, -20 },
  { 1059, 9, 9, 16, 3, -8 },
  { 1070, 18, 43, 19, 0, -40 },
  { 1167, 23, 42, 28, 3, -41 },
  { 1288, 16, 40, 28, 4, -40 },
  { 1368, 24, 41, 28, 2, -41 },
  { 1491, 24, 42, 28, 2, -41 },
  { 1617, 24, 40, 28, 2, -40 },
  { 1737, 23, 41, 28, 3, -40 },
  { 1855, 23, 41, 28, 3, -40 },
  { 1973, 24, 40, 28, 2, -40 },
  { 2093, 23, 42, 28, 3, -41 },
  { 2214, 23, 41, 28, 2, -41 },
  { 2332, 9, 31, 15, 3, -30 },
  { 2367, 10, 40, 14, 2, -30 },
  { 2417, 20, 26, 25, 2, -30 },
  { 2482, 20, 17, 28, 4, -26 },
  { 2525, 21, 26, 25, 3, -30 },
  { 2594, 22, 42, 25, 1, -41 },
  { 2710, 39, 51, 43, 2, -39 },
  { 2959, 32, 40, 33, 1, -40 },
  { 3119, 26, 40, 31, 3, -40 },
  { 3249, 27, 42, 32, 3, -41 },
  { 3391, 26, 40, 32, 3, -40 },
  { 3521, 23, 40, 27, 3, -40 },
  { 3636, 22, 40, 27, 3, -40 },
  { 3746, 27, 42, 33, 3, -41 },
  { 3888, 28, 40, 34, 3, -40 },
  { 4028, 8, 40, 15, 4, -40 },
  { 4068, 23, 41, 27, 1, -40 },
  { 4186, 28, 40, 31, 3, -40 },
  { 4326, 22, 40, 27, 3, -40 },
  { 4436, 36, 40, 42, 3, -40 },
  { 4616, 28, 40, 34, 3, -40 },
  { 4756, 28, 42, 34, 3, -41 },
  { 4903, 27, 40, 32, 3, -40 },
  { 5038, 29, 48, 34, 2, -41 },
  { 5212, 27, 40, 31, 3, -40 },
  { 5347, 26, 42, 30, 2, -41 },
  { 5484, 28, 40, 30, 1, -40 },
  { 5624, 26, 41, 32, 3, -40 },
  { 5758, 31, 40, 32, 1, -40 },
  { 5913, 40, 40, 42, 1, -40 },
  { 6113, 29, 40, 31, 1, -40 },
  { 6258, 30, 40, 30, 0, -40 },
  { 6408, 26, 40, 30, 2, -40 },
  { 6538, 11, 55, 15, 3, -46 },
  { 6614, 22, 43, 21, 0, -40 },
  { 6733, 11, 55, 15, 1, -46 },
  { 6809, 20, 20, 22, 1, -40 },
  { 6859, 21, 6, 22, 1, 0 },
  { 6875, 14, 8, 19, 1, -42 },
  { 6889, 23, 32, 26, 2, -31 },
  { 6981, 23, 43, 28, 3, -42 },
  { 7105, 22, 32, 26, 2, -31 },
  { 7193, 23, 43, 28, 2, -42 },
  { 7317, 23, 32, 27, 2, -31 },
  { 7409, 17, 43, 18, 1, -43 },
  { 7501, 23, 42, 28, 2, -31 },
  { 7622, 22, 42, 28, 3, -42 },
  { 7738, 8, 42, 14, 3, -42 },
  { 7780, 12, 53, 14, -1, -42 },
  { 7860, 24, 42, 27, 3, -42 },
  { 7986, 8, 42, 14, 3, -42 },
  { 8028, 36, 31, 42, 3, -31 },
  { 8168, 22, 31, 28, 3, -31 },
  { 8254, 24, 32, 28, 2, -31 },
  { 8350, 23, 42, 28, 3, -31 },
  { 8471, 23, 42, 28, 2, -31 },
  { 8592, 14, 31, 19, 3, -31 },
  { 8647, 21, 32, 25, 2, -31 },
  { 8731, 15, 38, 17, 1, -37 },
  { 8803, 22, 31, 28, 3, -30 },
  { 8889, 23, 30, 25, 1, -30 },
  { 8976, 33, 30, 35, 1, -30 },
  { 9100, 24, 30, 25, 1, -30 },
  { 9190, 24, 41, 25, 0, -30 },
  { 9313, 21, 30, 25, 2, -30 },
  { 9392, 13, 54, 17, 2, -44 },
  { 9480, 5, 47, 14, 5, -40 },
  { 9510, 14, 54, 17, 1, -44 },
  { 9605, 26, 12, 31, 3, -22 },
};

const GFXfont RobotoCondensed_Bold56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_BOLD56PT7B_H_
