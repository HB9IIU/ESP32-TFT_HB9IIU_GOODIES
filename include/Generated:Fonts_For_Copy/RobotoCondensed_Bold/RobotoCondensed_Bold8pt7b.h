#ifndef _ROBOTOCONDENSED_BOLD8PT7B_H_
#define _ROBOTOCONDENSED_BOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF0, 0x06, 0x76, 0x66, 0x06, 0x54, 0x29, 0x60, 0x45,
  0x98, 0x66, 0x8C, 0x63, 0x18, 0xEB, 0x38, 0xC0, 0x56, 0x94, 0x95, 0x56,
  0x4C, 0x62, 0x44, 0xF4, 0x60, 0xC0, 0x40, 0x09, 0x29, 0x00, 0x67, 0x99,
  0xD6, 0x75, 0x50, 0x6B, 0x22, 0x4F, 0x6B, 0x26, 0x96, 0x22, 0x6A, 0xF2,
  0x74, 0x61, 0x96, 0x24, 0xED, 0xD6, 0xF3, 0x22, 0x44, 0x67, 0x66, 0x96,
  0x6E, 0x97, 0x26, 0x41, 0xC1, 0x80, 0x71, 0x80, 0xE3, 0x80, 0xC7, 0x00,
  0x74, 0xA0, 0x80, 0x31, 0x27, 0x6D, 0xB6, 0xE4, 0x0C, 0x21, 0x14, 0xA7,
  0x4C, 0xED, 0xDF, 0xDF, 0x65, 0xCC, 0xD7, 0xED, 0xDD, 0xDE, 0xFC, 0xCE,
  0xCF, 0xFC, 0xCE, 0xCC, 0x75, 0xCF, 0xD7, 0xDD, 0xDF, 0xDD, 0xFC, 0x24,
  0x9A, 0xC0, 0xDF, 0xEE, 0xFD, 0xCC, 0xCC, 0xCF, 0xCF, 0x3F, 0x7D, 0xFF,
  0xF0, 0xDD, 0xFF, 0xDD, 0x65, 0xDD, 0xD7, 0xED, 0xDF, 0xCC, 0x65, 0xDD,
  0xD7, 0x10, 0xED, 0xDE, 0xFD, 0x6D, 0x43, 0x97, 0xF2, 0x22, 0x22, 0xDD,
  0xDD, 0xD7, 0x96, 0x94, 0xA6, 0x10, 0xB6, 0xD7, 0x9E, 0x79, 0x20, 0xD5,
  0x66, 0x7D, 0x95, 0x66, 0x22, 0xF1, 0x26, 0x4F, 0xFF, 0xFF, 0x99, 0x26,
  0x40, 0xD5, 0x57, 0x4A, 0x80, 0xE0, 0x40, 0xE6, 0xAE, 0xCC, 0xFD, 0xDE,
  0x72, 0x30, 0x33, 0xFB, 0xB7, 0x6F, 0x86, 0x6B, 0x24, 0x80, 0xF9, 0x97,
  0x36, 0x88, 0xEB, 0xBB, 0xCF, 0xF0, 0xCF, 0xFE, 0xCC, 0xEC, 0xEF, 0xFF,
  0xF0, 0xFB, 0xFF, 0xFF, 0xEB, 0xBB, 0x69, 0x96, 0xFD, 0xDE, 0xCC, 0xFB,
  0xB7, 0x33, 0xDB, 0x60, 0xF8, 0xB0, 0x75, 0x40, 0xBB, 0xB7, 0xAD, 0xA0,
  0xAD, 0x54, 0xA0, 0x66, 0x6E, 0xA6, 0x64, 0x4C, 0xED, 0x70, 0x56, 0x54,
  0x7E, 0x95, 0x58, 0x70,
};

const GFXglyph RobotoCondensed_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 1, 0, -6 },
  { 20, 2, 8, 3, 0, -6 },
  { 22, 2, 8, 3, 0, -6 },
  { 24, 4, 4, 4, 0, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 2, 2, 2, 0, -1 },
  { 29, 2, 1, 3, 0, -3 },
  { 30, 2, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 4, 6, 4, 0, -6 },
  { 37, 2, 6, 4, 1, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 3, 3, 4, 0, -4 },
  { 68, 3, 3, 4, 1, -4 },
  { 70, 3, 3, 4, 0, -4 },
  { 72, 3, 6, 4, 0, -6 },
  { 75, 6, 8, 6, 0, -6 },
  { 81, 5, 6, 5, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 5, 0, -6 },
  { 91, 4, 6, 5, 0, -6 },
  { 94, 4, 6, 4, 0, -6 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 4, 6, 5, 0, -6 },
  { 103, 4, 6, 5, 0, -6 },
  { 106, 1, 6, 2, 1, -6 },
  { 107, 3, 6, 4, 0, -6 },
  { 110, 4, 6, 4, 0, -6 },
  { 113, 4, 6, 4, 0, -6 },
  { 116, 6, 6, 6, 0, -6 },
  { 121, 4, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 0, -6 },
  { 127, 4, 6, 5, 0, -6 },
  { 130, 4, 7, 5, 0, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 4, 6, 5, 0, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 6, 6, 6, 0, -6 },
  { 155, 4, 6, 4, 0, -6 },
  { 158, 4, 6, 4, 0, -6 },
  { 161, 4, 6, 4, 0, -6 },
  { 164, 2, 8, 2, 0, -7 },
  { 166, 3, 6, 3, 0, -6 },
  { 169, 2, 8, 2, 0, -7 },
  { 171, 3, 3, 3, 0, -6 },
  { 173, 3, 1, 3, 0, 0 },
  { 174, 2, 1, 3, 0, -6 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 3, 4, 4, 0, -4 },
  { 182, 4, 6, 4, 0, -6 },
  { 185, 4, 4, 4, 0, -4 },
  { 187, 3, 6, 3, 0, -6 },
  { 190, 4, 6, 4, 0, -4 },
  { 193, 4, 6, 4, 0, -6 },
  { 196, 2, 6, 2, 0, -6 },
  { 198, 2, 8, 2, 0, -6 },
  { 200, 4, 6, 4, 0, -6 },
  { 203, 2, 6, 2, 0, -6 },
  { 205, 6, 4, 6, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 4, 6, 4, 0, -4 },
  { 215, 4, 6, 4, 0, -4 },
  { 218, 3, 4, 3, 0, -4 },
  { 220, 3, 4, 4, 0, -4 },
  { 222, 2, 5, 2, 0, -5 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 3, 4, 4, 0, -4 },
  { 228, 5, 4, 5, 0, -4 },
  { 231, 4, 4, 4, 0, -4 },
  { 233, 4, 6, 4, 0, -4 },
  { 236, 3, 4, 4, 0, -4 },
  { 238, 2, 7, 2, 0, -6 },
  { 240, 1, 7, 2, 1, -6 },
  { 241, 2, 7, 2, 0, -6 },
  { 243, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_Bold8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_BOLD8PT7B_H_
