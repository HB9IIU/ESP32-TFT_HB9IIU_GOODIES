#ifndef _ROBOTOCONDENSED_BOLD12PT7B_H_
#define _ROBOTOCONDENSED_BOLD12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA2, 0x80, 0xF6, 0x80, 0x28, 0xA2, 0x9F, 0x2B, 0xF3, 0x14,
  0x50, 0x23, 0xBD, 0x2C, 0x38, 0xD2, 0xD3, 0x88, 0xC2, 0xAB, 0x34, 0x20,
  0xF5, 0x55, 0x1C, 0x30, 0xF1, 0xA3, 0x87, 0x0A, 0xB7, 0x3E, 0x7C, 0xF8,
  0x4B, 0x49, 0x24, 0x99, 0x20, 0x89, 0x92, 0x49, 0x2D, 0x40, 0x25, 0x1E,
  0xE5, 0x80, 0x31, 0xBF, 0xF3, 0x18, 0x57, 0xE0, 0xB0, 0x32, 0x22, 0x64,
  0x44, 0xC8, 0x67, 0xA5, 0x39, 0xCE, 0x5E, 0x60, 0x3E, 0x92, 0x49, 0x20,
  0x79, 0xEC, 0x82, 0x18, 0xC2, 0x18, 0x7C, 0x7A, 0xC2, 0x33, 0x84, 0x3B,
  0x78, 0x18, 0x63, 0x8E, 0x59, 0x6F, 0xC6, 0x18, 0xF6, 0x21, 0xE9, 0x0E,
  0x7E, 0x70, 0x77, 0x31, 0xED, 0x4E, 0x7E, 0x70, 0xFC, 0x21, 0x86, 0x10,
  0xC3, 0x08, 0x60, 0x7F, 0x9F, 0xF9, 0x9F, 0xF0, 0x6F, 0x99, 0xDF, 0x17,
  0x60, 0xB0, 0x2C, 0x48, 0x00, 0x12, 0x58, 0x1B, 0xB0, 0xF1, 0x80, 0xF0,
  0xF0, 0x8E, 0x3E, 0x80, 0x76, 0xC6, 0x33, 0x10, 0x04, 0x20, 0x1E, 0x10,
  0x93, 0x4A, 0x95, 0x4E, 0xA7, 0x54, 0xBE, 0x40, 0x30, 0x0F, 0x00, 0x18,
  0x70, 0xE1, 0x46, 0xCD, 0x9F, 0x23, 0xC6, 0xF4, 0xE7, 0x3F, 0x4E, 0x73,
  0xF0, 0x76, 0xE3, 0x08, 0x42, 0x3B, 0x70, 0xF4, 0xE7, 0x18, 0xC6, 0x73,
  0xF0, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0xF8, 0xF8, 0x88, 0xF8, 0x88, 0x80,
  0x76, 0xE3, 0x08, 0x4E, 0x3B, 0x78, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3,
  0x8C, 0xFF, 0x80, 0x18, 0xC6, 0x31, 0x8F, 0x6B, 0x70, 0x9A, 0x6B, 0x28,
  0xE3, 0xC9, 0x26, 0x98, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC7, 0x8F, 0x9F,
  0x7A, 0xB5, 0x6E, 0xDD, 0x92, 0xCF, 0x3E, 0xFB, 0xAE, 0xF9, 0xE7, 0x8C,
  0x73, 0x68, 0xE3, 0x8E, 0x38, 0xF6, 0x70, 0xF4, 0xE3, 0x19, 0xFA, 0x10,
  0x80, 0x73, 0x68, 0xE3, 0x8E, 0x38, 0xF6, 0x78, 0x60, 0x80, 0xF4, 0xE7,
  0x39, 0xFA, 0x53, 0x98, 0x39, 0xB4, 0xD8, 0x38, 0x3C, 0xDB, 0x38, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x8C, 0x63, 0x18, 0xC6, 0x3B, 0x70,
  0xC6, 0x89, 0xB3, 0x66, 0xC5, 0x0E, 0x1C, 0x30, 0xC9, 0xA4, 0x97, 0x4B,
  0xA7, 0x73, 0xB9, 0xDC, 0x6C, 0x36, 0x00, 0xCC, 0xD9, 0xA1, 0xC3, 0x07,
  0x1A, 0x36, 0xCC, 0xCD, 0x36, 0x9E, 0x38, 0xC3, 0x0C, 0x30, 0xFC, 0x31,
  0x86, 0x30, 0xC6, 0x10, 0xFC, 0xEA, 0xAA, 0xAB, 0xC2, 0x10, 0xC6, 0x10,
  0xC6, 0x10, 0xC0, 0xD5, 0x55, 0x57, 0x26, 0x5D, 0xF8, 0x44, 0x72, 0xC6,
  0xF5, 0xED, 0xE0, 0x84, 0x3D, 0xA9, 0xCE, 0x7A, 0xF0, 0x7A, 0xF1, 0x8C,
  0x2D, 0xC0, 0x08, 0x5E, 0xBC, 0xE7, 0x2F, 0x78, 0x7B, 0xD3, 0xFC, 0x34,
  0xE0, 0x36, 0xF6, 0x66, 0x66, 0x60, 0x7B, 0x73, 0x9C, 0xBD, 0xEB, 0x78,
  0x88, 0xFB, 0x99, 0x99, 0x90, 0xDF, 0xC0, 0x51, 0x55, 0x5F, 0x84, 0x2D,
  0x6E, 0x73, 0xD6, 0x98, 0xFF, 0x80, 0xFF, 0xFE, 0x4C, 0x99, 0x32, 0x64,
  0x80, 0xFF, 0x99, 0x99, 0x90, 0x71, 0xEC, 0xB3, 0xC9, 0xE7, 0x80, 0xF7,
  0xA7, 0x39, 0xFB, 0xD0, 0x80, 0x7A, 0xF3, 0x9C, 0xAD, 0xE1, 0x08, 0xFE,
  0x49, 0x20, 0x72, 0xD0, 0xE1, 0xED, 0xC0, 0x7D, 0xB6, 0xDB, 0x99, 0x99,
  0x9F, 0xF0, 0xDA, 0xD6, 0xE7, 0x18, 0xC0, 0xD3, 0xB5, 0x7B, 0xF6, 0xED,
  0x99, 0x00, 0xDB, 0x9C, 0x67, 0x3F, 0x60, 0xDA, 0xD6, 0xE7, 0x18, 0x8C,
  0x60, 0x78, 0xCC, 0x66, 0x23, 0xE0, 0x2D, 0xB5, 0x9B, 0x6C, 0x80, 0xFF,
  0xE0, 0xC9, 0x26, 0x5A, 0x4B, 0x00, 0xCD, 0x6C,
};

const GFXglyph RobotoCondensed_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 3, 3, 4, 0, -9 },
  { 6, 6, 9, 6, 0, -9 },
  { 13, 5, 11, 6, 1, -10 },
  { 20, 6, 9, 8, 1, -9 },
  { 27, 7, 9, 7, 0, -9 },
  { 35, 2, 3, 2, 0, -9 },
  { 36, 3, 12, 4, 1, -9 },
  { 41, 3, 12, 4, 0, -9 },
  { 46, 5, 5, 5, 0, -9 },
  { 50, 5, 6, 6, 0, -7 },
  { 54, 2, 4, 3, 0, -1 },
  { 55, 3, 1, 4, 1, -4 },
  { 56, 2, 2, 3, 1, -2 },
  { 57, 4, 10, 4, 0, -9 },
  { 62, 5, 9, 6, 1, -9 },
  { 68, 3, 9, 6, 1, -9 },
  { 72, 6, 9, 6, 0, -9 },
  { 79, 5, 9, 6, 0, -9 },
  { 85, 6, 9, 6, 0, -9 },
  { 92, 5, 9, 6, 1, -9 },
  { 98, 5, 9, 6, 1, -9 },
  { 104, 6, 9, 6, 0, -9 },
  { 111, 4, 9, 6, 1, -9 },
  { 116, 4, 9, 6, 1, -9 },
  { 121, 2, 7, 3, 1, -7 },
  { 123, 3, 10, 3, 0, -7 },
  { 127, 5, 5, 5, 0, -6 },
  { 131, 4, 3, 6, 1, -5 },
  { 133, 4, 5, 5, 1, -6 },
  { 136, 5, 9, 5, 0, -9 },
  { 142, 9, 11, 9, 0, -8 },
  { 155, 7, 9, 7, 0, -9 },
  { 163, 5, 9, 7, 1, -9 },
  { 169, 5, 9, 7, 1, -9 },
  { 175, 5, 9, 7, 1, -9 },
  { 181, 5, 9, 6, 1, -9 },
  { 187, 4, 9, 6, 1, -9 },
  { 192, 5, 9, 7, 1, -9 },
  { 198, 6, 9, 7, 1, -9 },
  { 205, 1, 9, 3, 1, -9 },
  { 207, 5, 9, 6, 0, -9 },
  { 213, 6, 9, 7, 1, -9 },
  { 220, 4, 9, 6, 1, -9 },
  { 225, 7, 9, 9, 1, -9 },
  { 233, 6, 9, 7, 1, -9 },
  { 240, 6, 9, 7, 1, -9 },
  { 247, 5, 9, 7, 1, -9 },
  { 253, 6, 11, 7, 1, -9 },
  { 262, 5, 9, 7, 1, -9 },
  { 268, 6, 9, 6, 0, -9 },
  { 275, 6, 9, 7, 0, -9 },
  { 282, 5, 9, 7, 1, -9 },
  { 288, 7, 9, 7, 0, -9 },
  { 296, 9, 9, 9, 0, -9 },
  { 307, 7, 9, 7, 0, -9 },
  { 315, 6, 9, 7, 0, -9 },
  { 322, 6, 9, 6, 0, -9 },
  { 329, 2, 12, 3, 1, -10 },
  { 332, 5, 10, 5, 0, -9 },
  { 339, 2, 12, 3, 0, -10 },
  { 342, 4, 4, 5, 0, -9 },
  { 344, 5, 1, 5, 0, 0 },
  { 345, 3, 2, 4, 0, -9 },
  { 346, 5, 7, 6, 0, -7 },
  { 351, 5, 9, 6, 1, -9 },
  { 357, 5, 7, 6, 0, -7 },
  { 362, 5, 9, 6, 0, -9 },
  { 368, 5, 7, 6, 0, -7 },
  { 373, 4, 9, 4, 0, -9 },
  { 378, 5, 9, 6, 0, -7 },
  { 384, 4, 9, 6, 1, -9 },
  { 389, 1, 10, 3, 1, -10 },
  { 391, 2, 12, 3, 0, -10 },
  { 394, 5, 9, 6, 1, -9 },
  { 400, 1, 9, 3, 1, -9 },
  { 402, 7, 7, 9, 1, -7 },
  { 409, 4, 7, 6, 1, -7 },
  { 413, 6, 7, 6, 0, -7 },
  { 419, 5, 9, 6, 1, -7 },
  { 425, 5, 9, 6, 0, -7 },
  { 431, 3, 7, 4, 1, -7 },
  { 434, 5, 7, 5, 0, -7 },
  { 439, 3, 8, 4, 0, -8 },
  { 442, 4, 7, 6, 1, -7 },
  { 446, 5, 7, 5, 0, -7 },
  { 451, 7, 7, 8, 0, -7 },
  { 458, 5, 7, 5, 0, -7 },
  { 463, 5, 9, 5, 0, -7 },
  { 469, 5, 7, 5, 0, -7 },
  { 474, 3, 11, 4, 0, -9 },
  { 479, 1, 11, 3, 1, -9 },
  { 481, 3, 11, 4, 0, -9 },
  { 486, 5, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_Bold12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_BOLD12PT7B_H_
