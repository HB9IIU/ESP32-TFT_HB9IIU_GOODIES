#ifndef _ROBOTOCONDENSED_BOLD23PT7B_H_
#define _ROBOTOCONDENSED_BOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0x77, 0x77, 0x66, 0x66, 0x00, 0x6F, 0x60, 0xDF, 0x7D,
  0xF6, 0xDB, 0x60, 0x0D, 0x86, 0x61, 0x98, 0x66, 0x1B, 0x1F, 0xF7, 0xFC,
  0x6C, 0x33, 0x0C, 0xCF, 0xFF, 0xFF, 0x36, 0x0D, 0x83, 0x61, 0x98, 0x66,
  0x00, 0x0C, 0x03, 0x01, 0xE0, 0xFC, 0x7F, 0x9C, 0xE7, 0x3D, 0xC0, 0x78,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0x80, 0xEE, 0x3F, 0x8E, 0x7F, 0x9F, 0xE1,
  0xE0, 0x30, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x33, 0x11, 0x99, 0x8C, 0xC8,
  0x66, 0xC1, 0xFC, 0x0F, 0x60, 0x06, 0x00, 0x37, 0x03, 0x7C, 0x1B, 0x71,
  0x99, 0x8C, 0xCC, 0xC6, 0xE0, 0x3E, 0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x7F,
  0x07, 0x38, 0x73, 0x87, 0x70, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0xEE, 0xEE,
  0xEE, 0x7E, 0xE7, 0xEE, 0x3C, 0xFF, 0xC7, 0xFE, 0x3E, 0xF0, 0xFF, 0xF0,
  0x08, 0x71, 0x8E, 0x31, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0xE3, 0x86, 0x18,
  0x61, 0xC3, 0x0E, 0x18, 0x70, 0x80, 0x86, 0x38, 0xC7, 0x18, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0x9C, 0xCE, 0x62, 0x00, 0x0C, 0x03, 0x00,
  0xC1, 0xB7, 0xFF, 0xC3, 0x81, 0xE0, 0xEC, 0x33, 0x80, 0x40, 0x1C, 0x0E,
  0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0x33, 0x37, 0x76, 0x60, 0xFF, 0xFF, 0xC0, 0x7F, 0x70, 0x06, 0x0C, 0x38,
  0x60, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0xE1,
  0x80, 0x1E, 0x0F, 0xC7, 0xF9, 0xCE, 0xE3, 0xB8, 0xEE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8E, 0xE3, 0x9C, 0xE7, 0xF8, 0xFC, 0x1E, 0x00, 0x04,
  0xFF, 0xFF, 0xDC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x3E, 0x1F, 0xCF, 0xFB, 0x8E, 0xE3, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x03,
  0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x1F,
  0xCF, 0xFB, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x7C, 0x1E, 0x07, 0xC0, 0x38,
  0x0E, 0xE3, 0xB8, 0xEF, 0xF9, 0xFC, 0x3E, 0x00, 0x07, 0x01, 0xC0, 0xF0,
  0x7C, 0x1F, 0x0F, 0xC3, 0x71, 0xDC, 0x77, 0x39, 0xCF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70,
  0x1C, 0x07, 0xE1, 0xFE, 0xF7, 0x80, 0xE0, 0x3C, 0x0F, 0xE3, 0xFC, 0xE7,
  0xF9, 0xFC, 0x1E, 0x00, 0x07, 0x07, 0xC3, 0xF1, 0xE0, 0x70, 0x1C, 0x0E,
  0xF3, 0xFE, 0xFF, 0xB8, 0xFE, 0x1F, 0x87, 0xE1, 0xDC, 0xF7, 0xF8, 0xFC,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x00,
  0x1E, 0x1F, 0xC7, 0xF9, 0xCE, 0xF3, 0xBC, 0xE7, 0x39, 0xFC, 0x3E, 0x1F,
  0xC7, 0x3B, 0x8E, 0xE3, 0xBC, 0xEF, 0xF9, 0xFE, 0x3E, 0x00, 0x1E, 0x3F,
  0x9F, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0xBF, 0xCF, 0xE0, 0x70,
  0x38, 0x38, 0xFC, 0x7C, 0x38, 0x00, 0x7F, 0x70, 0x00, 0x00, 0x07, 0xF7,
  0xFF, 0x60, 0x00, 0x00, 0x07, 0x77, 0x6E, 0xEC, 0x01, 0x07, 0x3F, 0xFC,
  0xF0, 0xF0, 0xFC, 0x3F, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x3F, 0x07, 0xE0, 0xF8, 0x7C, 0xFD, 0xF8,
  0xF0, 0x40, 0x00, 0x3C, 0x7F, 0xFF, 0xE7, 0xE7, 0x07, 0x07, 0x0E, 0x1E,
  0x1C, 0x38, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x18, 0x03, 0xE0, 0x0F, 0xF8,
  0x1C, 0x1C, 0x30, 0x0C, 0x70, 0x06, 0x61, 0xC6, 0x63, 0xE2, 0xC6, 0x63,
  0xC6, 0x63, 0xCE, 0x63, 0xCC, 0x63, 0xCC, 0x62, 0xCC, 0x66, 0xCE, 0xE6,
  0xC7, 0xFC, 0xE7, 0x38, 0x60, 0x00, 0x70, 0x00, 0x38, 0x20, 0x1F, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x01, 0xDC, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF1, 0xE1, 0xC7, 0x07, 0x9C, 0x0E, 0xF0, 0x38, 0xFF, 0x1F, 0xF3, 0xFF,
  0x78, 0xEF, 0x1F, 0xE3, 0xFC, 0x77, 0x9E, 0xFF, 0x9F, 0xFB, 0xC7, 0xF8,
  0xFF, 0x0F, 0xE3, 0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0x1F, 0x07, 0xF9, 0xFF,
  0x38, 0x7F, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x7F, 0x0E, 0xE1, 0xDF, 0xF9, 0xFE, 0x1F, 0x00, 0xFE, 0x1F, 0xF3, 0xFF,
  0x78, 0xEF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xE3, 0xBF, 0xF7, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x00, 0x1F, 0x87, 0xF9, 0xFF, 0xB8, 0x7F, 0x0F, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x7F, 0x8F, 0xF0, 0x7F, 0x0E, 0xE1, 0xDF, 0xF9, 0xFF,
  0x1F, 0x80, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x7E, 0x3F, 0x3F, 0xFC, 0xFE, 0x3C, 0x00, 0xF1, 0xEF, 0x1E,
  0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0x70, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x8F, 0x78, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF0, 0xF0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1F, 0xF7, 0x3F, 0xEE, 0x6F,
  0xDD, 0xDF, 0x9B, 0xBF, 0xBE, 0x7F, 0x7C, 0xFE, 0xF9, 0xFC, 0xF3, 0xF9,
  0xC7, 0xF3, 0x8E, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7,
  0xEE, 0x7E, 0xE7, 0xEF, 0x7E, 0x77, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F,
  0xE1, 0xFE, 0x0F, 0xE0, 0xF0, 0x1F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0,
  0xF7, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0xFF, 0x1F, 0xFB, 0xFF, 0x78,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xFF, 0xFF, 0xFB, 0xFC, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xFC, 0x7F, 0xE7,
  0x0E, 0xF0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xF0, 0xE7, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0xC0, 0x1E, 0x00, 0xE0,
  0x04, 0xFF, 0x1F, 0xFB, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E,
  0xFF, 0xDF, 0xF3, 0xFE, 0x7B, 0xCF, 0x39, 0xE7, 0xBC, 0x77, 0x8F, 0xF0,
  0xE0, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEE, 0x1D, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0x00, 0xEE, 0x1F, 0xC3, 0xBF, 0xF3, 0xFC, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE3, 0xDF, 0xF3, 0xFE, 0x1F,
  0x00, 0xF0, 0x7B, 0x83, 0xDC, 0x1C, 0xF0, 0xE7, 0x8F, 0x1C, 0x78, 0xE3,
  0x87, 0x1C, 0x1C, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x07, 0x00, 0xE3, 0x8F, 0xE3, 0x8E, 0xE3, 0x8E, 0xE3,
  0xCE, 0xE7, 0xCE, 0xF7, 0xCE, 0x77, 0xCE, 0x77, 0xDC, 0x76, 0xFC, 0x76,
  0xFC, 0x7E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x70, 0x77, 0x8F, 0x38, 0xE3, 0xDE, 0x1D, 0xC1, 0xDC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xDC, 0x3D, 0xC3, 0x9E,
  0x38, 0xE7, 0x8F, 0x70, 0x70, 0xF0, 0x77, 0x0F, 0x78, 0xE3, 0x8E, 0x39,
  0xC3, 0xDC, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0xE0, 0xE0, 0x38, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x78,
  0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xFF, 0xE0, 0x38, 0x71, 0xF3, 0x66,
  0xDD, 0xF1, 0xE3, 0xFF, 0xFF, 0xFF, 0xE0, 0xF3, 0x8E, 0x3E, 0x3F, 0xBD,
  0xFC, 0x70, 0x39, 0xFD, 0xFF, 0xC7, 0xE3, 0xFF, 0xFF, 0xEF, 0x70, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xF3, 0xFE, 0xFF, 0xB8, 0xEE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3B, 0xFE, 0xFF, 0xBB, 0xC0, 0x3E, 0x3F,
  0xBF, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xDF, 0xC7, 0xC0,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xEE, 0xFF, 0xFF, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0x7F, 0x9D, 0xC0, 0x3E, 0x3F, 0xBF,
  0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x7F, 0xDF, 0xE3, 0xC0, 0x0E,
  0x3C, 0xF9, 0xC3, 0x87, 0x3F, 0xFF, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0x3D, 0xBF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xFF, 0xDF, 0xE7, 0xF0, 0x38, 0x1D, 0xFE, 0xFE, 0x3E, 0x00, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xBD, 0xFF, 0xFF, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0xEF, 0x60, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0x38, 0xF1, 0x80, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xEF, 0xBE, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x3B, 0x9E, 0xEF, 0x3B, 0x8F, 0xC3, 0xF0, 0xFE,
  0x3F, 0xCE, 0x73, 0x9E, 0xE3, 0xB8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xEF, 0x39, 0xFF, 0xFB, 0xFF, 0xFF, 0x1C, 0x7E, 0x38, 0xFC,
  0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C,
  0x70, 0xEF, 0x7F, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x70, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xBF, 0xE7, 0xF0, 0xF8, 0xEF, 0x3F, 0xEF, 0xFB, 0x8E, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xBF, 0xEF, 0xFB, 0xBC, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x3B, 0xBF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xFF, 0xDF, 0xE7, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0xEF, 0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x3E, 0x3F, 0xBD,
  0xDC, 0xFF, 0x03, 0xF0, 0xFC, 0x1E, 0xE3, 0xFB, 0x9F, 0xC7, 0xC0, 0x38,
  0x70, 0xE7, 0xEF, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xE7, 0xC7,
  0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF,
  0xDF, 0xE7, 0x70, 0xF1, 0xDC, 0xF7, 0x39, 0xCE, 0x3B, 0x8E, 0xC3, 0xF0,
  0xFC, 0x1F, 0x07, 0x81, 0xE0, 0x38, 0xF3, 0x9D, 0xCE, 0x77, 0x39, 0xDD,
  0xE6, 0x77, 0xB8, 0xDF, 0xE3, 0x6F, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3, 0xC1,
  0xC7, 0x07, 0x1C, 0x73, 0xDE, 0xE3, 0xB8, 0xFC, 0x1F, 0x07, 0x81, 0xE0,
  0x7C, 0x3F, 0x0E, 0xE7, 0x39, 0xC7, 0xF1, 0xDC, 0xF7, 0x39, 0xCE, 0x7B,
  0x8F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x07, 0x07,
  0xC1, 0xE0, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x1E, 0x1C, 0x38, 0x38,
  0x70, 0xFF, 0xFF, 0xFF, 0x19, 0xCC, 0xE7, 0x39, 0xCE, 0x77, 0xB9, 0xC7,
  0x39, 0xCE, 0x73, 0x9C, 0x73, 0x84, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x38, 0xC7, 0x39, 0xCE, 0x73, 0x8E, 0x77, 0x39, 0xCE, 0x73, 0x99, 0xCE,
  0x40, 0x38, 0xEF, 0x9F, 0xFF, 0x73, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 6, 6, 7, 1, -17 },
  { 15, 10, 17, 12, 1, -17 },
  { 37, 10, 21, 12, 1, -19 },
  { 64, 13, 17, 15, 1, -17 },
  { 92, 12, 17, 13, 1, -17 },
  { 118, 2, 6, 4, 1, -17 },
  { 120, 6, 23, 7, 1, -18 },
  { 138, 5, 23, 7, 1, -18 },
  { 153, 10, 10, 10, 0, -17 },
  { 166, 9, 12, 11, 1, -13 },
  { 180, 4, 7, 6, 0, -3 },
  { 184, 6, 3, 8, 1, -9 },
  { 187, 4, 3, 7, 1, -3 },
  { 189, 7, 18, 8, 0, -17 },
  { 205, 10, 17, 12, 1, -17 },
  { 227, 6, 17, 12, 2, -17 },
  { 240, 10, 17, 12, 1, -17 },
  { 262, 10, 17, 12, 1, -17 },
  { 284, 10, 17, 12, 1, -17 },
  { 306, 10, 17, 12, 1, -17 },
  { 328, 10, 17, 12, 1, -17 },
  { 350, 10, 17, 12, 1, -17 },
  { 372, 10, 17, 12, 1, -17 },
  { 394, 9, 17, 12, 1, -17 },
  { 414, 4, 12, 6, 1, -12 },
  { 420, 4, 16, 6, 1, -12 },
  { 428, 8, 10, 10, 1, -12 },
  { 438, 9, 8, 12, 1, -11 },
  { 447, 9, 10, 10, 1, -12 },
  { 459, 8, 17, 10, 1, -17 },
  { 476, 16, 21, 18, 1, -16 },
  { 518, 14, 17, 14, 0, -17 },
  { 548, 11, 17, 13, 1, -17 },
  { 572, 11, 17, 13, 1, -17 },
  { 596, 11, 17, 13, 1, -17 },
  { 620, 10, 17, 11, 1, -17 },
  { 642, 9, 17, 11, 1, -17 },
  { 662, 11, 17, 13, 1, -17 },
  { 686, 12, 17, 14, 1, -17 },
  { 712, 4, 17, 6, 1, -17 },
  { 721, 9, 17, 11, 1, -17 },
  { 741, 12, 17, 13, 1, -17 },
  { 767, 9, 17, 11, 1, -17 },
  { 787, 15, 17, 17, 1, -17 },
  { 819, 12, 17, 14, 1, -17 },
  { 845, 12, 17, 14, 1, -17 },
  { 871, 11, 17, 13, 1, -17 },
  { 895, 12, 20, 14, 1, -17 },
  { 925, 11, 17, 13, 1, -17 },
  { 949, 11, 17, 12, 1, -17 },
  { 973, 11, 17, 12, 1, -17 },
  { 997, 11, 17, 13, 1, -17 },
  { 1021, 13, 17, 13, 0, -17 },
  { 1049, 16, 17, 17, 1, -17 },
  { 1083, 12, 17, 13, 0, -17 },
  { 1109, 12, 17, 12, 0, -17 },
  { 1135, 10, 17, 12, 1, -17 },
  { 1157, 5, 23, 6, 1, -19 },
  { 1172, 9, 18, 9, 0, -17 },
  { 1193, 5, 23, 6, 0, -19 },
  { 1208, 7, 8, 9, 1, -17 },
  { 1215, 9, 3, 9, 0, 0 },
  { 1219, 5, 3, 8, 1, -17 },
  { 1221, 9, 12, 11, 1, -12 },
  { 1235, 10, 18, 11, 1, -18 },
  { 1258, 9, 12, 11, 1, -12 },
  { 1272, 9, 18, 11, 1, -18 },
  { 1293, 9, 12, 11, 1, -12 },
  { 1307, 7, 18, 8, 0, -18 },
  { 1323, 9, 17, 12, 1, -12 },
  { 1343, 9, 18, 11, 1, -18 },
  { 1364, 4, 16, 6, 1, -16 },
  { 1372, 6, 21, 6, -1, -16 },
  { 1388, 10, 18, 11, 1, -18 },
  { 1411, 3, 18, 6, 1, -18 },
  { 1418, 15, 12, 17, 1, -12 },
  { 1441, 9, 12, 11, 1, -12 },
  { 1455, 10, 12, 11, 1, -12 },
  { 1470, 10, 17, 11, 1, -12 },
  { 1492, 9, 17, 11, 1, -12 },
  { 1512, 6, 12, 8, 1, -12 },
  { 1521, 9, 12, 10, 1, -12 },
  { 1535, 7, 15, 7, 0, -15 },
  { 1549, 9, 12, 11, 1, -12 },
  { 1563, 10, 12, 10, 0, -12 },
  { 1578, 14, 12, 15, 0, -12 },
  { 1599, 10, 12, 10, 0, -12 },
  { 1614, 10, 17, 10, 0, -12 },
  { 1636, 8, 12, 10, 1, -12 },
  { 1648, 5, 22, 7, 1, -18 },
  { 1662, 2, 20, 6, 2, -17 },
  { 1667, 5, 22, 7, 1, -18 },
  { 1681, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_Bold23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_BOLD23PT7B_H_
