#ifndef _ROBOTOCONDENSED_BOLD24PT7B_H_
#define _ROBOTOCONDENSED_BOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x70, 0x06, 0xFF, 0x60, 0xCF, 0x3C,
  0xF3, 0xCF, 0x30, 0x0D, 0x81, 0xB0, 0x76, 0x0C, 0xC1, 0x98, 0xFF, 0xDF,
  0xF8, 0xD8, 0x1B, 0x06, 0x63, 0xFF, 0x7F, 0xE3, 0x30, 0x6E, 0x0D, 0x81,
  0xB0, 0x66, 0x00, 0x04, 0x01, 0x01, 0xE0, 0xFE, 0x7F, 0x9C, 0xF7, 0x1D,
  0xC7, 0x78, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xF8, 0x7E, 0x1F, 0xCF, 0x7F,
  0xCF, 0xE1, 0xF0, 0x30, 0x0C, 0x00, 0x38, 0x03, 0xE0, 0x3B, 0x19, 0x9D,
  0x8C, 0xEC, 0x76, 0xC1, 0xF6, 0x07, 0x60, 0x03, 0x00, 0x37, 0x81, 0xFE,
  0x1B, 0x30, 0xD9, 0x8C, 0xCC, 0xE6, 0x60, 0x3F, 0x00, 0xF0, 0x1E, 0x03,
  0xF0, 0x7F, 0x87, 0x38, 0x73, 0x87, 0x38, 0x3F, 0x03, 0xE0, 0x3C, 0x77,
  0xE7, 0xFF, 0xEE, 0x7E, 0xE3, 0xEF, 0x3C, 0xFF, 0xE7, 0xFE, 0x3E, 0xF0,
  0xFF, 0xF0, 0x04, 0x31, 0xCE, 0x31, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3,
  0x86, 0x18, 0x71, 0xC7, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x70,
  0xC3, 0x8E, 0x38, 0xE1, 0x87, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x1C, 0x63,
  0x8C, 0x20, 0x0E, 0x00, 0xC0, 0x18, 0x3B, 0x6F, 0xFE, 0x1E, 0x07, 0xC1,
  0xD8, 0x31, 0x82, 0x20, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x39, 0xCE, 0x67,
  0x39, 0x80, 0xFF, 0xFF, 0xC0, 0x27, 0x77, 0x06, 0x06, 0x0E, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0x1E, 0x0F, 0xC7, 0xF9, 0xCF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xDC, 0xF7, 0xF8, 0xFE, 0x1E, 0x00, 0x04,
  0xFF, 0xFF, 0xDC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x1E, 0x1F, 0xE7, 0xFB, 0xCF, 0xE3, 0xF8, 0xF0, 0x3C, 0x0E, 0x07, 0x83,
  0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x1F,
  0xE7, 0xFB, 0xCF, 0xE3, 0xC0, 0xF0, 0x38, 0x7E, 0x1F, 0x07, 0xE0, 0x3C,
  0x07, 0xE1, 0xF8, 0xFF, 0xF9, 0xFE, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0xF8,
  0x3E, 0x1F, 0x86, 0xE3, 0xB8, 0xCE, 0x73, 0xB8, 0xEF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x7F, 0xDF, 0xF7, 0xFD, 0xC0, 0x70,
  0x1C, 0x07, 0xF1, 0xFE, 0xFF, 0xC0, 0xF0, 0x1C, 0x07, 0xF1, 0xFC, 0xF7,
  0xF9, 0xFE, 0x1E, 0x00, 0x07, 0x07, 0xC3, 0xF1, 0xE0, 0x70, 0x1C, 0x0F,
  0xF3, 0xFE, 0xFF, 0xFC, 0xFE, 0x1F, 0x87, 0xF1, 0xDC, 0xF7, 0xFC, 0xFE,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x00,
  0x1E, 0x0F, 0xE7, 0xF9, 0xCF, 0xF3, 0xFC, 0xF7, 0x39, 0xFE, 0x3F, 0x1F,
  0xE7, 0x3F, 0xC7, 0xE1, 0xFC, 0xF7, 0xFD, 0xFE, 0x1F, 0x00, 0x1E, 0x0F,
  0xC7, 0xFB, 0xCE, 0xE3, 0xF8, 0x7E, 0x1F, 0xCF, 0x7F, 0xDF, 0xF3, 0xDC,
  0x0E, 0x03, 0x81, 0xE3, 0xF0, 0xF8, 0x38, 0x00, 0x27, 0x77, 0x00, 0x00,
  0x00, 0x27, 0x77, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x77, 0x7E, 0xEC,
  0x01, 0x07, 0x1F, 0x7F, 0xF8, 0xE0, 0xF8, 0x7F, 0x1F, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x3F, 0x0F,
  0xE0, 0xF8, 0x1C, 0x7E, 0xFE, 0xFC, 0x78, 0x20, 0x00, 0x3E, 0x3F, 0xBF,
  0xDC, 0xFE, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x07, 0x03, 0x80, 0x00,
  0xC0, 0xF0, 0x78, 0x18, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1C, 0x1C, 0x38,
  0x06, 0x30, 0x06, 0x61, 0xE3, 0x63, 0xF3, 0xE7, 0x33, 0xC6, 0x33, 0xC6,
  0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x63, 0xCE, 0x77, 0xE7,
  0xFE, 0x63, 0xBC, 0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x07,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF9,
  0xE0, 0xE7, 0x83, 0x9C, 0x0F, 0xF0, 0x3C, 0xFF, 0x1F, 0xFB, 0xFF, 0xF8,
  0xFF, 0x0F, 0xE1, 0xFC, 0x7F, 0x9E, 0xFF, 0x9F, 0xFB, 0xC7, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0x83, 0xFC, 0x7F, 0xE7,
  0x0E, 0xF0, 0xFF, 0x07, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x0F, 0xF0, 0xF7, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x1F, 0xF3,
  0xFF, 0x78, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE3, 0xFF, 0xF7, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0,
  0xFF, 0x07, 0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x07, 0xF0,
  0x77, 0x87, 0x7F, 0xF3, 0xFE, 0x0F, 0x80, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7E, 0x3F, 0x1F, 0xFE, 0xFE, 0x3E, 0x00,
  0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0x8F, 0x78, 0xFF, 0x0F, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x0F,
  0xF0, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFE, 0x37, 0xFE, 0x77, 0xFE, 0x77, 0xF6, 0x77, 0xF7, 0xE7, 0xF7, 0xEF,
  0xF7, 0xEF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF0, 0x7F,
  0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFE, 0x7F, 0xE7, 0xF7, 0x7F,
  0x77, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x70,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x8F, 0x7F, 0xE3, 0xFC,
  0x0F, 0x80, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x77,
  0x0F, 0x7F, 0xE3, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x70, 0x02, 0xFF, 0x8F,
  0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0xFF, 0xEF,
  0xFC, 0xFF, 0x8F, 0x38, 0xF3, 0xCF, 0x1C, 0xF1, 0xEF, 0x1E, 0xF0, 0xF0,
  0x1F, 0x0F, 0xF9, 0xFF, 0x78, 0xFF, 0x1F, 0xE0, 0x1E, 0x03, 0xF8, 0x1F,
  0x80, 0xF8, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xDF, 0xF9, 0xFE, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDF, 0xF9, 0xFE, 0x1F, 0x80,
  0xF0, 0x39, 0xC0, 0xE7, 0x87, 0x9E, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8F,
  0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC7, 0xF3, 0xCF, 0x73, 0xCF, 0x77, 0xEE, 0x77, 0xEE, 0x77, 0xEE,
  0x77, 0x6E, 0x7E, 0x6E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x7B, 0xC3, 0x8E, 0x3C, 0x79, 0xC1, 0xDE,
  0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x81,
  0xDE, 0x1E, 0x70, 0xE3, 0xCF, 0x1E, 0x70, 0x78, 0xF0, 0x7B, 0x83, 0x9E,
  0x3C, 0x71, 0xC3, 0x8E, 0x0E, 0xF0, 0x77, 0x03, 0xB8, 0x0F, 0x80, 0x7C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7F, 0xFF, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38,
  0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0xFF, 0xFF, 0x38, 0x38, 0x3C, 0x7C, 0x6C, 0x6E, 0xE6, 0xE6, 0xC7,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xC3, 0x8E, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E,
  0x03, 0x8F, 0xE7, 0xFB, 0xCE, 0xE3, 0xB8, 0xEF, 0xF9, 0xFE, 0x3B, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xCF, 0xFB, 0xFF, 0xF3, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xFF, 0xFF, 0xBB, 0xC0, 0x3E,
  0x3F, 0xBF, 0xFC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE3, 0xF1, 0xFF, 0xEF,
  0xE3, 0xE0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xCF, 0xF7, 0xFF, 0xFF,
  0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xFF, 0x7F, 0xCF,
  0x70, 0x1E, 0x1F, 0xC7, 0xFB, 0xCE, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3C, 0x27, 0xF9, 0xFE, 0x1F, 0x00, 0x0F, 0x1F, 0x3F, 0x38, 0x38, 0xFE,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3D, 0xDF, 0xFF, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC,
  0x7F, 0xFD, 0xFF, 0x3D, 0xC0, 0x70, 0x3D, 0xFE, 0x7F, 0x8F, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xFE, 0xF3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xF0, 0x0F, 0xF6,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF3, 0xC6, 0x00,
  0x03, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F,
  0xEF, 0xBC, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE7, 0xBD, 0xE7,
  0xB8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xEE, 0x3D, 0xE7, 0x9C,
  0xF3, 0xDE, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0x3C, 0xFF, 0xFE, 0xFF, 0xFE, 0xF3, 0xCE, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xEF, 0x3F, 0xEF, 0xFB, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xC0, 0x1E, 0x1F, 0xE7, 0xFB, 0xCF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xF7, 0xF9, 0xFE, 0x1E, 0x00,
  0xEF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x3D,
  0xDF, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF,
  0xFD, 0xFF, 0x3F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0xEF, 0xFF,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF0, 0x3E, 0x3F, 0xBF, 0xFC,
  0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xF1, 0xFF, 0xEF, 0xE3, 0xE0, 0x38,
  0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xCF,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xFC, 0xFF, 0xFD, 0xFF, 0x3D, 0xC0, 0xF1, 0xDC, 0x77, 0x3D, 0xCE, 0x3B,
  0x8E, 0xE3, 0xB8, 0xEC, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0E, 0x00, 0xF3,
  0x8E, 0xE7, 0x39, 0xCE, 0x73, 0x9E, 0xE7, 0x7D, 0xC6, 0xFB, 0x8F, 0xB6,
  0x1F, 0x7C, 0x3E, 0xF8, 0x7C, 0xF0, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x00,
  0x71, 0xCF, 0x78, 0xEE, 0x1F, 0xC1, 0xF0, 0x3E, 0x03, 0x80, 0xF8, 0x1F,
  0x07, 0xF0, 0xEE, 0x3D, 0xE7, 0x1C, 0xF1, 0xDC, 0x77, 0x3D, 0xCF, 0x7B,
  0x8E, 0xE3, 0xB8, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0E, 0x03, 0x81,
  0xC1, 0xF0, 0x7C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xE0, 0xF0,
  0x70, 0x70, 0x78, 0x38, 0x3F, 0xFF, 0xFF, 0xF8, 0x08, 0x63, 0x8C, 0x71,
  0xC7, 0x1C, 0x71, 0xCF, 0x38, 0xE1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x38,
  0xE0, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x8E, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC3, 0x8F, 0x3D, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x88,
  0x00, 0x38, 0x6F, 0x9D, 0xFF, 0xF3, 0xEE, 0x38,
};

const GFXglyph RobotoCondensed_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 6, 6, 8, 1, -18 },
  { 15, 11, 17, 13, 1, -17 },
  { 39, 10, 21, 12, 1, -19 },
  { 66, 13, 17, 15, 1, -17 },
  { 94, 12, 17, 14, 1, -17 },
  { 120, 2, 6, 4, 1, -18 },
  { 122, 6, 24, 8, 1, -19 },
  { 140, 6, 24, 8, 1, -19 },
  { 158, 11, 10, 11, 0, -17 },
  { 172, 10, 13, 11, 1, -15 },
  { 189, 5, 7, 6, 0, -3 },
  { 194, 6, 3, 9, 1, -9 },
  { 197, 4, 4, 7, 1, -4 },
  { 199, 8, 18, 8, 0, -17 },
  { 217, 10, 17, 12, 1, -17 },
  { 239, 6, 17, 12, 2, -17 },
  { 252, 10, 17, 12, 1, -17 },
  { 274, 10, 17, 12, 1, -17 },
  { 296, 10, 17, 12, 1, -17 },
  { 318, 10, 17, 12, 1, -17 },
  { 340, 10, 17, 12, 1, -17 },
  { 362, 10, 17, 12, 1, -17 },
  { 384, 10, 17, 12, 1, -17 },
  { 406, 10, 17, 12, 1, -17 },
  { 428, 4, 14, 7, 1, -14 },
  { 435, 4, 18, 6, 1, -14 },
  { 444, 8, 11, 11, 1, -13 },
  { 455, 8, 9, 12, 2, -12 },
  { 464, 9, 11, 11, 1, -13 },
  { 477, 9, 17, 11, 1, -17 },
  { 497, 16, 22, 18, 1, -17 },
  { 541, 14, 17, 14, 0, -17 },
  { 571, 11, 17, 13, 1, -17 },
  { 595, 12, 17, 14, 1, -17 },
  { 621, 11, 17, 14, 1, -17 },
  { 645, 10, 17, 12, 1, -17 },
  { 667, 10, 17, 11, 1, -17 },
  { 689, 12, 17, 14, 1, -17 },
  { 715, 12, 17, 15, 1, -17 },
  { 741, 3, 17, 6, 2, -17 },
  { 748, 9, 17, 12, 1, -17 },
  { 768, 12, 17, 13, 1, -17 },
  { 794, 10, 17, 11, 1, -17 },
  { 816, 16, 17, 18, 1, -17 },
  { 850, 12, 17, 15, 1, -17 },
  { 876, 12, 17, 14, 1, -17 },
  { 902, 12, 17, 14, 1, -17 },
  { 928, 12, 20, 14, 1, -17 },
  { 958, 12, 17, 13, 1, -17 },
  { 984, 11, 17, 13, 1, -17 },
  { 1008, 11, 17, 13, 1, -17 },
  { 1032, 11, 17, 14, 1, -17 },
  { 1056, 14, 17, 14, 0, -17 },
  { 1086, 16, 17, 18, 1, -17 },
  { 1120, 13, 17, 13, 0, -17 },
  { 1148, 13, 17, 13, 0, -17 },
  { 1176, 11, 17, 13, 1, -17 },
  { 1200, 5, 24, 6, 1, -20 },
  { 1215, 9, 18, 9, 0, -17 },
  { 1236, 5, 24, 6, 0, -20 },
  { 1251, 8, 9, 9, 1, -17 },
  { 1260, 9, 3, 10, 0, 0 },
  { 1264, 6, 4, 8, 1, -18 },
  { 1267, 10, 13, 11, 1, -13 },
  { 1284, 10, 18, 12, 1, -18 },
  { 1307, 9, 13, 11, 1, -13 },
  { 1322, 10, 18, 12, 1, -18 },
  { 1345, 10, 13, 11, 1, -13 },
  { 1362, 8, 18, 8, 0, -18 },
  { 1380, 10, 18, 12, 1, -13 },
  { 1403, 10, 18, 12, 1, -18 },
  { 1426, 4, 19, 6, 1, -19 },
  { 1436, 6, 24, 6, -1, -19 },
  { 1454, 11, 18, 11, 1, -18 },
  { 1479, 4, 18, 6, 1, -18 },
  { 1488, 16, 13, 18, 1, -13 },
  { 1514, 10, 13, 12, 1, -13 },
  { 1531, 10, 13, 12, 1, -13 },
  { 1548, 10, 18, 12, 1, -13 },
  { 1571, 10, 18, 12, 1, -13 },
  { 1594, 6, 13, 8, 1, -13 },
  { 1604, 9, 13, 11, 1, -13 },
  { 1619, 7, 16, 7, 0, -16 },
  { 1633, 10, 13, 12, 1, -13 },
  { 1650, 10, 13, 11, 0, -13 },
  { 1667, 15, 13, 15, 0, -13 },
  { 1692, 11, 13, 11, 0, -13 },
  { 1710, 10, 18, 11, 0, -13 },
  { 1733, 9, 13, 11, 1, -13 },
  { 1748, 6, 23, 7, 1, -19 },
  { 1766, 2, 20, 6, 2, -17 },
  { 1771, 6, 23, 7, 1, -19 },
  { 1789, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_Bold24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_BOLD24PT7B_H_
