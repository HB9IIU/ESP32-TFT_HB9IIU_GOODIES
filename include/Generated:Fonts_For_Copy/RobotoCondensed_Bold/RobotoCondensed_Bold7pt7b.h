#ifndef _ROBOTOCONDENSED_BOLD7PT7B_H_
#define _ROBOTOCONDENSED_BOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x7D, 0xF4, 0x0E, 0xBA, 0xC0, 0xCE, 0x27, 0x70, 0x66,
  0x4B, 0xF0, 0xC0, 0x1A, 0xA4, 0x25, 0x58, 0x5E, 0x80, 0x5D, 0x20, 0xC0,
  0xC0, 0xC0, 0x56, 0x80, 0x76, 0xD6, 0xF8, 0x74, 0xAE, 0x65, 0x9E, 0x2D,
  0xF2, 0x73, 0x96, 0x73, 0xD6, 0xE4, 0xA4, 0x75, 0xD6, 0x77, 0x94, 0xC3,
  0x88, 0x39, 0x80, 0x7C, 0x8D, 0x00, 0xE5, 0x04, 0x32, 0x6F, 0xBB, 0xA0,
  0x80, 0x66, 0x67, 0x90, 0xE9, 0xE9, 0xE0, 0x69, 0x89, 0x60, 0xE9, 0x99,
  0xE0, 0xF3, 0xCE, 0xF3, 0xC8, 0x69, 0xB9, 0x70, 0x99, 0xF9, 0x90, 0xF8,
  0x24, 0x9E, 0xBA, 0xEA, 0xB0, 0x92, 0x4E, 0xCE, 0xF7, 0x5A, 0x80, 0xDD,
  0xBB, 0x90, 0x69, 0x99, 0x60, 0xE9, 0xF8, 0x80, 0x69, 0x99, 0x61, 0xE9,
  0xEA, 0xB0, 0x68, 0x6A, 0x60, 0xF4, 0x44, 0x40, 0x99, 0x99, 0x60, 0x99,
  0x66, 0x60, 0xAD, 0x5E, 0xA5, 0x00, 0xB6, 0x66, 0xB0, 0xB6, 0x64, 0x40,
  0xE5, 0x2E, 0xEA, 0xAC, 0x91, 0x24, 0xFE, 0x5A, 0x80, 0xE0, 0x40, 0x67,
  0xF0, 0x9E, 0xDE, 0x76, 0x30, 0x2E, 0xDE, 0x77, 0x30, 0x75, 0x40, 0x76,
  0xB6, 0x9E, 0xDA, 0xF8, 0xFC, 0x97, 0x7A, 0xF8, 0xFD, 0x6B, 0x50, 0xF6,
  0xD0, 0x76, 0xB0, 0xF6, 0xF8, 0x76, 0xF2, 0xEA, 0x51, 0xF0, 0x3A, 0x40,
  0xB6, 0xF0, 0xB5, 0x20, 0xBB, 0x75, 0xA9, 0x50, 0xB5, 0x24, 0x00, 0xE9,
  0x70, 0x59, 0x50, 0x78, 0xA5, 0xA0, 0x5A,
};

const GFXglyph RobotoCondensed_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 5, 4, 0, -5 },
  { 5, 3, 7, 4, 0, -6 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 1, 2, 1, 0, -5 },
  { 15, 2, 8, 2, 0, -6 },
  { 17, 2, 8, 2, 0, -6 },
  { 19, 3, 3, 3, 0, -5 },
  { 21, 3, 4, 3, 0, -4 },
  { 23, 1, 2, 2, 0, -1 },
  { 24, 2, 1, 3, 0, -3 },
  { 25, 2, 1, 2, 0, -1 },
  { 26, 2, 5, 2, 0, -5 },
  { 28, 3, 5, 4, 0, -5 },
  { 30, 1, 5, 4, 1, -5 },
  { 31, 3, 5, 4, 0, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 0, -5 },
  { 43, 3, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 0, -5 },
  { 47, 2, 4, 2, 0, -4 },
  { 48, 1, 5, 2, 0, -4 },
  { 49, 3, 4, 3, 0, -4 },
  { 51, 3, 2, 4, 0, -3 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 5, 3, 0, -5 },
  { 56, 5, 7, 5, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 4, 5, 4, 0, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 3, 5, 3, 0, -5 },
  { 75, 3, 5, 3, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 1, 5, 2, 0, -5 },
  { 84, 3, 5, 3, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 3, 5, 3, 0, -5 },
  { 91, 5, 5, 5, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 4, 6, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 5, 5, 5, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 3, 5, 4, 0, -5 },
  { 134, 2, 7, 2, 0, -6 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 1, 7, 2, 0, -6 },
  { 139, 3, 3, 3, 0, -5 },
  { 141, 3, 1, 3, 0, 0 },
  { 142, 2, 1, 2, 0, -5 },
  { 143, 3, 4, 3, 0, -4 },
  { 145, 3, 5, 3, 0, -5 },
  { 147, 3, 4, 3, 0, -4 },
  { 149, 3, 5, 3, 0, -5 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 2, 5, 2, 0, -5 },
  { 155, 3, 5, 4, 0, -4 },
  { 157, 3, 5, 3, 0, -5 },
  { 159, 1, 5, 2, 0, -5 },
  { 160, 1, 7, 2, 0, -5 },
  { 161, 3, 5, 3, 0, -5 },
  { 163, 1, 5, 2, 0, -5 },
  { 164, 5, 4, 5, 0, -4 },
  { 167, 3, 4, 3, 0, -4 },
  { 169, 3, 4, 3, 0, -4 },
  { 171, 3, 5, 3, 0, -4 },
  { 173, 3, 5, 3, 0, -4 },
  { 175, 2, 4, 2, 0, -4 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 2, 5, 2, 0, -5 },
  { 180, 3, 4, 3, 0, -4 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 3, 6, 3, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 2, 6, 2, 0, -5 },
  { 195, 1, 6, 2, 0, -5 },
  { 196, 2, 6, 2, 0, -5 },
  { 198, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_Bold7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_BOLD7PT7B_H_
