#ifndef _ROBOTOCONDENSED_BOLD17PT7B_H_
#define _ROBOTOCONDENSED_BOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x1B, 0xE0, 0xBB, 0xBB, 0xB0, 0x34, 0x68, 0xD1,
  0x6F, 0xE5, 0x9A, 0x7F, 0x68, 0x91, 0x62, 0xC0, 0x10, 0x20, 0xE3, 0xEE,
  0xF9, 0xF8, 0x3C, 0x3C, 0x1F, 0x3E, 0x7F, 0xCF, 0x04, 0x08, 0x60, 0x79,
  0x24, 0x92, 0xCF, 0x43, 0x40, 0x7C, 0x2F, 0x34, 0x92, 0x49, 0xE0, 0xE0,
  0x38, 0x3E, 0x1B, 0x1D, 0x87, 0x83, 0x81, 0xED, 0xB6, 0xDF, 0x67, 0x3F,
  0x8F, 0x60, 0xF8, 0x13, 0x66, 0x4C, 0xCC, 0xCC, 0xCC, 0x46, 0x63, 0x10,
  0x43, 0x18, 0x63, 0x18, 0xC3, 0x18, 0xCC, 0x63, 0x19, 0x8C, 0x40, 0x18,
  0x18, 0xFE, 0x7E, 0x38, 0x2C, 0x24, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C,
  0x18, 0x6D, 0xB4, 0xFF, 0x5F, 0x80, 0x08, 0xC6, 0x23, 0x18, 0xC4, 0x63,
  0x11, 0x8C, 0x00, 0x78, 0xFB, 0x36, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x99,
  0xF1, 0xC0, 0x1B, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x79, 0xFB,
  0x3E, 0x70, 0xC1, 0x86, 0x1C, 0x71, 0xC3, 0xFF, 0xF0, 0x79, 0xFB, 0x38,
  0x70, 0xC7, 0x8F, 0x07, 0xCF, 0x9F, 0xF3, 0xC0, 0x1C, 0x38, 0xF1, 0xE6,
  0xCD, 0xB3, 0x7F, 0xFE, 0x18, 0x30, 0x60, 0x7D, 0xFB, 0x86, 0x0F, 0x9F,
  0x83, 0x83, 0xCF, 0x9D, 0xF1, 0xC0, 0x18, 0xF1, 0x87, 0x0D, 0xDF, 0xB3,
  0xE3, 0xC7, 0xDD, 0xF1, 0xC0, 0xFF, 0xFC, 0x30, 0x61, 0xC3, 0x06, 0x1C,
  0x30, 0x61, 0xC3, 0x00, 0x79, 0xFB, 0xB6, 0x7E, 0xCF, 0x9F, 0x67, 0xCF,
  0x9F, 0xF3, 0xC0, 0x79, 0xFB, 0x36, 0x7C, 0xF9, 0xFF, 0xBF, 0x0C, 0x39,
  0xE3, 0x80, 0x5F, 0x80, 0x02, 0xFC, 0x27, 0x60, 0x00, 0x00, 0x66, 0x66,
  0x40, 0x02, 0x1C, 0xF7, 0x8F, 0x07, 0x83, 0x81, 0xFF, 0xF0, 0x3F, 0xFC,
  0x83, 0x8F, 0x87, 0x1F, 0xEE, 0x20, 0x3C, 0xFF, 0x98, 0x30, 0xE3, 0x86,
  0x0C, 0x00, 0x20, 0xE0, 0xC0, 0x0F, 0x07, 0x39, 0x81, 0x20, 0x3C, 0x73,
  0x9E, 0x66, 0xCC, 0xD9, 0x93, 0x33, 0x66, 0x7D, 0xE6, 0xEC, 0x00, 0xC0,
  0x0E, 0xC0, 0xF8, 0x0C, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x0C, 0xC3, 0x30,
  0xCE, 0x7F, 0x9F, 0xE6, 0x1F, 0x87, 0xFC, 0xFE, 0xC6, 0xC7, 0xC6, 0xFE,
  0xFE, 0xC7, 0xC7, 0xC7, 0xFE, 0xFC, 0x3C, 0x7E, 0xE7, 0xC3, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC3, 0xE7, 0x7E, 0x3C, 0xF8, 0xFE, 0xC6, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC6, 0xFE, 0xF8, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xBF,
  0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x1F, 0xBF, 0x60,
  0xC1, 0x83, 0x06, 0x00, 0x3C, 0x7E, 0xE7, 0xC3, 0xC0, 0xCF, 0xCF, 0xC3,
  0xC3, 0xE3, 0x7F, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0xE6, 0xCD, 0xF9, 0xE0, 0xC7, 0xC6, 0xCE, 0xDC,
  0xD8, 0xF8, 0xFC, 0xFC, 0xCE, 0xCE, 0xC7, 0xC7, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xE0, 0xFC, 0x3F, 0xC7, 0xF8,
  0xFF, 0x17, 0xB6, 0xF6, 0xDE, 0xDB, 0xDE, 0x79, 0xCF, 0x39, 0xE6, 0x30,
  0xE3, 0xE3, 0xF3, 0xF3, 0xFB, 0xDB, 0xDF, 0xCF, 0xCF, 0xC7, 0xC7, 0xC3,
  0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C,
  0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0,
  0x3C, 0x3F, 0x39, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x73, 0x9F,
  0x87, 0xC0, 0x70, 0x18, 0xFC, 0xFE, 0xC7, 0xC7, 0xC7, 0xC6, 0xFE, 0xFC,
  0xCC, 0xCE, 0xC6, 0xC7, 0x7C, 0xFE, 0xC6, 0xC6, 0xE0, 0x78, 0x1E, 0x06,
  0xC7, 0xC6, 0xFE, 0x3C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xE7, 0xFE, 0x3C, 0xE1, 0xD8, 0x66, 0x39, 0xCE, 0x73,
  0x0C, 0xC3, 0x70, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0xE6, 0x36, 0x73,
  0x67, 0x36, 0x77, 0x67, 0x77, 0xD6, 0x3D, 0xE3, 0xDE, 0x3D, 0xE3, 0x9E,
  0x38, 0xE3, 0x8C, 0x63, 0xB9, 0x8D, 0xC7, 0xC1, 0xE0, 0xE0, 0x78, 0x3C,
  0x37, 0x1B, 0x9C, 0xEC, 0x70, 0xE3, 0xB1, 0x9C, 0xC6, 0xE3, 0x61, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFC, 0x38, 0x61, 0xC3,
  0x0C, 0x38, 0x61, 0xC3, 0xFF, 0xF0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB7,
  0xE0, 0xE0, 0xC1, 0x83, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60,
  0xE0, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7F, 0xF0, 0x30, 0xE3,
  0x9A, 0x6D, 0x30, 0xFF, 0xFC, 0x61, 0x8C, 0x7B, 0xFC, 0xC3, 0x7F, 0xBC,
  0xFF, 0x7C, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xB3, 0xE3, 0xC7, 0x8F, 0x3F,
  0xED, 0xC0, 0x7B, 0xFC, 0xF0, 0xC3, 0x0C, 0xFF, 0x78, 0x0E, 0x1C, 0x38,
  0x77, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F, 0xF7, 0xE0, 0x79, 0xFB, 0x37,
  0xFF, 0xF8, 0x31, 0x7E, 0x7C, 0x19, 0xDC, 0xEF, 0xFD, 0xCE, 0x73, 0x9C,
  0xE7, 0x00, 0x77, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0x7E, 0x1F, 0xF3,
  0xC0, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xB3, 0x67, 0xCF, 0x9F, 0x3E, 0x7C,
  0xE0, 0xF3, 0xFF, 0xFF, 0x6C, 0x36, 0xDB, 0x6D, 0xB7, 0xF0, 0xC1, 0x83,
  0x06, 0x0C, 0xFB, 0xB6, 0x78, 0xF9, 0xF3, 0x76, 0x6C, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xDD, 0xDF, 0xFB, 0x3B, 0xE6, 0x7C, 0xCF, 0x99, 0xF3, 0x3E,
  0x67, 0xCC, 0xE0, 0xDD, 0xFB, 0x36, 0x7C, 0xF9, 0xF3, 0xE7, 0xCE, 0x79,
  0xFB, 0x3E, 0x7C, 0x79, 0xF3, 0xFE, 0x78, 0xDD, 0xFB, 0x3E, 0x7C, 0x79,
  0xF3, 0xFE, 0xDD, 0x83, 0x06, 0x00, 0x7F, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3,
  0xFF, 0x7E, 0x1C, 0x38, 0x70, 0xDF, 0xEC, 0xCC, 0xCC, 0xC0, 0x3C, 0xFD,
  0x9B, 0x83, 0xC1, 0xD9, 0xBF, 0x3C, 0x73, 0xBF, 0xF7, 0x39, 0xCE, 0x73,
  0xCE, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0x7E, 0xE6, 0xCD, 0xBB,
  0x67, 0xC7, 0x8F, 0x1C, 0x18, 0xEC, 0xDB, 0xB6, 0xED, 0xBB, 0x7A, 0xDE,
  0xE3, 0xB8, 0xCE, 0x31, 0x80, 0x66, 0xFC, 0xF1, 0xE1, 0x87, 0x8F, 0x37,
  0x66, 0xE6, 0xCD, 0xBB, 0x63, 0xC7, 0x8E, 0x1C, 0x18, 0x71, 0xC3, 0x00,
  0xFF, 0xF1, 0x8E, 0x31, 0x8E, 0x3F, 0xFC, 0x11, 0x8C, 0x63, 0x19, 0xDC,
  0xE3, 0x8C, 0x63, 0x18, 0xC2, 0xFF, 0xFF, 0xFF, 0xF0, 0x43, 0x18, 0xC6,
  0x31, 0xC7, 0x39, 0x98, 0xC6, 0x31, 0x88, 0x63, 0xF3, 0xDE, 0xCC,
};

const GFXglyph RobotoCondensed_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 4, 1, -12 },
  { 6, 4, 5, 5, 1, -13 },
  { 9, 7, 12, 9, 1, -12 },
  { 20, 7, 16, 9, 1, -14 },
  { 34, 9, 12, 11, 1, -12 },
  { 48, 9, 12, 10, 1, -12 },
  { 62, 1, 5, 3, 1, -13 },
  { 63, 4, 17, 6, 1, -13 },
  { 72, 5, 17, 6, 0, -13 },
  { 83, 8, 7, 8, 0, -12 },
  { 90, 7, 8, 8, 1, -10 },
  { 97, 3, 5, 4, 0, -2 },
  { 99, 4, 2, 6, 1, -6 },
  { 100, 3, 3, 5, 1, -3 },
  { 102, 5, 13, 6, 0, -12 },
  { 111, 7, 12, 9, 1, -12 },
  { 122, 5, 12, 9, 1, -12 },
  { 130, 7, 12, 9, 1, -12 },
  { 141, 7, 12, 9, 1, -12 },
  { 152, 7, 12, 9, 1, -12 },
  { 163, 7, 12, 9, 1, -12 },
  { 174, 7, 12, 9, 1, -12 },
  { 185, 7, 12, 9, 1, -12 },
  { 196, 7, 12, 9, 1, -12 },
  { 207, 7, 12, 9, 1, -12 },
  { 218, 3, 10, 5, 1, -10 },
  { 222, 4, 13, 4, 0, -10 },
  { 229, 7, 8, 8, 0, -9 },
  { 236, 6, 5, 9, 1, -8 },
  { 240, 6, 8, 8, 1, -9 },
  { 246, 7, 12, 8, 0, -12 },
  { 257, 11, 16, 13, 1, -12 },
  { 279, 10, 12, 10, 0, -12 },
  { 294, 8, 12, 10, 1, -12 },
  { 306, 8, 12, 10, 1, -12 },
  { 318, 8, 12, 10, 1, -12 },
  { 330, 7, 12, 8, 1, -12 },
  { 341, 7, 12, 8, 1, -12 },
  { 352, 8, 12, 10, 1, -12 },
  { 364, 8, 12, 10, 1, -12 },
  { 376, 3, 12, 5, 1, -12 },
  { 381, 7, 12, 8, 0, -12 },
  { 392, 8, 12, 9, 1, -12 },
  { 404, 7, 12, 8, 1, -12 },
  { 415, 11, 12, 13, 1, -12 },
  { 432, 8, 12, 10, 1, -12 },
  { 444, 8, 12, 10, 1, -12 },
  { 456, 8, 12, 10, 1, -12 },
  { 468, 9, 14, 10, 1, -12 },
  { 484, 8, 12, 9, 1, -12 },
  { 496, 8, 12, 9, 1, -12 },
  { 508, 9, 12, 9, 0, -12 },
  { 522, 8, 12, 10, 1, -12 },
  { 534, 10, 12, 10, 0, -12 },
  { 549, 12, 12, 13, 0, -12 },
  { 567, 9, 12, 10, 0, -12 },
  { 581, 9, 12, 9, 0, -12 },
  { 595, 7, 12, 9, 1, -12 },
  { 606, 3, 17, 4, 1, -14 },
  { 613, 7, 13, 6, 0, -12 },
  { 625, 4, 17, 4, 0, -14 },
  { 634, 6, 6, 7, 0, -12 },
  { 639, 7, 2, 7, 0, 0 },
  { 641, 5, 3, 6, 0, -13 },
  { 643, 6, 9, 8, 1, -9 },
  { 650, 7, 13, 8, 1, -13 },
  { 662, 6, 9, 8, 1, -9 },
  { 669, 7, 13, 8, 1, -13 },
  { 681, 7, 9, 8, 1, -9 },
  { 689, 5, 13, 6, 0, -13 },
  { 698, 7, 12, 9, 1, -9 },
  { 709, 7, 13, 8, 1, -13 },
  { 721, 2, 12, 4, 1, -12 },
  { 724, 3, 15, 4, 0, -12 },
  { 730, 7, 13, 8, 1, -13 },
  { 742, 2, 13, 4, 1, -13 },
  { 746, 11, 9, 13, 1, -9 },
  { 759, 7, 9, 8, 1, -9 },
  { 767, 7, 9, 8, 1, -9 },
  { 775, 7, 12, 8, 1, -9 },
  { 786, 7, 12, 8, 1, -9 },
  { 797, 4, 9, 6, 1, -9 },
  { 802, 7, 9, 8, 0, -9 },
  { 810, 5, 11, 5, 0, -11 },
  { 817, 7, 9, 8, 1, -9 },
  { 825, 7, 9, 8, 0, -9 },
  { 833, 10, 9, 11, 0, -9 },
  { 845, 7, 9, 8, 0, -9 },
  { 853, 7, 12, 8, 0, -9 },
  { 864, 6, 9, 8, 1, -9 },
  { 871, 5, 16, 5, 0, -13 },
  { 881, 2, 14, 4, 1, -12 },
  { 885, 5, 16, 5, 0, -13 },
  { 895, 8, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_Bold17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_BOLD17PT7B_H_
