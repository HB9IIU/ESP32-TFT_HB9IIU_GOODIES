#ifndef _ROBOTOCONDENSED_BOLD47PT7B_H_
#define _ROBOTOCONDENSED_BOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Bold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Bold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0x00, 0x01,
  0xE7, 0xEF, 0xFF, 0xFF, 0xFE, 0x78, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0x7C, 0x7B, 0xE3, 0xDF, 0x1E, 0xF8, 0xF7, 0xC7, 0xBC, 0x3D,
  0xE1, 0xEF, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x83, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x9F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xE7, 0xF0, 0xFE, 0x7F, 0x9F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0xF0, 0x30, 0x3E, 0x3E, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE3, 0xC0, 0xF0, 0x78, 0xF0, 0x3C, 0x3E, 0x78,
  0x0F, 0x8F, 0xBC, 0x01, 0xE3, 0xCF, 0x00, 0x7F, 0xF7, 0x80, 0x0F, 0xF9,
  0xE0, 0x03, 0xFE, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xCF, 0xF0, 0x01, 0xF7, 0xFE, 0x00, 0x7B, 0xFF,
  0x80, 0x3C, 0xF1, 0xF0, 0x0F, 0x3C, 0x3C, 0x07, 0x9F, 0x0F, 0x01, 0xE7,
  0xC3, 0xC0, 0xF1, 0xF0, 0xF0, 0x3C, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x83, 0xE7, 0xC0, 0x40, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xDF, 0x80, 0x3F, 0x0F,
  0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F,
  0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7E, 0x1F, 0xF8, 0x7E, 0x3F, 0xFC,
  0x7E, 0x7F, 0xFE, 0x7C, 0xFE, 0xFE, 0x7C, 0xFC, 0x7F, 0xFC, 0xFC, 0x3F,
  0xFC, 0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xF8, 0xFE, 0x0F, 0xF8, 0xFE, 0x0F,
  0xF0, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFE, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x18, 0x07, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0x80, 0x10, 0x40, 0x07, 0x00,
  0x78, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC0, 0x78, 0x07, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0x02, 0xF8,
  0xF1, 0xEF, 0xEF, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xBE, 0x01, 0xF1, 0xF0,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x0C, 0x07, 0x00, 0x40, 0x20, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0xF8, 0xF8, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF9, 0xFC, 0x7F, 0x0F,
  0xE7, 0xE0, 0xFE, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0,
  0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFE,
  0x7F, 0x0F, 0xE3, 0xFB, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF9, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFD, 0xFF, 0x7F, 0xBF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF,
  0x9F, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x7C, 0xFC,
  0x03, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0x1F, 0xE0,
  0x40, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x7F, 0x0F,
  0xE7, 0xFB, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x7E, 0xFF,
  0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x9F, 0xEF, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xE3,
  0xFD, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0xFF, 0x3F, 0x9F, 0xC3, 0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xEF,
  0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFC, 0x7F, 0x3F, 0x87,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F,
  0x8F, 0xE7, 0xE0, 0xFE, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFD, 0xFC, 0x3F, 0xBF, 0xCF, 0xF7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0x7F, 0x9F,
  0xC3, 0xF3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7F, 0x7F,
  0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x7E, 0x0F,
  0xCF, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0x80, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xFF, 0xFF,
  0xFF, 0x7E, 0x78, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xF8, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3, 0xF1,
  0xF1, 0xF8, 0xF8, 0x78, 0x08, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF,
  0xEF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0x1E, 0x3C,
  0x07, 0xFC, 0x1E, 0x3C, 0x0F, 0xFE, 0x1E, 0x7C, 0x1F, 0xFE, 0x0F, 0x78,
  0x1F, 0x1E, 0x0F, 0x78, 0x3E, 0x1E, 0x0F, 0xF8, 0x3C, 0x1E, 0x0F, 0xF8,
  0x7C, 0x1E, 0x0F, 0xF8, 0x7C, 0x1E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0,
  0x78, 0x3E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F, 0xF0,
  0xF8, 0x3E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8, 0x3C, 0x1E, 0xF0,
  0xF8, 0x3C, 0x1E, 0xF0, 0xFC, 0x7C, 0x1E, 0xF8, 0x7C, 0xFE, 0x3C, 0xF8,
  0x7F, 0xFF, 0xFC, 0x78, 0x3F, 0xDF, 0xF8, 0x78, 0x3F, 0x8F, 0xF0, 0x7C,
  0x0F, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x1C, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x07, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0x3F, 0x80,
  0x7F, 0x7E, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0x7E,
  0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFE, 0x07, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0xFE, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x03, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xBF, 0x80,
  0x7F, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7F,
  0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFB, 0xF0, 0x1F, 0xE7, 0xE0, 0x3F, 0xCF,
  0xC0, 0xFF, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF8, 0x7E, 0x1F, 0xE0, 0xFC,
  0x3F, 0x81, 0xF8, 0xFF, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF,
  0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xE7, 0xF0, 0x3F, 0x8F, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xE1,
  0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x9F,
  0x80, 0x7F, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3E, 0xFF, 0xFF, 0xC0, 0xFB, 0xFF, 0xDF, 0x07, 0xEF, 0xFF, 0x7E,
  0x1F, 0x3F, 0xFD, 0xF8, 0x7C, 0xFF, 0xF7, 0xE3, 0xF3, 0xFF, 0xCF, 0xCF,
  0xCF, 0xFF, 0x3F, 0x3E, 0x7F, 0xFC, 0xFD, 0xF9, 0xFF, 0xF1, 0xF7, 0xE7,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0x1F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xF0, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0x1F, 0xFF, 0x07, 0xF8, 0x7F, 0xFC,
  0x1F, 0xE1, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0x03,
  0xF0, 0x7F, 0xFC, 0x0F, 0x81, 0xFC, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0x7E,
  0x1F, 0xFE, 0x7E, 0x3F, 0xFC, 0xFC, 0x7F, 0xF8, 0xFC, 0xFF, 0xF1, 0xF9,
  0xFF, 0xE1, 0xFB, 0xFF, 0xC3, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFE,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0xFE, 0xFC, 0x03,
  0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xFB,
  0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF0, 0xFE,
  0x0F, 0xC3, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F,
  0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0x7F, 0xC7,
  0xF0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xEF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07,
  0xF7, 0xF0, 0x1F, 0xDF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x1F, 0xDF, 0x81, 0xFC, 0x0F,
  0xEF, 0xC0, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0xC1,
  0xF9, 0xFC, 0x1F, 0xE0, 0xFC, 0xFE, 0x1F, 0xF0, 0xFE, 0x3F, 0x0F, 0xF8,
  0x7F, 0x1F, 0x87, 0xFC, 0x3F, 0x8F, 0xC3, 0xFE, 0x1F, 0x87, 0xE1, 0xFF,
  0x8F, 0xC3, 0xF9, 0xFF, 0xC7, 0xE0, 0xFC, 0xFF, 0xE3, 0xF0, 0x7E, 0x7D,
  0xF3, 0xF8, 0x3F, 0x3E, 0xF9, 0xF8, 0x1F, 0x9F, 0x7E, 0xFC, 0x0F, 0xCF,
  0xBF, 0x7E, 0x07, 0xFF, 0xCF, 0xBF, 0x01, 0xFF, 0xC7, 0xDF, 0x80, 0xFF,
  0xE3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F,
  0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC3,
  0xFC, 0x0F, 0xF1, 0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1F,
  0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0xFE, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x78,
  0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E,
  0x7C, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF9, 0xFE, 0x7F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xC7, 0xF7, 0xF0, 0xFE, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F,
  0x7F, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0x7E,
  0x0F, 0x8F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x7E, 0x0F, 0xEF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7E, 0xFE, 0x0F, 0xEF, 0xF9, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xCF, 0xF0, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xEF, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFD, 0xFE, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x3F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x7F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xF7, 0xE3, 0xFC,
  0xFC, 0x1F, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0x3F, 0x9F, 0x83, 0xF7, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x06, 0x3F, 0xE7, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xFC, 0x7F, 0xD1, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xBF, 0xCF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xBF, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF1, 0x80, 0xFE, 0x3C, 0x7F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF9, 0xF8, 0x7F, 0x7F, 0x8F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFD, 0xFE, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x3C, 0xFD, 0xFF, 0xFF, 0xEF, 0xCF,
  0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xF8, 0x07, 0x03, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xF3, 0xF8, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xFD, 0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF9,
  0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFB, 0xF0, 0x3F, 0xDF, 0xC1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFE, 0x0F,
  0xE7, 0xF0, 0x7F, 0xBF, 0x81, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x3E, 0x07,
  0xE3, 0xFB, 0xFC, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF,
  0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F,
  0x83, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xE0,
  0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x3F,
  0xFE, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xE0, 0xFC, 0xFC, 0x3E, 0x1F, 0x9F, 0xE3,
  0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x7F, 0xBF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFB, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x0F, 0xE7, 0xFB, 0xFE, 0x7F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x7E,
  0x0F, 0xCF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xFB, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xEF, 0xF0, 0xFE, 0x7E,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF,
  0xCF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07,
  0xCF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7F, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x87, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFF, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xBF, 0xDF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFD,
  0xF8, 0xFF, 0xBF, 0x0F, 0xC7, 0xE0, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0xC7, 0xF1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x0F, 0xDF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF8,
  0x7F, 0xFC, 0x1F, 0x87, 0xE7, 0xE1, 0xF8, 0x7E, 0x7E, 0x3F, 0x87, 0xE7,
  0xE3, 0xF8, 0x7E, 0x7E, 0x3F, 0xC7, 0xE7, 0xE3, 0xFC, 0x7C, 0x3E, 0x3F,
  0xCF, 0xC3, 0xF7, 0xFC, 0xFC, 0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xFE, 0xFC,
  0x3F, 0x7B, 0xEF, 0x81, 0xFF, 0x9E, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF,
  0x9F, 0xF8, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xFE, 0x0F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC3, 0xF9, 0xFC, 0x3F, 0x9F, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFB, 0xF8,
  0x3F, 0x9F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xCF, 0xE0, 0xFE, 0xFE, 0x07,
  0xE0, 0x7E, 0x03, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x60, 0x1E, 0x03, 0xE0, 0x7F, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xE0, 0x1E, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x07, 0x80, 0x7C, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7C, 0x07,
  0x80, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x81, 0xF3, 0xFF, 0x07, 0xDF,
  0xFE, 0x1F, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xC7, 0xFF, 0xBE, 0x0F,
  0xFC, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Bold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 33, 12, 3, -33 },
  { 30, 13, 13, 15, 1, -35 },
  { 52, 21, 33, 25, 2, -33 },
  { 139, 20, 42, 24, 2, -38 },
  { 244, 26, 33, 30, 2, -33 },
  { 352, 24, 33, 27, 2, -33 },
  { 451, 5, 13, 8, 1, -35 },
  { 460, 11, 47, 15, 3, -37 },
  { 525, 12, 47, 15, 1, -37 },
  { 596, 20, 20, 21, 1, -33 },
  { 646, 19, 24, 22, 2, -28 },
  { 703, 8, 14, 12, 1, -6 },
  { 717, 11, 5, 17, 3, -17 },
  { 724, 7, 7, 14, 3, -7 },
  { 731, 15, 36, 16, 0, -33 },
  { 799, 20, 33, 24, 2, -33 },
  { 882, 12, 33, 24, 4, -33 },
  { 932, 20, 33, 24, 2, -33 },
  { 1015, 19, 33, 24, 2, -33 },
  { 1094, 21, 33, 24, 1, -33 },
  { 1181, 20, 33, 24, 2, -33 },
  { 1264, 20, 33, 24, 2, -33 },
  { 1347, 20, 33, 24, 2, -33 },
  { 1430, 19, 33, 24, 2, -33 },
  { 1509, 19, 33, 24, 2, -33 },
  { 1588, 7, 26, 13, 3, -26 },
  { 1611, 9, 34, 12, 1, -26 },
  { 1650, 17, 22, 21, 1, -25 },
  { 1697, 18, 14, 24, 3, -22 },
  { 1729, 17, 22, 21, 3, -25 },
  { 1776, 18, 33, 21, 1, -33 },
  { 1851, 32, 43, 36, 2, -33 },
  { 2023, 27, 33, 28, 1, -33 },
  { 2135, 21, 33, 26, 3, -33 },
  { 2222, 23, 33, 27, 2, -33 },
  { 2317, 21, 33, 27, 3, -33 },
  { 2404, 19, 33, 23, 3, -33 },
  { 2483, 18, 33, 22, 3, -33 },
  { 2558, 23, 33, 28, 2, -33 },
  { 2653, 23, 33, 29, 3, -33 },
  { 2748, 7, 33, 13, 3, -33 },
  { 2777, 19, 33, 23, 1, -33 },
  { 2856, 23, 33, 26, 3, -33 },
  { 2951, 18, 33, 22, 3, -33 },
  { 3026, 30, 33, 36, 3, -33 },
  { 3150, 23, 33, 29, 3, -33 },
  { 3245, 24, 33, 28, 2, -33 },
  { 3344, 22, 33, 27, 3, -33 },
  { 3435, 24, 39, 28, 2, -33 },
  { 3552, 22, 33, 26, 3, -33 },
  { 3643, 22, 33, 25, 2, -33 },
  { 3734, 23, 33, 26, 1, -33 },
  { 3829, 22, 33, 27, 2, -33 },
  { 3920, 27, 33, 27, 0, -33 },
  { 4032, 33, 33, 35, 1, -33 },
  { 4169, 25, 33, 26, 1, -33 },
  { 4273, 25, 33, 26, 0, -33 },
  { 4377, 21, 33, 25, 2, -33 },
  { 4464, 8, 47, 12, 3, -39 },
  { 4511, 19, 36, 18, 0, -33 },
  { 4597, 9, 47, 12, 1, -39 },
  { 4650, 16, 17, 18, 1, -33 },
  { 4684, 18, 5, 19, 0, 0 },
  { 4696, 12, 7, 16, 1, -35 },
  { 4707, 19, 25, 22, 2, -25 },
  { 4767, 20, 35, 23, 2, -35 },
  { 4855, 18, 25, 22, 2, -25 },
  { 4912, 19, 35, 23, 2, -35 },
  { 4996, 19, 25, 22, 2, -25 },
  { 5056, 14, 35, 15, 1, -35 },
  { 5118, 19, 35, 24, 2, -25 },
  { 5202, 19, 35, 23, 2, -35 },
  { 5286, 7, 35, 12, 2, -35 },
  { 5317, 10, 45, 12, -1, -35 },
  { 5374, 21, 35, 22, 2, -35 },
  { 5466, 6, 35, 12, 3, -35 },
  { 5493, 30, 25, 35, 2, -25 },
  { 5587, 19, 25, 23, 2, -25 },
  { 5647, 20, 25, 23, 2, -25 },
  { 5710, 20, 35, 23, 2, -25 },
  { 5798, 19, 35, 23, 2, -25 },
  { 5882, 13, 25, 16, 2, -25 },
  { 5923, 19, 25, 21, 1, -25 },
  { 5983, 12, 31, 14, 1, -31 },
  { 6030, 19, 25, 23, 2, -25 },
  { 6090, 19, 25, 21, 1, -25 },
  { 6150, 28, 25, 30, 1, -25 },
  { 6238, 20, 25, 21, 1, -25 },
  { 6301, 21, 35, 21, 0, -25 },
  { 6393, 17, 25, 21, 2, -25 },
  { 6447, 12, 45, 14, 1, -37 },
  { 6515, 4, 39, 12, 4, -33 },
  { 6535, 12, 45, 14, 1, -37 },
  { 6603, 22, 10, 26, 2, -19 },
};

const GFXfont RobotoCondensed_Bold47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Bold47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Bold47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_BOLD47PT7B_H_
