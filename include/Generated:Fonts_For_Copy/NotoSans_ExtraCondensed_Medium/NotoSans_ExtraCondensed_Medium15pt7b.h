#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xAA, 0x3C, 0x99, 0x99, 0x34, 0x48, 0x93, 0xF2, 0x85, 0x0A,
  0x7E, 0x68, 0x91, 0x20, 0x27, 0xEB, 0x4E, 0x38, 0xE5, 0xBF, 0x88, 0x40,
  0xC6, 0x52, 0x29, 0x15, 0x8A, 0x95, 0x5F, 0x52, 0x29, 0x14, 0x92, 0x48,
  0xC0, 0x30, 0x68, 0x68, 0x68, 0x38, 0x30, 0x5A, 0xCE, 0xCC, 0x4E, 0x7B,
  0xF0, 0x29, 0x69, 0x24, 0x93, 0x26, 0xC4, 0x22, 0x33, 0x33, 0x32, 0x26,
  0xC0, 0x31, 0x7B, 0x0E, 0x48, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0xEA,
  0xFF, 0xF0, 0x0C, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x61, 0x0C, 0x00, 0x76,
  0xA7, 0x39, 0xCE, 0x73, 0x9E, 0x9C, 0x37, 0xFB, 0x33, 0x33, 0x33, 0x30,
  0x39, 0x60, 0xC3, 0x08, 0x61, 0x0C, 0x61, 0x0F, 0xC0, 0xF5, 0x86, 0x31,
  0x30, 0x63, 0x1C, 0xFC, 0x08, 0x61, 0x8A, 0x29, 0x24, 0xBF, 0xFC, 0x20,
  0x80, 0xF7, 0xA1, 0x0E, 0x78, 0x63, 0x1C, 0xFC, 0x33, 0x71, 0x0B, 0x6E,
  0x71, 0x9E, 0xDC, 0xFF, 0xF0, 0xC2, 0x08, 0x61, 0x04, 0x30, 0x86, 0x00,
  0x39, 0xB4, 0xD3, 0x68, 0xC6, 0x91, 0xC5, 0x37, 0x80, 0x66, 0xA7, 0x39,
  0xCF, 0xE3, 0x11, 0xB8, 0xF0, 0x0F, 0xF0, 0x0F, 0xA0, 0x04, 0x33, 0x30,
  0x70, 0x70, 0x40, 0xFC, 0x00, 0x3F, 0x83, 0x83, 0x83, 0x19, 0x8C, 0x00,
  0x76, 0xC6, 0x31, 0x18, 0x8C, 0x03, 0x18, 0x1C, 0x62, 0x41, 0x9D, 0xB5,
  0xA5, 0xA5, 0xAD, 0xBF, 0x80, 0x40, 0x3C, 0x10, 0x70, 0xA1, 0x42, 0x8D,
  0x99, 0x3E, 0x45, 0x8F, 0x18, 0xF3, 0xEC, 0xF3, 0xCB, 0xCC, 0xF3, 0xCF,
  0x2F, 0x80, 0x3D, 0xAC, 0x30, 0x82, 0x08, 0x20, 0xC1, 0x97, 0x80, 0xF3,
  0xEC, 0xF3, 0xC7, 0x1C, 0x71, 0xCF, 0x6F, 0x00, 0xFF, 0xCC, 0xCF, 0xCC,
  0xCC, 0xF0, 0xFF, 0xCC, 0xCF, 0xFC, 0xCC, 0xC0, 0x3D, 0x9C, 0x30, 0x82,
  0x79, 0xE1, 0xC5, 0x97, 0xC0, 0xC7, 0x1C, 0x71, 0xC7, 0xFC, 0x71, 0xC7,
  0x1C, 0x40, 0xF6, 0x66, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xAE, 0xCF, 0x2D, 0xB4, 0xF3, 0xCF, 0x34, 0xDB, 0x2C, 0xC0,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC1, 0xF0, 0xF8, 0xB4, 0x5A, 0x2D,
  0xBE, 0x57, 0x2B, 0x95, 0xCE, 0xE2, 0x60, 0xC7, 0x8F, 0x9D, 0x3B, 0x72,
  0xE7, 0xCF, 0x8F, 0x1E, 0x18, 0x38, 0xDB, 0x14, 0x38, 0x70, 0xE1, 0xC3,
  0xC4, 0x99, 0xE0, 0xF7, 0xF3, 0x9C, 0xEF, 0xD8, 0xC6, 0x30, 0x38, 0xDB,
  0x14, 0x38, 0x70, 0xE1, 0xC3, 0xC4, 0x99, 0xE0, 0x40, 0xC0, 0x80, 0xF3,
  0xEC, 0xB2, 0xCB, 0xEF, 0x34, 0xDB, 0x2C, 0xC0, 0x7F, 0xA1, 0x0C, 0x30,
  0xC3, 0x1C, 0xBC, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xCF, 0x37, 0x80, 0xC7, 0x8D, 0x12,
  0x24, 0xCD, 0x8A, 0x14, 0x28, 0x70, 0xC0, 0xC4, 0x78, 0x8F, 0x39, 0x25,
  0x24, 0xA4, 0x95, 0x9A, 0xB3, 0xDC, 0x31, 0x86, 0x30, 0xC6, 0x00, 0xCD,
  0x36, 0x8E, 0x30, 0xC3, 0x0E, 0x69, 0x3C, 0xC0, 0xC7, 0x34, 0x9A, 0x38,
  0xC3, 0x0C, 0x30, 0xC3, 0x00, 0xFF, 0xC6, 0x21, 0x18, 0x8C, 0x46, 0x3E,
  0xF2, 0x49, 0x24, 0x92, 0x4E, 0xC1, 0x04, 0x18, 0x20, 0x81, 0x04, 0x18,
  0x20, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x10, 0x20, 0xA1,
  0x44, 0x58, 0xC0, 0xFC, 0xCC, 0x78, 0x20, 0xCF, 0x4F, 0x34, 0xDF, 0x82,
  0x08, 0x2E, 0xCA, 0x28, 0xE3, 0x8B, 0x2B, 0x80, 0x7C, 0x88, 0x88, 0xD7,
  0x08, 0x43, 0xDD, 0xC6, 0x31, 0x8E, 0xDA, 0x74, 0xE3, 0xF8, 0x43, 0x2F,
  0x76, 0x6F, 0x66, 0x66, 0x66, 0x60, 0xEE, 0xE3, 0x18, 0xC7, 0x6D, 0x08,
  0x7E, 0xC0, 0x84, 0x21, 0x7D, 0xC6, 0x31, 0x8C, 0x62, 0xDF, 0xE0, 0x51,
  0x55, 0x55, 0x78, 0x84, 0x21, 0x39, 0x5B, 0x9E, 0x94, 0xE2, 0xFF, 0xE0,
  0xBF, 0x6C, 0xE2, 0x71, 0x38, 0x9C, 0x4E, 0x27, 0x13, 0xBE, 0xE3, 0x18,
  0xC6, 0x31, 0x76, 0xE3, 0x18, 0xC7, 0x6E, 0xBB, 0x28, 0xA3, 0x8E, 0x2C,
  0xAE, 0x82, 0x08, 0x20, 0xEE, 0xE3, 0x18, 0xC7, 0x6D, 0x08, 0x42, 0x10,
  0xBC, 0xC8, 0x88, 0x88, 0x7E, 0x10, 0xC3, 0x0E, 0x7E, 0x44, 0xF4, 0x44,
  0x44, 0x67, 0x8C, 0x63, 0x18, 0xC7, 0x7D, 0xCF, 0x24, 0x92, 0x79, 0xC3,
  0x0C, 0xCC, 0xE6, 0x55, 0x6A, 0xA5, 0x53, 0xB8, 0xCC, 0x66, 0xCD, 0x67,
  0x0C, 0x31, 0xE4, 0xB3, 0xCF, 0x24, 0x92, 0x78, 0xC3, 0x0C, 0x30, 0x8E,
  0x30, 0xF0, 0x8C, 0x46, 0x21, 0x1F, 0x19, 0x88, 0x42, 0x13, 0x8C, 0x21,
  0x08, 0x43, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x8C, 0x44, 0x44, 0x36, 0x44,
  0x44, 0xC0, 0xF6, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_Medium15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 7, 11, 7, 0, -11 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 9, 11, 10, 1, -11 },
  { 37, 8, 11, 8, 0, -11 },
  { 48, 1, 4, 3, 1, -11 },
  { 49, 3, 13, 4, 1, -11 },
  { 54, 4, 13, 4, 0, -11 },
  { 61, 6, 5, 6, 0, -11 },
  { 65, 6, 7, 7, 0, -9 },
  { 71, 2, 4, 3, 1, -2 },
  { 72, 4, 2, 4, 0, -5 },
  { 73, 2, 2, 4, 1, -2 },
  { 74, 6, 11, 6, 0, -11 },
  { 83, 5, 11, 7, 1, -11 },
  { 90, 4, 11, 7, 1, -11 },
  { 96, 6, 11, 7, 0, -11 },
  { 105, 5, 11, 7, 1, -11 },
  { 112, 6, 11, 7, 0, -11 },
  { 121, 5, 11, 7, 1, -11 },
  { 128, 5, 11, 7, 1, -11 },
  { 135, 6, 11, 7, 0, -11 },
  { 144, 6, 11, 7, 0, -11 },
  { 153, 5, 11, 7, 1, -11 },
  { 160, 2, 8, 4, 1, -8 },
  { 162, 2, 10, 4, 1, -8 },
  { 165, 6, 7, 7, 0, -9 },
  { 171, 6, 4, 7, 0, -7 },
  { 174, 6, 7, 7, 0, -9 },
  { 180, 5, 11, 5, 0, -11 },
  { 187, 8, 12, 10, 1, -11 },
  { 199, 7, 11, 7, 0, -11 },
  { 209, 6, 11, 7, 1, -11 },
  { 218, 6, 11, 7, 1, -11 },
  { 227, 6, 11, 8, 1, -11 },
  { 236, 4, 11, 6, 1, -11 },
  { 242, 4, 11, 6, 1, -11 },
  { 248, 6, 11, 8, 1, -11 },
  { 257, 6, 11, 8, 1, -11 },
  { 266, 4, 11, 4, 0, -11 },
  { 272, 4, 14, 4, -1, -11 },
  { 279, 6, 11, 7, 1, -11 },
  { 288, 4, 11, 6, 1, -11 },
  { 294, 9, 11, 11, 1, -11 },
  { 307, 7, 11, 9, 1, -11 },
  { 317, 7, 11, 8, 1, -11 },
  { 327, 5, 11, 7, 1, -11 },
  { 334, 7, 14, 8, 1, -11 },
  { 347, 6, 11, 7, 1, -11 },
  { 356, 5, 11, 6, 1, -11 },
  { 363, 6, 11, 6, 0, -11 },
  { 372, 6, 11, 8, 1, -11 },
  { 381, 7, 11, 7, 0, -11 },
  { 391, 11, 11, 11, 0, -11 },
  { 407, 6, 11, 6, 0, -11 },
  { 416, 6, 11, 6, 0, -11 },
  { 425, 5, 11, 6, 0, -11 },
  { 432, 3, 13, 5, 1, -11 },
  { 437, 6, 11, 6, 0, -11 },
  { 446, 4, 13, 5, 0, -11 },
  { 453, 7, 6, 7, 0, -11 },
  { 459, 6, 1, 6, 0, 1 },
  { 460, 3, 2, 4, 1, -11 },
  { 461, 6, 8, 6, 0, -8 },
  { 467, 6, 11, 7, 1, -11 },
  { 476, 4, 8, 5, 1, -8 },
  { 480, 5, 11, 7, 1, -11 },
  { 487, 5, 8, 6, 1, -8 },
  { 492, 4, 11, 4, 0, -11 },
  { 498, 5, 12, 7, 1, -8 },
  { 506, 5, 11, 7, 1, -11 },
  { 513, 1, 11, 3, 1, -11 },
  { 515, 2, 15, 3, 0, -11 },
  { 519, 5, 11, 6, 1, -11 },
  { 526, 1, 11, 3, 1, -11 },
  { 528, 9, 8, 11, 1, -8 },
  { 537, 5, 8, 7, 1, -8 },
  { 542, 5, 8, 7, 1, -8 },
  { 547, 6, 12, 7, 1, -8 },
  { 556, 5, 12, 7, 1, -8 },
  { 564, 4, 8, 5, 1, -8 },
  { 568, 5, 8, 5, 0, -8 },
  { 573, 4, 10, 4, 0, -10 },
  { 578, 5, 8, 7, 1, -8 },
  { 583, 6, 8, 6, 0, -8 },
  { 589, 9, 8, 9, 0, -8 },
  { 598, 6, 8, 6, 0, -8 },
  { 604, 6, 12, 6, 0, -8 },
  { 613, 5, 8, 5, 0, -8 },
  { 618, 5, 13, 5, 0, -11 },
  { 627, 2, 15, 6, 2, -11 },
  { 631, 4, 13, 5, 1, -11 },
  { 638, 6, 2, 7, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Medium15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM15PT7B_H_
