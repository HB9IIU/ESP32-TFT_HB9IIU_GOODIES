#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE6, 0x66, 0x66, 0x60, 0x00, 0xFF,
  0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80,
  0x0E, 0x30, 0x38, 0xC0, 0xE3, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0xC0, 0xC6,
  0x3F, 0xFF, 0xFF, 0xFC, 0x71, 0x81, 0xC6, 0x06, 0x38, 0x18, 0xE0, 0x63,
  0x81, 0x8C, 0x3F, 0xFE, 0xFF, 0xF8, 0xE3, 0x03, 0x9C, 0x0C, 0x70, 0x31,
  0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x06, 0x00, 0x60, 0x06, 0x01, 0xFE,
  0x3F, 0xF7, 0xE6, 0x76, 0x0E, 0x60, 0xE6, 0x07, 0x60, 0x7E, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x6F, 0x06, 0x70, 0x67, 0x06, 0x78, 0x67,
  0xF7, 0xEF, 0xFE, 0x7F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x1C,
  0x07, 0x01, 0xF0, 0x38, 0x1D, 0xC1, 0x80, 0xCE, 0x1C, 0x0E, 0x30, 0xC0,
  0x71, 0x86, 0x03, 0x8C, 0x70, 0x1C, 0x63, 0x00, 0xE3, 0x18, 0x07, 0x19,
  0xC0, 0x38, 0xCC, 0xF8, 0xCE, 0xE7, 0xE7, 0xF7, 0x73, 0x1F, 0x33, 0x18,
  0x73, 0x98, 0xE0, 0x1C, 0xC7, 0x00, 0xC6, 0x38, 0x0E, 0x31, 0xC0, 0x61,
  0x8E, 0x03, 0x0C, 0x70, 0x38, 0x63, 0x01, 0x83, 0xB8, 0x1C, 0x0F, 0xC0,
  0xE0, 0x7C, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x39, 0xC0, 0x38, 0xC0,
  0x38, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3F, 0x1E, 0x7F, 0x9E, 0x73, 0x9C, 0xF3, 0xDC, 0xE1, 0xDC,
  0xE0, 0xFC, 0xE0, 0xF8, 0xE0, 0x78, 0xF0, 0xF8, 0x7F, 0xFC, 0x7F, 0xDE,
  0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C,
  0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1E, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xC1, 0xC1, 0xC3,
  0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x00, 0x0E, 0x00,
  0xE0, 0x0E, 0x04, 0x66, 0xFF, 0xEF, 0xFF, 0x0F, 0x01, 0xF0, 0x3B, 0x87,
  0x9C, 0x31, 0x81, 0x10, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x3B, 0xDE, 0xE7, 0x39, 0x9C, 0xFF, 0xFF,
  0xF8, 0xEF, 0xFF, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x0F, 0x01, 0xFC, 0x3F, 0xC3, 0x9E, 0x70, 0xE7, 0x0F, 0x70, 0x77, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x77, 0x07, 0x70, 0xF7, 0x0E, 0x78, 0xE3, 0xFE, 0x3F, 0xC1, 0xF8,
  0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0xE7, 0x47, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x1F, 0x07, 0xFC, 0xFF, 0xE6, 0x1E, 0x40, 0xE0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x07, 0xFC, 0xFF, 0xE6, 0x1E, 0x40, 0xE0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x1F, 0xC1, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0x70, 0x3F, 0x81,
  0xBC, 0x1D, 0xE0, 0xCF, 0x0E, 0x78, 0x63, 0xC7, 0x1E, 0x38, 0xF3, 0x87,
  0x9C, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1D, 0x83, 0xFE, 0x7F, 0xE4, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF8, 0x3D, 0xFF, 0xBF, 0xE7, 0xF8,
  0x03, 0xE0, 0xFE, 0x1F, 0xE3, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x78, 0xEF, 0xEE, 0xFE, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x77, 0x07, 0x70, 0x77, 0x07, 0x78, 0xF3, 0xFE, 0x3F, 0xC0, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8F, 0x70, 0x77, 0x07, 0x70, 0x77, 0x0F,
  0x78, 0xE3, 0x9E, 0x1F, 0xC0, 0xF8, 0x1F, 0x83, 0xFE, 0x78, 0xE7, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x9F, 0x3F, 0xE1, 0xFC,
  0x0F, 0x03, 0xF8, 0x7F, 0xC7, 0x9E, 0x70, 0xEF, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0x0F, 0x79, 0xF7, 0xF7, 0x3F, 0x70, 0xC7,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC6, 0xFC, 0x7F, 0x87, 0xE0,
  0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x33, 0xDE, 0xF3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0x7B, 0x9C, 0xE6, 0x70, 0x00,
  0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x1E, 0x3F, 0xE7, 0xFD, 0x8F, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x81, 0xE0, 0x70, 0x00, 0xF8,
  0x00, 0x3F, 0xE0, 0x07, 0xCF, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xC3, 0x80,
  0x0C, 0x38, 0x00, 0xE3, 0x0F, 0xC6, 0x71, 0xFC, 0x67, 0x38, 0xC7, 0x63,
  0x8C, 0x76, 0x30, 0xC7, 0x63, 0x1C, 0x7E, 0x31, 0xC7, 0xE3, 0x1C, 0x76,
  0x31, 0xC6, 0x63, 0x1C, 0x66, 0x39, 0x4E, 0x61, 0xF7, 0xC7, 0x1E, 0x78,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x20, 0x0F, 0x9E,
  0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0x70,
  0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1E,
  0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x3F, 0xF9, 0xE3,
  0xEF, 0x07, 0x78, 0x3B, 0xC1, 0xDE, 0x0E, 0xF0, 0x77, 0x87, 0xBF, 0xF9,
  0xFF, 0x0F, 0xFE, 0x78, 0x7B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x0F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF0, 0x07, 0xC1, 0xFF,
  0x3F, 0xF3, 0xC2, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x13, 0xFF, 0x1F, 0xF0, 0xFE, 0xFC, 0x03, 0xFF,
  0x0F, 0xFE, 0x3C, 0xFC, 0xF0, 0xF3, 0xC1, 0xEF, 0x03, 0xBC, 0x0E, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xFF, 0x8F,
  0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0x86, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x77, 0x01,
  0xDE, 0x07, 0x78, 0x1C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x7E, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0xBE, 0xFE, 0xFC, 0x20, 0xF0, 0x3B,
  0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xE0,
  0xF7, 0x83, 0xDC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x38,
  0x3C, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0xF0, 0xF3, 0xC1,
  0xCF, 0x07, 0xBC, 0x0F, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0xC0,
  0x3F, 0xEE, 0x03, 0x7E, 0xE0, 0x77, 0xEE, 0x07, 0x7E, 0x60, 0x77, 0xE7,
  0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x0E, 0x7E, 0x38, 0xC7, 0xE3, 0x9C, 0x7E,
  0x39, 0xC7, 0xE1, 0x9C, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFB, 0x83, 0xF7,
  0x07, 0xE7, 0x0F, 0xCE, 0x1F, 0x9E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x39,
  0xF8, 0x73, 0xF0, 0x77, 0xE0, 0xEF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xC3, 0xE3, 0xC7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3B, 0xC0, 0x73, 0x81, 0xE7, 0x87, 0x87, 0xFF,
  0x07, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xFC, 0xFF, 0xEF, 0x3E, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x1E, 0xFF, 0xEF,
  0xFC, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xC7,
  0x83, 0xDE, 0x03, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3B, 0xC0, 0x73, 0x81, 0xE7, 0x87, 0x87, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0xFC, 0x07, 0xFE, 0x3F, 0xF9, 0xE7, 0xCF, 0x0F, 0x78, 0x3B, 0xC1,
  0xDE, 0x0E, 0xF0, 0x77, 0x87, 0xBC, 0x3D, 0xE7, 0xCF, 0xFC, 0x7F, 0xC3,
  0xCE, 0x1E, 0x78, 0xF1, 0xC7, 0x8E, 0x3C, 0x79, 0xE1, 0xCF, 0x0F, 0x78,
  0x3B, 0xC1, 0xFE, 0x07, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x8E, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0xC1, 0xEF,
  0xFC, 0xFF, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xEF, 0x03, 0xBC, 0x0E, 0x78, 0x79, 0xFF, 0xC3, 0xFF, 0x07,
  0xF0, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7B, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0x9E, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xF0, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x07, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B,
  0x80, 0x37, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0xE0, 0x1C,
  0x07, 0xE0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x70, 0x3C, 0x0E, 0x70, 0x3C,
  0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7E, 0x0E, 0x78, 0x7E, 0x1E, 0x38, 0x7E,
  0x1C, 0x38, 0x66, 0x1C, 0x38, 0x66, 0x1C, 0x38, 0xE7, 0x1C, 0x3C, 0xE7,
  0x3C, 0x1C, 0xE7, 0x38, 0x1C, 0xC3, 0x38, 0x1D, 0xC3, 0x38, 0x1D, 0xC3,
  0xB8, 0x1D, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x70, 0x39,
  0xC0, 0xE3, 0x87, 0x8E, 0x1C, 0x3C, 0x70, 0x73, 0x81, 0xCE, 0x03, 0xB8,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x1C, 0xE0, 0x73, 0x83, 0xCF, 0x0E, 0x1C, 0x38, 0x71, 0xE1,
  0xE7, 0x03, 0xBC, 0x0F, 0xE0, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x78,
  0x70, 0xE1, 0xC3, 0x8F, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xF8,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x01, 0xCE, 0x0E,
  0x38, 0x38, 0x61, 0xC1, 0xC7, 0x07, 0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0x70,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x1F, 0x8F, 0xF8,
  0xEF, 0x90, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0x3F, 0xEF, 0x9F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x7F, 0x9F, 0x7F, 0x67, 0xCC, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xCF,
  0xFE, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xFD, 0xEE, 0xFE, 0xE7, 0xC0,
  0x0F, 0xC7, 0xF3, 0xFD, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xF7, 0x3F, 0xC7, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xEF,
  0x3F, 0xF9, 0xFF, 0xDE, 0x3E, 0xE0, 0xF7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0xF7, 0x07, 0xBC, 0x7D, 0xF7,
  0xE7, 0xF7, 0x1F, 0x38, 0x0F, 0x83, 0xFC, 0x3D, 0xE7, 0x0E, 0x70, 0x77,
  0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x13, 0xCE, 0x3F, 0xE0, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xFC, 0xFF, 0x3F, 0xC3, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0x1F, 0x39, 0xFD, 0xCF, 0xEE, 0xF1, 0xF7, 0x07, 0xB8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x07,
  0xB8, 0x3D, 0xC3, 0xEF, 0xBF, 0x3F, 0xF8, 0xFB, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x39, 0x03, 0xCF, 0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xCF,
  0xFE, 0xF0, 0xEF, 0x0E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0,
  0x5F, 0xF4, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x71,
  0xC7, 0x08, 0x00, 0x07, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFE, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xE1,
  0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xF0, 0xEE, 0x0F, 0xF0, 0xFF,
  0x0F, 0x78, 0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE7,
  0x87, 0x9D, 0xF9, 0xFB, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF, 0x0F, 0x0F, 0xC1,
  0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83,
  0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07,
  0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1C, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x0E,
  0xF0, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0x0F, 0x81, 0xFF,
  0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x38, 0x3B, 0xC1, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0xF7, 0x07, 0x38, 0x39, 0xE1, 0xC7, 0xBC, 0x3F,
  0xE0, 0xFE, 0x00, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x0F, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07,
  0xF0, 0xFF, 0xDE, 0xEF, 0xEE, 0x7C, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0x39, 0xFD, 0xCF, 0xEE, 0xF1,
  0xF7, 0x07, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xF7, 0x07, 0xB8, 0x3D, 0xC3, 0xEF, 0xBF, 0x3F, 0xF8, 0xFB, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x1F, 0xEF, 0xFB, 0x82,
  0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0E, 0x03, 0xC0,
  0xF8, 0x3B, 0xFE, 0xFF, 0xBF, 0xC0, 0x18, 0x0C, 0x06, 0x03, 0x03, 0xF7,
  0xFB, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0xF1, 0xF8, 0xFC, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x7B, 0xFF, 0x7F, 0x67, 0xCC, 0xE0, 0x7F, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x07, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xCE,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x06, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x38, 0x00, 0xE0, 0x70, 0x77, 0x0F, 0x07, 0x70, 0xF8, 0x77, 0x0F, 0x87,
  0x70, 0xD8, 0xE7, 0x0D, 0x8E, 0x39, 0xD8, 0xE3, 0x9D, 0xCE, 0x39, 0x9C,
  0xE3, 0x99, 0xDC, 0x39, 0x8D, 0xC1, 0xF8, 0xDC, 0x1F, 0x8D, 0xC1, 0xF8,
  0xDC, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x70,
  0x77, 0x0F, 0x38, 0xE3, 0x8E, 0x1D, 0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xFC, 0x1D, 0xC3, 0xDC, 0x38, 0xE7, 0x8E, 0x70,
  0xFF, 0x07, 0xE0, 0x7F, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x70,
  0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x06,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x83,
  0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x83, 0xC3, 0xE1, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC3, 0xE3, 0xC1, 0xF0,
  0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03,
  0xC1, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x3E, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xE0, 0x3C, 0x1F,
  0x0F, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0xC3, 0xF0, 0xF0, 0x00, 0x38, 0x0F, 0xF8, 0xFF, 0xFF, 0x07, 0xE8,
  0x04, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 9, 9, 13, 2, -24 },
  { 24, 14, 24, 16, 1, -24 },
  { 66, 12, 27, 15, 1, -25 },
  { 107, 21, 24, 23, 1, -24 },
  { 170, 16, 24, 17, 1, -24 },
  { 218, 3, 9, 7, 2, -24 },
  { 222, 7, 29, 10, 2, -24 },
  { 248, 7, 29, 10, 1, -24 },
  { 274, 12, 12, 14, 1, -25 },
  { 292, 13, 15, 15, 1, -19 },
  { 317, 5, 8, 8, 1, -4 },
  { 322, 7, 3, 9, 1, -10 },
  { 325, 4, 4, 8, 2, -4 },
  { 327, 11, 24, 13, 1, -24 },
  { 360, 12, 24, 14, 1, -24 },
  { 396, 8, 24, 14, 2, -24 },
  { 420, 12, 24, 14, 1, -24 },
  { 456, 12, 24, 14, 1, -24 },
  { 492, 13, 24, 14, 1, -24 },
  { 531, 11, 24, 14, 2, -24 },
  { 564, 12, 24, 14, 1, -24 },
  { 600, 12, 24, 14, 1, -24 },
  { 636, 12, 24, 14, 1, -24 },
  { 672, 12, 24, 14, 1, -24 },
  { 708, 4, 18, 8, 2, -18 },
  { 717, 5, 22, 8, 1, -18 },
  { 731, 13, 15, 15, 1, -19 },
  { 756, 13, 9, 15, 1, -16 },
  { 771, 13, 15, 15, 1, -19 },
  { 796, 10, 24, 11, 0, -24 },
  { 826, 20, 27, 22, 1, -24 },
  { 894, 16, 24, 16, 0, -24 },
  { 942, 13, 24, 16, 2, -24 },
  { 981, 12, 24, 15, 2, -24 },
  { 1017, 14, 24, 17, 2, -24 },
  { 1059, 10, 24, 14, 2, -24 },
  { 1089, 10, 24, 13, 2, -24 },
  { 1119, 14, 24, 18, 2, -24 },
  { 1161, 14, 24, 18, 2, -24 },
  { 1203, 8, 24, 10, 1, -24 },
  { 1227, 8, 31, 8, -2, -24 },
  { 1258, 14, 24, 15, 2, -24 },
  { 1300, 10, 24, 13, 2, -24 },
  { 1330, 20, 24, 24, 2, -24 },
  { 1390, 15, 24, 19, 2, -24 },
  { 1435, 15, 24, 19, 2, -24 },
  { 1480, 12, 24, 15, 2, -24 },
  { 1516, 15, 30, 19, 2, -24 },
  { 1573, 13, 24, 16, 2, -24 },
  { 1612, 12, 24, 14, 1, -24 },
  { 1648, 13, 24, 13, 0, -24 },
  { 1687, 14, 24, 18, 2, -24 },
  { 1729, 15, 24, 15, 0, -24 },
  { 1774, 24, 24, 24, 0, -24 },
  { 1846, 14, 24, 14, 0, -24 },
  { 1888, 14, 24, 14, 0, -24 },
  { 1930, 11, 24, 12, 1, -24 },
  { 1963, 7, 29, 10, 2, -24 },
  { 1989, 12, 24, 13, 0, -24 },
  { 2025, 7, 29, 10, 1, -24 },
  { 2051, 14, 14, 15, 1, -24 },
  { 2076, 14, 2, 14, 0, 3 },
  { 2080, 7, 5, 9, 1, -25 },
  { 2085, 11, 18, 14, 1, -18 },
  { 2110, 12, 25, 16, 2, -25 },
  { 2148, 10, 18, 12, 1, -18 },
  { 2171, 13, 25, 16, 1, -25 },
  { 2212, 12, 18, 14, 1, -18 },
  { 2239, 10, 25, 9, 0, -25 },
  { 2271, 13, 26, 16, 1, -18 },
  { 2314, 12, 25, 15, 2, -25 },
  { 2352, 3, 25, 7, 2, -25 },
  { 2362, 6, 33, 7, -1, -25 },
  { 2387, 12, 25, 14, 2, -25 },
  { 2425, 3, 25, 7, 2, -25 },
  { 2435, 19, 18, 23, 2, -18 },
  { 2478, 12, 18, 15, 2, -18 },
  { 2505, 13, 18, 15, 1, -18 },
  { 2535, 12, 26, 16, 2, -18 },
  { 2574, 13, 26, 16, 1, -18 },
  { 2617, 8, 18, 10, 2, -18 },
  { 2635, 10, 18, 12, 1, -18 },
  { 2658, 9, 22, 9, 0, -22 },
  { 2683, 11, 18, 15, 2, -18 },
  { 2708, 13, 18, 13, 0, -18 },
  { 2738, 20, 18, 21, 0, -18 },
  { 2783, 12, 18, 13, 0, -18 },
  { 2810, 13, 26, 13, 0, -18 },
  { 2853, 9, 18, 11, 1, -18 },
  { 2874, 9, 29, 12, 1, -24 },
  { 2907, 3, 33, 14, 5, -25 },
  { 2920, 10, 29, 12, 1, -24 },
  { 2957, 13, 5, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Medium33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM33PT7B_H_
