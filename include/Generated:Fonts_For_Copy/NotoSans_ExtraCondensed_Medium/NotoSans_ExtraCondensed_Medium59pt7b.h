#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xE3, 0xC7, 0x8F, 0x00, 0x00, 0x00, 0x00, 0xC7, 0xEF, 0xDF, 0xFF, 0xFF,
  0xFD, 0xF8, 0x40, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7,
  0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x07,
  0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xF3, 0xE0, 0x79, 0xF0, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC1, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xF8,
  0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF3, 0x87, 0x1F, 0x8E,
  0x04, 0x7C, 0x38, 0x01, 0xF0, 0xE0, 0x0F, 0xC3, 0x80, 0x3F, 0x0E, 0x00,
  0x7C, 0x38, 0x01, 0xF0, 0xE0, 0x07, 0xE3, 0x80, 0x1F, 0xEE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0E, 0xFE, 0x00, 0x39, 0xF8,
  0x00, 0xE3, 0xE0, 0x03, 0x8F, 0x80, 0x0E, 0x3F, 0x00, 0x38, 0xFC, 0x00,
  0xE3, 0xE0, 0x03, 0x8F, 0xB0, 0x0E, 0x7E, 0xF8, 0x3B, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0x80, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x03, 0xC0, 0x03, 0xEF,
  0x80, 0x1E, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x01, 0xE1, 0xF0, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x3C, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x1E, 0x00, 0x0F,
  0x83, 0xE0, 0xF0, 0x00, 0x7C, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x78,
  0x00, 0x1F, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x07, 0xC1,
  0xF1, 0xE0, 0xF8, 0x1E, 0x0F, 0x1F, 0x0F, 0xE0, 0xF0, 0x78, 0xF8, 0xFF,
  0x87, 0x83, 0xC7, 0x8F, 0xFE, 0x3E, 0x3E, 0x7C, 0x7D, 0xF0, 0xFB, 0xE3,
  0xE7, 0xC7, 0xC7, 0xFF, 0x1E, 0x3C, 0x1E, 0x1F, 0xF1, 0xF1, 0xE0, 0xF0,
  0x7F, 0x0F, 0x0F, 0x07, 0xC0, 0xE0, 0x78, 0xF8, 0x3E, 0x00, 0x07, 0xC7,
  0xC1, 0xF0, 0x00, 0x3C, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x7C, 0x00,
  0x1F, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x3E, 0x00, 0x3E,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x3C, 0x00,
  0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x0F,
  0xC3, 0xFF, 0xE0, 0xFC, 0x3F, 0x7E, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E,
  0x3F, 0x0F, 0x8F, 0xC1, 0xF8, 0xF8, 0xFC, 0x0F, 0xDF, 0x8F, 0xC0, 0xFD,
  0xF8, 0xF8, 0x07, 0xFF, 0x0F, 0x80, 0x3F, 0xF0, 0xF8, 0x03, 0xFE, 0x0F,
  0xC0, 0x1F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE, 0x03,
  0xFE, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFD, 0xF8,
  0x3F, 0xFF, 0x9F, 0xC1, 0xFF, 0xF0, 0xFE, 0x0F, 0xFC, 0x07, 0xF0, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x70, 0xF0, 0x67, 0xEF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0xF9,
  0xF0, 0x1F, 0x8F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xC0, 0xE0, 0x70, 0x02,
  0x02, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x7E,
  0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x7E, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x83, 0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8,
  0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x8F, 0xDF, 0x3F, 0x3F, 0xFE, 0x7D, 0xF0, 0xF9, 0xC1, 0xF1, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xDF, 0xF1, 0xF0, 0x1F,
  0xC6, 0x00, 0x7E, 0x10, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0x8F, 0xF0, 0xE0, 0x1F, 0xC6, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x70, 0x07, 0xFB, 0xF9, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x05, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7B,
  0xF0, 0x00, 0x7B, 0xF0, 0x00, 0xF3, 0xF0, 0x00, 0xF3, 0xF0, 0x01, 0xF3,
  0xF0, 0x01, 0xE3, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xC3, 0xF0, 0x07, 0xC3,
  0xF0, 0x07, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x03, 0xF0, 0x1F, 0x03,
  0xF0, 0x1E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC2, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE8, 0x00, 0xFE, 0xE0, 0x1F, 0xEF, 0xEF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x05, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xF1, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x01,
  0xF1, 0xFE, 0x07, 0xDF, 0xFC, 0x1F, 0x7F, 0xF8, 0xFF, 0xFF, 0xF3, 0xFE,
  0x1F, 0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07,
  0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7,
  0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE3, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7F, 0x3F, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xEF, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0,
  0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x83, 0xFD, 0xFE, 0x3F, 0xE7,
  0xFF, 0xDF, 0x1F, 0xFE, 0xF8, 0xFF, 0xE7, 0xC3, 0xFE, 0x3E, 0x03, 0xC3,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0xE7, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF, 0xFF,
  0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0x7E, 0xFF, 0xFF,
  0xFF, 0x7E, 0x7E, 0x18, 0x1E, 0x1F, 0x8F, 0xCF, 0xF7, 0xF9, 0xF8, 0xFC,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE7, 0xF3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3, 0xF7,
  0xFD, 0xC0, 0x7E, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x3C, 0x3E, 0x01, 0xFE, 0x0F, 0x8F, 0x01, 0xFF, 0xC1, 0xE7, 0xC0, 0xFF,
  0xF0, 0x79, 0xF0, 0x7F, 0xFC, 0x1F, 0x78, 0x1F, 0x0F, 0x07, 0xFE, 0x0F,
  0x83, 0xC1, 0xFF, 0x83, 0xE0, 0xF0, 0x3F, 0xE0, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7C, 0x1F, 0x03, 0xFC, 0x1F, 0x07, 0xC0, 0xFF, 0x07, 0xC1, 0xF0, 0x3F,
  0xC1, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x1F, 0x03, 0xFC, 0x1F, 0x07, 0xC0,
  0xFF, 0x07, 0xC1, 0xF0, 0x7F, 0xC1, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F,
  0x07, 0xBC, 0x1F, 0x07, 0xC1, 0xEF, 0x07, 0xC3, 0xF0, 0xFB, 0xE0, 0xF8,
  0xFC, 0x3C, 0xF8, 0x3F, 0xF7, 0xFF, 0x3E, 0x07, 0xFC, 0xFF, 0x87, 0x81,
  0xFE, 0x3F, 0xE1, 0xF0, 0x1F, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C,
  0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC,
  0x03, 0xF1, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0x07, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x01,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x7F, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xBF, 0x07, 0xF8, 0x06, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFE, 0x03, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFC, 0x0F, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x1F, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0xE0, 0xFF, 0x00, 0x70,
  0x7F, 0x80, 0x04, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xC3, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0xFF, 0xF7, 0xFF,
  0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x1E, 0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xFC,
  0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFB,
  0xE0, 0x00, 0xFB, 0xFF, 0x7C, 0x00, 0x1F, 0x7F, 0xFF, 0x80, 0x03, 0xEF,
  0xFE, 0xF8, 0x00, 0x7D, 0xFF, 0xDF, 0x00, 0x1F, 0x3F, 0xFB, 0xE0, 0x03,
  0xE7, 0xFF, 0x7C, 0x00, 0x7C, 0xFF, 0xE7, 0xC0, 0x0F, 0x3F, 0xFC, 0xF8,
  0x03, 0xE7, 0xFF, 0x9F, 0x00, 0x7C, 0xFF, 0xF1, 0xF0, 0x0F, 0x9F, 0xFE,
  0x3E, 0x03, 0xE3, 0xFF, 0xC7, 0xC0, 0x7C, 0x7F, 0xF8, 0xF8, 0x0F, 0x8F,
  0xFF, 0x0F, 0x81, 0xE1, 0xFF, 0xE1, 0xF0, 0x7C, 0x3F, 0xFC, 0x3E, 0x0F,
  0x87, 0xFF, 0x87, 0xE1, 0xF0, 0xFF, 0xF0, 0x7C, 0x7C, 0x1F, 0xFE, 0x0F,
  0x8F, 0x83, 0xFF, 0xC1, 0xF1, 0xF0, 0x7F, 0xF8, 0x1F, 0x3C, 0x0F, 0xFF,
  0x03, 0xEF, 0x81, 0xFF, 0xE0, 0x7D, 0xF0, 0x3F, 0xFC, 0x0F, 0xBE, 0x07,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC, 0x01, 0xF0, 0x07, 0xFF,
  0x80, 0x3E, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFE, 0xF8, 0x01,
  0xFF, 0xBF, 0x00, 0x7F, 0xF7, 0xC0, 0x1F, 0xFD, 0xF8, 0x07, 0xFF, 0x7E,
  0x01, 0xFF, 0xCF, 0x80, 0x7F, 0xF3, 0xF0, 0x1F, 0xFC, 0x7C, 0x07, 0xFF,
  0x1F, 0x81, 0xFF, 0xC3, 0xE0, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F, 0x07,
  0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF8, 0x7F, 0xF0, 0x3E, 0x1F, 0xFC, 0x0F,
  0xC7, 0xFF, 0x03, 0xF1, 0xFF, 0xC0, 0x7E, 0x7F, 0xF0, 0x1F, 0x9F, 0xFC,
  0x03, 0xE7, 0xFF, 0x00, 0xFD, 0xFF, 0xC0, 0x1F, 0x7F, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xCF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC1, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7,
  0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0xC0,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xF0, 0xFC, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0x81, 0xE7, 0xF0, 0x02, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x81, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFD,
  0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x8F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0x3E, 0x00,
  0x7F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x78, 0x03, 0xF0, 0xFC, 0x01, 0xEF,
  0x00, 0x7E, 0x1F, 0x80, 0x7D, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xBE, 0x01,
  0xF0, 0x3E, 0x01, 0xF7, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0x9F, 0x01, 0xF8, 0x1F, 0x81, 0xF1, 0xE0, 0x3F, 0x01, 0xF0,
  0x3E, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0x07, 0xE0, 0xF8,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0x1F, 0x87, 0xC1, 0xE0,
  0xFC, 0x01, 0xF0, 0xF8, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x07, 0xC7, 0xE0,
  0x07, 0xE3, 0xE0, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x1F, 0x1F, 0x80, 0x1F,
  0x9F, 0x01, 0xE3, 0xF0, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x00, 0xF9, 0xF0, 0x1F,
  0x7E, 0x00, 0x1F, 0xBC, 0x01, 0xEF, 0xC0, 0x01, 0xF7, 0x80, 0x3D, 0xF0,
  0x00, 0x3F, 0xF0, 0x07, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F,
  0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80,
  0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0x7C,
  0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0x0F, 0xE0,
  0x80, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xF7, 0xE1, 0xFF, 0x7F, 0xFD, 0xF3,
  0xFF, 0x9F, 0x3F, 0xF9, 0xF1, 0xFE, 0x1F, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE1, 0xFC,
  0x0F, 0x9F, 0xF8, 0x3E, 0x7F, 0xF0, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xF0, 0x7F, 0x3F, 0x80, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x3F, 0x3F, 0xC0, 0xFC,
  0xFF, 0x8F, 0xF3, 0xEF, 0xFF, 0x8F, 0xBF, 0xFC, 0x3E, 0x7F, 0xF0, 0xF0,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0x23, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x04, 0x7F, 0x9F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xE1, 0xF0, 0x7F,
  0xE7, 0xC3, 0xFF, 0x9F, 0x1F, 0xFF, 0x7C, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F,
  0xCF, 0xC0, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0xC7,
  0xFC, 0x7F, 0xFD, 0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0x9F, 0x03, 0xFC, 0x3C,
  0x01, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E,
  0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x0C, 0x3F, 0xC1, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x03, 0xF8, 0x7C, 0x1F, 0xF9, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F,
  0xFF, 0xFC, 0xFE, 0x0F, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF3,
  0xF0, 0x3F, 0xCF, 0xF1, 0xFF, 0x1F, 0xFF, 0x7C, 0x7F, 0xF9, 0xF0, 0xFF,
  0xE7, 0xC0, 0xFF, 0x1F, 0x00, 0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x88,
  0x00, 0x7E, 0x38, 0x07, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFB,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF0,
  0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE0, 0x03, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x3F, 0x07, 0xE0, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF, 0x1F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x07,
  0xE1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F,
  0x1F, 0x80, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFE, 0x01, 0xF7, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFD, 0xF0, 0x1F, 0xCF, 0xC0, 0xFC,
  0x3E, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8,
  0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xC0,
  0x3F, 0x3E, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0xFF, 0x03, 0xFC, 0x3C, 0x7F, 0xE1, 0xFF, 0x8F,
  0xBF, 0xFC, 0xFF, 0xF3, 0xEF, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xC3, 0xFF, 0x07, 0xEF, 0xE0, 0x7F, 0x81, 0xFB, 0xF0, 0x1F, 0xC0,
  0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xF0, 0x0F, 0xFE, 0x00,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xF8,
  0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFF,
  0xE0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xF0,
  0x0F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0xF8, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xF0, 0xFF, 0x0F, 0x1F, 0xF8,
  0xFB, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF3, 0xE0,
  0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x3E, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x3F, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0xF0, 0x7F, 0x03, 0xC7, 0xFE, 0x0F, 0x9F, 0xFC, 0x3E, 0xFF,
  0xF8, 0xFF, 0xDF, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF8,
  0x0F, 0xCF, 0xF0, 0x3F, 0x3F, 0xF3, 0xFC, 0xFB, 0xFF, 0xE3, 0xEF, 0xFF,
  0x0F, 0x9F, 0xFC, 0x3E, 0x1F, 0xC0, 0xF8, 0x0C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x7C,
  0x1F, 0xF9, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xFF, 0xFC, 0xFE,
  0x0F, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0xCF,
  0xF3, 0xFF, 0x1F, 0xFF, 0x7C, 0x7F, 0xFD, 0xF0, 0xFF, 0xE7, 0xC0, 0xFE,
  0x1F, 0x00, 0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0xF0, 0x7F, 0xC7, 0xFF, 0x1F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xFF, 0xBF, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE7, 0xF1, 0xF7, 0xE0,
  0x13, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xDF, 0x9F, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE1, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0xB8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0x20, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFD, 0xF7, 0xFF, 0xDF, 0x3F, 0xF9, 0xF1, 0xFE, 0x1F, 0x01, 0x80,
  0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF,
  0x80, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFB, 0xE0, 0x0F, 0xE0, 0x0F, 0x9F, 0x80, 0x7F, 0x00, 0x7C, 0xFC,
  0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xE0, 0x3F, 0x1F, 0x01, 0xFF, 0x01,
  0xF0, 0xF8, 0x0F, 0x78, 0x0F, 0x87, 0xE0, 0x7B, 0xC0, 0xFC, 0x3F, 0x03,
  0xDE, 0x07, 0xE1, 0xF8, 0x3E, 0xF0, 0x3E, 0x07, 0xC1, 0xF7, 0xC1, 0xF0,
  0x3E, 0x0F, 0xBE, 0x0F, 0x81, 0xF8, 0x78, 0xF0, 0xFC, 0x0F, 0xC3, 0xC7,
  0x87, 0xE0, 0x3E, 0x1E, 0x3C, 0x3E, 0x01, 0xF1, 0xF1, 0xF1, 0xF0, 0x0F,
  0x8F, 0x8F, 0x8F, 0x80, 0x7E, 0x78, 0x7C, 0xFC, 0x03, 0xF3, 0xC1, 0xE7,
  0xC0, 0x0F, 0x9E, 0x0F, 0x3E, 0x00, 0x7D, 0xF0, 0x79, 0xF0, 0x03, 0xEF,
  0x83, 0xEF, 0x80, 0x1F, 0x7C, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0x7C, 0x07, 0xC3,
  0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0x8F,
  0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0xC0, 0x3E,
  0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8,
  0x7C, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC,
  0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x80,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x07,
  0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0x05, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0xA0, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Medium59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 43, 14, 4, -42 },
  { 39, 17, 15, 23, 3, -42 },
  { 71, 26, 42, 28, 1, -42 },
  { 208, 22, 48, 26, 2, -45 },
  { 340, 37, 44, 41, 2, -43 },
  { 544, 28, 44, 30, 2, -43 },
  { 698, 7, 15, 13, 3, -42 },
  { 712, 13, 51, 18, 3, -42 },
  { 795, 14, 51, 18, 1, -42 },
  { 885, 20, 21, 24, 2, -45 },
  { 938, 22, 28, 26, 2, -35 },
  { 1015, 9, 15, 14, 2, -7 },
  { 1032, 13, 6, 17, 2, -19 },
  { 1042, 8, 9, 14, 3, -8 },
  { 1051, 21, 42, 22, 1, -42 },
  { 1162, 22, 44, 26, 2, -43 },
  { 1283, 15, 42, 26, 3, -42 },
  { 1362, 21, 43, 26, 2, -43 },
  { 1475, 21, 44, 26, 2, -43 },
  { 1591, 24, 42, 26, 1, -42 },
  { 1717, 20, 43, 26, 3, -42 },
  { 1825, 22, 44, 26, 2, -43 },
  { 1946, 22, 42, 26, 2, -42 },
  { 2062, 22, 44, 26, 2, -43 },
  { 2183, 21, 44, 26, 2, -43 },
  { 2299, 8, 33, 14, 3, -32 },
  { 2332, 9, 40, 14, 2, -32 },
  { 2377, 22, 26, 26, 2, -34 },
  { 2449, 22, 17, 26, 2, -29 },
  { 2496, 22, 26, 26, 2, -34 },
  { 2568, 17, 44, 20, 1, -43 },
  { 2662, 34, 48, 40, 3, -43 },
  { 2866, 28, 42, 28, 0, -42 },
  { 3013, 23, 42, 29, 4, -42 },
  { 3134, 23, 44, 27, 3, -43 },
  { 3261, 24, 42, 31, 4, -42 },
  { 3387, 18, 42, 24, 4, -42 },
  { 3482, 18, 42, 23, 4, -42 },
  { 3577, 26, 44, 32, 3, -43 },
  { 3720, 24, 42, 32, 4, -42 },
  { 3846, 13, 42, 17, 2, -42 },
  { 3915, 13, 54, 14, -3, -42 },
  { 4003, 24, 42, 28, 4, -42 },
  { 4129, 18, 42, 22, 4, -42 },
  { 4224, 35, 42, 43, 4, -42 },
  { 4408, 26, 42, 35, 4, -42 },
  { 4545, 27, 44, 33, 3, -43 },
  { 4694, 21, 42, 27, 4, -42 },
  { 4805, 27, 53, 33, 3, -43 },
  { 4984, 24, 42, 28, 4, -42 },
  { 5110, 20, 44, 25, 2, -43 },
  { 5220, 22, 42, 23, 1, -42 },
  { 5336, 24, 43, 32, 4, -42 },
  { 5465, 27, 42, 27, 0, -42 },
  { 5607, 43, 42, 43, 0, -42 },
  { 5833, 25, 42, 25, 0, -42 },
  { 5965, 25, 42, 25, 0, -42 },
  { 6097, 20, 42, 22, 1, -42 },
  { 6202, 13, 51, 18, 4, -42 },
  { 6285, 21, 42, 22, 1, -42 },
  { 6396, 12, 51, 18, 2, -42 },
  { 6473, 26, 23, 28, 1, -42 },
  { 6548, 25, 4, 25, 0, 5 },
  { 6561, 12, 9, 16, 2, -45 },
  { 6575, 20, 33, 25, 2, -32 },
  { 6658, 22, 46, 28, 4, -45 },
  { 6785, 18, 33, 21, 2, -32 },
  { 6860, 22, 46, 28, 2, -45 },
  { 6987, 21, 33, 25, 2, -32 },
  { 7074, 16, 45, 16, 1, -45 },
  { 7164, 22, 46, 28, 2, -32 },
  { 7291, 20, 45, 28, 4, -45 },
  { 7404, 7, 44, 13, 3, -44 },
  { 7443, 11, 58, 13, -1, -44 },
  { 7523, 21, 45, 25, 4, -45 },
  { 7642, 5, 45, 13, 4, -45 },
  { 7671, 34, 32, 41, 4, -32 },
  { 7807, 20, 32, 28, 4, -32 },
  { 7887, 23, 33, 27, 2, -32 },
  { 7982, 22, 46, 28, 4, -32 },
  { 8109, 22, 46, 28, 2, -32 },
  { 8236, 14, 32, 19, 4, -32 },
  { 8292, 17, 33, 21, 2, -32 },
  { 8363, 15, 40, 17, 1, -39 },
  { 8438, 20, 33, 28, 4, -32 },
  { 8521, 23, 32, 23, 0, -32 },
  { 8613, 37, 32, 37, 0, -32 },
  { 8761, 21, 32, 23, 1, -32 },
  { 8845, 23, 46, 23, 0, -32 },
  { 8978, 17, 32, 19, 1, -32 },
  { 9046, 17, 51, 21, 2, -42 },
  { 9155, 5, 59, 24, 10, -45 },
  { 9192, 17, 51, 21, 2, -42 },
  { 9301, 22, 8, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Medium59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM59PT7B_H_
