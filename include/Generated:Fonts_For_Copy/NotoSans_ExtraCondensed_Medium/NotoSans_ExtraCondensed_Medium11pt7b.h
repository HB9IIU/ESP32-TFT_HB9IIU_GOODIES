#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x31, 0xBE, 0xA5, 0x7D, 0x4A, 0x27, 0xA6, 0x33,
  0xF2, 0x20, 0x65, 0x52, 0xA5, 0x77, 0x63, 0x4A, 0x93, 0x61, 0x45, 0x18,
  0x6A, 0x69, 0x9F, 0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x12, 0x4A, 0x50, 0x2F,
  0x76, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0, 0x80, 0x11, 0x22, 0x44, 0x48,
  0x75, 0x5D, 0xDD, 0x57, 0x7D, 0x55, 0x79, 0x11, 0x22, 0x4F, 0x79, 0x17,
  0x31, 0x1F, 0x11, 0x8C, 0xA5, 0x7C, 0x42, 0xF2, 0x72, 0x4F, 0x34, 0x4B,
  0xDD, 0x57, 0xF1, 0x11, 0x22, 0x24, 0x75, 0x57, 0x79, 0x97, 0x65, 0x9D,
  0x71, 0x16, 0xC4, 0x50, 0x1C, 0x1B, 0x30, 0x60, 0x80, 0xF8, 0x3E, 0xC1,
  0x8E, 0x88, 0x00, 0xE4, 0x94, 0x82, 0x38, 0x89, 0x6B, 0x5A, 0xB5, 0x55,
  0x20, 0x38, 0x21, 0x94, 0xA5, 0x3F, 0x31, 0xE9, 0x9E, 0xB9, 0x9E, 0x78,
  0x88, 0x88, 0x87, 0xEB, 0x99, 0x99, 0x9E, 0xF2, 0x79, 0x27, 0xF2, 0x4F,
  0x24, 0x78, 0x88, 0xB9, 0x97, 0x99, 0x9F, 0x99, 0x99, 0xE9, 0x24, 0x97,
  0x24, 0x92, 0x49, 0x3C, 0x9A, 0xAC, 0xEA, 0xA9, 0x92, 0x49, 0x27, 0x87,
  0x3C, 0xF3, 0xB6, 0xDB, 0x6D, 0x8E, 0x73, 0xDA, 0xD6, 0x73, 0x74, 0xA7,
  0x18, 0xCE, 0x4E, 0xEB, 0x9B, 0xE8, 0x88, 0x74, 0xA7, 0x18, 0xCE, 0x4E,
  0x30, 0x80, 0xEB, 0x9B, 0xEA, 0xA9, 0x74, 0xC6, 0x31, 0x1F, 0xF2, 0x22,
  0x22, 0x22, 0x99, 0x99, 0x99, 0x9F, 0x8C, 0x54, 0xA5, 0x28, 0xC4, 0x99,
  0x99, 0xDB, 0x5A, 0x5A, 0x66, 0x66, 0x66, 0xD2, 0x94, 0x42, 0x29, 0x53,
  0x9E, 0x94, 0xC2, 0x10, 0x84, 0xF1, 0x22, 0x44, 0x4F, 0xEA, 0xAA, 0xB0,
  0x84, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0x3C, 0x21, 0x94, 0xA8, 0x80,
  0xF8, 0xE0, 0x71, 0x3D, 0x97, 0x88, 0xE9, 0x99, 0x9E, 0x74, 0xCC, 0x47,
  0x18, 0xDE, 0xBD, 0xED, 0x6D, 0x75, 0xF8, 0x47, 0x6B, 0xA4, 0x92, 0x6A,
  0xF7, 0xB5, 0xBC, 0x72, 0x60, 0x88, 0xEA, 0xBB, 0xBB, 0xBF, 0x45, 0x55,
  0x58, 0x88, 0xBA, 0xCE, 0xAB, 0xFF, 0xEE, 0xDA, 0x69, 0xA6, 0x90, 0xEA,
  0xBB, 0xBB, 0x72, 0xB3, 0x95, 0x38, 0xE9, 0x99, 0x9E, 0x88, 0x80, 0x6A,
  0xF7, 0xB5, 0xB4, 0x63, 0x18, 0xEA, 0xA0, 0x68, 0x42, 0x3E, 0x5D, 0x24,
  0x98, 0xB6, 0xDB, 0xC0, 0x99, 0x56, 0x66, 0x93, 0x69, 0xB3, 0x66, 0xCD,
  0x80, 0x96, 0x66, 0x69, 0x99, 0x56, 0x62, 0x24, 0x80, 0xE5, 0xA5, 0xC0,
  0x2D, 0x2C, 0x92, 0x64, 0xFF, 0xE0, 0xC4, 0x44, 0x32, 0x44, 0x4C, 0x4D,
  0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 1, -8 },
  { 4, 5, 8, 5, 0, -8 },
  { 9, 4, 9, 5, 0, -8 },
  { 14, 7, 8, 8, 0, -8 },
  { 21, 6, 8, 6, 0, -8 },
  { 27, 1, 3, 2, 1, -8 },
  { 28, 2, 10, 3, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 4, 4, 5, 0, -8 },
  { 37, 5, 5, 5, 0, -6 },
  { 41, 2, 2, 3, 0, -1 },
  { 42, 3, 1, 3, 0, -3 },
  { 43, 1, 1, 3, 1, -1 },
  { 44, 4, 8, 4, 0, -8 },
  { 48, 4, 8, 5, 0, -8 },
  { 52, 2, 8, 5, 1, -8 },
  { 54, 4, 8, 5, 0, -8 },
  { 58, 4, 8, 5, 0, -8 },
  { 62, 5, 8, 5, 0, -8 },
  { 67, 3, 8, 5, 1, -8 },
  { 70, 4, 8, 5, 0, -8 },
  { 74, 4, 8, 5, 0, -8 },
  { 78, 4, 8, 5, 0, -8 },
  { 82, 4, 8, 5, 0, -8 },
  { 86, 1, 6, 3, 1, -6 },
  { 87, 2, 7, 3, 0, -6 },
  { 89, 5, 5, 5, 0, -6 },
  { 93, 5, 3, 5, 0, -5 },
  { 95, 5, 5, 5, 0, -6 },
  { 99, 3, 8, 4, 0, -8 },
  { 102, 7, 9, 7, 0, -8 },
  { 110, 5, 8, 5, 0, -8 },
  { 115, 4, 8, 5, 1, -8 },
  { 119, 4, 8, 5, 1, -8 },
  { 123, 4, 8, 6, 1, -8 },
  { 127, 3, 8, 5, 1, -8 },
  { 130, 3, 8, 4, 1, -8 },
  { 133, 4, 8, 6, 1, -8 },
  { 137, 4, 8, 6, 1, -8 },
  { 141, 3, 8, 3, 0, -8 },
  { 144, 3, 10, 3, -1, -8 },
  { 148, 4, 8, 5, 1, -8 },
  { 152, 3, 8, 4, 1, -8 },
  { 155, 6, 8, 8, 1, -8 },
  { 161, 5, 8, 6, 1, -8 },
  { 166, 5, 8, 6, 1, -8 },
  { 171, 4, 8, 5, 1, -8 },
  { 175, 5, 10, 6, 1, -8 },
  { 182, 4, 8, 5, 1, -8 },
  { 186, 4, 8, 5, 0, -8 },
  { 190, 4, 8, 4, 0, -8 },
  { 194, 4, 8, 6, 1, -8 },
  { 198, 5, 8, 5, 0, -8 },
  { 203, 8, 8, 8, 0, -8 },
  { 211, 5, 8, 5, 0, -8 },
  { 216, 5, 8, 5, 0, -8 },
  { 221, 4, 8, 4, 0, -8 },
  { 225, 2, 10, 3, 1, -8 },
  { 228, 4, 8, 4, 0, -8 },
  { 232, 3, 10, 3, 0, -8 },
  { 236, 5, 5, 5, 0, -8 },
  { 240, 5, 1, 5, 0, 1 },
  { 241, 3, 1, 3, 0, -8 },
  { 242, 4, 6, 5, 0, -6 },
  { 245, 4, 8, 5, 1, -8 },
  { 249, 4, 6, 4, 0, -6 },
  { 252, 5, 8, 5, 0, -8 },
  { 257, 4, 6, 5, 0, -6 },
  { 260, 3, 8, 3, 0, -8 },
  { 263, 5, 9, 5, 0, -6 },
  { 269, 4, 8, 5, 1, -8 },
  { 273, 1, 8, 2, 1, -8 },
  { 274, 2, 11, 2, 0, -8 },
  { 277, 4, 8, 5, 1, -8 },
  { 281, 1, 8, 2, 1, -8 },
  { 282, 6, 6, 8, 1, -6 },
  { 287, 4, 6, 5, 1, -6 },
  { 290, 5, 6, 5, 0, -6 },
  { 294, 4, 9, 5, 1, -6 },
  { 299, 5, 9, 5, 0, -6 },
  { 305, 2, 6, 3, 1, -6 },
  { 307, 4, 6, 4, 0, -6 },
  { 310, 3, 7, 3, 0, -7 },
  { 313, 3, 6, 5, 1, -6 },
  { 316, 4, 6, 4, 0, -6 },
  { 319, 7, 6, 7, 0, -6 },
  { 325, 4, 6, 4, 0, -6 },
  { 328, 4, 9, 4, 0, -6 },
  { 333, 3, 6, 4, 0, -6 },
  { 336, 3, 10, 4, 0, -8 },
  { 340, 1, 11, 5, 2, -8 },
  { 342, 4, 10, 4, 0, -8 },
  { 347, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Medium11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM11PT7B_H_
