#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium42pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF8, 0xF8, 0xFF, 0x8F, 0xF8,
  0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x07, 0x70,
  0x70, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFC, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x87, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1E, 0x01,
  0xC7, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x01, 0xFF, 0x87, 0xFF, 0x9F, 0xFF, 0x7D, 0x8C,
  0xF3, 0x01, 0xE6, 0x03, 0x8C, 0x07, 0x98, 0x0F, 0x30, 0x1F, 0x60, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1B, 0xE0, 0x33,
  0xC0, 0x63, 0xC0, 0xC7, 0x81, 0x8F, 0x03, 0x1F, 0x86, 0x7B, 0xEF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x03, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x3E, 0x00, 0xF0, 0x1F, 0xC0, 0x38, 0x07, 0xF8, 0x1E, 0x03, 0x8E,
  0x07, 0x00, 0xE3, 0xC1, 0xC0, 0x38, 0xF0, 0xF0, 0x0E, 0x1C, 0x38, 0x03,
  0x87, 0x0E, 0x00, 0xE1, 0xC7, 0x80, 0x38, 0x71, 0xC0, 0x0E, 0x1C, 0x70,
  0x03, 0x87, 0x38, 0x00, 0xE3, 0xCE, 0x3E, 0x38, 0xE3, 0x9F, 0xCE, 0x39,
  0xCF, 0x79, 0xFE, 0x73, 0x8E, 0x7F, 0x3C, 0xE3, 0x8F, 0x8E, 0x78, 0xE0,
  0x03, 0x9E, 0x3C, 0x01, 0xE7, 0x8F, 0x00, 0x71, 0xE3, 0xC0, 0x1C, 0x78,
  0xF0, 0x0E, 0x1E, 0x3C, 0x03, 0x87, 0x8F, 0x00, 0xE0, 0xE3, 0x80, 0x70,
  0x38, 0xE0, 0x1C, 0x0E, 0x38, 0x0F, 0x03, 0xFE, 0x03, 0x80, 0x7F, 0x00,
  0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xE7,
  0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x1E, 0x3F, 0xE1, 0xE7, 0xDF, 0x1E,
  0x78, 0xF3, 0xCF, 0x87, 0xBC, 0xF0, 0x7F, 0xCF, 0x03, 0xFC, 0xF0, 0x1F,
  0x8F, 0x01, 0xF8, 0xF8, 0x1F, 0x07, 0x83, 0xF8, 0x7E, 0x7F, 0xC7, 0xFF,
  0xBC, 0x3F, 0xF3, 0xE1, 0xFE, 0x1F, 0xFF, 0xFE, 0xF7, 0xB9, 0xCE, 0x73,
  0x9C, 0x07, 0xC1, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C,
  0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x06, 0x38, 0x4F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0xC0, 0xF3, 0x83, 0xC7, 0x83,
  0x86, 0x02, 0x08, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3E, 0x7C, 0xF1, 0xE3,
  0xCF, 0x1E, 0x3C, 0x70, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC3, 0xE7, 0xC7, 0x87, 0x8F, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x7C, 0x1E, 0x78, 0x3C, 0xF0,
  0xF1, 0xF3, 0xE1, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x7C,
  0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0x7F, 0xCF, 0x31, 0xE4, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x1F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C, 0x30,
  0x3E, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x78, 0x7C, 0x20,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x80, 0x3E, 0x70, 0xFC, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x07, 0x3C, 0x03, 0x9E,
  0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x70,
  0x78, 0x38, 0x3C, 0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0xB8, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x20,
  0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7D, 0x00, 0xFB, 0xC7, 0xE7, 0xFF, 0x8F,
  0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xF8, 0x43,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x9F, 0x0F, 0x7F, 0x1F, 0xFF, 0x3F, 0xBF, 0x7C, 0x1E, 0xF0, 0x3D,
  0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0x78, 0x3C, 0xF0, 0x79, 0xF3, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3E,
  0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3C,
  0x3C, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3E, 0x7C, 0x7C, 0x3C, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7E, 0xFF, 0x3F, 0xEE, 0x1F,
  0xCE, 0x0F, 0x9E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x21, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0x31, 0xEF, 0xBF, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x9E, 0xFD, 0xE7, 0x80, 0x18, 0x79, 0xF3, 0xF3, 0xC7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9,
  0xF3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xC3, 0x8F, 0x00, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x3F, 0xC7, 0xFF, 0x1F, 0xFC, 0xF3, 0xF2, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x0F,
  0x80, 0x78, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x38,
  0x00, 0x0E, 0x78, 0x3F, 0x8F, 0x70, 0x7F, 0xC7, 0x70, 0xFB, 0x87, 0xF0,
  0xE3, 0x87, 0xF1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1,
  0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1,
  0xC3, 0x87, 0xE1, 0xC7, 0x87, 0xE1, 0xC7, 0x8E, 0xF1, 0xFF, 0xFE, 0xF0,
  0xFC, 0xFC, 0x70, 0x78, 0x78, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x40, 0x0F, 0xC3, 0xC0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xBC, 0x00, 0x7B,
  0xC0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xC0, 0x7C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0x8E, 0x3E, 0x02, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x01,
  0x1F, 0xCE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x07, 0xE7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0,
  0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0,
  0x1E, 0x78, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xE3, 0xE1, 0xF0, 0x08, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDF, 0x00,
  0x7B, 0xE0, 0x0F, 0x3E, 0x01, 0xE7, 0xE0, 0x3C, 0x7F, 0x1F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3C, 0xFF, 0xFF,
  0xF7, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE1, 0xFE, 0xFF, 0xFF, 0xF0,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0xEF, 0xDF, 0xEF, 0xE7, 0xE0, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC,
  0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xC3, 0xC3, 0xE1, 0xE1, 0xE0,
  0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7C, 0xF0, 0x3E, 0x7C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C,
  0x78, 0x1F, 0x3C, 0x07, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7C, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xEF, 0xF7, 0x00, 0x77,
  0xFB, 0x80, 0x7B, 0xFD, 0xE0, 0x3D, 0xFE, 0xF0, 0x1C, 0xFF, 0x38, 0x1E,
  0x7F, 0x9E, 0x0F, 0x3F, 0xCF, 0x07, 0x1F, 0xE3, 0x83, 0x8F, 0xF1, 0xC3,
  0xC7, 0xF8, 0xF1, 0xE3, 0xFC, 0x78, 0xE1, 0xFE, 0x1C, 0x70, 0xFF, 0x0F,
  0x78, 0x7F, 0x87, 0xB8, 0x3F, 0xC3, 0xDC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x03, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0xFF,
  0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x3C, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xF7, 0x81, 0xFE, 0xF0, 0x3F, 0xCE, 0x07, 0xF9, 0xE0, 0xFF, 0x3C,
  0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xFE, 0x1E,
  0x3F, 0xC1, 0xE7, 0xF8, 0x3C, 0xFF, 0x03, 0xDF, 0xE0, 0x7B, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xF9, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7,
  0x80, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F,
  0x9F, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xBC,
  0x3F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFC, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xF9, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F,
  0x9F, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F,
  0x07, 0xC7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3C, 0x78, 0x1E, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1F, 0x3C, 0x0F,
  0x9E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7C, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF,
  0x9F, 0xFE, 0xF8, 0x1B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7E, 0x03, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE1, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0x7C, 0x0F, 0x9F, 0x8F, 0xC7, 0xFF, 0xC3,
  0xFF, 0xC0, 0x7F, 0xC0, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBC,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C,
  0x1E, 0x03, 0x83, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1D,
  0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x7B,
  0xE0, 0x1F, 0x00, 0xF3, 0xC0, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x07, 0xCF,
  0x01, 0xF8, 0x0F, 0x1E, 0x03, 0xF0, 0x1E, 0x3E, 0x07, 0xF0, 0x3C, 0x3C,
  0x0E, 0xE0, 0x78, 0x78, 0x3D, 0xC0, 0xF0, 0xF0, 0x7B, 0x83, 0xC1, 0xE0,
  0xF7, 0x07, 0x81, 0xE1, 0xCF, 0x0F, 0x03, 0xC3, 0x9E, 0x1E, 0x07, 0x8F,
  0x1C, 0x3C, 0x0F, 0x1E, 0x38, 0xF0, 0x1E, 0x3C, 0x71, 0xE0, 0x1C, 0x70,
  0xF3, 0xC0, 0x3C, 0xE1, 0xE7, 0x80, 0x79, 0xC1, 0xCF, 0x00, 0xF7, 0x83,
  0xBC, 0x01, 0xEF, 0x07, 0x78, 0x01, 0xDC, 0x0E, 0xF0, 0x03, 0xB8, 0x1F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x78, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x7C, 0x1E, 0x1E,
  0x07, 0x87, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x3C,
  0x03, 0xCF, 0x01, 0xE3, 0xE0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0xC3,
  0xC0, 0xF1, 0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x01, 0xF0, 0xF8, 0x07, 0xBC,
  0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78,
  0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0x77, 0x80, 0x3C, 0xF0, 0x0E, 0x3C, 0x07,
  0x87, 0x01, 0xC1, 0xE0, 0xF0, 0x38, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x80,
  0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0,
  0xE3, 0xE1, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x07,
  0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xE1, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFB, 0xC3, 0xF7, 0xFD, 0xE7, 0xFB, 0xC7,
  0xE7, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE7, 0xC3, 0xDF, 0xC7, 0xFF,
  0xCF, 0xEF, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC1, 0xEF, 0xC7, 0xDD, 0xFF, 0x39, 0xFE,
  0x71, 0xF8, 0x07, 0xE1, 0xFF, 0x3F, 0xF7, 0xFE, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC3, 0x3F, 0xF3, 0xFF, 0x0F,
  0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x1F, 0x3C, 0xFF, 0x79, 0xFF, 0xF7,
  0xEF, 0xEF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0xC7, 0xEF, 0xFD, 0xCF, 0xF3, 0x8F,
  0xC7, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F, 0x1E, 0x78, 0x3D, 0xC0, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x5F, 0x03,
  0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0x0F, 0xF0, 0xFA,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x8E, 0x3F, 0x9C, 0xFF, 0xBB,
  0xF7, 0xF7, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xE3, 0xF7, 0xFF, 0xE7, 0xFB, 0xC7,
  0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF4, 0x03,
  0xCF, 0xBF, 0x9F, 0xFE, 0x3F, 0xF8, 0x3F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xCF, 0x8F, 0x7F, 0x3B, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0x77, 0xFE, 0xF7, 0x00, 0x00, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0,
  0x0E, 0x1F, 0x1F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F,
  0x1E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7B,
  0xC1, 0xF7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0xF3,
  0xC1, 0xEF, 0x03, 0xFE, 0x07, 0x7C, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF0,
  0x78, 0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0xBC, 0x0F, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0xF8,
  0xE7, 0xF1, 0xFC, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x1F,
  0xF0, 0x7C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xE3, 0xE3, 0x9F, 0xCE, 0xFF, 0xBF,
  0xBF, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x07,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7E, 0xFC, 0x78, 0x3C, 0xF8, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x1E, 0x78,
  0x3C, 0x7C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0xE3, 0xE1, 0xCF,
  0xE3, 0xBF, 0xE7, 0xF7, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0xF7, 0xE3, 0xEF, 0xFF,
  0x9E, 0xFF, 0x3C, 0xFC, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F,
  0x8E, 0x3F, 0x9C, 0xFF, 0xBB, 0xF7, 0xF7, 0x83, 0xFF, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xE3,
  0xF7, 0xFF, 0xE7, 0xFB, 0xC7, 0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0xE3, 0xF9, 0xFE, 0xFF, 0xBF, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0xCE,
  0xF8, 0x2F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x4F, 0xF1, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xFE, 0x3F, 0xFF, 0xDD, 0xFE, 0x73, 0xF1, 0xC0, 0xF0, 0x0F, 0xF8,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E,
  0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x1E, 0x03, 0xDE, 0x07,
  0xC0, 0xF7, 0x83, 0xF0, 0x3D, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07, 0x9E,
  0x0F, 0xC1, 0xE3, 0xC3, 0xB8, 0x78, 0xF1, 0xEE, 0x1C, 0x3C, 0x73, 0x8F,
  0x0F, 0x1C, 0xE3, 0xC1, 0xC7, 0x38, 0xF0, 0x79, 0xCF, 0x3C, 0x1E, 0xF1,
  0xCE, 0x07, 0xBC, 0x77, 0x81, 0xEE, 0x1D, 0xE0, 0x3B, 0x87, 0x78, 0x0E,
  0xE1, 0xDC, 0x03, 0xB8, 0x77, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x78, 0x1F,
  0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0x78,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78,
  0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x3F, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x7F,
  0x0F, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0xFC, 0x0F, 0x80,
  0xC0, 0x00, 0x1C, 0x01, 0x7F, 0x81, 0xFF, 0xE7, 0xFF, 0xFF, 0xC1, 0xFF,
  0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Medium42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 30, 10, 3, -30 },
  { 20, 12, 11, 17, 2, -30 },
  { 37, 18, 30, 20, 1, -30 },
  { 105, 15, 34, 18, 2, -32 },
  { 169, 26, 30, 29, 2, -30 },
  { 267, 20, 30, 21, 1, -30 },
  { 342, 5, 11, 9, 2, -30 },
  { 349, 10, 37, 13, 2, -30 },
  { 396, 10, 37, 13, 1, -30 },
  { 443, 15, 15, 17, 1, -32 },
  { 472, 16, 20, 18, 1, -25 },
  { 512, 7, 11, 10, 1, -5 },
  { 522, 10, 4, 12, 1, -13 },
  { 527, 5, 5, 10, 2, -5 },
  { 531, 15, 30, 16, 1, -30 },
  { 588, 15, 30, 18, 2, -30 },
  { 645, 11, 30, 18, 2, -30 },
  { 687, 16, 30, 18, 1, -30 },
  { 747, 16, 30, 18, 1, -30 },
  { 807, 17, 30, 18, 1, -30 },
  { 871, 15, 30, 18, 2, -30 },
  { 928, 15, 30, 18, 2, -30 },
  { 985, 16, 30, 18, 1, -30 },
  { 1045, 16, 30, 18, 1, -30 },
  { 1105, 16, 30, 18, 1, -30 },
  { 1165, 6, 23, 10, 2, -23 },
  { 1183, 7, 29, 10, 1, -23 },
  { 1209, 16, 19, 18, 1, -24 },
  { 1247, 16, 12, 18, 1, -21 },
  { 1271, 16, 19, 18, 1, -24 },
  { 1309, 13, 30, 14, 0, -30 },
  { 1358, 24, 33, 28, 2, -30 },
  { 1457, 20, 30, 20, 0, -30 },
  { 1532, 16, 30, 21, 3, -30 },
  { 1592, 16, 30, 19, 2, -30 },
  { 1652, 17, 30, 22, 3, -30 },
  { 1716, 12, 30, 17, 3, -30 },
  { 1761, 12, 30, 17, 3, -30 },
  { 1806, 19, 30, 23, 2, -30 },
  { 1878, 17, 30, 23, 3, -30 },
  { 1942, 10, 30, 12, 1, -30 },
  { 1980, 9, 38, 10, -2, -30 },
  { 2023, 17, 30, 20, 3, -30 },
  { 2087, 12, 30, 16, 3, -30 },
  { 2132, 25, 30, 31, 3, -30 },
  { 2226, 19, 30, 25, 3, -30 },
  { 2298, 20, 30, 24, 2, -30 },
  { 2373, 15, 30, 19, 3, -30 },
  { 2430, 20, 37, 24, 2, -30 },
  { 2523, 17, 30, 20, 3, -30 },
  { 2587, 14, 30, 17, 2, -30 },
  { 2640, 16, 30, 17, 0, -30 },
  { 2700, 17, 30, 23, 3, -30 },
  { 2764, 19, 30, 19, 0, -30 },
  { 2836, 31, 30, 31, 0, -30 },
  { 2953, 18, 30, 18, 0, -30 },
  { 3021, 17, 30, 17, 0, -30 },
  { 3085, 14, 30, 16, 1, -30 },
  { 3138, 9, 37, 13, 3, -30 },
  { 3180, 15, 30, 16, 1, -30 },
  { 3237, 9, 37, 13, 1, -30 },
  { 3279, 18, 17, 20, 1, -30 },
  { 3318, 18, 2, 18, 0, 4 },
  { 3323, 8, 7, 12, 2, -32 },
  { 3330, 15, 23, 18, 1, -23 },
  { 3374, 15, 32, 20, 3, -32 },
  { 3434, 12, 23, 15, 2, -23 },
  { 3469, 15, 32, 20, 2, -32 },
  { 3529, 14, 23, 18, 2, -23 },
  { 3570, 12, 32, 11, 0, -32 },
  { 3618, 15, 33, 20, 2, -23 },
  { 3680, 14, 32, 20, 3, -32 },
  { 3736, 5, 31, 9, 2, -31 },
  { 3756, 8, 41, 9, -1, -31 },
  { 3797, 15, 32, 18, 3, -32 },
  { 3857, 4, 32, 9, 3, -32 },
  { 3873, 24, 23, 29, 3, -23 },
  { 3942, 14, 23, 20, 3, -23 },
  { 3983, 16, 23, 19, 2, -23 },
  { 4029, 15, 33, 20, 3, -23 },
  { 4091, 15, 33, 20, 2, -23 },
  { 4153, 10, 23, 13, 3, -23 },
  { 4182, 12, 23, 15, 1, -23 },
  { 4217, 10, 28, 12, 1, -28 },
  { 4252, 14, 23, 20, 3, -23 },
  { 4293, 16, 23, 16, 0, -23 },
  { 4339, 26, 23, 26, 0, -23 },
  { 4414, 16, 23, 16, 0, -23 },
  { 4460, 16, 33, 16, 0, -23 },
  { 4526, 12, 23, 13, 1, -23 },
  { 4561, 12, 37, 15, 1, -30 },
  { 4617, 4, 42, 17, 7, -32 },
  { 4638, 12, 37, 15, 2, -30 },
  { 4694, 16, 6, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Medium42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM42PT7B_H_
