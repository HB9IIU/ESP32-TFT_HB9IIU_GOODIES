#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x00, 0x00, 0x00, 0x7B, 0xEF,
  0xFF, 0xFB, 0xE0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xEF, 0x07,
  0x00, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03,
  0xC3, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x80,
  0x38, 0x78, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x78, 0x70,
  0x07, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x1E,
  0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x01,
  0xC3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x7F,
  0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x7D, 0xC6, 0x7C, 0xE0, 0x3C,
  0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xE7, 0x00, 0xFB, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0x7C, 0x03, 0x9F, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xE0,
  0x39, 0xF8, 0x1C, 0xF7, 0x8F, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x1C, 0x01, 0xFC, 0x01, 0xE0, 0x1F, 0xF0, 0x0E, 0x00,
  0xF7, 0x80, 0xF0, 0x0F, 0x1E, 0x07, 0x80, 0x78, 0xF0, 0x38, 0x03, 0xC7,
  0x83, 0xC0, 0x1C, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0xE0, 0x07, 0x07, 0x0F,
  0x00, 0x38, 0x38, 0x78, 0x01, 0xC1, 0xC3, 0x80, 0x0E, 0x0E, 0x3C, 0x00,
  0x70, 0x71, 0xC1, 0x83, 0xC7, 0x9E, 0x3F, 0x1E, 0x3C, 0xF3, 0xFC, 0x71,
  0xE7, 0x1F, 0xF3, 0xDE, 0x79, 0xE7, 0x9F, 0xF3, 0xCE, 0x1C, 0x7F, 0x1C,
  0x70, 0xF1, 0xF1, 0xE7, 0x87, 0x80, 0x0F, 0x3C, 0x3C, 0x00, 0x71, 0xE1,
  0xE0, 0x07, 0x8F, 0x0F, 0x00, 0x38, 0x78, 0x78, 0x01, 0xC3, 0xC3, 0xC0,
  0x1E, 0x1E, 0x1E, 0x00, 0xE0, 0x70, 0xF0, 0x0F, 0x03, 0x87, 0x80, 0x78,
  0x1E, 0x38, 0x03, 0x80, 0xF3, 0xC0, 0x3C, 0x03, 0xFE, 0x01, 0xE0, 0x1F,
  0xE0, 0x1E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF9, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0xF0, 0xFF, 0xC1, 0xE1,
  0xF7, 0xC3, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x9F, 0x1E, 0x0F, 0xBC, 0x7C,
  0x0F, 0x78, 0xF8, 0x1F, 0xF1, 0xF0, 0x1F, 0xC3, 0xE0, 0x3F, 0x87, 0xC0,
  0x3E, 0x07, 0xC0, 0xFE, 0x0F, 0x83, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0x7C, 0x1F, 0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x03, 0x8E, 0x39, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x00,
  0xF7, 0xC0, 0xF1, 0xE0, 0xF8, 0xF8, 0x18, 0x38, 0x04, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF1, 0xE3, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0x83, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7C, 0xF0, 0x3E, 0x78,
  0x1F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C,
  0x07, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0xC1, 0xE3, 0xF1, 0xF0, 0xFF, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0,
  0x7F, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xDF, 0xF9, 0xF7, 0x1F, 0x21, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xE0,
  0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0x60, 0x3E, 0x20, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xC7, 0x07, 0xE3, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF6, 0x01, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xDF, 0x00, 0x7B, 0xE0, 0x0E, 0x7C, 0x03, 0xCF, 0x80,
  0x71, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x03,
  0x83, 0xE0, 0xF0, 0x7C, 0x1C, 0x0F, 0x87, 0x81, 0xF0, 0xE0, 0x3E, 0x3C,
  0x07, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x10, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE8, 0x03, 0xF6, 0x03, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xF8, 0x11, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x8F, 0xC3, 0xCF,
  0xF1, 0xEF, 0xFC, 0xFF, 0xFF, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x01, 0xEF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xDE, 0x03, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3E, 0x1F, 0x8F, 0x03,
  0xE7, 0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x9F, 0x01, 0xE3, 0xC0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x1F, 0x07, 0xCF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x3E, 0x1F, 0x9F, 0x03,
  0xE7, 0xC0, 0x7D, 0xE0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xE3, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xC7, 0xE7, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xBF, 0x3F, 0x9F, 0xFF, 0xC7, 0xFD, 0xE1, 0xFC,
  0xF0, 0x7C, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x27, 0xFF, 0xFF, 0xFD, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xC0, 0x10, 0xF9,
  0xF3, 0xE7, 0xCF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E,
  0x3C, 0x70, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xE3,
  0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xC4, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x7C, 0x1C, 0x38,
  0x1F, 0xF1, 0xE7, 0x83, 0xFF, 0x1E, 0x78, 0x78, 0xF0, 0xE7, 0x07, 0x0F,
  0x0E, 0x70, 0xF0, 0xF0, 0xEF, 0x0F, 0x0F, 0x0F, 0xF0, 0xE0, 0xF0, 0xFF,
  0x0E, 0x0F, 0x0F, 0xF0, 0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0E, 0xF1, 0xE0,
  0xE0, 0xEF, 0x0E, 0x1E, 0x0E, 0xF0, 0xE1, 0xE0, 0xEF, 0x0E, 0x1E, 0x1E,
  0xF0, 0xF1, 0xF1, 0xCF, 0x0F, 0xFF, 0xFC, 0x70, 0x7F, 0x3F, 0x87, 0x83,
  0xF3, 0xF0, 0x78, 0x0C, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x07,
  0xE0, 0x78, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0xFF,
  0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x7F, 0xBE, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7B,
  0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x87, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0x87, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xC3, 0x87, 0xC0, 0x23, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x20,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x81, 0xF8,
  0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x83, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x0F, 0x0F,
  0xC0, 0x08, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xF1,
  0xF0, 0x07, 0x8F, 0xC0, 0x3C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0x78, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0x78, 0x00, 0xFF, 0xFF, 0x80, 0x1E, 0xFF, 0xF8,
  0x01, 0xEF, 0xFB, 0xC0, 0x1E, 0xFF, 0xBC, 0x03, 0xCF, 0xFB, 0xC0, 0x3C,
  0xFF, 0xBE, 0x03, 0xCF, 0xF9, 0xE0, 0x3C, 0xFF, 0x9E, 0x07, 0x8F, 0xF9,
  0xE0, 0x78, 0xFF, 0x8F, 0x07, 0x8F, 0xF8, 0xF0, 0x70, 0xFF, 0x8F, 0x0F,
  0x0F, 0xF8, 0xF0, 0xF0, 0xFF, 0x87, 0x8F, 0x0F, 0xF8, 0x79, 0xE0, 0xFF,
  0x87, 0x9E, 0x0F, 0xF8, 0x3D, 0xE0, 0xFF, 0x83, 0xDC, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x81, 0xF8, 0x0F,
  0xF8, 0x1F, 0x80, 0xFF, 0x81, 0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF7,
  0x80, 0x7F, 0xFE, 0x03, 0xFE, 0xF0, 0x1F, 0xF7, 0xC0, 0xFF, 0x9E, 0x07,
  0xFC, 0xF8, 0x3F, 0xE7, 0xC1, 0xFF, 0x1E, 0x0F, 0xF8, 0xF8, 0x7F, 0xC3,
  0xC3, 0xFE, 0x1F, 0x1F, 0xF0, 0x78, 0xFF, 0x83, 0xE7, 0xFC, 0x1F, 0x3F,
  0xE0, 0x79, 0xFF, 0x03, 0xEF, 0xF8, 0x0F, 0x7F, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xE7,
  0xC0, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3F, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xC1, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3E, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0x0F, 0xFF, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xF0, 0xFC, 0x07, 0xC3,
  0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0xC0,
  0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3F, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7C,
  0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0x3E, 0xFC, 0x04,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0xE0, 0x7E,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xBC, 0x01, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xEF,
  0x80, 0x0F, 0x9E, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0,
  0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E,
  0x07, 0x80, 0xF8, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0x01,
  0xFF, 0x80, 0x1F, 0x00, 0x7D, 0xE0, 0x0F, 0xC0, 0x1F, 0x78, 0x03, 0xF0,
  0x07, 0x9F, 0x00, 0xFC, 0x01, 0xE7, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x0F,
  0xE0, 0x3E, 0x3C, 0x07, 0xF8, 0x0F, 0x8F, 0x01, 0xFE, 0x03, 0xC3, 0xE0,
  0x7B, 0x80, 0xF0, 0xF8, 0x1E, 0xE0, 0x7C, 0x3E, 0x07, 0x3C, 0x1F, 0x07,
  0x83, 0xCF, 0x07, 0xC1, 0xE0, 0xF3, 0xC1, 0xE0, 0x7C, 0x3C, 0xF0, 0x78,
  0x1F, 0x0F, 0x1C, 0x3E, 0x07, 0xC3, 0x87, 0x8F, 0x80, 0xF1, 0xE1, 0xE3,
  0xE0, 0x3C, 0x78, 0x78, 0xF0, 0x0F, 0x1E, 0x1E, 0x3C, 0x03, 0xE7, 0x83,
  0x9F, 0x00, 0xF9, 0xC0, 0xF7, 0xC0, 0x1E, 0xF0, 0x3D, 0xF0, 0x07, 0xBC,
  0x0F, 0x78, 0x01, 0xEF, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x77, 0x80, 0x1F,
  0xF0, 0x1D, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x03,
  0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x81,
  0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF9, 0xF0,
  0x0F, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F,
  0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x01, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x1C, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7E, 0x0F, 0x7C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E, 0x7F,
  0x7F, 0xF7, 0x3F, 0xE7, 0x1F, 0xC7, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x3C, 0x1E, 0x7F, 0x8F, 0x7F, 0xE7, 0xBF, 0xF3,
  0xF8, 0xFD, 0xF8, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3E, 0xFF, 0x3F, 0x7B, 0xFF, 0x3C, 0xFF, 0x1E, 0x3F, 0x00, 0x03,
  0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x19, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF8, 0x13, 0xFB, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xE1, 0xE3, 0xFC, 0xF3, 0xFF,
  0x79, 0xFF, 0xFD, 0xF8, 0xFE, 0xF8, 0x3F, 0x78, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7F, 0x3F, 0x9F, 0xFB, 0xC7, 0xFD, 0xE1,
  0xFC, 0x70, 0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3C, 0x3E,
  0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x02, 0x3F, 0x1E,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0x83,
  0xFE, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0xF3, 0xC7, 0xFD, 0xE7, 0xFF, 0xF7, 0xE3, 0xFB, 0xE0, 0xFD, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xFD, 0xFE, 0x7F, 0xEF,
  0x1F, 0xF7, 0x87, 0xF3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x60, 0x1F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F,
  0xFF, 0x81, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE, 0xF7, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x77, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x3D, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBC, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0xBF, 0xDF, 0xEF, 0xE7, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xEF, 0x03, 0xE7, 0x81, 0xF3,
  0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x7C,
  0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7E,
  0x78, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xE3, 0xC0, 0xF1,
  0xE0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x1E, 0x7F, 0x8F, 0xF3,
  0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0x7F, 0xEF, 0xE3, 0xFC, 0x7F, 0xF8, 0x3F,
  0x07, 0xFE, 0x07, 0xE0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xFF,
  0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0,
  0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0,
  0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80,
  0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x80,
  0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0xF3,
  0xFC, 0xF7, 0xFE, 0xF7, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3F,
  0x1F, 0x03, 0xC7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF,
  0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x07, 0xC3, 0xF7, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0xF0, 0x79, 0xFE, 0x3D, 0xFF, 0x9E, 0xFF, 0xCF, 0xE3, 0xF7, 0xE0,
  0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xF7, 0xE0, 0xFB, 0xFD,
  0xFD, 0xEF, 0xFC, 0xF3, 0xFC, 0x78, 0xFC, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0xF3, 0xC7,
  0xFD, 0xE7, 0xFF, 0xF7, 0xE3, 0xFB, 0xE0, 0xFD, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xFD, 0xFE, 0x7F, 0xEF, 0x1F, 0xF7,
  0x87, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xFE, 0x7F, 0xCF, 0xFB, 0xFF, 0xFF, 0xFC, 0x3F, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0x7C, 0x19, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x7F, 0x01, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0x8F, 0xF8, 0x07, 0xDE,
  0x01, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x8F, 0x03, 0xE3, 0xC0,
  0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78,
  0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x7B, 0xC0, 0x7E,
  0x07, 0xDE, 0x03, 0xF0, 0x3C, 0xF8, 0x3F, 0x81, 0xE7, 0xC1, 0xFC, 0x0F,
  0x1E, 0x0F, 0xE0, 0xF8, 0xF0, 0x77, 0x87, 0xC7, 0x83, 0xBC, 0x3C, 0x3E,
  0x3C, 0xE1, 0xE1, 0xF1, 0xE7, 0x0F, 0x07, 0x8F, 0x38, 0xF8, 0x3C, 0x71,
  0xE7, 0x81, 0xE3, 0x8F, 0x3C, 0x0F, 0xBC, 0x79, 0xE0, 0x3D, 0xE1, 0xCF,
  0x01, 0xEF, 0x0E, 0x78, 0x0F, 0x78, 0x77, 0x80, 0x7B, 0x83, 0xBC, 0x03,
  0xDC, 0x1F, 0xE0, 0x0E, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3F,
  0x00, 0xF8, 0x1F, 0xBC, 0x0F, 0x9F, 0x07, 0x87, 0x87, 0xC3, 0xE3, 0xC0,
  0xF3, 0xE0, 0x79, 0xE0, 0x3E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF8, 0x0F, 0x3C, 0x0F, 0x9F, 0x07, 0xC7, 0x83, 0xC3, 0xE3, 0xE0, 0xF1,
  0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xDE, 0x01, 0xF7,
  0xC0, 0x79, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0x78, 0x0F, 0x1E,
  0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x1F,
  0xE0, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1F,
  0x83, 0xFC, 0x1F, 0xC0, 0xF8, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x5F, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xE8, 0x00, 0x60,
};

const GFXglyph NotoSans_ExtraCondensed_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 34, 11, 3, -34 },
  { 27, 13, 13, 19, 3, -34 },
  { 49, 20, 34, 22, 1, -34 },
  { 134, 17, 39, 21, 2, -36 },
  { 217, 29, 34, 33, 2, -34 },
  { 341, 23, 34, 24, 1, -34 },
  { 439, 5, 13, 10, 3, -34 },
  { 448, 11, 41, 14, 2, -34 },
  { 505, 11, 41, 14, 1, -34 },
  { 562, 17, 17, 19, 1, -36 },
  { 599, 18, 22, 21, 1, -28 },
  { 649, 7, 11, 11, 2, -5 },
  { 659, 11, 5, 13, 1, -15 },
  { 666, 5, 6, 11, 3, -6 },
  { 670, 16, 34, 18, 1, -34 },
  { 738, 17, 34, 21, 2, -34 },
  { 811, 12, 34, 21, 3, -34 },
  { 862, 16, 34, 21, 2, -34 },
  { 930, 17, 34, 21, 2, -34 },
  { 1003, 19, 34, 21, 1, -34 },
  { 1084, 17, 34, 21, 2, -34 },
  { 1157, 17, 34, 21, 2, -34 },
  { 1230, 18, 34, 21, 1, -34 },
  { 1307, 18, 34, 21, 1, -34 },
  { 1384, 17, 34, 21, 2, -34 },
  { 1457, 5, 26, 11, 3, -26 },
  { 1474, 7, 32, 11, 2, -26 },
  { 1502, 18, 21, 21, 1, -27 },
  { 1550, 18, 13, 21, 1, -23 },
  { 1580, 18, 21, 21, 1, -27 },
  { 1628, 15, 34, 16, 0, -34 },
  { 1692, 28, 38, 32, 2, -34 },
  { 1825, 22, 34, 22, 0, -34 },
  { 1919, 18, 34, 23, 3, -34 },
  { 1996, 18, 34, 21, 2, -34 },
  { 2073, 20, 34, 25, 3, -34 },
  { 2158, 14, 34, 19, 3, -34 },
  { 2218, 14, 34, 19, 3, -34 },
  { 2278, 21, 34, 26, 2, -34 },
  { 2368, 19, 34, 26, 3, -34 },
  { 2449, 11, 34, 14, 1, -34 },
  { 2496, 10, 43, 11, -2, -34 },
  { 2550, 19, 34, 22, 3, -34 },
  { 2631, 14, 34, 18, 3, -34 },
  { 2691, 28, 34, 35, 3, -34 },
  { 2810, 21, 34, 28, 3, -34 },
  { 2900, 22, 34, 26, 2, -34 },
  { 2994, 17, 34, 21, 3, -34 },
  { 3067, 22, 42, 26, 2, -34 },
  { 3183, 19, 34, 22, 3, -34 },
  { 3264, 16, 34, 20, 2, -34 },
  { 3332, 17, 34, 19, 1, -34 },
  { 3405, 19, 34, 25, 3, -34 },
  { 3486, 22, 34, 22, 0, -34 },
  { 3580, 34, 34, 34, 0, -34 },
  { 3725, 20, 34, 20, 0, -34 },
  { 3810, 20, 34, 20, 0, -34 },
  { 3895, 16, 34, 18, 1, -34 },
  { 3963, 10, 42, 15, 3, -34 },
  { 4016, 16, 34, 18, 1, -34 },
  { 4084, 10, 42, 15, 1, -34 },
  { 4137, 20, 19, 22, 1, -34 },
  { 4185, 20, 3, 20, 0, 4 },
  { 4193, 9, 8, 13, 2, -36 },
  { 4202, 16, 26, 20, 1, -26 },
  { 4254, 17, 36, 22, 3, -36 },
  { 4331, 14, 26, 17, 2, -26 },
  { 4377, 17, 36, 22, 2, -36 },
  { 4454, 16, 26, 20, 2, -26 },
  { 4506, 14, 36, 13, 0, -36 },
  { 4569, 17, 37, 22, 2, -26 },
  { 4648, 16, 36, 22, 3, -36 },
  { 4720, 5, 35, 10, 3, -35 },
  { 4742, 9, 46, 10, -1, -35 },
  { 4794, 17, 36, 20, 3, -36 },
  { 4871, 4, 36, 10, 3, -36 },
  { 4889, 27, 26, 33, 3, -26 },
  { 4977, 16, 26, 22, 3, -26 },
  { 5029, 18, 26, 22, 2, -26 },
  { 5088, 17, 37, 22, 3, -26 },
  { 5167, 17, 37, 22, 2, -26 },
  { 5246, 11, 26, 15, 3, -26 },
  { 5282, 14, 26, 16, 1, -26 },
  { 5328, 11, 31, 13, 1, -31 },
  { 5371, 16, 25, 22, 3, -25 },
  { 5421, 18, 25, 18, 0, -25 },
  { 5478, 29, 25, 29, 0, -25 },
  { 5569, 17, 25, 18, 1, -25 },
  { 5623, 18, 36, 18, 0, -25 },
  { 5704, 13, 25, 15, 1, -25 },
  { 5745, 14, 42, 17, 1, -34 },
  { 5819, 4, 47, 20, 8, -36 },
  { 5843, 13, 42, 17, 2, -34 },
  { 5912, 18, 7, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Medium47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM47PT7B_H_
