#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFD,
  0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0x7C,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07,
  0xC0, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE7, 0xF3, 0x83, 0x1F, 0x8E, 0x00, 0x7C, 0x38, 0x01, 0xF0, 0xE0,
  0x07, 0xC3, 0x80, 0x1F, 0x0E, 0x00, 0x7C, 0x38, 0x01, 0xF0, 0xE0, 0x07,
  0xE3, 0x80, 0x0F, 0xEE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x39, 0xFC, 0x00, 0xE3, 0xF0, 0x03, 0x87, 0xC0,
  0x0E, 0x1F, 0x00, 0x38, 0x7C, 0x00, 0xE1, 0xF0, 0x03, 0x87, 0xE0, 0x0E,
  0x3F, 0xE0, 0x38, 0xFF, 0xF0, 0xEF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x3E,
  0x7C, 0x01, 0xF0, 0x01, 0xF0, 0xF0, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x1E,
  0x00, 0x1E, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x3E, 0x03, 0xC0, 0x03, 0xE0,
  0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x81, 0xE0,
  0x00, 0xF8, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x3E, 0x00, 0x0F, 0x81,
  0xE0, 0xF0, 0x00, 0x3E, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x78, 0x1E, 0x07, 0x83, 0xE3, 0xE1, 0xFC, 0x1E, 0x0F,
  0x8F, 0x0F, 0xF8, 0x7C, 0x3E, 0x7C, 0x7F, 0xF1, 0xF0, 0xF1, 0xF1, 0xF7,
  0xE3, 0xE7, 0xC7, 0x8F, 0x8F, 0x8F, 0xFE, 0x3E, 0x3E, 0x1E, 0x1F, 0xF8,
  0xF8, 0xF0, 0x7C, 0x3F, 0xC3, 0xC7, 0xC1, 0xF0, 0x7E, 0x1F, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x7C, 0x00, 0x0F,
  0x87, 0xC1, 0xF0, 0x00, 0x3C, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x7C,
  0x00, 0x7C, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0x0F, 0x87, 0x80, 0x07, 0x80,
  0x3E, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0xFC, 0x3F, 0xFF, 0x07, 0xE3, 0xF9, 0xF8, 0x3F,
  0x1F, 0x87, 0xE1, 0xF1, 0xFC, 0x3F, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x7E,
  0x07, 0xF7, 0xE3, 0xF0, 0x1F, 0xFE, 0x1F, 0x80, 0x7F, 0xF0, 0xFC, 0x03,
  0xFF, 0x87, 0xE0, 0x0F, 0xF8, 0x3F, 0x00, 0x3F, 0xC1, 0xF8, 0x01, 0xFC,
  0x0F, 0xC0, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0x81, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xEF, 0xC1, 0xFF, 0xFE, 0x7F, 0x07, 0xFF,
  0xC1, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x09, 0xE3, 0xE3, 0xCF, 0xEF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFC, 0x7F, 0x0F, 0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x8F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F,
  0x87, 0xC7, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x7E, 0x08, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x7F, 0x3F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF, 0xFF,
  0x3F, 0x7E, 0x3F, 0x3C, 0x3F, 0x18, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0xC3,
  0xC0, 0x3F, 0x0C, 0x00, 0xFE, 0x10, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xF8, 0x3F,
  0xC3, 0x80, 0x3F, 0x8C, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFA, 0x00, 0x0F, 0xEF, 0x00, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xC0, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x40, 0x03, 0xFB, 0x80, 0x7F,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xE0, 0x40, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x1E, 0x01, 0xF1, 0xFF, 0x07, 0xCF, 0xFE, 0x1F, 0x7F, 0xFC,
  0x7D, 0xFF, 0xF1, 0xFF, 0x9F, 0xEF, 0xF8, 0x3F, 0xBF, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFE,
  0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0x7E,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x9F, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xCF, 0xE0, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0xE3, 0xF0, 0x0F,
  0xE7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0xE7, 0xFC, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFD,
  0xFC, 0x0F, 0xF7, 0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFB, 0xF0, 0xFF, 0xCF, 0xC0, 0xFE, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x20,
  0x1F, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E,
  0x3F, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x0F, 0xE6, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x1F, 0xF0, 0x7C, 0x78, 0x07, 0xFF,
  0x07, 0x9F, 0x01, 0xFF, 0xE0, 0xFB, 0xE0, 0x7F, 0xFC, 0x1F, 0x7C, 0x1F,
  0x0F, 0x83, 0xEF, 0x03, 0xE1, 0xF0, 0x3F, 0xE0, 0xF8, 0x3E, 0x07, 0xFC,
  0x1F, 0x07, 0xC0, 0xFF, 0x83, 0xE0, 0xF8, 0x1F, 0xF0, 0x78, 0x1F, 0x03,
  0xFC, 0x1F, 0x03, 0xE0, 0x7F, 0x83, 0xE0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F,
  0x81, 0xFE, 0x0F, 0x81, 0xF0, 0x3F, 0xC1, 0xF0, 0x3E, 0x07, 0xF8, 0x3E,
  0x07, 0xC1, 0xFF, 0x07, 0xC0, 0xF8, 0x3F, 0xE0, 0x78, 0x3F, 0x07, 0xFE,
  0x0F, 0x87, 0xE0, 0xF7, 0xC1, 0xF0, 0xFC, 0x3E, 0xF8, 0x3F, 0x3B, 0xC7,
  0x9F, 0x03, 0xFF, 0x7F, 0xF1, 0xE0, 0x7F, 0xE7, 0xFC, 0x3E, 0x07, 0xF8,
  0xFF, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x30,
  0x00, 0x7F, 0x80, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC,
  0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x0F, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFC, 0x07, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0x0F, 0x83, 0xF8, 0x03, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x43, 0xFC, 0x07, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0xF1, 0xF8,
  0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xE3,
  0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0x83, 0xFC, 0x00,
  0x60, 0xFF, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0xC0, 0x0F, 0xC3, 0xFC, 0x01,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xF3, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF3,
  0xFF, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F,
  0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x03,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0xFE, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0x80,
  0x3F, 0xCF, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xDF, 0xFF, 0xF0, 0x00,
  0x7D, 0xFF, 0xDF, 0x00, 0x07, 0xDF, 0xFD, 0xF0, 0x00, 0x7D, 0xFF, 0xDF,
  0x00, 0x0F, 0x9F, 0xFC, 0xF8, 0x00, 0xF9, 0xFF, 0xCF, 0x80, 0x0F, 0x9F,
  0xFC, 0xF8, 0x01, 0xF9, 0xFF, 0xCF, 0xC0, 0x1F, 0x1F, 0xFC, 0x7C, 0x01,
  0xF1, 0xFF, 0xC7, 0xC0, 0x1F, 0x1F, 0xFC, 0x7C, 0x03, 0xE1, 0xFF, 0xC7,
  0xE0, 0x3E, 0x1F, 0xFC, 0x3E, 0x03, 0xE1, 0xFF, 0xC3, 0xE0, 0x7E, 0x1F,
  0xFC, 0x3F, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0xFC, 0x1F, 0x07,
  0xC1, 0xFF, 0xC1, 0xF0, 0xF8, 0x1F, 0xFC, 0x1F, 0x8F, 0x81, 0xFF, 0xC0,
  0xF8, 0xF8, 0x1F, 0xFC, 0x0F, 0x8F, 0x81, 0xFF, 0xC0, 0xF9, 0xF0, 0x1F,
  0xFC, 0x0F, 0xDF, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFE, 0xF8, 0x01, 0xFF, 0xDF,
  0x80, 0x3F, 0xFB, 0xF0, 0x07, 0xFF, 0x3F, 0x00, 0xFF, 0xE7, 0xE0, 0x1F,
  0xFC, 0x7C, 0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xF0, 0xF8, 0x0F, 0xFE, 0x1F,
  0x81, 0xFF, 0xC3, 0xF0, 0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFF,
  0xE0, 0x7C, 0x1F, 0xFC, 0x0F, 0xC3, 0xFF, 0x81, 0xF8, 0x7F, 0xF0, 0x1F,
  0x8F, 0xFE, 0x03, 0xF1, 0xFF, 0xC0, 0x3F, 0x3F, 0xF8, 0x07, 0xE7, 0xFF,
  0x00, 0x7C, 0xFF, 0xE0, 0x0F, 0xDF, 0xFC, 0x01, 0xFB, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x1F, 0xE0, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0xFE, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0,
  0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x1F,
  0xE0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0xFE, 0x01, 0x8F, 0xE0, 0x04, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xFB, 0xF0, 0x3F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x07,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xA0, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF7, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF7, 0xE0, 0x03,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xFE, 0x00,
  0x7E, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xDE, 0x00, 0xFC,
  0x3F, 0x00, 0x7D, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xDF, 0x00, 0xFC, 0x1F,
  0x80, 0x79, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x1F, 0x80,
  0xF9, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x0F, 0x80, 0xF9,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F,
  0x00, 0x7C, 0x1F, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x7C, 0x3F, 0x00,
  0x7E, 0x3F, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x00, 0x7E,
  0x3E, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x7C, 0x7E, 0x00, 0x3E, 0x3E,
  0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xE0, 0x3E, 0xFC, 0x00, 0x3F, 0x7C, 0x03,
  0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x03, 0xEF,
  0xC0, 0x01, 0xF7, 0xC0, 0x1E, 0xFC, 0x00, 0x1F, 0x7C, 0x01, 0xEF, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x9F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0xFC,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC3, 0xE0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00,
  0xFE, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF,
  0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07,
  0xCF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC1, 0xF0,
  0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF0,
  0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0x87, 0xF8,
  0x30, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xFF, 0xE0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF0, 0x7E, 0xFE, 0x03,
  0xF7, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xBF, 0x8F, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0x9F, 0x3F, 0xF8, 0xF8, 0x7F,
  0x87, 0xC0, 0x60, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF1, 0xFE, 0x0F, 0xCF, 0xFC, 0x3F, 0x7F, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE,
  0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFF, 0x03, 0xFB, 0xFF, 0xBF, 0xCF,
  0xBF, 0xFF, 0x3E, 0x7F, 0xF8, 0xF8, 0xFF, 0xC3, 0xE1, 0xFE, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0x21, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x04, 0x3F,
  0xEF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x04, 0x07, 0xE0, 0x7F, 0x8F, 0xC1, 0xFF, 0x9F, 0x87, 0xFF, 0xBF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFE, 0x0F, 0xF9, 0xF8, 0x0F, 0xF7,
  0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x81, 0xFE,
  0x3F, 0xCF, 0xFC, 0x7F, 0xFE, 0xF8, 0x7F, 0xF9, 0xF0, 0x7F, 0xE3, 0xE0,
  0x7F, 0x87, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0,
  0x1F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F,
  0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x87, 0xE0, 0x06, 0x1F,
  0xE0, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xB8, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x83, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xF8, 0x7C, 0x1F, 0xF8, 0xF8, 0x7F, 0xF9, 0xF1, 0xFF, 0xFB, 0xE3, 0xFF,
  0xFF, 0xCF, 0xE0, 0xFF, 0x9F, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFC, 0x01,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xFC,
  0x03, 0xF9, 0xF8, 0x0F, 0xF3, 0xF8, 0x1F, 0xE3, 0xFD, 0xFF, 0xC7, 0xFF,
  0xFF, 0x87, 0xFF, 0xBF, 0x07, 0xFE, 0x7E, 0x07, 0xF8, 0xFC, 0x01, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x40, 0x01, 0xF8, 0xE0, 0x0F, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0x60, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0xC0, 0x7E, 0x3F, 0xC3, 0xF7, 0xFF, 0x1F, 0x3F, 0xFC, 0xFB,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xE1, 0xFD, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0x10, 0xF9, 0xFB, 0xFF, 0xEF, 0xDF,
  0x9E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xC0, 0x01,
  0x00, 0xF8, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0x83, 0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0x7F, 0x03, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3E, 0xFE, 0x00, 0xFB, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xDF, 0x80, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFE,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x10, 0x1E, 0x0F, 0xF0,
  0x3F, 0xC3, 0xE7, 0xFF, 0x0F, 0xFC, 0x7C, 0xFF, 0xF3, 0xFF, 0xCF, 0xBF,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xC1, 0xFF, 0x83, 0xF7,
  0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00,
  0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0x7F, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xE0,
  0x0F, 0x80, 0x3F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0xFF,
  0xF0, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x00,
  0x7F, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x0F,
  0x80, 0x3F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xF0,
  0x07, 0xC0, 0x1F, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0x7F,
  0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0x80,
  0x3F, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x08,
  0x07, 0x83, 0xFC, 0x3E, 0x7F, 0xF1, 0xF3, 0xFF, 0xCF, 0xBF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xE0, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE1, 0xF8, 0x1F, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x03,
  0xE1, 0xFE, 0x0F, 0x8F, 0xFC, 0x3E, 0x7F, 0xF8, 0xFB, 0xFF, 0xF3, 0xEF,
  0xBF, 0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xBF,
  0x80, 0x7E, 0xFF, 0x03, 0xFB, 0xFF, 0xBF, 0xCF, 0xBF, 0xFF, 0x3F, 0x7F,
  0xF8, 0xFC, 0xFF, 0xC3, 0xF1, 0xFE, 0x0F, 0xC0, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x07, 0xF8, 0x7C, 0x1F, 0xF8, 0xF8, 0x7F, 0xF9, 0xF1,
  0xFF, 0xFB, 0xE3, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0x9F, 0x80, 0xFF, 0x7F,
  0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xE3,
  0xFD, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xBF, 0x07, 0xFE, 0x7E, 0x07,
  0xF8, 0xFC, 0x01, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x09, 0xE0,
  0xFF, 0xE3, 0xFF, 0xCF, 0xEF, 0xBF, 0xDF, 0x7F, 0xBF, 0xFF, 0x7F, 0xC0,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB,
  0xF8, 0xFB, 0xF0, 0x0D, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x03,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F,
  0xFC, 0x01, 0x60, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x60, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0x7C, 0xFF, 0xF3, 0xE3, 0xFF, 0x1F, 0x0F, 0xF0, 0xF8,
  0x0C, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xEF, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF8,
  0x03, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0xE0, 0x0F, 0x9F, 0x80, 0x7F, 0x80,
  0x7E, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0xF8, 0x07, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0xF0, 0x1F, 0x0F, 0xC0, 0xFF, 0xC0, 0x7C, 0x3F, 0x03, 0xEF, 0x03,
  0xF0, 0x7C, 0x0F, 0x3C, 0x0F, 0xC1, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0xE0,
  0xF3, 0xE0, 0xF8, 0x1F, 0x87, 0xCF, 0x87, 0xE0, 0x7E, 0x1F, 0x3E, 0x1F,
  0x80, 0xF8, 0x7C, 0x78, 0x7E, 0x03, 0xE1, 0xE1, 0xE1, 0xF0, 0x0F, 0xC7,
  0x87, 0xC7, 0xC0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x7C, 0xFC,
  0x01, 0xF3, 0xE1, 0xF3, 0xE0, 0x07, 0xCF, 0x83, 0xCF, 0x80, 0x1F, 0x3C,
  0x0F, 0x3E, 0x00, 0x7E, 0xF0, 0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0xFF, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03,
  0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x40, 0x07, 0xFC,
  0x80, 0x00, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 45, 15, 4, -44 },
  { 41, 18, 16, 24, 3, -44 },
  { 77, 27, 44, 29, 1, -44 },
  { 226, 22, 50, 27, 2, -46 },
  { 364, 38, 45, 42, 2, -44 },
  { 578, 29, 45, 31, 2, -44 },
  { 742, 7, 16, 13, 3, -44 },
  { 756, 14, 54, 18, 3, -44 },
  { 851, 13, 54, 18, 2, -44 },
  { 939, 21, 21, 25, 2, -46 },
  { 995, 23, 29, 27, 2, -36 },
  { 1079, 9, 15, 14, 2, -7 },
  { 1096, 14, 5, 17, 2, -19 },
  { 1105, 8, 9, 14, 3, -8 },
  { 1114, 22, 44, 23, 1, -44 },
  { 1235, 22, 45, 27, 2, -44 },
  { 1359, 16, 44, 27, 3, -44 },
  { 1447, 22, 44, 27, 2, -44 },
  { 1568, 22, 45, 27, 2, -44 },
  { 1692, 25, 44, 27, 1, -44 },
  { 1830, 21, 45, 27, 3, -44 },
  { 1949, 22, 45, 27, 2, -44 },
  { 2073, 23, 44, 27, 2, -44 },
  { 2200, 23, 45, 27, 2, -44 },
  { 2330, 22, 45, 27, 2, -44 },
  { 2454, 7, 34, 14, 4, -33 },
  { 2484, 9, 41, 14, 2, -33 },
  { 2531, 23, 28, 27, 2, -36 },
  { 2612, 23, 17, 27, 2, -30 },
  { 2661, 23, 28, 27, 2, -36 },
  { 2742, 18, 45, 20, 1, -44 },
  { 2844, 35, 49, 41, 3, -44 },
  { 3059, 29, 44, 29, 0, -44 },
  { 3219, 24, 44, 30, 4, -44 },
  { 3351, 23, 45, 28, 3, -44 },
  { 3481, 25, 44, 32, 4, -44 },
  { 3619, 18, 44, 25, 4, -44 },
  { 3718, 18, 44, 24, 4, -44 },
  { 3817, 27, 45, 34, 3, -44 },
  { 3969, 25, 44, 33, 4, -44 },
  { 4107, 14, 44, 18, 2, -44 },
  { 4184, 13, 56, 15, -3, -44 },
  { 4275, 25, 44, 28, 4, -44 },
  { 4413, 18, 44, 23, 4, -44 },
  { 4512, 36, 44, 45, 4, -44 },
  { 4710, 27, 44, 36, 4, -44 },
  { 4859, 28, 45, 34, 3, -44 },
  { 5017, 22, 44, 28, 4, -44 },
  { 5138, 28, 54, 34, 3, -44 },
  { 5327, 24, 44, 29, 4, -44 },
  { 5459, 21, 45, 25, 2, -44 },
  { 5578, 22, 44, 24, 1, -44 },
  { 5699, 25, 45, 33, 4, -44 },
  { 5840, 28, 44, 28, 0, -44 },
  { 5994, 44, 44, 44, 0, -44 },
  { 6236, 25, 44, 26, 0, -44 },
  { 6374, 25, 44, 25, 0, -44 },
  { 6512, 21, 44, 23, 1, -44 },
  { 6628, 13, 54, 19, 4, -44 },
  { 6716, 22, 44, 23, 1, -44 },
  { 6837, 13, 54, 19, 2, -44 },
  { 6925, 27, 25, 29, 1, -44 },
  { 7010, 26, 4, 26, 0, 5 },
  { 7023, 13, 10, 17, 2, -47 },
  { 7040, 21, 35, 26, 2, -34 },
  { 7132, 22, 47, 29, 4, -46 },
  { 7262, 19, 35, 22, 2, -34 },
  { 7346, 23, 47, 29, 2, -46 },
  { 7482, 22, 34, 26, 2, -33 },
  { 7576, 17, 47, 16, 1, -47 },
  { 7676, 23, 49, 29, 2, -34 },
  { 7817, 21, 46, 29, 4, -46 },
  { 7938, 7, 46, 13, 3, -46 },
  { 7979, 11, 61, 13, -1, -46 },
  { 8063, 22, 46, 26, 4, -46 },
  { 8190, 6, 46, 13, 4, -46 },
  { 8225, 35, 34, 43, 4, -34 },
  { 8374, 21, 34, 29, 4, -34 },
  { 8464, 23, 35, 28, 2, -34 },
  { 8565, 22, 49, 29, 4, -34 },
  { 8700, 23, 49, 29, 2, -34 },
  { 8841, 15, 34, 19, 4, -34 },
  { 8905, 17, 35, 21, 2, -34 },
  { 8980, 15, 41, 17, 1, -40 },
  { 9057, 21, 34, 29, 4, -33 },
  { 9147, 24, 33, 24, 0, -33 },
  { 9246, 38, 33, 38, 0, -33 },
  { 9403, 22, 33, 24, 1, -33 },
  { 9494, 24, 48, 24, 0, -33 },
  { 9638, 17, 33, 20, 1, -33 },
  { 9709, 17, 54, 22, 2, -44 },
  { 9824, 5, 61, 25, 10, -47 },
  { 9863, 18, 54, 22, 2, -44 },
  { 9985, 23, 9, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Medium61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM61PT7B_H_
