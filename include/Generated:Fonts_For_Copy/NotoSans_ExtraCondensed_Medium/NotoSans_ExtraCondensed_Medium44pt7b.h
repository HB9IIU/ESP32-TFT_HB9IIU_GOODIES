#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0x9C, 0xE7, 0x38, 0x00, 0x03, 0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0xFB, 0xC3,
  0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0x9C, 0x1C, 0x03, 0x87, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x78, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x70, 0xE0, 0x0E, 0x1C,
  0x03, 0xC7, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC3, 0x83, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0x8F, 0x00, 0xE1, 0xE0,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x70, 0x0F, 0x1E, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0xF9, 0x84, 0xF1, 0x80, 0xF1,
  0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF9, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xBE, 0x01,
  0x9E, 0x01, 0x8F, 0x01, 0x8F, 0x01, 0x8E, 0x81, 0x9E, 0xE1, 0xBE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x00, 0x08, 0x07, 0xE0, 0x0E, 0x01,
  0xFE, 0x01, 0xC0, 0x39, 0xC0, 0x78, 0x0F, 0x3C, 0x0E, 0x01, 0xC3, 0x83,
  0xC0, 0x38, 0x70, 0x70, 0x07, 0x0E, 0x0E, 0x00, 0xE1, 0xC3, 0xC0, 0x1C,
  0x3C, 0x70, 0x03, 0x87, 0x8E, 0x00, 0x70, 0xF3, 0xC0, 0x0E, 0x1C, 0x70,
  0x01, 0xC3, 0x8E, 0x3E, 0x38, 0x73, 0xCF, 0xE7, 0x9E, 0x73, 0xFE, 0x73,
  0x8E, 0x71, 0xCF, 0xF3, 0xCE, 0x38, 0xFC, 0x73, 0xC7, 0x8F, 0x1E, 0x78,
  0xF0, 0x03, 0x8F, 0x1E, 0x00, 0x71, 0xE3, 0xC0, 0x1E, 0x3C, 0x38, 0x03,
  0x87, 0x8F, 0x00, 0x70, 0xF1, 0xE0, 0x1E, 0x1E, 0x3C, 0x03, 0x83, 0xC7,
  0x80, 0x70, 0x38, 0xE0, 0x1E, 0x07, 0x1C, 0x03, 0x80, 0xFF, 0x80, 0xF0,
  0x0F, 0xE0, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x07, 0x8F, 0x3C, 0x7C, 0xF9, 0xF3, 0xE7, 0x87, 0x9E,
  0x7C, 0x3E, 0xF3, 0xE0, 0xFF, 0x9F, 0x03, 0xF8, 0xF8, 0x1F, 0xC7, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFE, 0xF0,
  0xFF, 0xE7, 0xC1, 0xFC, 0x1F, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC,
  0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x1E,
  0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x71, 0xCE,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1E, 0x78, 0x3E, 0x7C, 0x1C, 0x38, 0x0C, 0x30, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x9E, 0x3C,
  0x78, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xE7, 0xFF, 0x7D,
  0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7C, 0x7C, 0x7C,
  0x3C, 0x78, 0x3C, 0x78, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x7C, 0x7C, 0x3E, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE,
  0xFB, 0xFE, 0xFF, 0x9F, 0x63, 0xE8, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x78, 0x3E, 0x30, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE,
  0x78, 0x3E, 0x20, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x3F,
  0x78, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x0F,
  0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x7F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x88, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x10, 0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF7, 0xCF,
  0xEF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xF8, 0xF7,
  0xFC, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3E, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC1, 0xE3, 0xE0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0x8F, 0x87, 0x83, 0xE7,
  0x81, 0xF3, 0xC0, 0x7D, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xDE, 0x03, 0xEF, 0x81, 0xE7, 0xE3, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F,
  0xFF, 0x1F, 0xEF, 0x0F, 0xCF, 0x07, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x21, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x77, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x19, 0xEF, 0xFF, 0xFE, 0x39, 0xF7, 0xDF, 0x7D,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7D,
  0xF7, 0x9E, 0x7B, 0xCF, 0x3C, 0xE3, 0x80, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0x80, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x70, 0xF8, 0x81, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x83, 0xE0, 0x0F, 0x80,
  0x3C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x0E, 0x07, 0xF1, 0xE7, 0x87, 0xFC, 0x39, 0xC1, 0xFF, 0x0E,
  0x70, 0xF1, 0xC3, 0xBC, 0x38, 0x70, 0xFF, 0x1E, 0x1C, 0x3F, 0xC7, 0x87,
  0x0F, 0xE1, 0xC1, 0xC3, 0xF8, 0x70, 0x70, 0xFE, 0x1C, 0x1C, 0x3F, 0x87,
  0x0F, 0x0E, 0xE1, 0xC3, 0xC3, 0xB8, 0x70, 0xF0, 0xEE, 0x1E, 0x3C, 0x3B,
  0xC3, 0x9F, 0x9C, 0xF0, 0xFE, 0xFF, 0x1C, 0x1F, 0x9F, 0x87, 0x03, 0xC3,
  0xC1, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x80, 0x0F, 0xE1, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x01, 0xE3,
  0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x0F, 0x7C, 0x00,
  0x7B, 0xE0, 0x03, 0xE0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x0F,
  0xEF, 0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x07, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1,
  0xFF, 0xF8, 0xF0, 0xFE, 0x78, 0x0F, 0xBC, 0x03, 0xDE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC,
  0x07, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8, 0x31, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x21, 0xFE, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE3, 0xC7, 0xF8, 0xF0, 0x3F, 0x3C, 0x07, 0xCF, 0x00, 0xFB, 0xC0, 0x3E,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x3E,
  0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x07, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xC1, 0xE1, 0xF0,
  0x04, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0xEF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xF3, 0xF8, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xF3, 0xFF,
  0xF7, 0xFB, 0xF8, 0xF0, 0xF8, 0x0F, 0xBE, 0x03, 0xCF, 0x81, 0xF3, 0xE0,
  0x78, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xEF, 0x80, 0xFB, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0x9F, 0x03, 0xE3,
  0xC0, 0xF8, 0xF8, 0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0x7C, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xDC, 0x00, 0xEF, 0xF7, 0x80, 0x3B, 0xFD, 0xE0,
  0x1E, 0xFF, 0x38, 0x07, 0xBF, 0xCF, 0x01, 0xCF, 0xF3, 0xC0, 0xF3, 0xFC,
  0xF0, 0x3C, 0xFF, 0x1C, 0x0F, 0x3F, 0xC7, 0x83, 0x8F, 0xF1, 0xE1, 0xE3,
  0xFC, 0x78, 0x78, 0xFF, 0x0F, 0x1C, 0x3F, 0xC3, 0xCF, 0x0F, 0xF0, 0xF3,
  0xC3, 0xFC, 0x1C, 0xF0, 0xFF, 0x07, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F,
  0xF0, 0x3F, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3C, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0x78, 0x0F, 0xF7, 0x80, 0xFF, 0x7C, 0x0F, 0xF3,
  0xC0, 0xFF, 0x3C, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF8, 0xFF, 0x07, 0x8F, 0xF0, 0x78, 0xFF, 0x03, 0xCF,
  0xF0, 0x3C, 0xFF, 0x03, 0xEF, 0xF0, 0x1E, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xF0, 0xFC, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80,
  0x3C, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF1, 0xFE,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x01, 0xF0, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0,
  0x01, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0x7C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC7, 0xF8, 0xF0, 0x3E,
  0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF,
  0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0x1F, 0x03, 0xC3, 0xC0, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F,
  0x01, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE7, 0xE3, 0xDF, 0x01, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xF6, 0x03, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xBE, 0x01, 0xE7, 0xC0, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0x9E,
  0x00, 0x3D, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0,
  0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0,
  0x3E, 0x3C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0,
  0x3C, 0x3C, 0x0E, 0x70, 0x7C, 0x3E, 0x0E, 0x70, 0x7C, 0x1E, 0x1E, 0x78,
  0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78,
  0x78, 0x1F, 0x1C, 0x38, 0xF8, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x3C,
  0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F, 0x38, 0x1D,
  0xF0, 0x07, 0xB8, 0x1D, 0xE0, 0x07, 0xF8, 0x1D, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x7C, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x07, 0xBC,
  0x03, 0xCF, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1F, 0x0F, 0x83, 0xC3,
  0xE0, 0xF8, 0xF0, 0x3E, 0x7C, 0x07, 0x9E, 0x01, 0xFF, 0x80, 0x7C, 0xF8,
  0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x79, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x83,
  0xC3, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0xFF, 0xFE, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x79, 0xE0,
  0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x78,
  0xF0, 0x0F, 0x1E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xF3, 0xF1, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x3F, 0xF8, 0xFF,
  0xF3, 0xFD, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFB, 0xC1, 0xF7, 0xC7, 0xEF, 0xFD, 0xCF, 0xF3, 0x8F, 0xC7, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xF8, 0xF7, 0xFC, 0xFF,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xFE, 0x7E, 0xFF,
  0xFC, 0xE7, 0xF8, 0xE3, 0xF0, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7,
  0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xE3, 0x9F, 0xFC, 0x7F, 0xE1, 0xFE, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x0F, 0x8F, 0x1F, 0xEF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7C, 0x3F,
  0x78, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7E, 0x7F, 0x3F, 0xFF, 0x3F, 0xEF,
  0x1F, 0xC7, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xF3, 0xE7, 0x83, 0xCF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x13, 0xE0, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x01,
  0xE0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0x1F, 0xEF, 0x3F,
  0xEF, 0x7F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x3F, 0x7E,
  0x7F, 0x3F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x40, 0x1E, 0x70, 0x7E, 0x7F, 0xFC, 0x7F,
  0xF8, 0x3F, 0xF0, 0x02, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE7, 0xE3,
  0xDF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x6F, 0xFF, 0xF6, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x06, 0x0F, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1F, 0x9F, 0xFE, 0xFE, 0xFC, 0x30, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF0,
  0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFD, 0xE0, 0xF9, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3E,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xF0, 0x7C, 0x73, 0xFC,
  0xFF, 0xBB, 0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0xC1,
  0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07, 0xF8,
  0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x7F,
  0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07,
  0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0xFF, 0x03, 0xE0,
  0x7F, 0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xE3, 0xF1,
  0xCF, 0xF3, 0xBF, 0xF7, 0xFF, 0xEF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1E, 0x7C, 0x1E, 0x7E,
  0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xE3, 0xF0, 0xE7, 0xF8, 0xF7,
  0xFC, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xFE,
  0x7E, 0xFF, 0xFC, 0xF7, 0xF8, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0x1F, 0xEF, 0x3F, 0xEF, 0x7F,
  0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7E, 0x7F, 0x3F,
  0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xE3, 0xFC, 0xFB, 0x9F, 0x77, 0xEF, 0xE3, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x0F, 0xE1, 0xFF, 0xDF, 0xFC, 0xF9, 0xE7, 0x81, 0x7C, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xFF, 0x1F, 0xFF, 0xFB,
  0xFF, 0x8F, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x7F, 0xBF,
  0xF7, 0xFE, 0xFF, 0xC7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xC4, 0xFF, 0x8F, 0xF0, 0xFE, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xEF, 0xFF,
  0xDF, 0xF7, 0x9F, 0xCF, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x01,
  0xE7, 0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0x71, 0xE0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xEF, 0x03,
  0xE0, 0x3D, 0xE0, 0x7E, 0x07, 0xBC, 0x0F, 0xC1, 0xF7, 0x81, 0xF8, 0x3C,
  0xF8, 0x7F, 0x07, 0x8F, 0x0E, 0xE0, 0xF1, 0xE1, 0xDE, 0x1E, 0x3C, 0x3B,
  0xC7, 0x87, 0x87, 0x38, 0xF0, 0x79, 0xE7, 0x1E, 0x0F, 0x3C, 0xE3, 0xC1,
  0xE7, 0x1E, 0x78, 0x3C, 0xE3, 0xDE, 0x07, 0x9C, 0x7B, 0xC0, 0x73, 0x87,
  0x78, 0x0F, 0xF0, 0xEF, 0x01, 0xFC, 0x1D, 0xC0, 0x3F, 0x83, 0xB8, 0x07,
  0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x78, 0x0F, 0x3E, 0x0F, 0x8F, 0x07, 0x87, 0xC3,
  0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBE, 0x07, 0x8F, 0x03, 0xC7, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF1, 0xF0, 0x3D, 0xF0, 0x1F, 0xF8, 0x07, 0xBC, 0x07, 0xDE,
  0x03, 0xEF, 0x01, 0xE7, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C,
  0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x79,
  0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x02, 0x3E,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08,
  0x07, 0xC0, 0xFE, 0x07, 0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x3F, 0xC1, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x08,
  0x00, 0xBF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFC, 0x03, 0xFA,
  0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 13, 11, 18, 2, -31 },
  { 39, 19, 31, 21, 1, -31 },
  { 113, 16, 36, 19, 2, -33 },
  { 185, 27, 32, 31, 2, -32 },
  { 293, 21, 32, 22, 1, -32 },
  { 377, 5, 11, 10, 2, -31 },
  { 384, 10, 39, 13, 2, -32 },
  { 433, 10, 39, 13, 1, -32 },
  { 482, 16, 15, 18, 1, -33 },
  { 512, 17, 21, 19, 1, -26 },
  { 557, 7, 11, 10, 1, -5 },
  { 567, 10, 4, 12, 1, -14 },
  { 572, 6, 6, 10, 2, -6 },
  { 577, 15, 32, 17, 1, -32 },
  { 637, 16, 32, 19, 2, -32 },
  { 701, 11, 31, 19, 3, -31 },
  { 744, 16, 32, 19, 1, -32 },
  { 808, 16, 32, 19, 1, -32 },
  { 872, 18, 32, 19, 1, -32 },
  { 944, 15, 31, 19, 2, -31 },
  { 1003, 16, 32, 19, 2, -32 },
  { 1067, 17, 31, 19, 1, -31 },
  { 1133, 17, 32, 19, 1, -32 },
  { 1201, 16, 32, 19, 1, -32 },
  { 1265, 5, 24, 10, 3, -24 },
  { 1280, 6, 30, 10, 2, -24 },
  { 1303, 17, 20, 19, 1, -26 },
  { 1346, 17, 13, 19, 1, -22 },
  { 1374, 17, 20, 19, 1, -26 },
  { 1417, 14, 32, 15, 0, -32 },
  { 1473, 26, 36, 30, 2, -32 },
  { 1590, 21, 31, 21, 0, -31 },
  { 1672, 17, 31, 22, 3, -31 },
  { 1738, 17, 32, 20, 2, -32 },
  { 1806, 18, 31, 23, 3, -31 },
  { 1876, 13, 31, 18, 3, -31 },
  { 1927, 13, 31, 17, 3, -31 },
  { 1978, 20, 32, 24, 2, -32 },
  { 2058, 18, 31, 24, 3, -31 },
  { 2128, 10, 31, 13, 1, -31 },
  { 2167, 9, 40, 11, -2, -31 },
  { 2212, 18, 31, 21, 3, -31 },
  { 2282, 13, 31, 17, 3, -31 },
  { 2333, 26, 31, 32, 3, -31 },
  { 2434, 20, 31, 26, 3, -31 },
  { 2512, 21, 32, 25, 2, -32 },
  { 2596, 16, 31, 20, 3, -31 },
  { 2658, 21, 39, 25, 2, -32 },
  { 2761, 18, 31, 21, 3, -31 },
  { 2831, 15, 32, 18, 2, -32 },
  { 2891, 17, 31, 17, 0, -31 },
  { 2957, 18, 31, 24, 3, -31 },
  { 3027, 20, 31, 20, 0, -31 },
  { 3105, 32, 31, 32, 0, -31 },
  { 3229, 18, 31, 19, 0, -31 },
  { 3299, 18, 31, 18, 0, -31 },
  { 3369, 15, 31, 17, 1, -31 },
  { 3428, 9, 39, 14, 3, -32 },
  { 3472, 15, 32, 17, 1, -32 },
  { 3532, 10, 39, 14, 1, -32 },
  { 3581, 19, 17, 21, 1, -31 },
  { 3622, 19, 3, 19, 0, 4 },
  { 3630, 9, 7, 12, 2, -34 },
  { 3638, 15, 24, 19, 1, -24 },
  { 3683, 16, 33, 21, 3, -33 },
  { 3749, 13, 24, 16, 2, -24 },
  { 3788, 16, 33, 21, 2, -33 },
  { 3854, 15, 24, 19, 2, -24 },
  { 3899, 13, 34, 12, 0, -34 },
  { 3955, 16, 35, 21, 2, -24 },
  { 4025, 15, 33, 21, 3, -33 },
  { 4087, 4, 33, 10, 3, -33 },
  { 4104, 8, 44, 10, -1, -33 },
  { 4148, 16, 33, 19, 3, -33 },
  { 4214, 4, 33, 10, 3, -33 },
  { 4231, 25, 24, 31, 3, -24 },
  { 4306, 15, 24, 21, 3, -24 },
  { 4351, 16, 24, 20, 2, -24 },
  { 4399, 16, 35, 21, 3, -24 },
  { 4469, 16, 35, 21, 2, -24 },
  { 4539, 11, 24, 14, 3, -24 },
  { 4572, 13, 24, 15, 1, -24 },
  { 4611, 11, 29, 12, 1, -29 },
  { 4651, 15, 24, 21, 3, -24 },
  { 4696, 17, 24, 17, 0, -24 },
  { 4747, 27, 24, 28, 0, -24 },
  { 4828, 17, 24, 17, 0, -24 },
  { 4879, 17, 35, 17, 0, -24 },
  { 4954, 12, 24, 14, 1, -24 },
  { 4990, 13, 39, 16, 1, -32 },
  { 5054, 4, 44, 18, 7, -34 },
  { 5076, 12, 39, 16, 2, -32 },
  { 5135, 17, 7, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Medium44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM44PT7B_H_
