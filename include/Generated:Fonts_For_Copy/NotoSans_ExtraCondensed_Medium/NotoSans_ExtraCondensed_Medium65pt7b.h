#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF8, 0x00,
  0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C,
  0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFE, 0xE3, 0xE7, 0xF1, 0xC0, 0xCF, 0xC3, 0x80,
  0x1F, 0x87, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x1C, 0x00, 0xF8, 0x38, 0x01,
  0xF8, 0x70, 0x03, 0xF0, 0xE0, 0x07, 0xF1, 0xC0, 0x07, 0xF3, 0x80, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0x7F, 0x80, 0x0E, 0x7F, 0x00, 0x1C, 0x7F, 0x00, 0x38, 0x7E, 0x00, 0x70,
  0xFC, 0x00, 0xE1, 0xF8, 0x01, 0xC3, 0xF0, 0x03, 0x87, 0xF0, 0x07, 0x0F,
  0xF0, 0x0E, 0x3F, 0x78, 0x1C, 0xFE, 0xFF, 0x3F, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0x80, 0x03, 0xF7, 0xE0, 0x07, 0xC0, 0x01, 0xF1, 0xF0,
  0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x1F, 0x00,
  0x01, 0xF0, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0x3C,
  0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x07, 0xC3, 0xE0, 0x30, 0x0F, 0x83, 0xE1,
  0xF0, 0xFE, 0x07, 0xC1, 0xF1, 0xF0, 0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0xFF,
  0xE1, 0xF0, 0x7C, 0x78, 0x7F, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3F,
  0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0xFE, 0x3E, 0x3E, 0x0F, 0x87, 0xFF, 0x1F,
  0x1F, 0x07, 0xC1, 0xFF, 0x0F, 0x8F, 0x83, 0xE0, 0x3E, 0x0F, 0x87, 0xC1,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x81,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x80,
  0x3C, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xCF,
  0x80, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x01, 0xF8, 0x3F, 0xFE, 0x07, 0xF0, 0xFE, 0xFE, 0x0F, 0xE1, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xFC, 0x7E, 0x3F, 0x81,
  0xF8, 0xFC, 0x7F, 0x03, 0xFB, 0xF8, 0xFC, 0x03, 0xFF, 0xE1, 0xF8, 0x03,
  0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0x07, 0xE0, 0x07, 0xFE, 0x0F, 0xC0, 0x07,
  0xFC, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0xE0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xF8, 0x7F,
  0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x38, 0x00, 0x00, 0xFF, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x9F, 0x3E, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1C, 0x1F, 0x07, 0x3F, 0x3E, 0x7E,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x0F,
  0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0xC1, 0xFC, 0x1F, 0x80, 0xF0,
  0x3E, 0x00, 0x60, 0x30, 0x00, 0x40, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E,
  0x10, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x81, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x8F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x3F, 0xBF, 0x7F, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x78,
  0x3F, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3E, 0x03, 0xFC, 0x38, 0x01, 0xFC, 0x10, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xDF, 0xFC, 0x3C, 0x03,
  0xFC, 0x38, 0x01, 0xFC, 0x10, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x80, 0x01, 0xFE, 0xC0, 0x01, 0xFC, 0xF8, 0x07, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0xF9, 0xF8, 0x00, 0x1E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF0,
  0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x08, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xA0, 0x00, 0xFE, 0x60,
  0x03, 0xFC, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x18, 0x03, 0xF1, 0xFF, 0x07, 0xE7, 0xFF, 0x0F, 0xDF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFE, 0xFF, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x8F, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F,
  0x80, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F,
  0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x3F,
  0xC7, 0xFF, 0x3F, 0xFF, 0xBE, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0x7E, 0x07,
  0xFE, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x20, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x1F,
  0x0F, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0x7E, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1,
  0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9E, 0x07, 0xF9, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x03, 0xFF, 0x07, 0xC3,
  0xE0, 0x1F, 0xFE, 0x0F, 0x8F, 0x80, 0xFF, 0xF8, 0x3E, 0x7C, 0x07, 0xFF,
  0xE0, 0xF9, 0xF0, 0x3F, 0x0F, 0x81, 0xE7, 0xC0, 0xF8, 0x3E, 0x07, 0xDF,
  0x07, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F,
  0x81, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xFE, 0x0F, 0x80, 0xF8, 0x1F, 0xF8,
  0x3E, 0x03, 0xE0, 0x7F, 0xE0, 0xF8, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7E,
  0x07, 0xFE, 0x0F, 0x81, 0xF8, 0x1F, 0xF8, 0x3E, 0x07, 0xE0, 0x7F, 0xE0,
  0xF8, 0x1F, 0x81, 0xEF, 0x83, 0xE0, 0x7E, 0x0F, 0xBE, 0x0F, 0x81, 0xF8,
  0x3E, 0xF8, 0x1F, 0x07, 0xE0, 0xFB, 0xE0, 0x7C, 0x3F, 0x83, 0xCF, 0x81,
  0xF8, 0xEE, 0x1F, 0x3F, 0x03, 0xFF, 0xBF, 0xFC, 0x7C, 0x0F, 0xFC, 0xFF,
  0xE1, 0xF0, 0x1F, 0xF1, 0xFF, 0x07, 0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0x80,
  0x30, 0x03, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFC,
  0x1F, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xE0, 0x3C, 0x1F, 0xE0, 0x04, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x01, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x40, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xE3, 0xF0, 0x07,
  0xF8, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFB, 0xF0,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xE3, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0x81, 0xFE,
  0x00, 0x0C, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x3F, 0x0F, 0xF0,
  0x01, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x87, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF1, 0xFC, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0,
  0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF3, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE,
  0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0xFF, 0xEF,
  0x80, 0x00, 0xFF, 0xFF, 0xBF, 0x00, 0x03, 0xEF, 0xFE, 0xFC, 0x00, 0x0F,
  0xBF, 0xFD, 0xF0, 0x00, 0x7E, 0xFF, 0xF7, 0xE0, 0x01, 0xFB, 0xFF, 0xDF,
  0x80, 0x07, 0xCF, 0xFF, 0x3E, 0x00, 0x1F, 0x3F, 0xFC, 0xF8, 0x00, 0xFC,
  0xFF, 0xF3, 0xF0, 0x03, 0xE3, 0xFF, 0xCF, 0xC0, 0x0F, 0x8F, 0xFF, 0x1F,
  0x00, 0x7E, 0x3F, 0xFC, 0x7C, 0x01, 0xF8, 0xFF, 0xF1, 0xF8, 0x07, 0xC3,
  0xFF, 0xC7, 0xE0, 0x1F, 0x0F, 0xFF, 0x0F, 0x80, 0xFC, 0x3F, 0xFC, 0x3F,
  0x03, 0xE0, 0xFF, 0xF0, 0xFC, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7E, 0x0F,
  0xFF, 0x07, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x87, 0xC0, 0xFF, 0xF0, 0x7E,
  0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0xFC, 0x0F, 0xFF, 0x03, 0xF3, 0xE0, 0x3F,
  0xFC, 0x0F, 0xCF, 0x80, 0xFF, 0xF0, 0x3F, 0x3E, 0x03, 0xFF, 0xC0, 0x7D,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0xFC, 0x00, 0xFF, 0xF7,
  0xE0, 0x07, 0xFF, 0x9F, 0x80, 0x3F, 0xFE, 0xFC, 0x01, 0xFF, 0xF3, 0xF0,
  0x0F, 0xFF, 0x9F, 0x80, 0x7F, 0xFC, 0xFE, 0x03, 0xFF, 0xE3, 0xF0, 0x1F,
  0xFF, 0x1F, 0x80, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0xC3, 0xF0, 0x3F, 0xFE,
  0x0F, 0xC1, 0xFF, 0xF0, 0x7E, 0x0F, 0xFF, 0x83, 0xF8, 0x7F, 0xFC, 0x0F,
  0xC3, 0xFF, 0xE0, 0x7E, 0x1F, 0xFF, 0x01, 0xF8, 0xFF, 0xF8, 0x0F, 0xC7,
  0xFF, 0xC0, 0x7F, 0x1F, 0xFE, 0x01, 0xF8, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF,
  0x80, 0x3F, 0x3F, 0xFC, 0x01, 0xF9, 0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0x00,
  0x3F, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0xFC,
  0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F,
  0xDF, 0x80, 0xFF, 0x3F, 0x07, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xE0, 0xFF, 0xC3, 0xF0, 0x1F, 0xF1, 0xF8, 0x03, 0xF8, 0xFC,
  0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFC,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F,
  0x8F, 0xC0, 0x7F, 0x87, 0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0x87,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1,
  0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F,
  0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xF0, 0x3E, 0x3F, 0xC0, 0x0C, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x60, 0x00, 0xFE, 0xF0, 0x03, 0xF9, 0xFF, 0x3F, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x00, 0x74, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFB,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x7E,
  0x00, 0x3F, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7B, 0xE0, 0x07, 0xE1, 0xFC,
  0x01, 0xF7, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x83, 0xF0,
  0x07, 0xDF, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xBF, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF1, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xE3, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x01, 0xFC, 0x1F,
  0x87, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x0F, 0x83, 0xF8, 0x03, 0xF0, 0x7C,
  0x1F, 0x07, 0xF0, 0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0,
  0x7E, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x7C, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x03,
  0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x07,
  0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0x03, 0xF7, 0xC0, 0x1F,
  0x7E, 0x00, 0x07, 0xEF, 0x80, 0x3E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x7D,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x7B, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x0F,
  0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0x3F, 0xE0, 0xE0, 0x3F, 0x82, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0x7F, 0x80, 0xFD, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0,
  0x7F, 0xDF, 0xF3, 0xFF, 0x7F, 0xFF, 0x7C, 0xFF, 0xF9, 0xF1, 0xFF, 0xC7,
  0xC3, 0xFC, 0x1F, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0x00,
  0xFC, 0x3F, 0xC0, 0xFC, 0x7F, 0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFE,
  0xFF, 0x80, 0xFE, 0xFF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xF8,
  0xFC, 0xFF, 0xF0, 0xF8, 0xFF, 0xF0, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0xF0, 0x33, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x4F,
  0xF0, 0x39, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xC0, 0x05, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x3F, 0x07, 0xFC,
  0x3F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFF, 0x3F, 0x3F, 0xFF, 0xBF, 0x3F, 0xFF,
  0xFF, 0x7F, 0x83, 0xFF, 0x7F, 0x01, 0xFF, 0x7E, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x01,
  0xFF, 0x7F, 0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF,
  0x3F, 0x0F, 0xFE, 0x3F, 0x07, 0xFC, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0x3F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x00, 0xF9, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x23, 0xFC, 0x03, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFC, 0x3F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFF, 0x3F, 0x1F, 0xFF, 0xBF,
  0x3F, 0xFF, 0xBF, 0x3F, 0x83, 0xFF, 0x7F, 0x01, 0xFF, 0x7F, 0x00, 0xFF,
  0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0xFF,
  0x7F, 0x01, 0xFF, 0x7F, 0x83, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF,
  0x1F, 0xFF, 0x3F, 0x0F, 0xFE, 0x3F, 0x07, 0xFC, 0x3F, 0x00, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x60, 0x01, 0xFC,
  0x7C, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xE0, 0x3F, 0x1F, 0xF0, 0x7E, 0x7F, 0xF8, 0xFD, 0xFF, 0xF1, 0xFB, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0xEF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xE0, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x03, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F,
  0xBF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0x7E, 0x03, 0xFC, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x1E, 0x03, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0x8F, 0xFE, 0x1F, 0xFE,
  0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0xFD, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0xF8, 0x7F, 0xBF, 0xC0, 0x7F, 0xC0, 0xFE,
  0xFF, 0x01, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x0F, 0x01, 0xF0, 0xFF, 0x83, 0xE3, 0xFF, 0xC7, 0xCF, 0xFF,
  0x8F, 0xDF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0x7F, 0x80, 0xFE,
  0xFF, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0xF8, 0x3F, 0xC0, 0xF8, 0xFF, 0xF0, 0xFC, 0xFF, 0xF8,
  0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFD, 0xFF, 0xF8, 0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xF0, 0xFC, 0x3F, 0xC0,
  0xFC, 0x07, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFF, 0x3F,
  0x1F, 0xFF, 0xBF, 0x3F, 0xFF, 0xBF, 0x3F, 0x83, 0xFF, 0x7F, 0x01, 0xFF,
  0x7F, 0x00, 0xFF, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0x7E, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x7F, 0x83, 0xFF, 0x3F, 0xFF, 0xBF,
  0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFE, 0x3F, 0x07, 0xFC, 0x3F,
  0x00, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xFD, 0xFE,
  0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xBF, 0x1F, 0x80, 0x67, 0xF0, 0x04, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xBC,
  0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE1, 0x0F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x70, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFD, 0xFC, 0x1F, 0xF7, 0xFF, 0xF7, 0xCF, 0xFF, 0xDF,
  0x3F, 0xFE, 0x7C, 0x7F, 0xF1, 0xF0, 0xFF, 0x87, 0xC0, 0x38, 0x00, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC,
  0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x07,
  0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0xC0, 0x3F, 0x3F,
  0x01, 0xF7, 0x80, 0x7E, 0x7E, 0x03, 0xEF, 0x81, 0xF8, 0x7E, 0x07, 0xDF,
  0x03, 0xF0, 0xFC, 0x0F, 0xBE, 0x07, 0xE1, 0xF8, 0x1E, 0x7C, 0x0F, 0xC3,
  0xF0, 0x7C, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0xF8, 0x7E, 0x07, 0xE1, 0xF1,
  0xF0, 0xFC, 0x0F, 0xC3, 0xE3, 0xE1, 0xF8, 0x1F, 0x87, 0xC7, 0xC3, 0xF0,
  0x3F, 0x1F, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x1F, 0x1F, 0x80, 0x7E, 0x7C,
  0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x7C, 0xF8,
  0x03, 0xF3, 0xE0, 0xF9, 0xF0, 0x03, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xDF,
  0x01, 0xEF, 0xC0, 0x0F, 0xBE, 0x03, 0xDF, 0x80, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7F, 0x00,
  0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x83,
  0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF,
  0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7,
  0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C,
  0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFD, 0x00, 0x07, 0xF8,
  0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 47, 16, 4, -46 },
  { 48, 18, 16, 26, 4, -46 },
  { 84, 29, 46, 31, 1, -46 },
  { 251, 23, 53, 29, 3, -49 },
  { 404, 41, 48, 45, 2, -47 },
  { 650, 31, 48, 33, 2, -47 },
  { 836, 7, 16, 14, 4, -46 },
  { 850, 15, 57, 19, 3, -47 },
  { 957, 14, 57, 19, 2, -47 },
  { 1057, 23, 23, 27, 2, -49 },
  { 1124, 25, 30, 29, 2, -38 },
  { 1218, 10, 16, 15, 2, -7 },
  { 1238, 15, 7, 18, 2, -21 },
  { 1252, 8, 9, 15, 4, -8 },
  { 1261, 23, 47, 25, 1, -47 },
  { 1397, 23, 48, 28, 3, -47 },
  { 1535, 16, 46, 28, 4, -46 },
  { 1627, 24, 47, 28, 2, -47 },
  { 1768, 24, 48, 28, 2, -47 },
  { 1912, 27, 47, 28, 1, -47 },
  { 2071, 23, 47, 28, 3, -46 },
  { 2207, 23, 48, 28, 3, -47 },
  { 2345, 24, 46, 28, 2, -46 },
  { 2483, 24, 48, 28, 2, -47 },
  { 2627, 24, 48, 28, 2, -47 },
  { 2771, 8, 36, 15, 4, -35 },
  { 2807, 10, 44, 15, 2, -35 },
  { 2862, 25, 30, 29, 2, -38 },
  { 2956, 25, 18, 29, 2, -32 },
  { 3013, 25, 30, 29, 2, -38 },
  { 3107, 19, 48, 22, 1, -47 },
  { 3221, 38, 52, 44, 3, -47 },
  { 3468, 31, 46, 31, 0, -46 },
  { 3647, 24, 46, 32, 5, -46 },
  { 3785, 25, 48, 30, 3, -47 },
  { 3935, 26, 46, 34, 5, -46 },
  { 4085, 19, 46, 27, 5, -46 },
  { 4195, 19, 46, 26, 5, -46 },
  { 4305, 29, 48, 36, 3, -47 },
  { 4479, 26, 46, 36, 5, -46 },
  { 4629, 15, 46, 19, 2, -46 },
  { 4716, 14, 59, 16, -3, -46 },
  { 4820, 26, 46, 30, 5, -46 },
  { 4970, 19, 46, 25, 5, -46 },
  { 5080, 38, 46, 48, 5, -46 },
  { 5299, 29, 46, 38, 5, -46 },
  { 5466, 31, 48, 37, 3, -47 },
  { 5652, 23, 46, 30, 5, -46 },
  { 5785, 31, 58, 37, 3, -47 },
  { 6010, 25, 46, 31, 5, -46 },
  { 6154, 23, 48, 27, 2, -47 },
  { 6292, 24, 46, 26, 1, -46 },
  { 6430, 27, 47, 35, 4, -46 },
  { 6589, 30, 46, 30, 0, -46 },
  { 6762, 47, 46, 47, 0, -46 },
  { 7033, 27, 46, 27, 0, -46 },
  { 7189, 27, 46, 27, 0, -46 },
  { 7345, 22, 46, 24, 1, -46 },
  { 7472, 14, 57, 20, 4, -47 },
  { 7572, 23, 47, 25, 1, -47 },
  { 7708, 14, 57, 20, 2, -47 },
  { 7808, 28, 25, 30, 1, -46 },
  { 7896, 28, 5, 28, 0, 5 },
  { 7914, 13, 11, 18, 3, -50 },
  { 7932, 22, 37, 28, 2, -36 },
  { 8034, 24, 50, 31, 4, -49 },
  { 8184, 19, 37, 24, 3, -36 },
  { 8272, 24, 50, 31, 3, -49 },
  { 8422, 22, 37, 28, 3, -36 },
  { 8524, 18, 50, 17, 1, -50 },
  { 8637, 24, 52, 31, 3, -36 },
  { 8793, 23, 49, 30, 4, -49 },
  { 8934, 7, 48, 14, 4, -48 },
  { 8976, 12, 64, 14, -1, -48 },
  { 9072, 23, 49, 28, 4, -49 },
  { 9213, 6, 49, 14, 4, -49 },
  { 9250, 38, 36, 46, 4, -36 },
  { 9421, 23, 36, 30, 4, -36 },
  { 9525, 24, 37, 30, 3, -36 },
  { 9636, 24, 52, 31, 4, -36 },
  { 9792, 24, 52, 31, 3, -36 },
  { 9948, 16, 36, 21, 4, -36 },
  { 10020, 19, 37, 23, 2, -36 },
  { 10108, 16, 44, 18, 1, -43 },
  { 10196, 22, 36, 30, 4, -35 },
  { 10295, 25, 35, 25, 0, -35 },
  { 10405, 39, 35, 41, 1, -35 },
  { 10576, 24, 35, 25, 1, -35 },
  { 10681, 25, 51, 25, 0, -35 },
  { 10841, 19, 35, 21, 1, -35 },
  { 10925, 19, 57, 23, 2, -47 },
  { 11061, 5, 65, 27, 11, -50 },
  { 11102, 18, 57, 23, 3, -47 },
  { 11231, 25, 9, 29, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Medium65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM65PT7B_H_
