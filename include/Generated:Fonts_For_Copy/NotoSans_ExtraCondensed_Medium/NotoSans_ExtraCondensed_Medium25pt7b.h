#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xF6, 0xE7, 0xE7,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0x88,
  0xFF, 0xDF, 0xF8, 0xCC, 0x19, 0x83, 0x30, 0x66, 0x7F, 0xFF, 0xFE, 0x66,
  0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0x08, 0x04, 0x0F, 0xCF, 0xFE, 0x96,
  0x43, 0x21, 0xD0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x98, 0x4C, 0x27, 0x96,
  0xFF, 0x1E, 0x02, 0x01, 0x00, 0x78, 0x30, 0xF0, 0xC3, 0x31, 0x86, 0x63,
  0x0C, 0xCC, 0x19, 0x98, 0x33, 0x30, 0x66, 0xCE, 0xCD, 0xBE, 0xF2, 0x6D,
  0xED, 0x98, 0x1B, 0x30, 0x66, 0x60, 0xCC, 0xC1, 0x99, 0x86, 0x13, 0x0C,
  0x3E, 0x38, 0x38, 0x3C, 0x03, 0xE0, 0x77, 0x06, 0x70, 0x67, 0x07, 0x60,
  0x76, 0x03, 0xC0, 0x38, 0x07, 0xCE, 0xEE, 0xEC, 0x6E, 0xC7, 0xCC, 0x3C,
  0xC3, 0x8E, 0x3C, 0xFF, 0xE7, 0xCF, 0xFD, 0xB6, 0xD8, 0x1C, 0x63, 0x0C,
  0x71, 0x86, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC3, 0x0C,
  0x18, 0x70, 0xC7, 0x18, 0xE3, 0x18, 0xE3, 0x18, 0xC6, 0x31, 0x8C, 0x67,
  0x31, 0x9C, 0xCE, 0x60, 0x18, 0x18, 0x99, 0xFF, 0xFF, 0x3C, 0x76, 0x67,
  0x24, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0x76, 0x6E, 0xCC, 0xFF, 0xC0, 0x7D, 0x80, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x00, 0x3C, 0x3F, 0x1D, 0xCC, 0x6E,
  0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x8C,
  0xCE, 0x7F, 0x1F, 0x00, 0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x7F, 0xB1, 0xC0,
  0x60, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x07, 0x03, 0x03, 0x83, 0x81, 0x81,
  0xC1, 0xC0, 0xFF, 0xFF, 0xC0, 0x7E, 0x7F, 0xB1, 0xC0, 0x60, 0x38, 0x18,
  0x0C, 0x1C, 0x3C, 0x1F, 0x01, 0xC0, 0x70, 0x38, 0x1C, 0x0F, 0x0E, 0xFF,
  0x7F, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xF8, 0x17, 0x06, 0xE0,
  0xDC, 0x33, 0x86, 0x71, 0x8E, 0x31, 0xCF, 0xFF, 0xFF, 0xC0, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xFC,
  0xFF, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x0E, 0xFF, 0x7F, 0x00,
  0x0F, 0x1F, 0x8E, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xBC, 0xFF, 0x71, 0xF8,
  0xF8, 0x3E, 0x1F, 0x1F, 0x8E, 0xC6, 0x7F, 0x1F, 0x00, 0xFF, 0xFF, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x00, 0x3E, 0x3F, 0xB8, 0xDC, 0x7E, 0x3F,
  0x1D, 0x8C, 0xFC, 0x3C, 0x1F, 0x19, 0xDC, 0x7C, 0x1E, 0x0F, 0x07, 0xC7,
  0x7F, 0x1F, 0x00, 0x3C, 0x3F, 0x39, 0xDC, 0x6C, 0x3E, 0x1F, 0x0F, 0x87,
  0xE3, 0xBF, 0xDF, 0xE2, 0x70, 0x30, 0x18, 0x1C, 0x1C, 0x7E, 0x3E, 0x00,
  0x4F, 0xB0, 0x00, 0x00, 0x3E, 0xC0, 0x46, 0xE6, 0x00, 0x00, 0x00, 0x07,
  0x66, 0xEC, 0xC0, 0x00, 0x80, 0xC1, 0xE3, 0xE7, 0xC7, 0x83, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x60, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x80, 0x60, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0E, 0x1E, 0x3C, 0x78,
  0x30, 0x10, 0x00, 0x7C, 0xFE, 0x47, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x1C,
  0x18, 0x18, 0x30, 0x30, 0x00, 0x00, 0x38, 0x38, 0x38, 0x07, 0xC0, 0x1F,
  0xE0, 0x60, 0xE1, 0x80, 0xC6, 0x00, 0xCC, 0x7D, 0x99, 0x99, 0x66, 0x33,
  0xCC, 0xE7, 0x99, 0x8F, 0x33, 0x1E, 0x66, 0x3C, 0xCC, 0xD8, 0xFF, 0x99,
  0xCE, 0x30, 0x00, 0x70, 0x00, 0x60, 0x20, 0x7F, 0x80, 0x7E, 0x00, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB8, 0x19, 0x81, 0x98, 0x39,
  0x83, 0x1C, 0x30, 0xC3, 0xFC, 0x7F, 0xC7, 0x0E, 0x60, 0xE6, 0x06, 0xE0,
  0x6E, 0x07, 0xFC, 0x7F, 0xB1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8E, 0xFE,
  0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xFF, 0x7F, 0x00, 0x0F,
  0x8F, 0xF3, 0x89, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xE1, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0xCC, 0x7B, 0x0E, 0xC1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x6C, 0x3B, 0x1C, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0xFE, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x80, 0x0F, 0xC3, 0xFC, 0xE1, 0xB8, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0x36, 0x06, 0xC0,
  0xDC, 0x19, 0xC3, 0x3F, 0xE1, 0xFC, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x70, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFB, 0xF0, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3B, 0xFB, 0x80, 0xC1, 0xF0,
  0xEC, 0x33, 0x1C, 0xC6, 0x33, 0x8D, 0xC3, 0x70, 0xF8, 0x3F, 0x0E, 0xC3,
  0x38, 0xC6, 0x31, 0xCC, 0x73, 0x0E, 0xC3, 0xB0, 0x70, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0xFC, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFB, 0x07,
  0xF6, 0x1B, 0xEC, 0x37, 0xDC, 0x6F, 0x99, 0xDF, 0x33, 0x3E, 0x66, 0x7C,
  0x6C, 0xF8, 0xF1, 0xF1, 0xE3, 0xE3, 0xC7, 0xC3, 0x8F, 0x86, 0x1C, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xB0, 0xF6, 0x1E, 0x63, 0xCC, 0x79,
  0xCF, 0x19, 0xE3, 0xBC, 0x37, 0x86, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1C,
  0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0x60, 0x6E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x70, 0xE3, 0x9E,
  0x3F, 0xC1, 0xF8, 0xFC, 0x7F, 0x33, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x86,
  0xC7, 0x7F, 0xBF, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00,
  0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0x60, 0x6E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x70, 0xE7, 0x9E,
  0x3F, 0xC1, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0xFC, 0x3F, 0x8C,
  0xF3, 0x0E, 0xC3, 0xB0, 0xEC, 0x3B, 0x0C, 0xCF, 0x3F, 0x8F, 0xC3, 0x38,
  0xC6, 0x31, 0xCC, 0x73, 0x0E, 0xC3, 0xB0, 0x70, 0x3F, 0x3F, 0xBC, 0xDC,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x30, 0x1C,
  0x0D, 0x0E, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x8E,
  0x7F, 0x8F, 0xC0, 0xE0, 0x7E, 0x06, 0x60, 0xE6, 0x0E, 0x60, 0xC7, 0x0C,
  0x30, 0xC3, 0x1C, 0x31, 0x83, 0x98, 0x19, 0x81, 0xB8, 0x1B, 0x01, 0xB0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xE0, 0xC0, 0xF8, 0x30, 0x7E, 0x0E,
  0x1D, 0x87, 0x87, 0x61, 0xE1, 0x98, 0x78, 0x67, 0x1E, 0x39, 0xC6, 0xCE,
  0x33, 0x33, 0x8C, 0xCC, 0xC3, 0x33, 0x30, 0xEC, 0xDC, 0x3B, 0x1F, 0x07,
  0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x03, 0x83, 0x80, 0x61,
  0xDC, 0x77, 0x18, 0xCE, 0x3B, 0x06, 0xC1, 0xF0, 0x78, 0x0E, 0x03, 0x81,
  0xE0, 0x7C, 0x3B, 0x0C, 0xE3, 0x19, 0xC6, 0x61, 0xF8, 0x30, 0xE0, 0xF8,
  0x76, 0x1D, 0xC6, 0x33, 0x8C, 0xC3, 0xB0, 0x7C, 0x1E, 0x07, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0x07,
  0x06, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x3F, 0xFC, 0x06, 0x00, 0xC0, 0x3C, 0x07, 0x81, 0xB8, 0x33,
  0x0C, 0x71, 0x86, 0x60, 0xFC, 0x0C, 0xFF, 0xFF, 0xFC, 0xE3, 0x8C, 0x30,
  0x1C, 0x7E, 0x67, 0x03, 0x03, 0x03, 0x3F, 0x7B, 0xE3, 0xC3, 0xC3, 0xC7,
  0xFF, 0x7B, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x63, 0xF9, 0xCE, 0xE3,
  0x61, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0x7F, 0xB7, 0x80,
  0x1D, 0x3E, 0x72, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0x61,
  0x7E, 0x3E, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0xCD, 0xF6, 0xEF, 0xE3,
  0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0x63, 0xBF, 0xCF, 0x60,
  0x1C, 0x1F, 0x1D, 0xCC, 0x6E, 0x3E, 0x0F, 0xFF, 0xFF, 0xC0, 0x70, 0x38,
  0x0C, 0x17, 0xF1, 0xF8, 0x1E, 0x7C, 0xE1, 0x83, 0x07, 0xBF, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x19, 0xBE, 0xDD,
  0xFC, 0x7E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x6C, 0x77, 0xF9,
  0xEC, 0x06, 0x03, 0x01, 0xA1, 0xDF, 0xCF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xCC, 0xFE, 0xF7, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x5F, 0x80, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x27,
  0x70, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x37, 0x7E, 0xE0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1B, 0x1D, 0x8C, 0xCC, 0x6E, 0x36,
  0x1F, 0x0F, 0xC7, 0x63, 0x39, 0x8C, 0xC6, 0x63, 0xB0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x8C, 0x73, 0xFB, 0xEE, 0xFD, 0xF1, 0xC7, 0xC7, 0x0F,
  0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3,
  0xC3, 0x0F, 0x0C, 0x30, 0x8C, 0xFE, 0xF7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1C, 0x1F, 0x9D, 0xDC, 0x7E, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xCC, 0x7F,
  0x3D, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x6F,
  0xF6, 0xF3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x19, 0xBE, 0xDD,
  0xFC, 0x7E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x6C, 0x77, 0xF9,
  0xEC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x8F, 0x7F, 0xB8, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x38, 0xFF, 0x96, 0x0C, 0x1C,
  0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x7F, 0xDF, 0x80, 0x30, 0x60, 0xF7, 0xE3,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0x9F, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xD8, 0xEC, 0x77,
  0xF9, 0xEC, 0xE1, 0xF8, 0x66, 0x19, 0x86, 0x63, 0x9C, 0xC3, 0x30, 0xCC,
  0x37, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x00, 0xE3, 0x87, 0xC7, 0x0D,
  0x8F, 0x1B, 0x1E, 0x36, 0x3C, 0xEE, 0xD9, 0x9D, 0xB3, 0x1B, 0x36, 0x36,
  0x7C, 0x6C, 0xF8, 0xD1, 0xE0, 0xE3, 0xC1, 0xC7, 0x83, 0x87, 0x00, 0xE1,
  0xB1, 0xDC, 0xC6, 0x63, 0xF0, 0xF0, 0x78, 0x38, 0x1E, 0x1F, 0x0D, 0xCE,
  0x66, 0x3F, 0x0C, 0xE1, 0xF8, 0x66, 0x19, 0x86, 0x73, 0x9C, 0xC3, 0x30,
  0xCC, 0x37, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x0E, 0x07, 0x81, 0xC0, 0xFD, 0xFB, 0xF0, 0xE1, 0x87, 0x0E, 0x18, 0x70,
  0xC3, 0x86, 0x0F, 0xFF, 0xC0, 0x0E, 0x3C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x63, 0xC7, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xE1,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xE0, 0xC1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x30, 0x78, 0xF1, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0x8F, 0x1C, 0x00, 0x20, 0xFC, 0x7F, 0xF0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 18, 6, 1, -18 },
  { 10, 8, 7, 10, 1, -18 },
  { 17, 11, 18, 12, 0, -18 },
  { 42, 9, 20, 11, 1, -19 },
  { 65, 15, 18, 17, 1, -18 },
  { 99, 12, 18, 13, 1, -18 },
  { 126, 3, 7, 5, 1, -18 },
  { 129, 6, 22, 7, 1, -18 },
  { 146, 5, 22, 7, 1, -18 },
  { 160, 8, 9, 10, 1, -19 },
  { 169, 9, 12, 11, 1, -15 },
  { 183, 4, 6, 6, 1, -3 },
  { 186, 5, 2, 7, 1, -8 },
  { 188, 3, 3, 6, 1, -3 },
  { 190, 9, 18, 10, 0, -18 },
  { 211, 9, 18, 11, 1, -18 },
  { 232, 7, 18, 11, 1, -18 },
  { 248, 9, 18, 11, 1, -18 },
  { 269, 9, 18, 11, 1, -18 },
  { 290, 11, 18, 11, 0, -18 },
  { 315, 9, 18, 11, 1, -18 },
  { 336, 9, 18, 11, 1, -18 },
  { 357, 9, 18, 11, 1, -18 },
  { 378, 9, 18, 11, 1, -18 },
  { 399, 9, 18, 11, 1, -18 },
  { 420, 3, 14, 6, 1, -14 },
  { 426, 4, 17, 6, 1, -14 },
  { 435, 9, 12, 11, 1, -15 },
  { 449, 9, 7, 11, 1, -12 },
  { 457, 9, 12, 11, 1, -15 },
  { 471, 8, 18, 8, 0, -18 },
  { 489, 15, 20, 17, 1, -18 },
  { 527, 12, 18, 12, 0, -18 },
  { 554, 9, 18, 12, 2, -18 },
  { 575, 10, 18, 11, 1, -18 },
  { 598, 10, 18, 13, 2, -18 },
  { 621, 7, 18, 10, 2, -18 },
  { 637, 7, 18, 10, 2, -18 },
  { 653, 11, 18, 14, 1, -18 },
  { 678, 10, 18, 14, 2, -18 },
  { 701, 6, 18, 7, 1, -18 },
  { 715, 5, 23, 6, -1, -18 },
  { 730, 10, 18, 12, 2, -18 },
  { 753, 7, 18, 10, 2, -18 },
  { 769, 15, 18, 18, 2, -18 },
  { 803, 11, 18, 15, 2, -18 },
  { 828, 12, 18, 14, 1, -18 },
  { 855, 9, 18, 11, 2, -18 },
  { 876, 12, 22, 14, 1, -18 },
  { 909, 10, 18, 12, 2, -18 },
  { 932, 9, 18, 10, 1, -18 },
  { 953, 10, 18, 10, 0, -18 },
  { 976, 10, 18, 13, 2, -18 },
  { 999, 12, 18, 12, 0, -18 },
  { 1026, 18, 18, 18, 0, -18 },
  { 1067, 10, 18, 11, 0, -18 },
  { 1090, 10, 18, 10, 0, -18 },
  { 1113, 8, 18, 9, 1, -18 },
  { 1131, 5, 22, 8, 2, -18 },
  { 1145, 9, 18, 10, 0, -18 },
  { 1166, 5, 22, 8, 1, -18 },
  { 1180, 11, 10, 12, 0, -18 },
  { 1194, 11, 2, 11, 0, 2 },
  { 1197, 5, 4, 7, 1, -19 },
  { 1200, 8, 14, 11, 1, -14 },
  { 1214, 9, 19, 12, 2, -19 },
  { 1236, 8, 14, 9, 1, -14 },
  { 1250, 9, 19, 12, 1, -19 },
  { 1272, 9, 14, 11, 1, -14 },
  { 1288, 7, 19, 7, 0, -19 },
  { 1305, 9, 20, 12, 1, -14 },
  { 1328, 8, 19, 12, 2, -19 },
  { 1347, 3, 19, 6, 1, -19 },
  { 1355, 4, 25, 6, 0, -19 },
  { 1368, 9, 19, 11, 2, -19 },
  { 1390, 2, 19, 6, 2, -19 },
  { 1395, 14, 14, 18, 2, -14 },
  { 1420, 8, 14, 12, 2, -14 },
  { 1434, 9, 14, 11, 1, -14 },
  { 1450, 9, 20, 12, 2, -14 },
  { 1473, 9, 20, 12, 1, -14 },
  { 1496, 6, 14, 8, 2, -14 },
  { 1507, 7, 14, 9, 1, -14 },
  { 1520, 7, 16, 7, 0, -16 },
  { 1534, 9, 14, 12, 1, -14 },
  { 1550, 10, 14, 10, 0, -14 },
  { 1568, 15, 14, 16, 0, -14 },
  { 1595, 9, 14, 10, 0, -14 },
  { 1611, 10, 20, 10, 0, -14 },
  { 1636, 7, 14, 8, 1, -14 },
  { 1649, 7, 22, 9, 1, -18 },
  { 1669, 2, 25, 10, 4, -19 },
  { 1676, 7, 22, 9, 1, -18 },
  { 1696, 9, 4, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Medium25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM25PT7B_H_
