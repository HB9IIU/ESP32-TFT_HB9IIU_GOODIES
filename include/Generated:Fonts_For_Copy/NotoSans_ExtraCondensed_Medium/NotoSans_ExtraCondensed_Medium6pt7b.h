#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x5F, 0xE0, 0x79, 0xC0, 0xED, 0x35, 0xCB, 0xF0, 0x80,
  0xEA, 0x40, 0x95, 0x80, 0x7C, 0x74, 0xC0, 0xC0, 0x80, 0x5A, 0xFF, 0xD5,
  0xD7, 0xD7, 0x5B, 0xA0, 0xF7, 0xFF, 0xD5, 0xDF, 0xF7, 0xA0, 0xB0, 0x74,
  0xF0, 0x9C, 0xDA, 0xFF, 0xFE, 0x5B, 0x50, 0xFA, 0xF0, 0xF2, 0x20, 0xF6,
  0xE0, 0xFB, 0xFA, 0xF2, 0xB0, 0xBE, 0xD0, 0xEB, 0xF8, 0xBB, 0x50, 0xAB,
  0x9D, 0xBB, 0xBE, 0xD0, 0xF6, 0xB0, 0xF7, 0x40, 0xF6, 0xB2, 0xF7, 0x50,
  0xE7, 0xD5, 0xB6, 0xF0, 0xB7, 0x20, 0xBB, 0x55, 0xC9, 0x70, 0xE9, 0x20,
  0xDB, 0xEA, 0xC0, 0x95, 0xF8, 0x54, 0xE0, 0x80, 0xFC, 0x9A, 0xDE, 0xEC,
  0x5F, 0xC0, 0xFC, 0x6E, 0x80, 0xFF, 0xAF, 0xC0, 0xF0, 0xF8, 0x93, 0x6A,
  0xF8, 0xFB, 0xB0, 0xFC, 0xF7, 0x00, 0xF7, 0xC0, 0xFD, 0xE8, 0xDC, 0xBB,
  0xFC, 0xF4, 0xDE, 0x60, 0xDC, 0xD7, 0xEC, 0x59, 0x40, 0xFC, 0xD5, 0x80,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 2, 3, 2, 0, -5 },
  { 17, 2, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 2, 4, 3, 0, -4 },
  { 23, 2, 4, 3, 0, -4 },
  { 24, 2, 4, 3, 0, -4 },
  { 25, 2, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 0, -4 },
  { 29, 2, 4, 3, 0, -4 },
  { 30, 2, 4, 3, 0, -4 },
  { 31, 2, 4, 3, 0, -4 },
  { 32, 2, 4, 3, 0, -4 },
  { 33, 1, 3, 1, 0, -3 },
  { 34, 1, 4, 1, 0, -3 },
  { 35, 2, 3, 3, 0, -4 },
  { 36, 2, 2, 3, 0, -3 },
  { 37, 2, 3, 3, 0, -4 },
  { 38, 2, 4, 2, 0, -4 },
  { 39, 4, 4, 4, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 3, 4, 3, 0, -4 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 2, 4, 2, 0, -4 },
  { 56, 1, 5, 1, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 2, 4, 2, 0, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 5, 3, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 2, 4, 3, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 2, 4, 2, 0, -4 },
  { 85, 2, 5, 2, 0, -4 },
  { 87, 2, 4, 2, 0, -4 },
  { 88, 1, 5, 2, 0, -4 },
  { 89, 3, 2, 3, 0, -4 },
  { 90, 3, 1, 3, 0, 0 },
  { 91, 1, 1, 2, 0, -5 },
  { 92, 2, 3, 3, 0, -3 },
  { 93, 3, 5, 3, 0, -5 },
  { 95, 2, 3, 2, 0, -3 },
  { 96, 2, 5, 3, 0, -5 },
  { 98, 2, 3, 3, 0, -3 },
  { 99, 2, 5, 2, 0, -5 },
  { 101, 2, 4, 3, 0, -3 },
  { 102, 2, 5, 3, 0, -5 },
  { 104, 1, 4, 1, 0, -4 },
  { 105, 1, 5, 1, 0, -4 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 1, 5, 1, 0, -5 },
  { 109, 4, 3, 4, 0, -3 },
  { 111, 2, 3, 3, 0, -3 },
  { 112, 3, 3, 3, 0, -3 },
  { 114, 3, 4, 3, 0, -3 },
  { 116, 2, 4, 3, 0, -3 },
  { 117, 2, 3, 2, 0, -3 },
  { 118, 2, 3, 2, 0, -3 },
  { 119, 2, 4, 2, 0, -4 },
  { 120, 2, 3, 3, 0, -3 },
  { 121, 2, 3, 2, 0, -3 },
  { 122, 4, 3, 4, 0, -3 },
  { 124, 2, 3, 2, 0, -3 },
  { 125, 2, 4, 2, 0, -3 },
  { 126, 2, 3, 2, 0, -3 },
  { 127, 2, 5, 2, 0, -4 },
  { 129, 1, 6, 2, 1, -5 },
  { 130, 2, 5, 2, 0, -4 },
  { 132, 2, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Medium6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM6PT7B_H_
