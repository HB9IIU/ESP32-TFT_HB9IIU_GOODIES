#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xDB, 0x6D, 0x80, 0xFB, 0xEF, 0xCF, 0x9A, 0x34, 0x68,
  0xC0, 0x09, 0x82, 0x61, 0x98, 0x66, 0x7F, 0xDF, 0xF1, 0x90, 0x44, 0x13,
  0x3F, 0xFF, 0xFC, 0xCC, 0x33, 0x0C, 0x83, 0x20, 0x98, 0x08, 0x1C, 0x7F,
  0xEA, 0xC8, 0xC8, 0xC8, 0x78, 0x3C, 0x0E, 0x0B, 0x0B, 0x0B, 0x8B, 0xFE,
  0x7C, 0x08, 0x08, 0x30, 0x21, 0xE1, 0x0D, 0x8C, 0x32, 0x30, 0xCC, 0x83,
  0x36, 0x0C, 0xD8, 0x32, 0x4E, 0xDB, 0x7D, 0xED, 0x33, 0x64, 0xC1, 0xB3,
  0x06, 0xCC, 0x31, 0x30, 0xC4, 0xC2, 0x1B, 0x18, 0x38, 0x18, 0x07, 0x81,
  0x98, 0x33, 0x06, 0x60, 0xCC, 0x1F, 0x01, 0xE0, 0x38, 0x0F, 0x9B, 0x33,
  0x67, 0xCC, 0x79, 0x87, 0x31, 0xE7, 0xFE, 0x7C, 0xE0, 0xFF, 0xA4, 0x80,
  0x18, 0xCC, 0x66, 0x31, 0x9C, 0xC6, 0x31, 0x8C, 0x61, 0x8C, 0x63, 0x8C,
  0x31, 0x80, 0x86, 0x18, 0xC3, 0x18, 0xC6, 0x38, 0xC6, 0x31, 0x9C, 0xC6,
  0x33, 0x19, 0x8C, 0x00, 0x18, 0x18, 0x18, 0xF6, 0xFF, 0x38, 0x6C, 0x66,
  0x24, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x6D, 0xED, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x81, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0xE0, 0x00, 0x18, 0x3E, 0x76, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x66, 0x7E, 0x3C, 0x1C, 0xF7, 0xFB, 0x4C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x38, 0xFE, 0xEE, 0x87,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xE0, 0xFF,
  0xFF, 0x38, 0xFE, 0xCE, 0x07, 0x03, 0x07, 0x06, 0x1E, 0x38, 0x3E, 0x07,
  0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0x03, 0x01, 0xC0, 0x70, 0x3C, 0x0F,
  0x06, 0xC1, 0xB0, 0xCC, 0x33, 0x18, 0xC6, 0x33, 0x0C, 0xFF, 0xFF, 0xF0,
  0x30, 0x0C, 0x03, 0x00, 0x7E, 0x7E, 0x60, 0x60, 0xC0, 0xC0, 0xFC, 0xFE,
  0x07, 0x03, 0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0x0E, 0x3E, 0x79, 0x60,
  0x60, 0xC0, 0xC0, 0xDE, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0x67, 0x7E,
  0x3C, 0xFF, 0xFF, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x70, 0x18, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0x66,
  0x7E, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x7E, 0x18, 0x7C,
  0xE6, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x7B, 0x03, 0x07, 0x06,
  0x0E, 0x7C, 0x78, 0x5F, 0xA0, 0x00, 0x01, 0xFE, 0x5F, 0xA0, 0x00, 0x01,
  0xB7, 0xB6, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xF0, 0x3C, 0x0E, 0x03, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x07,
  0x1C, 0x70, 0xE0, 0x80, 0x39, 0xF9, 0x38, 0x30, 0x60, 0xC3, 0x86, 0x18,
  0x30, 0xC1, 0x80, 0x00, 0x0C, 0x1C, 0x30, 0x03, 0x00, 0x7E, 0x0E, 0x1C,
  0x60, 0x66, 0x01, 0xB3, 0xEF, 0x33, 0x39, 0x99, 0xCC, 0xCE, 0x46, 0x72,
  0x23, 0x9B, 0x3C, 0xDD, 0xE7, 0xB9, 0x80, 0x0C, 0x00, 0x30, 0x20, 0xFE,
  0x03, 0xE0, 0x0E, 0x01, 0xC0, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xE1,
  0x8C, 0x31, 0x87, 0xF1, 0xFF, 0x30, 0xE6, 0x0C, 0xC1, 0xB8, 0x37, 0x07,
  0xFE, 0xFF, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xCF, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC7, 0xFE, 0xFC, 0x0E, 0x0F, 0xCE, 0x4E, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0xC2, 0x7F, 0x1F, 0x80,
  0xFC, 0x7F, 0xB1, 0xD8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF8, 0x7C, 0x36, 0x3B, 0xF9, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xFF,
  0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x3F,
  0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x07, 0x07, 0xF3, 0x8D, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xE3, 0xF8, 0xFE, 0x0F, 0x83, 0x60, 0xD8, 0x37,
  0x0C, 0xFF, 0x1F, 0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFB, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xDF, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xFF, 0xE4, 0x00, 0xC3, 0xE3,
  0xB1, 0x99, 0xCD, 0xC6, 0xC3, 0xE1, 0xF0, 0xF8, 0x6E, 0x33, 0x19, 0xCC,
  0x66, 0x3B, 0x0D, 0x87, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0F, 0xFF, 0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xE8, 0x6F, 0x63, 0x7B, 0x1B, 0xD8, 0x9E, 0x6C, 0xF3, 0x67, 0x9B, 0x3C,
  0xF1, 0xE3, 0x8F, 0x1C, 0x78, 0xC3, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0,
  0xF6, 0x3D, 0x8F, 0x33, 0xCC, 0xF3, 0xBC, 0x6F, 0x1B, 0xC3, 0xF0, 0xFC,
  0x3F, 0x07, 0x0E, 0x07, 0xF1, 0xEE, 0x38, 0xE6, 0x0D, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0C, 0xC1, 0x9C, 0x71, 0xFC,
  0x1F, 0x00, 0xFC, 0xFE, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xCE, 0xFC, 0xF8,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0E, 0x07, 0xF1, 0xEF, 0x38, 0xE6,
  0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x76, 0x0C,
  0xC1, 0x9C, 0x71, 0xFC, 0x1F, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0xFC,
  0x7F, 0x31, 0xD8, 0xEC, 0x76, 0x3B, 0x19, 0xFC, 0xFC, 0x6E, 0x33, 0x19,
  0xCC, 0x66, 0x3B, 0x0D, 0x87, 0x1C, 0x7F, 0xFE, 0xC0, 0xC0, 0xC0, 0xE0,
  0x70, 0x3C, 0x1E, 0x06, 0x07, 0x07, 0x07, 0x86, 0xFE, 0xFC, 0xFF, 0xFF,
  0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1B, 0xFC, 0xFC, 0xC0, 0xFC,
  0x19, 0x83, 0x30, 0xE6, 0x18, 0xE3, 0x0C, 0x61, 0x9C, 0x33, 0x07, 0x60,
  0x6C, 0x0D, 0x81, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0xC1, 0xC3, 0xF0, 0xE1,
  0x98, 0x70, 0xCC, 0x38, 0x66, 0x34, 0x73, 0x1B, 0x39, 0xCD, 0x98, 0x66,
  0xCC, 0x32, 0x66, 0x1B, 0x33, 0x0D, 0x8F, 0x86, 0xC7, 0x81, 0xE3, 0xC0,
  0xE1, 0xE0, 0x70, 0xF0, 0x38, 0x38, 0xE1, 0x9C, 0xE3, 0x30, 0xCC, 0x3E,
  0x07, 0x81, 0xE0, 0x30, 0x1E, 0x07, 0x83, 0xE0, 0xCC, 0x33, 0x18, 0xE6,
  0x1B, 0x87, 0xE1, 0xD8, 0x66, 0x39, 0xCC, 0x33, 0x0D, 0x83, 0xE0, 0x78,
  0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7F, 0x7F,
  0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60,
  0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0xFF, 0x80, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x03, 0xFF, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80, 0x0C,
  0x03, 0x81, 0xE0, 0x6C, 0x33, 0x0C, 0x67, 0x19, 0x83, 0xE0, 0xC0, 0xFF,
  0xC0, 0xE3, 0x1C, 0x70, 0x18, 0x7E, 0x46, 0x06, 0x07, 0x0F, 0x7F, 0xE7,
  0xC7, 0xC7, 0xC7, 0xFB, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xC7, 0xFB,
  0xCD, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x8D, 0xFE, 0xDE,
  0x00, 0x1C, 0xFD, 0xD7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x83, 0xF3,
  0xE0, 0x03, 0x03, 0x03, 0x03, 0x13, 0x7F, 0x67, 0xE3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x39, 0x18, 0x7E, 0x66, 0xC3, 0xC3, 0xC3,
  0xFF, 0xC0, 0xC0, 0xC0, 0x60, 0x7F, 0x3E, 0x0C, 0x7C, 0xC9, 0x83, 0x06,
  0x3F, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x18,
  0x7F, 0x67, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B,
  0x03, 0x03, 0x03, 0x6F, 0x7E, 0x10, 0xE0, 0xE0, 0xE0, 0xE0, 0xEC, 0xFF,
  0xF7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFD,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0x20, 0x07, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0xEE, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x1B, 0x99, 0xDC, 0xEC, 0x7C, 0x3F, 0x1F, 0x8E, 0xE7, 0x33, 0x9D, 0xC6,
  0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x33, 0x7F,
  0xEF, 0x79, 0xB8, 0xE7, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xF8, 0xC3, 0xE3,
  0x0F, 0x8C, 0x3E, 0x30, 0xF8, 0xC3, 0xE3, 0x0C, 0x0C, 0xDF, 0xF7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x18, 0x3F, 0x19,
  0xDC, 0x6C, 0x36, 0x1F, 0x0F, 0x87, 0xC3, 0x61, 0x98, 0xCF, 0xE3, 0xE0,
  0x0C, 0x6F, 0xBC, 0xDC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8,
  0xDF, 0xEF, 0xE7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x18, 0x7F,
  0x67, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0x7D, 0xF8, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE0, 0x3B, 0xFC, 0x70, 0xC3, 0x87, 0x8F, 0x0C, 0x38, 0xFF,
  0xF8, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xF3,
  0xC0, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x63, 0x7F,
  0x39, 0xE3, 0xB1, 0x98, 0xCC, 0x66, 0x31, 0xB0, 0xD8, 0x6C, 0x36, 0x0A,
  0x07, 0x03, 0x80, 0xE3, 0x8D, 0x8E, 0x36, 0x79, 0xD9, 0xA6, 0x66, 0x99,
  0xDB, 0x63, 0x4D, 0x8F, 0x3C, 0x3C, 0xF0, 0xF1, 0xC1, 0xC7, 0x06, 0x1C,
  0xE3, 0xBB, 0x8D, 0x86, 0xC1, 0xC0, 0xE0, 0x70, 0x7C, 0x36, 0x3B, 0x98,
  0xDC, 0x70, 0xE3, 0xB1, 0x98, 0xCC, 0x67, 0x31, 0xB0, 0xD8, 0x6C, 0x16,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x61, 0x70, 0xF0, 0x20, 0x00, 0xFC,
  0x71, 0x8E, 0x30, 0xC7, 0x18, 0xE3, 0x0F, 0xFF, 0x1C, 0xE3, 0x0C, 0x30,
  0xC3, 0x0C, 0x73, 0x0F, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xE1, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38,
  0x31, 0xCC, 0x30, 0xC3, 0x0C, 0x31, 0xCE, 0x30, 0x60, 0xFE, 0xE7, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 16, 6, 1, -16 },
  { 7, 7, 6, 9, 1, -16 },
  { 13, 10, 16, 11, 0, -16 },
  { 33, 8, 18, 10, 1, -17 },
  { 51, 14, 17, 16, 1, -17 },
  { 81, 11, 17, 12, 1, -17 },
  { 105, 3, 6, 5, 1, -16 },
  { 108, 5, 21, 7, 1, -17 },
  { 122, 5, 21, 7, 1, -17 },
  { 136, 8, 9, 9, 1, -18 },
  { 145, 8, 11, 10, 1, -14 },
  { 156, 3, 6, 5, 1, -3 },
  { 159, 5, 2, 7, 1, -7 },
  { 161, 3, 3, 5, 1, -3 },
  { 163, 9, 17, 9, 0, -17 },
  { 183, 8, 17, 10, 1, -17 },
  { 200, 6, 16, 10, 1, -16 },
  { 212, 8, 17, 10, 1, -17 },
  { 229, 8, 17, 10, 1, -17 },
  { 246, 10, 17, 10, 0, -17 },
  { 268, 8, 16, 10, 1, -16 },
  { 284, 8, 17, 10, 1, -17 },
  { 301, 8, 16, 10, 1, -16 },
  { 317, 8, 17, 10, 1, -17 },
  { 334, 8, 17, 10, 1, -17 },
  { 351, 3, 13, 5, 1, -13 },
  { 356, 3, 16, 5, 1, -13 },
  { 362, 8, 10, 10, 1, -13 },
  { 372, 8, 6, 10, 1, -11 },
  { 378, 8, 10, 10, 1, -13 },
  { 388, 7, 17, 8, 0, -17 },
  { 403, 13, 19, 15, 1, -17 },
  { 434, 11, 16, 11, 0, -16 },
  { 456, 8, 16, 11, 2, -16 },
  { 472, 9, 17, 11, 1, -17 },
  { 492, 9, 16, 12, 2, -16 },
  { 510, 6, 16, 9, 2, -16 },
  { 522, 6, 16, 9, 2, -16 },
  { 534, 10, 17, 13, 1, -17 },
  { 556, 9, 16, 13, 2, -16 },
  { 574, 5, 16, 7, 1, -16 },
  { 584, 5, 21, 6, -1, -16 },
  { 598, 9, 16, 11, 2, -16 },
  { 616, 6, 16, 9, 2, -16 },
  { 628, 13, 16, 17, 2, -16 },
  { 654, 10, 16, 14, 2, -16 },
  { 674, 11, 17, 13, 1, -17 },
  { 698, 8, 16, 11, 2, -16 },
  { 714, 11, 21, 13, 1, -17 },
  { 743, 9, 16, 11, 2, -16 },
  { 761, 8, 17, 10, 1, -17 },
  { 778, 9, 16, 9, 0, -16 },
  { 796, 9, 16, 12, 2, -16 },
  { 814, 11, 16, 11, 0, -16 },
  { 836, 17, 16, 17, 0, -16 },
  { 870, 10, 16, 10, 0, -16 },
  { 890, 10, 16, 10, 0, -16 },
  { 910, 8, 16, 9, 0, -16 },
  { 926, 5, 21, 7, 2, -17 },
  { 940, 8, 17, 9, 0, -17 },
  { 957, 5, 21, 7, 1, -17 },
  { 971, 10, 9, 11, 0, -16 },
  { 983, 10, 1, 10, 0, 2 },
  { 985, 5, 4, 6, 1, -18 },
  { 988, 8, 13, 10, 1, -13 },
  { 1001, 9, 17, 11, 1, -17 },
  { 1021, 7, 13, 8, 1, -13 },
  { 1033, 8, 17, 11, 1, -17 },
  { 1050, 8, 13, 10, 1, -13 },
  { 1063, 7, 18, 6, 0, -18 },
  { 1079, 8, 19, 11, 1, -13 },
  { 1098, 8, 17, 11, 1, -17 },
  { 1115, 3, 17, 5, 1, -17 },
  { 1122, 4, 23, 5, 0, -17 },
  { 1134, 9, 17, 10, 1, -17 },
  { 1154, 3, 17, 5, 1, -17 },
  { 1161, 14, 13, 16, 1, -13 },
  { 1184, 8, 13, 11, 1, -13 },
  { 1197, 9, 13, 11, 1, -13 },
  { 1212, 9, 19, 11, 1, -13 },
  { 1234, 8, 19, 11, 1, -13 },
  { 1253, 6, 13, 7, 1, -13 },
  { 1263, 6, 13, 8, 1, -13 },
  { 1273, 6, 15, 6, 0, -15 },
  { 1285, 8, 12, 11, 1, -12 },
  { 1297, 9, 12, 9, 0, -12 },
  { 1311, 14, 12, 14, 0, -12 },
  { 1332, 9, 12, 9, 0, -12 },
  { 1346, 9, 18, 9, 0, -12 },
  { 1367, 6, 12, 7, 1, -12 },
  { 1376, 6, 20, 8, 1, -16 },
  { 1391, 2, 23, 10, 4, -18 },
  { 1397, 6, 20, 8, 1, -16 },
  { 1412, 9, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Medium23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM23PT7B_H_
