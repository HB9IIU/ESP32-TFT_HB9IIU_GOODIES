#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x00, 0x0E, 0xFF,
  0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x0E, 0x70,
  0x31, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x3F, 0xFF,
  0xFF, 0xFC, 0x63, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x0F, 0xFF,
  0xBF, 0xFE, 0x39, 0xC0, 0xC7, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6,
  0x07, 0x18, 0x00, 0x06, 0x00, 0x60, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x62,
  0xE6, 0x0E, 0x60, 0xE6, 0x07, 0x60, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x07, 0xE0, 0x67, 0x06, 0x70, 0x67, 0x86, 0x7E, 0x7E, 0xFF, 0xC7, 0xF8,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x06, 0x07, 0xE0, 0x60, 0x66,
  0x0E, 0x06, 0x70, 0xC0, 0xE7, 0x1C, 0x0E, 0x31, 0xC0, 0xE3, 0x18, 0x0E,
  0x33, 0x80, 0xE3, 0x30, 0x0E, 0x73, 0x3C, 0x67, 0x77, 0xE6, 0x66, 0x66,
  0x7E, 0x66, 0x73, 0xCE, 0xE7, 0x00, 0xCE, 0x30, 0x1C, 0xE3, 0x01, 0xCE,
  0x30, 0x18, 0xE3, 0x03, 0x8E, 0x70, 0x30, 0xE7, 0x03, 0x06, 0x60, 0x70,
  0x7E, 0x06, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xEF, 0x01, 0xCE, 0x03,
  0x1C, 0x06, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xF1, 0xCE, 0xF3, 0xB8, 0xE7, 0x70, 0xFE, 0xE1, 0xF9,
  0xC1, 0xF3, 0x81, 0xC7, 0x87, 0xC7, 0xFF, 0x8F, 0xFB, 0x8F, 0xC7, 0x80,
  0xFF, 0xFF, 0xFF, 0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x0E, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x70, 0xE0, 0xC1, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x1C,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x86,
  0x1C, 0x38, 0xE1, 0xC7, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x77, 0x7F, 0xFF,
  0xFF, 0xC7, 0xC0, 0xDC, 0x3B, 0x8E, 0x38, 0x44, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7B, 0xDC, 0xE7, 0x3B,
  0x9C, 0xFF, 0xFF, 0xF8, 0xEF, 0xFE, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x00, 0x0F, 0x03, 0xFC, 0x3F, 0xC7, 0x9E, 0x70, 0xE7, 0x0E, 0x70,
  0xEF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFF, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x3F, 0xC3, 0xFC, 0x1F,
  0x80, 0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x3F, 0x07, 0xFC, 0xFF, 0xC6, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0x07, 0xFC, 0xFF, 0xE4, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x3C, 0x1F, 0x01, 0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE8, 0x1E, 0xF7, 0xEF, 0xFC, 0x7F, 0x80, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x37, 0x03, 0xB8, 0x19,
  0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x87, 0x1C, 0x30, 0xE3, 0x87, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0xFF, 0x9F, 0xF3, 0xFE, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1F, 0xE3, 0xFE, 0x7F, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x41, 0xEE, 0xF9, 0xFF, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x1F,
  0xE3, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x61, 0x0E, 0xFC, 0xEF,
  0xEF, 0x9E, 0xF0, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x07, 0x70,
  0xE7, 0x8E, 0x3F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0xC7, 0x9E, 0x70, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F,
  0x79, 0xE7, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF8, 0x7F, 0xC7, 0x1E, 0xF0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x1F, 0x7F,
  0x73, 0xF6, 0x1C, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x4F,
  0x87, 0xF8, 0x7E, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF,
  0xE0, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xEE, 0x73,
  0x9D, 0xCE, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0E,
  0x00, 0x80, 0x00, 0x3F, 0x3F, 0xE7, 0xFD, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x3C, 0x1C, 0x0E, 0x01, 0xC1, 0x80, 0x1C, 0x70, 0x01, 0x8C, 0x1E,
  0x33, 0x8F, 0xE7, 0x63, 0x9C, 0xEC, 0x73, 0x8D, 0x8C, 0x71, 0xF1, 0x8E,
  0x3E, 0x71, 0xC7, 0xCE, 0x38, 0xF9, 0xC7, 0x1F, 0x18, 0xE7, 0x63, 0x3C,
  0xCC, 0x7F, 0xF9, 0xC7, 0x9E, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x80, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x36, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x87, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x38, 0x38, 0xF0, 0x79, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xDE, 0x03, 0xFC, 0x03, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x1E, 0xFF, 0xCF, 0xFC,
  0xE3, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xFF, 0xEF, 0xFE, 0xFF, 0x80, 0x0F, 0xE1, 0xFF, 0x3F, 0xE7, 0x82, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3F,
  0xE1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xEE, 0x0F,
  0x70, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC3,
  0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xFF, 0xB8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0x9F, 0x02, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x77,
  0x01, 0xDE, 0x07, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0x80, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0xFF,
  0xFC, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x9F, 0xFF, 0x80, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xEF, 0x80, 0xE0, 0x7F,
  0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1C, 0x71, 0xE3, 0x8E, 0x1C, 0xF0, 0xE7,
  0x07, 0x78, 0x3B, 0x81, 0xFE, 0x0F, 0xF0, 0x7B, 0xC3, 0xCE, 0x1C, 0x78,
  0xE1, 0xC7, 0x0F, 0x38, 0x39, 0xC1, 0xCE, 0x0F, 0x70, 0x3B, 0x81, 0xE0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFB, 0x81, 0xFF, 0x70, 0x37,
  0xEE, 0x0E, 0xFC, 0xC1, 0xDF, 0x9C, 0x3B, 0xF3, 0x86, 0x7E, 0x71, 0xCF,
  0xC6, 0x39, 0xF8, 0xE6, 0x3F, 0x1D, 0xC7, 0xE1, 0xB8, 0xFC, 0x3F, 0x1F,
  0x87, 0xC3, 0xF0, 0xF8, 0x7E, 0x0F, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x38,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFB,
  0x87, 0xF7, 0x0F, 0xE7, 0x1F, 0xCE, 0x3F, 0x9E, 0x7F, 0x1C, 0xFE, 0x39,
  0xFC, 0x39, 0xF8, 0x73, 0xF0, 0x77, 0xE0, 0xEF, 0xC1, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC3, 0xC3, 0xC7, 0x03, 0x9E, 0x07, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x1D, 0xE0, 0x79, 0xC0, 0xE3, 0xC3, 0xC3, 0xFF, 0x07,
  0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xFC, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x7E, 0xFF, 0xCF,
  0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC3, 0xC3, 0xC7, 0x03,
  0x9E, 0x07, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xE0,
  0x79, 0xC0, 0xE3, 0xC3, 0xC3, 0xFF, 0x07, 0xFE, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0x07, 0xFE, 0x3F,
  0xF9, 0xC3, 0xCE, 0x0E, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0, 0xF7, 0x07,
  0x38, 0x79, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0x8E, 0x1C, 0x70, 0xE1, 0xC7,
  0x0E, 0x38, 0x79, 0xC1, 0xCE, 0x0F, 0x70, 0x3B, 0x81, 0xE0, 0x1F, 0xC7,
  0xFD, 0xFF, 0xB8, 0x2F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0xFF, 0xFD, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x1E,
  0xE0, 0xF7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0xE0, 0x1F, 0xC0, 0x39, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x70, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x07,
  0x70, 0x0E, 0xE0, 0x1D, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0xC0, 0xF0, 0x3B,
  0x81, 0xE0, 0xF7, 0x07, 0xC1, 0xCE, 0x0F, 0x83, 0x9C, 0x1B, 0x07, 0x3C,
  0x37, 0x0E, 0x38, 0x6E, 0x3C, 0x71, 0xDC, 0x70, 0xE3, 0xB8, 0xE1, 0xC7,
  0x31, 0xC3, 0xCC, 0x73, 0x83, 0x98, 0xEF, 0x07, 0x71, 0xDC, 0x0E, 0xE3,
  0xB8, 0x1D, 0xC3, 0x70, 0x1B, 0x06, 0xE0, 0x36, 0x0D, 0xC0, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x3B,
  0x83, 0xCE, 0x1C, 0x70, 0xE3, 0xCE, 0x0E, 0x70, 0x77, 0x81, 0xF8, 0x0F,
  0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x03, 0xB8,
  0x1C, 0xE1, 0xE7, 0x0E, 0x3C, 0x70, 0xE7, 0x07, 0x38, 0x3F, 0xC0, 0xE0,
  0xE0, 0x3F, 0x81, 0xDC, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x83,
  0x9C, 0x1D, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFC, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1F, 0x00, 0xD8, 0x0E, 0xE0, 0x63, 0x07, 0x1C, 0x30, 0xE3, 0x83,
  0x9C, 0x1D, 0xC0, 0x7E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0,
  0xE1, 0xE1, 0xC1, 0xC0, 0x06, 0x0F, 0xF0, 0xFF, 0x10, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x1F, 0x3F, 0xEF, 0xFF, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7F, 0x9F, 0x7E, 0xE7, 0xDC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE2, 0x0E, 0xFC, 0xFF, 0xCF, 0x9E, 0xF0, 0xEE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0E, 0xF0,
  0xEF, 0x9E, 0xFF, 0xCE, 0xF8, 0x02, 0x07, 0xF3, 0xF9, 0xE2, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xF3, 0x3F, 0xC7, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x04, 0x71, 0xF7, 0x3F, 0xF7, 0x8F, 0x70, 0xF7, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70, 0xF7,
  0x9F, 0x3F, 0xF1, 0xF3, 0x02, 0x01, 0xF8, 0x3F, 0xC7, 0x9E, 0x70, 0xE7,
  0x0E, 0xE0, 0x6E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0xC6, 0x3F, 0xE1, 0xFC, 0x0F, 0x8F, 0xC7, 0x27, 0x83,
  0x81, 0xC0, 0xE0, 0xFE, 0xFF, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x04, 0x01,
  0xF7, 0x3F, 0xF7, 0x9F, 0x70, 0xF7, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x07, 0x70, 0xF7, 0xDF, 0x3F, 0xF1,
  0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x61, 0xE7, 0xFE, 0x7F, 0xC0,
  0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x87, 0x7E,
  0xFF, 0xDF, 0x3F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x71, 0xC7, 0x00, 0x00,
  0x07, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x3F, 0xFF, 0x98, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1E, 0xE1, 0xCE, 0x38, 0xE3, 0x8E,
  0x70, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x0E, 0x38, 0xE3, 0x8E,
  0x38, 0xE1, 0xCE, 0x1C, 0xE0, 0xEE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x06, 0x1D, 0xF1, 0xF3, 0xFF, 0x7F, 0x78,
  0xF9, 0xEF, 0x1E, 0x1D, 0xC1, 0xC3, 0xB8, 0x38, 0x7F, 0x07, 0x0F, 0xE0,
  0xE1, 0xFC, 0x1C, 0x3F, 0x83, 0x87, 0xF0, 0x70, 0xFE, 0x0E, 0x1F, 0xC1,
  0xC3, 0xF8, 0x38, 0x7F, 0x07, 0x0F, 0xE0, 0xE1, 0xFC, 0x1C, 0x3C, 0x02,
  0x1D, 0xFB, 0xFF, 0x7C, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C,
  0x02, 0x01, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xF7, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x77, 0x07, 0x70, 0xF3, 0xDE,
  0x3F, 0xC1, 0xF8, 0x03, 0x0E, 0xFC, 0xFF, 0xCF, 0x9E, 0xF0, 0xEE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0E,
  0xF0, 0xEF, 0x9E, 0xEF, 0xCE, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x04, 0x01, 0xF7, 0x3F, 0xF7, 0x8F,
  0x70, 0xF7, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x77, 0x07, 0x70, 0xF7, 0xDF, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x02, 0xCF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x0C, 0x1F, 0xDF, 0xFE, 0x2E, 0x07, 0x03, 0xC0, 0xF0,
  0x7C, 0x1F, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0xCF, 0xFF, 0x7F, 0x00,
  0x18, 0x18, 0x18, 0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0x1F, 0x1F, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC3, 0xFF, 0xFB, 0xFF, 0x3E, 0x60, 0xE0, 0x77, 0x07,
  0x70, 0x77, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0x9C, 0x39, 0xC1, 0x9C,
  0x1D, 0xC1, 0xD8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0,
  0xF0, 0x77, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xF8, 0xE7,
  0x1D, 0x8E, 0x39, 0x99, 0xC3, 0x99, 0x9C, 0x39, 0x99, 0xC3, 0xB9, 0xDC,
  0x1B, 0x9D, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xF7, 0x8E, 0x38, 0xE3, 0x9C,
  0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x81, 0xDC,
  0x39, 0xC3, 0x9C, 0x78, 0xE7, 0x0E, 0xF0, 0x70, 0xE0, 0x77, 0x07, 0x70,
  0x77, 0x0E, 0x70, 0xE3, 0x8E, 0x38, 0xE3, 0x9C, 0x19, 0xC1, 0xDC, 0x1D,
  0xC1, 0xD8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0x70, 0x00, 0xFF, 0x7F,
  0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x87, 0xC3, 0xE3, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC7, 0xC3, 0xC0, 0xF8,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x83,
  0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7C, 0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0x3C, 0x1E, 0x1E, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x3E, 0x3E, 0x1E, 0x00, 0x00, 0x17,
  0xC1, 0xFF, 0xFC, 0x7F, 0x81, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 9, 8, 13, 2, -23 },
  { 22, 14, 23, 15, 1, -23 },
  { 63, 12, 26, 14, 1, -24 },
  { 102, 20, 23, 22, 1, -23 },
  { 160, 15, 23, 16, 1, -23 },
  { 204, 3, 8, 7, 2, -23 },
  { 207, 7, 28, 10, 2, -23 },
  { 232, 7, 28, 10, 1, -23 },
  { 257, 11, 11, 13, 1, -24 },
  { 273, 12, 15, 14, 1, -19 },
  { 296, 5, 8, 7, 1, -4 },
  { 301, 7, 3, 9, 1, -10 },
  { 304, 4, 4, 7, 2, -4 },
  { 306, 11, 23, 12, 1, -23 },
  { 338, 12, 23, 14, 1, -23 },
  { 373, 8, 23, 14, 2, -23 },
  { 396, 12, 23, 14, 1, -23 },
  { 431, 12, 23, 14, 1, -23 },
  { 466, 13, 23, 14, 1, -23 },
  { 504, 11, 23, 14, 2, -23 },
  { 536, 12, 23, 14, 1, -23 },
  { 571, 12, 23, 14, 1, -23 },
  { 606, 12, 23, 14, 1, -23 },
  { 641, 12, 23, 14, 1, -23 },
  { 676, 4, 17, 8, 2, -17 },
  { 685, 5, 21, 8, 1, -17 },
  { 699, 12, 15, 14, 1, -19 },
  { 722, 12, 9, 14, 1, -16 },
  { 736, 12, 15, 14, 1, -19 },
  { 759, 10, 23, 11, 0, -23 },
  { 788, 19, 26, 22, 1, -23 },
  { 850, 15, 23, 15, 0, -23 },
  { 894, 12, 23, 16, 2, -23 },
  { 929, 12, 23, 15, 2, -23 },
  { 964, 13, 23, 17, 2, -23 },
  { 1002, 10, 23, 13, 2, -23 },
  { 1031, 10, 23, 13, 2, -23 },
  { 1060, 14, 23, 18, 2, -23 },
  { 1101, 13, 23, 18, 2, -23 },
  { 1139, 7, 23, 9, 1, -23 },
  { 1160, 7, 29, 8, -2, -23 },
  { 1186, 13, 23, 15, 2, -23 },
  { 1224, 10, 23, 12, 2, -23 },
  { 1253, 19, 23, 23, 2, -23 },
  { 1308, 15, 23, 19, 2, -23 },
  { 1352, 15, 23, 18, 2, -23 },
  { 1396, 12, 23, 15, 2, -23 },
  { 1431, 15, 28, 18, 2, -23 },
  { 1484, 13, 23, 15, 2, -23 },
  { 1522, 11, 23, 13, 1, -23 },
  { 1554, 12, 23, 13, 0, -23 },
  { 1589, 13, 23, 17, 2, -23 },
  { 1627, 15, 23, 15, 0, -23 },
  { 1671, 23, 23, 23, 0, -23 },
  { 1738, 13, 23, 14, 0, -23 },
  { 1776, 13, 23, 13, 0, -23 },
  { 1814, 10, 23, 12, 1, -23 },
  { 1843, 7, 28, 10, 2, -23 },
  { 1868, 12, 23, 12, 0, -23 },
  { 1903, 7, 28, 10, 1, -23 },
  { 1928, 13, 13, 15, 1, -23 },
  { 1950, 14, 2, 14, 0, 3 },
  { 1954, 7, 6, 9, 1, -25 },
  { 1960, 11, 18, 14, 1, -18 },
  { 1985, 12, 24, 15, 2, -24 },
  { 2021, 10, 18, 12, 1, -18 },
  { 2044, 12, 24, 15, 1, -24 },
  { 2080, 12, 18, 14, 1, -18 },
  { 2107, 9, 24, 9, 0, -24 },
  { 2134, 12, 26, 15, 1, -18 },
  { 2173, 11, 24, 15, 2, -24 },
  { 2206, 3, 24, 7, 2, -24 },
  { 2215, 6, 32, 7, -1, -24 },
  { 2239, 12, 24, 14, 2, -24 },
  { 2275, 3, 24, 7, 2, -24 },
  { 2284, 19, 18, 22, 2, -18 },
  { 2327, 11, 18, 15, 2, -18 },
  { 2352, 12, 18, 15, 1, -18 },
  { 2379, 12, 26, 15, 2, -18 },
  { 2418, 12, 26, 15, 1, -18 },
  { 2457, 8, 18, 10, 2, -18 },
  { 2475, 9, 18, 11, 1, -18 },
  { 2496, 8, 21, 9, 0, -21 },
  { 2517, 11, 17, 15, 2, -17 },
  { 2541, 12, 17, 13, 0, -17 },
  { 2567, 20, 17, 20, 0, -17 },
  { 2610, 12, 17, 12, 0, -17 },
  { 2636, 12, 25, 13, 0, -17 },
  { 2674, 9, 17, 10, 1, -17 },
  { 2694, 9, 28, 11, 1, -23 },
  { 2726, 3, 32, 13, 5, -24 },
  { 2738, 9, 28, 11, 1, -23 },
  { 2770, 12, 5, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Medium32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM32PT7B_H_
