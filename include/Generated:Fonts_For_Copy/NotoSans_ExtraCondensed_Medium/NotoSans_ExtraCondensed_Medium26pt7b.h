#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0xDB, 0x6D, 0x80, 0xFF, 0x00, 0xE7, 0x67, 0x67,
  0x67, 0x67, 0x67, 0x63, 0x18, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33,
  0x3F, 0xFF, 0xFF, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x8F, 0xFC, 0x66, 0x08,
  0xC3, 0x10, 0x66, 0x0C, 0xC1, 0x98, 0x00, 0x08, 0x04, 0x03, 0x8F, 0xF7,
  0xBF, 0x43, 0x21, 0x90, 0xE8, 0x3C, 0x0F, 0x81, 0xE0, 0xB8, 0x4C, 0x27,
  0x13, 0xEF, 0xFF, 0x87, 0x01, 0x00, 0x80, 0x40, 0x30, 0x30, 0x78, 0x30,
  0xCC, 0x30, 0xCC, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0xCC, 0xC0, 0xCC, 0xC0,
  0xCD, 0x9E, 0xED, 0xBE, 0x79, 0xB3, 0x33, 0x33, 0x03, 0x33, 0x03, 0x33,
  0x06, 0x33, 0x06, 0x33, 0x06, 0x33, 0x0C, 0x3E, 0x0C, 0x1E, 0x1C, 0x03,
  0xE0, 0x77, 0x07, 0x30, 0x63, 0x07, 0x30, 0x77, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x6E, 0xE6, 0xC7, 0xEC, 0x3E, 0xC3, 0xCC, 0x1C, 0xE3, 0xC7,
  0xFE, 0x7E, 0x70, 0xED, 0xB6, 0xD8, 0x0C, 0x61, 0x8C, 0x31, 0xC6, 0x18,
  0x63, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x0C, 0x38, 0x61, 0xC0,
  0xC3, 0x86, 0x1C, 0x30, 0xC3, 0x86, 0x18, 0x61, 0x87, 0x18, 0x61, 0x86,
  0x38, 0xE3, 0x0C, 0x61, 0x8C, 0x00, 0x1C, 0x0C, 0x06, 0x1F, 0x7F, 0xF8,
  0xE0, 0xD8, 0xEE, 0x66, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F,
  0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x77, 0x66, 0xEC, 0xFF,
  0xF0, 0x6F, 0x60, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x0E, 0x00, 0x1C, 0x1F, 0x9F, 0xCC, 0x7E, 0x3F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8E, 0xC7, 0x73, 0x3F, 0x8F,
  0x80, 0x06, 0x1C, 0x79, 0xFF, 0x6C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3C, 0x3F, 0xBF, 0xC8, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xC0, 0xE0,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3C, 0x7F, 0xB9, 0xC8, 0x70, 0x38, 0x1C, 0x0E,
  0x0E, 0x3E, 0x1E, 0x0F, 0xC0, 0x70, 0x38, 0x0C, 0x0E, 0x07, 0x87, 0xFF,
  0xBF, 0x80, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x58, 0x1B, 0x02, 0x60,
  0xCC, 0x19, 0x86, 0x30, 0xC6, 0x30, 0xC6, 0x19, 0xFF, 0xFF, 0xF8, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x7F, 0x3F, 0x9F, 0xCC, 0x06, 0x03, 0x01,
  0x80, 0xD0, 0xFF, 0x3F, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x07, 0x87,
  0xFF, 0xBF, 0x80, 0x07, 0x0F, 0x8F, 0x2E, 0x06, 0x03, 0x03, 0x81, 0xDC,
  0xDF, 0x7B, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x86, 0xC3, 0x73, 0x9F, 0x8F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07,
  0x00, 0x1E, 0x1F, 0xC7, 0x3B, 0x8E, 0xE1, 0xB8, 0x66, 0x39, 0xDC, 0x3E,
  0x07, 0x87, 0xF1, 0x8E, 0xE1, 0xB0, 0x7C, 0x1F, 0x06, 0xE3, 0x9F, 0xE3,
  0xE0, 0x1C, 0x3F, 0x1D, 0xDC, 0x7E, 0x3E, 0x0F, 0x07, 0x83, 0xE3, 0xF1,
  0xDF, 0xE7, 0xB0, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x3F, 0x1F, 0x00, 0xDF,
  0xA0, 0x00, 0x00, 0x6F, 0x80, 0x67, 0x70, 0x00, 0x00, 0x00, 0x07, 0x76,
  0x6E, 0xC0, 0x00, 0xC0, 0xF0, 0x78, 0x78, 0x78, 0x38, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x7C,
  0x7C, 0x7C, 0x3C, 0x0C, 0x02, 0x00, 0x3C, 0xFE, 0x7F, 0x07, 0x03, 0x03,
  0x07, 0x06, 0x0E, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x38, 0x38,
  0x38, 0x03, 0xC0, 0x1F, 0xE0, 0x70, 0xE1, 0xC0, 0x63, 0x00, 0xCC, 0x38,
  0xD8, 0xF9, 0xB3, 0x33, 0xC6, 0x67, 0x98, 0xCF, 0x31, 0x9E, 0x63, 0x3C,
  0xC6, 0x79, 0xDC, 0xF1, 0xEF, 0x31, 0xDE, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x40, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x81, 0xD8, 0x19, 0x81, 0x98, 0x19, 0xC3, 0x9C, 0x38, 0xC3, 0xFC, 0x3F,
  0xE7, 0xFE, 0x70, 0x67, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x70, 0xF8, 0x3F,
  0xCF, 0xFB, 0x0E, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0xFF, 0x3F, 0x8C, 0x7B,
  0x06, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xBF, 0xEF, 0xE0, 0x07, 0x87,
  0xF3, 0xFD, 0xE0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x4F, 0xF0, 0xFC, 0xF0, 0x1F,
  0xE3, 0xFE, 0x61, 0xCC, 0x1D, 0x83, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1F,
  0x03, 0xE0, 0x6C, 0x0D, 0x83, 0xB0, 0x76, 0x1C, 0xC7, 0x9F, 0xE3, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x00, 0x07, 0xC1, 0xFF, 0x3E, 0xE3, 0x82, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x1F, 0xE1, 0xFE, 0x07, 0xE0, 0x76, 0x07, 0x70, 0x77,
  0x07, 0x38, 0x71, 0xFF, 0x0F, 0xE0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFF, 0xC0, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x9F, 0xFE,
  0xC1, 0xF0, 0x7C, 0x3B, 0x0C, 0xC7, 0x33, 0x8C, 0xE3, 0x70, 0xDC, 0x3F,
  0x0F, 0xC3, 0xB8, 0xC6, 0x31, 0xCC, 0x73, 0x0E, 0xC3, 0xB0, 0x7C, 0x1C,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x83, 0xFB, 0x06, 0xF6, 0x0D, 0xEC, 0x1B, 0xDC, 0x77, 0x98, 0xCF,
  0x31, 0x9E, 0x73, 0x3C, 0x6C, 0x78, 0xD8, 0xF1, 0xB1, 0xE3, 0xE3, 0xC3,
  0x87, 0x87, 0x0F, 0x0E, 0x18, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x87,
  0xB0, 0xF7, 0x1E, 0x63, 0xCC, 0x79, 0xCF, 0x19, 0xE3, 0xBC, 0x37, 0x87,
  0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0x80, 0x0F, 0x01, 0xFC, 0x3F,
  0xE7, 0x0E, 0x70, 0x76, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x36, 0x07, 0x70, 0x77, 0x06, 0x38, 0xE3, 0xFC, 0x1F,
  0x80, 0xF0, 0x7F, 0x3F, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE7,
  0xBF, 0xDF, 0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x0F,
  0x01, 0xFC, 0x3F, 0xE7, 0x0E, 0x70, 0x76, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x07, 0x70, 0x77, 0x06, 0x38,
  0xE3, 0xFC, 0x1F, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0xF8, 0x3F,
  0x8F, 0xF3, 0x0E, 0xC3, 0xB0, 0xEC, 0x3B, 0x0E, 0xC3, 0xBF, 0xCF, 0xE3,
  0x38, 0xCE, 0x31, 0xCC, 0x73, 0x0E, 0xC3, 0xB0, 0x6C, 0x1C, 0x1E, 0x3F,
  0xDF, 0xDC, 0x2E, 0x07, 0x03, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x07, 0xC7, 0x7F, 0xBF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x87, 0xE1, 0xDF, 0xE3, 0xF0, 0xE0, 0x7E, 0x07, 0xE0,
  0x66, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x9C, 0x39,
  0xC1, 0x98, 0x19, 0x81, 0xB8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xB0, 0x70, 0x66, 0x1A,
  0x0C, 0xE3, 0x63, 0x9C, 0x6C, 0x73, 0x8D, 0x8E, 0x31, 0xB1, 0x86, 0x76,
  0x30, 0xCC, 0xEE, 0x1D, 0x8D, 0xC3, 0xB1, 0xB8, 0x36, 0x36, 0x06, 0xC6,
  0xC0, 0xF0, 0xD8, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x38, 0x38, 0x00, 0x60,
  0xEE, 0x39, 0xC7, 0x18, 0xC3, 0xB8, 0x37, 0x06, 0xC0, 0xF8, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x81, 0xB0, 0x77, 0x0E, 0xE1, 0x8C, 0x71, 0xCC, 0x1B,
  0x83, 0x80, 0xE0, 0xFC, 0x19, 0x87, 0x38, 0xE7, 0x18, 0x67, 0x0E, 0xE0,
  0xD8, 0x1B, 0x03, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0C,
  0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x7F, 0xE0, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x0F, 0x00, 0xF0,
  0x1F, 0x81, 0x98, 0x39, 0xC3, 0x0C, 0x30, 0xE6, 0x06, 0xE0, 0x70, 0xFF,
  0xFF, 0xFC, 0xE3, 0x8C, 0x30, 0x7E, 0x3F, 0x90, 0xC0, 0x70, 0x38, 0x7D,
  0xFF, 0xE7, 0xE3, 0xE1, 0xF0, 0xFC, 0xFF, 0xFB, 0xCC, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x79, 0xFE, 0xE3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xE3, 0xF1, 0xFF, 0xDB, 0xC0, 0x3F, 0x7E, 0x70, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x71, 0x7F, 0x3F, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x73, 0xDD, 0xFF, 0x73, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0xF7, 0xFC, 0xF3, 0x3E,
  0x3F, 0x98, 0xFC, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x0E,
  0x17, 0xF9, 0xF8, 0x0F, 0x1E, 0x3A, 0x30, 0x30, 0x30, 0x7E, 0xFE, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3C,
  0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1D, 0xCF, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x01, 0x90, 0xE7, 0xF1, 0xF8,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x79, 0xFE, 0xE3, 0x71, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x70, 0x7D,
  0x80, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x37, 0x30, 0x03, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x7F, 0xE0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x0F, 0x8E, 0xC6, 0x66, 0x37, 0x1B, 0x0F, 0xC7, 0x63,
  0xB9, 0x9C, 0xC6, 0x63, 0xB0, 0xD8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDE, 0x79, 0xFF, 0xFB, 0x9E, 0x36, 0x1C, 0x7C, 0x30, 0xF8, 0x61, 0xF0,
  0xC3, 0xE1, 0x87, 0xC3, 0x0F, 0x86, 0x1F, 0x0C, 0x3E, 0x18, 0x7C, 0x30,
  0xF8, 0x61, 0xC0, 0xDE, 0x7F, 0xB8, 0xD8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1C, 0x3F, 0x1F, 0xE7, 0x3B, 0x86,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x19, 0xCE, 0x7F, 0x0F,
  0xC0, 0xDE, 0x7F, 0xB8, 0xFC, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF8, 0xFC, 0x7F, 0xF6, 0xF3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00,
  0x3C, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1D, 0xCF, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0xDF, 0xFF, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00,
  0x7F, 0xFF, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0C, 0x1C, 0x7F, 0xFF,
  0x80, 0x30, 0x60, 0xC3, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x1F, 0x1E, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0xFF, 0xFB, 0xCC, 0xE1, 0xD8, 0x76, 0x19,
  0x86, 0x73, 0x8C, 0xE3, 0x30, 0xCC, 0x3B, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x03, 0x80, 0xE1, 0xC3, 0x63, 0xC7, 0x63, 0xC7, 0x63, 0xC6, 0x73, 0xC6,
  0x73, 0x66, 0x36, 0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x3E, 0x2C,
  0x1E, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xDC, 0xE3, 0x38, 0xEC, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0xC3, 0x31, 0xCE, 0x71, 0xB8, 0x70,
  0xE1, 0xD8, 0x76, 0x19, 0xC6, 0x73, 0x8C, 0xE3, 0x30, 0xCC, 0x3B, 0x07,
  0xC1, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x07, 0x81,
  0xC0, 0xFF, 0xFC, 0x30, 0xE1, 0x87, 0x0E, 0x18, 0x70, 0xC3, 0x87, 0x0F,
  0xFF, 0xC0, 0x02, 0x3C, 0x78, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC7,
  0x0F, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0x83, 0xC3, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x81, 0xE1, 0xC1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0x71, 0xE3, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x9E, 0x38, 0x00, 0x70, 0x7F, 0xF8, 0xFE, 0x0C,
};

const GFXglyph NotoSans_ExtraCondensed_Medium26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 19, 6, 2, -19 },
  { 9, 8, 7, 10, 1, -19 },
  { 16, 11, 19, 12, 1, -19 },
  { 43, 9, 22, 11, 1, -20 },
  { 68, 16, 19, 18, 1, -19 },
  { 106, 12, 19, 13, 1, -19 },
  { 135, 3, 7, 6, 1, -19 },
  { 138, 6, 23, 8, 1, -19 },
  { 156, 6, 23, 8, 1, -19 },
  { 174, 9, 9, 11, 1, -20 },
  { 185, 10, 12, 11, 1, -15 },
  { 200, 4, 6, 6, 1, -3 },
  { 203, 6, 2, 7, 1, -8 },
  { 205, 4, 3, 6, 1, -3 },
  { 207, 10, 19, 10, 0, -19 },
  { 231, 9, 19, 11, 1, -19 },
  { 253, 7, 19, 11, 1, -19 },
  { 270, 9, 19, 11, 1, -19 },
  { 292, 9, 19, 11, 1, -19 },
  { 314, 11, 19, 11, 0, -19 },
  { 341, 9, 19, 11, 1, -19 },
  { 363, 9, 19, 11, 1, -19 },
  { 385, 10, 19, 11, 1, -19 },
  { 409, 10, 19, 11, 1, -19 },
  { 433, 9, 19, 11, 1, -19 },
  { 455, 3, 14, 6, 2, -14 },
  { 461, 4, 17, 6, 1, -14 },
  { 470, 10, 12, 11, 1, -15 },
  { 485, 10, 8, 11, 1, -13 },
  { 495, 10, 12, 11, 1, -15 },
  { 510, 8, 19, 9, 0, -19 },
  { 529, 15, 21, 17, 1, -19 },
  { 569, 12, 19, 12, 0, -19 },
  { 598, 10, 19, 13, 2, -19 },
  { 622, 10, 19, 12, 1, -19 },
  { 646, 11, 19, 14, 2, -19 },
  { 673, 8, 19, 11, 2, -19 },
  { 692, 7, 19, 10, 2, -19 },
  { 709, 12, 19, 14, 1, -19 },
  { 738, 10, 19, 14, 2, -19 },
  { 762, 6, 19, 8, 1, -19 },
  { 777, 5, 24, 6, -1, -19 },
  { 792, 10, 19, 12, 2, -19 },
  { 816, 7, 19, 10, 2, -19 },
  { 833, 15, 19, 19, 2, -19 },
  { 869, 11, 19, 15, 2, -19 },
  { 896, 12, 19, 15, 1, -19 },
  { 925, 9, 19, 12, 2, -19 },
  { 947, 12, 23, 15, 1, -19 },
  { 982, 10, 19, 12, 2, -19 },
  { 1006, 9, 19, 11, 1, -19 },
  { 1028, 10, 19, 10, 0, -19 },
  { 1052, 10, 19, 14, 2, -19 },
  { 1076, 12, 19, 12, 0, -19 },
  { 1105, 19, 19, 19, 0, -19 },
  { 1151, 11, 19, 11, 0, -19 },
  { 1178, 11, 19, 11, 0, -19 },
  { 1205, 8, 19, 10, 1, -19 },
  { 1224, 5, 23, 8, 2, -19 },
  { 1239, 10, 19, 10, 0, -19 },
  { 1263, 5, 23, 8, 1, -19 },
  { 1278, 12, 11, 12, 0, -19 },
  { 1295, 11, 2, 11, 0, 2 },
  { 1298, 5, 4, 7, 1, -20 },
  { 1301, 9, 14, 11, 1, -14 },
  { 1317, 9, 20, 12, 2, -20 },
  { 1340, 8, 14, 9, 1, -14 },
  { 1354, 10, 20, 12, 1, -20 },
  { 1379, 9, 14, 11, 1, -14 },
  { 1395, 8, 20, 7, 0, -20 },
  { 1415, 10, 20, 12, 1, -14 },
  { 1440, 9, 20, 12, 2, -20 },
  { 1463, 3, 19, 6, 1, -19 },
  { 1471, 4, 25, 6, 0, -19 },
  { 1484, 9, 20, 11, 2, -20 },
  { 1507, 2, 20, 6, 2, -20 },
  { 1512, 15, 14, 18, 2, -14 },
  { 1539, 9, 14, 12, 2, -14 },
  { 1555, 10, 14, 12, 1, -14 },
  { 1573, 9, 20, 12, 2, -14 },
  { 1596, 10, 20, 12, 1, -14 },
  { 1621, 6, 14, 8, 2, -14 },
  { 1632, 7, 14, 9, 1, -14 },
  { 1645, 7, 17, 7, 0, -17 },
  { 1660, 9, 14, 12, 2, -14 },
  { 1676, 10, 14, 10, 0, -14 },
  { 1694, 16, 14, 16, 0, -14 },
  { 1722, 10, 14, 10, 0, -14 },
  { 1740, 10, 20, 10, 0, -14 },
  { 1765, 7, 14, 8, 1, -14 },
  { 1778, 7, 23, 9, 1, -19 },
  { 1799, 3, 26, 11, 4, -20 },
  { 1809, 7, 23, 9, 1, -19 },
  { 1830, 10, 4, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Medium26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM26PT7B_H_
