#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x8F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x9F, 0xC3, 0x80,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xF9, 0xC1, 0xE3, 0xF0,
  0xE0, 0x13, 0xF8, 0x70, 0x01, 0xF8, 0x38, 0x00, 0xFC, 0x1C, 0x00, 0x7E,
  0x0E, 0x00, 0x3F, 0x07, 0x00, 0x1F, 0x83, 0x80, 0x0F, 0xE1, 0xC0, 0x07,
  0xF0, 0xE0, 0x01, 0xFC, 0x70, 0x00, 0xFF, 0xB8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1D,
  0xFF, 0x00, 0x0E, 0x3F, 0x80, 0x07, 0x0F, 0xE0, 0x03, 0x87, 0xF0, 0x01,
  0xC1, 0xF8, 0x00, 0xE0, 0xFC, 0x00, 0x70, 0x7E, 0x00, 0x38, 0x3F, 0x00,
  0x1C, 0x1F, 0xC0, 0x0E, 0x0F, 0xF0, 0x07, 0x0F, 0xFE, 0x03, 0x8F, 0xEF,
  0xF1, 0xDF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x07,
  0xE3, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xC1,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x81, 0xF8,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x80,
  0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x1F,
  0x87, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0xFC, 0x3F, 0xF0, 0xFC, 0x1F, 0x8F,
  0x87, 0xFF, 0x0F, 0xC1, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x1F, 0x1F, 0x8F,
  0xFF, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x3F, 0xFE, 0x1F, 0x1F, 0x87,
  0xE3, 0xFF, 0xE3, 0xF1, 0xF0, 0x7E, 0x1F, 0xFC, 0x3E, 0x1F, 0x03, 0xE0,
  0xFF, 0x83, 0xE1, 0xF0, 0x3E, 0x07, 0xF0, 0x7E, 0x3F, 0x03, 0xE0, 0x00,
  0x07, 0xC3, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0x83, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83,
  0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x80,
  0x0F, 0xCF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xF0, 0x7F, 0xFF, 0x01, 0xFC, 0x1F, 0xDF, 0xE0, 0x7F, 0x0F, 0xF3, 0xF8,
  0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x03,
  0xF8, 0xFE, 0x3F, 0x80, 0xFF, 0x3F, 0x0F, 0xE0, 0x1F, 0xDF, 0xC3, 0xF8,
  0x03, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xFE, 0x0F,
  0xE0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xF8, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x7C, 0x0E, 0x7E, 0x3E, 0x3F, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xFC,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3E,
  0x03, 0xE0, 0x07, 0x01, 0xC0, 0x01, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x83, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFD, 0xFD, 0xFE, 0x7F, 0xFF, 0x1F, 0xDF, 0x87, 0xF3, 0xC1,
  0xFC, 0x60, 0x7F, 0x10, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0xF0, 0xF8, 0x03, 0xFC,
  0x18, 0x00, 0x7F, 0x02, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0xF0, 0x70, 0x01, 0xFC, 0x10, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF9, 0x00, 0x03, 0xFE, 0x70, 0x01, 0xFF, 0x1F, 0xC1,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3E, 0xFE, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7C, 0x7F, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x3E, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x07,
  0xF0, 0x00, 0xF8, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x00, 0x7C, 0x0F, 0xE0,
  0x07, 0xE0, 0x7F, 0x00, 0x3E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0xFC, 0x01,
  0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC1, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xCF, 0xFF, 0x04,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xD8, 0x00, 0x3F, 0xCF, 0x00, 0x3F, 0xE7, 0xF9,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x0F,
  0xE7, 0xFF, 0x07, 0xF7, 0xFF, 0xC3, 0xFB, 0xFF, 0xF1, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0xBF, 0xE0, 0x1F, 0xDF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x81,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x3F,
  0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x3F,
  0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F,
  0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x7F, 0xCF, 0xF0, 0x3F, 0xF3, 0xFF, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xDF, 0xC3, 0xFF, 0xF7, 0xF0, 0x7F, 0xF9, 0xFC, 0x0F, 0xFC,
  0x7E, 0x00, 0x78, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0x1F, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x08, 0x3F, 0x1F, 0xDF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xF9, 0xFC, 0x38, 0x02, 0x03, 0xF8, 0x7F, 0x1F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF0, 0x3F, 0xE6,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC1,
  0xF0, 0x03, 0xFF, 0x81, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x7C, 0x3F, 0x01,
  0xFF, 0xFC, 0x1F, 0x8F, 0x80, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x3F, 0x0F,
  0xC0, 0xF9, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0x9F, 0x03, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0,
  0x3E, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0xFF, 0x03, 0xE0,
  0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x03, 0xF0,
  0x3F, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0x3E, 0x03, 0xEF,
  0xC1, 0xF8, 0x0F, 0x80, 0xFB, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0xFC, 0x1F,
  0x81, 0xF8, 0x0F, 0xBF, 0x03, 0xE0, 0x7E, 0x03, 0xEF, 0xC0, 0xF8, 0x1F,
  0x81, 0xFB, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x7C, 0x0F, 0xC3, 0xFC, 0x1F,
  0x1F, 0x03, 0xF8, 0xEF, 0x0F, 0xC7, 0xC0, 0x7F, 0xFB, 0xFF, 0xE1, 0xF8,
  0x1F, 0xFE, 0x7F, 0xF0, 0x7E, 0x03, 0xFF, 0x1F, 0xFC, 0x1F, 0x80, 0x7F,
  0x83, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x00,
  0x60, 0x00, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xE7, 0xF0,
  0x07, 0xFC, 0xFE, 0x00, 0x7F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFC, 0x07,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F,
  0xF9, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0xEF, 0xE0, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFE, 0x03, 0xC0, 0xFF, 0x80, 0x0C, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x02, 0x07, 0xFE, 0x01, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x3F, 0xF0, 0xFE,
  0x00, 0x7F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0,
  0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xF1, 0xFC, 0x01, 0xFF, 0x0F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0x1C, 0x0F,
  0xF8, 0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x7F,
  0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x7F, 0x07,
  0xFE, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0x7F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0xC3, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFC, 0x00, 0x7F, 0xEF, 0xF0, 0x03,
  0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFC,
  0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0xBF, 0x80, 0x03, 0xFE, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xDF,
  0x80, 0x00, 0x7E, 0xFF, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xFF, 0x3F, 0x00, 0x03, 0xF3, 0xFF, 0xEF, 0xC0, 0x00, 0xFD,
  0xFF, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0xFE, 0xFC, 0x00, 0x0F, 0xDF, 0xFF,
  0x9F, 0x80, 0x07, 0xE7, 0xFF, 0xE7, 0xE0, 0x01, 0xF9, 0xFF, 0xF9, 0xF8,
  0x00, 0x7E, 0x7F, 0xFE, 0x7F, 0x00, 0x1F, 0x1F, 0xFF, 0x8F, 0xC0, 0x0F,
  0xC7, 0xFF, 0xE3, 0xF0, 0x03, 0xF1, 0xFF, 0xF8, 0xFC, 0x00, 0xFC, 0x7F,
  0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xFF, 0x87, 0xE0, 0x1F, 0x87, 0xFF, 0xE1,
  0xF8, 0x07, 0xE1, 0xFF, 0xF8, 0x7E, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x0F, 0xC1,
  0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xFF,
  0x81, 0xF8, 0x7E, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x01, 0xFF, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7F, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFD, 0xF8, 0x00, 0x7F, 0xFD, 0xFC,
  0x00, 0x7F, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0xFE,
  0x00, 0x7F, 0xFE, 0x7E, 0x00, 0x7F, 0xFE, 0x7F, 0x00, 0x7F, 0xFE, 0x3F,
  0x00, 0x7F, 0xFE, 0x3F, 0x80, 0x7F, 0xFE, 0x3F, 0x80, 0x7F, 0xFE, 0x1F,
  0xC0, 0x7F, 0xFE, 0x1F, 0xC0, 0x7F, 0xFE, 0x0F, 0xC0, 0x7F, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x07,
  0xF0, 0x7F, 0xFE, 0x03, 0xF8, 0x7F, 0xFE, 0x03, 0xF8, 0x7F, 0xFE, 0x01,
  0xF8, 0x7F, 0xFE, 0x01, 0xFC, 0x7F, 0xFE, 0x01, 0xFC, 0x7F, 0xFE, 0x00,
  0xFE, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0xFE, 0x00,
  0x7F, 0x7F, 0xFE, 0x00, 0x3F, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xF8, 0xFF,
  0xF9, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0x7F, 0x0F, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xE0, 0xFC, 0x7F, 0x80, 0x1C, 0xFF, 0x00,
  0x04, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x80, 0x01, 0xFE, 0xE0, 0x01, 0xFE, 0xFC, 0x07,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFB, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0x9F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF9, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF9,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xF1, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x0F, 0x80, 0xFE, 0x00, 0x7E,
  0x03, 0xF0, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x00,
  0x7F, 0x03, 0xE0, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x7C, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x07, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x7C, 0x07,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xFC,
  0x03, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x01, 0xF8,
  0xFC, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x80, 0x01,
  0xFC, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00,
  0x00, 0xFD, 0xF8, 0x01, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x7F,
  0x00, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x01,
  0xFC, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x9F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xF7, 0xFE, 0x07, 0x01, 0xFE, 0x04, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFE, 0x3F, 0x3F, 0xC0, 0x3F, 0x7F, 0x80, 0x3F, 0x7F, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F,
  0x01, 0xFF, 0x7F, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F,
  0xFF, 0x1F, 0x1F, 0xFE, 0x1F, 0x07, 0xFC, 0x1F, 0x00, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x1F, 0xF8, 0x1F, 0xC7, 0xFF, 0x83,
  0xF9, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1,
  0xFF, 0x3F, 0xF0, 0x1F, 0xE7, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x3F, 0xDF,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F,
  0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xE0,
  0x0F, 0xE7, 0xFE, 0x03, 0xFC, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFB, 0xFF, 0xF8, 0x7E, 0x3F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC1, 0xF8, 0x3F,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x81, 0xC7,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x19, 0xFF, 0x87, 0xC7, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x03, 0xF0, 0x7F, 0x03, 0xFF, 0x1F, 0xC1, 0xFF, 0xE3,
  0xF0, 0xFF, 0xFC, 0xFC, 0x7F, 0xFF, 0xBF, 0x1F, 0xFF, 0xEF, 0xCF, 0xF8,
  0x7F, 0xF3, 0xF8, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF,
  0xC0, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xFC, 0xFF,
  0x01, 0xFF, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0xFB, 0xF1, 0xFF, 0xFE, 0xFC,
  0x3F, 0xFF, 0x3F, 0x07, 0xFF, 0x8F, 0xC0, 0xFF, 0xC1, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x0F, 0xCF,
  0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x02, 0x3F, 0xC0, 0x06, 0x0F, 0xF8, 0x1F, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0xFC, 0x3F, 0xFF, 0x3F, 0x1F, 0xFF,
  0xEF, 0xC7, 0xFF, 0xFB, 0xF3, 0xFE, 0x1F, 0xFC, 0xFE, 0x01, 0xFF, 0x7F,
  0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0,
  0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0xCF, 0xF8, 0x7F, 0xF1,
  0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x3F, 0x0F, 0xFF, 0xDF, 0xC1, 0xFF, 0xE7,
  0xF0, 0x3F, 0xE1, 0xFC, 0x01, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF9, 0x00, 0x00, 0xFE, 0x30, 0x00, 0x7F,
  0x8F, 0x80, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0xFE, 0x3F, 0xF8, 0x7F, 0x3F, 0xFE, 0x3F, 0xBF, 0xFF, 0x9F, 0xDF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0x87, 0xFB, 0xFF, 0x01, 0xFD, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFC,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xD1,
  0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x9F, 0x80,
  0x3F, 0x8F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01,
  0xFB, 0xFC, 0x00, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0xFE, 0x03, 0xFC, 0x7F,
  0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0,
  0x07, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xC7,
  0xFF, 0xC3, 0xFF, 0xE3, 0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFB, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xBF,
  0xC0, 0x1F, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xF8, 0x03, 0xFB, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xBF, 0xC0, 0x0F, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x1F, 0xFC, 0x3F, 0x1F, 0xFF, 0x1F, 0x9F,
  0xFF, 0xCF, 0xCF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0x83, 0xFD, 0xFF,
  0x80, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F,
  0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x3F, 0x00,
  0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x83, 0xFF,
  0x03, 0xF1, 0xFF, 0xF0, 0x7E, 0x3F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE7, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0x3F,
  0x9F, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0,
  0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF,
  0xE0, 0x0F, 0xF7, 0xFC, 0x01, 0xFC, 0xFF, 0xC0, 0x7F, 0x9F, 0xFE, 0x3F,
  0xE3, 0xFB, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0x0F, 0xE7, 0xFF, 0xE1, 0xFC,
  0x7F, 0xF8, 0x3F, 0x87, 0xFC, 0x07, 0xF0, 0x1E, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8,
  0xFC, 0x3F, 0xFF, 0x3F, 0x1F, 0xFF, 0xEF, 0xC7, 0xFF, 0xFB, 0xF3, 0xFE,
  0x1F, 0xFC, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xC0, 0x0F, 0xF7,
  0xF0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x3F,
  0xC0, 0xFF, 0xCF, 0xF8, 0x7F, 0xF1, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x3F,
  0x0F, 0xFF, 0xCF, 0xC1, 0xFF, 0xE7, 0xF0, 0x3F, 0xE1, 0xFC, 0x01, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xBF, 0x3F, 0xEF, 0xFF, 0xFB, 0xFF, 0xC2, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFC, 0x07, 0x8F, 0xC0, 0x08, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0xE0, 0x0F, 0xF7,
  0xF1, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFE, 0x30, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0x7F, 0xEF,
  0xFF, 0x9F, 0xFF, 0xEF, 0xCF, 0xFF, 0xE7, 0xE3, 0xFF, 0xF3, 0xF0, 0xFF,
  0xF1, 0xF8, 0x3F, 0xE0, 0xFC, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xFC, 0x01, 0xFC,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xF0, 0x07, 0xE3, 0xF8,
  0x07, 0xFF, 0x00, 0xFC, 0x7F, 0x00, 0xFB, 0xE0, 0x3F, 0x87, 0xE0, 0x1F,
  0x7C, 0x07, 0xF0, 0xFE, 0x07, 0xEF, 0x80, 0xFE, 0x1F, 0xC0, 0xF9, 0xF0,
  0x1F, 0x83, 0xF8, 0x1F, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE7, 0xE0, 0xFE,
  0x07, 0xE0, 0x7C, 0x7C, 0x1F, 0xC0, 0xFE, 0x1F, 0x8F, 0x83, 0xF0, 0x1F,
  0xC3, 0xF1, 0xF0, 0x7E, 0x03, 0xF8, 0x7C, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0x87, 0xE3, 0xF8, 0x07, 0xE1, 0xF0, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x0F,
  0x8F, 0xC0, 0x1F, 0xCF, 0xC1, 0xF1, 0xF8, 0x03, 0xF9, 0xF0, 0x3E, 0x3F,
  0x00, 0x3F, 0x3E, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0xFD, 0xF8, 0x00,
  0xFC, 0xF8, 0x0F, 0xBF, 0x00, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x01, 0xF7,
  0xE0, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xDF, 0x80, 0x07, 0xFF, 0x00,
  0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0x9F, 0xC0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xDF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x43, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x27, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x80, 0x01, 0xFF, 0x90, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 52, 17, 4, -51 },
  { 60, 20, 19, 28, 4, -51 },
  { 108, 31, 51, 34, 1, -51 },
  { 306, 25, 58, 31, 3, -54 },
  { 488, 44, 52, 49, 3, -51 },
  { 774, 34, 52, 36, 2, -51 },
  { 995, 8, 19, 15, 4, -51 },
  { 1014, 16, 62, 21, 3, -51 },
  { 1138, 16, 62, 21, 2, -51 },
  { 1262, 25, 25, 29, 2, -54 },
  { 1341, 27, 34, 31, 2, -42 },
  { 1456, 11, 17, 16, 2, -8 },
  { 1480, 16, 6, 20, 2, -22 },
  { 1492, 9, 10, 17, 4, -9 },
  { 1504, 25, 51, 27, 1, -51 },
  { 1664, 25, 52, 31, 3, -51 },
  { 1827, 18, 51, 31, 4, -51 },
  { 1942, 26, 51, 31, 2, -51 },
  { 2108, 26, 52, 31, 2, -51 },
  { 2277, 29, 51, 31, 1, -51 },
  { 2462, 25, 52, 31, 3, -51 },
  { 2625, 25, 52, 31, 3, -51 },
  { 2788, 27, 51, 31, 2, -51 },
  { 2961, 27, 52, 31, 2, -51 },
  { 3137, 26, 52, 31, 2, -51 },
  { 3306, 9, 40, 17, 4, -39 },
  { 3351, 11, 48, 17, 2, -39 },
  { 3417, 27, 32, 31, 2, -41 },
  { 3525, 27, 20, 31, 2, -35 },
  { 3593, 27, 32, 31, 2, -41 },
  { 3701, 21, 52, 24, 1, -51 },
  { 3838, 42, 57, 48, 3, -51 },
  { 4138, 34, 51, 34, 0, -51 },
  { 4355, 27, 51, 35, 5, -51 },
  { 4528, 28, 52, 32, 3, -51 },
  { 4710, 29, 51, 38, 5, -51 },
  { 4895, 21, 51, 29, 5, -51 },
  { 5029, 21, 51, 28, 5, -51 },
  { 5163, 32, 52, 39, 3, -51 },
  { 5371, 29, 51, 39, 5, -51 },
  { 5556, 17, 51, 21, 2, -51 },
  { 5665, 16, 65, 17, -4, -51 },
  { 5795, 29, 51, 33, 5, -51 },
  { 5980, 21, 51, 27, 5, -51 },
  { 6114, 42, 51, 52, 5, -51 },
  { 6382, 32, 51, 42, 5, -51 },
  { 6586, 34, 52, 40, 3, -51 },
  { 6807, 25, 51, 32, 5, -51 },
  { 6967, 34, 63, 40, 3, -51 },
  { 7235, 28, 51, 34, 5, -51 },
  { 7414, 24, 52, 30, 3, -51 },
  { 7570, 26, 51, 28, 1, -51 },
  { 7736, 28, 52, 38, 5, -51 },
  { 7918, 33, 51, 33, 0, -51 },
  { 8129, 52, 51, 52, 0, -51 },
  { 8461, 30, 51, 30, 0, -51 },
  { 8653, 30, 51, 30, 0, -51 },
  { 8845, 23, 51, 27, 2, -51 },
  { 8992, 15, 62, 22, 5, -51 },
  { 9109, 25, 51, 27, 1, -51 },
  { 9269, 15, 62, 22, 2, -51 },
  { 9386, 31, 29, 33, 1, -51 },
  { 9499, 31, 5, 30, 0, 6 },
  { 9519, 14, 11, 20, 3, -54 },
  { 9539, 24, 40, 31, 2, -39 },
  { 9659, 27, 55, 34, 4, -54 },
  { 9845, 21, 40, 26, 3, -39 },
  { 9950, 26, 55, 34, 3, -54 },
  { 10129, 25, 40, 31, 3, -39 },
  { 10254, 20, 54, 19, 1, -54 },
  { 10389, 26, 56, 34, 3, -39 },
  { 10571, 25, 54, 33, 4, -54 },
  { 10740, 8, 53, 16, 4, -53 },
  { 10793, 13, 70, 16, -1, -53 },
  { 10907, 25, 54, 30, 5, -54 },
  { 11076, 7, 54, 16, 4, -54 },
  { 11124, 42, 39, 50, 4, -39 },
  { 11329, 25, 39, 33, 4, -39 },
  { 11451, 27, 40, 33, 3, -39 },
  { 11586, 27, 56, 34, 4, -39 },
  { 11775, 26, 56, 34, 3, -39 },
  { 11957, 18, 39, 23, 4, -39 },
  { 12045, 21, 40, 25, 2, -39 },
  { 12150, 18, 48, 20, 1, -47 },
  { 12258, 25, 39, 33, 4, -38 },
  { 12380, 28, 38, 28, 0, -38 },
  { 12513, 43, 38, 45, 1, -38 },
  { 12718, 26, 38, 28, 1, -38 },
  { 12842, 28, 55, 28, 0, -38 },
  { 13035, 19, 38, 23, 2, -38 },
  { 13126, 21, 62, 25, 2, -51 },
  { 13289, 6, 71, 29, 12, -54 },
  { 13343, 20, 62, 25, 3, -51 },
  { 13498, 27, 10, 31, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Medium71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM71PT7B_H_
