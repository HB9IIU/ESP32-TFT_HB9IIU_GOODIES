#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x1F, 0x60, 0xE7, 0xCF, 0x9B, 0x36,
  0x6C, 0xC0, 0x0C, 0xC1, 0x90, 0x22, 0x04, 0xC1, 0x98, 0xFF, 0xC6, 0x60,
  0xCC, 0x19, 0x03, 0x23, 0xFF, 0x7F, 0xE3, 0x30, 0x66, 0x0C, 0xC1, 0x98,
  0x32, 0x00, 0x08, 0x04, 0x0F, 0xCF, 0xEC, 0x86, 0x43, 0x21, 0xD0, 0x78,
  0x0F, 0x03, 0xC1, 0x60, 0x98, 0x5F, 0x2D, 0xFC, 0x7C, 0x04, 0x02, 0x00,
  0x78, 0x61, 0xB0, 0xC3, 0x31, 0x06, 0x66, 0x0C, 0xCC, 0x19, 0xB0, 0x33,
  0x64, 0x66, 0xDE, 0xDB, 0x6C, 0xF6, 0xCC, 0x09, 0x98, 0x33, 0x30, 0x66,
  0x60, 0x8C, 0xC3, 0x19, 0x86, 0x3E, 0x18, 0x3C, 0x3C, 0x0F, 0xC1, 0x98,
  0x33, 0x06, 0x60, 0xEC, 0x0F, 0x01, 0xE0, 0x78, 0x1D, 0x9B, 0x3B, 0x63,
  0xEC, 0x79, 0x87, 0x39, 0xE7, 0xFE, 0x7C, 0xE0, 0xFF, 0xB6, 0xC0, 0x1C,
  0xE3, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xE3, 0x86, 0x18, 0x60,
  0xC3, 0x06, 0x1C, 0xC3, 0x18, 0x63, 0x18, 0xE3, 0x18, 0xC6, 0x31, 0x9C,
  0xE6, 0x33, 0x99, 0x8C, 0x00, 0x18, 0x18, 0xDB, 0xFF, 0x18, 0x3C, 0x66,
  0x66, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87, 0xFC, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x00, 0x6D, 0xFD, 0x80, 0xFF, 0xFE, 0x7D, 0x80, 0x03, 0x81, 0x80,
  0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0xE0, 0x00, 0x3E, 0x3F, 0x19, 0xDC, 0x6E, 0x36, 0x1B,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6E, 0x37, 0x19, 0x9C, 0xFC, 0x3C,
  0x00, 0x0C, 0x73, 0xFF, 0x6C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x7E, 0xFE, 0x47, 0x03, 0x03, 0x03, 0x07, 0x06, 0x0E, 0x0C,
  0x1C, 0x38, 0x30, 0x60, 0xE0, 0xFF, 0xFF, 0x7E, 0xFF, 0x87, 0x03, 0x03,
  0x03, 0x06, 0x3C, 0x3C, 0x0F, 0x03, 0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC,
  0x03, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0x18,
  0xC6, 0x33, 0xFF, 0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x3F,
  0x98, 0x0C, 0x06, 0x07, 0x03, 0xF1, 0xFC, 0x4F, 0x01, 0x80, 0xC0, 0x70,
  0x30, 0x1A, 0x1D, 0xFC, 0xFC, 0x00, 0x1F, 0x1F, 0x9C, 0x0C, 0x0E, 0x06,
  0x03, 0x79, 0xBE, 0xE7, 0x71, 0xB0, 0xF8, 0x7C, 0x3F, 0x19, 0x8C, 0xFE,
  0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x00, 0x3E, 0x3F,
  0xB8, 0xD8, 0x6C, 0x33, 0x19, 0xDC, 0x7C, 0x3C, 0x3B, 0xB8, 0xD8, 0x7C,
  0x3E, 0x1F, 0x8C, 0xFE, 0x3E, 0x00, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xE7, 0x7F, 0x3B, 0x03, 0x03, 0x07, 0x0E, 0x7C, 0x78, 0x7D,
  0x80, 0x00, 0x01, 0xF6, 0x7D, 0x80, 0x00, 0x01, 0xB7, 0xF6, 0x00, 0x81,
  0xC3, 0xC7, 0x8F, 0x06, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x20, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70, 0x3E, 0x07, 0x80,
  0xF0, 0x1C, 0x3C, 0x78, 0xF0, 0x60, 0x20, 0x00, 0x7C, 0xFE, 0x46, 0x07,
  0x06, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x00, 0x00, 0x38, 0x38,
  0x38, 0x0F, 0xC0, 0x71, 0xC3, 0x03, 0x98, 0x06, 0x63, 0x8D, 0x9F, 0x3C,
  0xCC, 0xF3, 0x33, 0xCC, 0xCF, 0x33, 0x3C, 0xCC, 0xF3, 0x33, 0xCD, 0xFB,
  0x1D, 0xE6, 0x00, 0x18, 0x00, 0x30, 0x20, 0x7F, 0x80, 0xFC, 0x00, 0x0E,
  0x01, 0xE0, 0x3C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xE1, 0xCC, 0x31, 0x86,
  0x30, 0xFF, 0x3F, 0xE7, 0x0C, 0xC1, 0x98, 0x3F, 0x07, 0xE0, 0x60, 0xFE,
  0x7F, 0xB1, 0xD8, 0x6C, 0x3E, 0x1B, 0x1D, 0xFC, 0xFE, 0x63, 0xB0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x1D, 0xFE, 0xFE, 0x00, 0x1F, 0x9F, 0xDC, 0x2E, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xE2,
  0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0xCC, 0x73, 0x0E, 0xC1, 0xB0, 0x6C, 0x1B,
  0x07, 0xC1, 0xF0, 0x7C, 0x1B, 0x06, 0xC3, 0xB0, 0xEC, 0x73, 0xF8, 0xFC,
  0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0xFD, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x7F, 0xFE, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFD,
  0xFB, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x1F, 0xE7, 0xF8, 0xE1, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x83, 0xF0, 0x76,
  0x0E, 0xE1, 0xDE, 0x39, 0xFF, 0x1F, 0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0x80, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xDF, 0xF8, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xCF, 0xFF, 0x70, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE6, 0xE3, 0x61,
  0xF0, 0xF8, 0x7E, 0x33, 0x19, 0xCC, 0x66, 0x3B, 0x0D, 0x87, 0xC3, 0x80,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xFE, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x6F,
  0x61, 0xBD, 0x86, 0xF6, 0x33, 0xD8, 0xCF, 0x33, 0x3C, 0xCC, 0xF3, 0x63,
  0xCF, 0x8F, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0xC3, 0x0C, 0xE0, 0xF8, 0x3F,
  0x0F, 0xC3, 0xF8, 0xF6, 0x3D, 0x8F, 0x33, 0xCC, 0xF3, 0xBC, 0x6F, 0x1F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xC0, 0x1F, 0x87, 0xF9, 0xC7, 0x30,
  0x76, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x36,
  0x0E, 0xC1, 0xDC, 0x71, 0xFE, 0x1F, 0x00, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x1F, 0x87, 0xF9, 0xC7, 0x30, 0x76, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x36, 0x0E, 0xC1, 0xDC, 0x71, 0xFE, 0x1F, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0xFC, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B,
  0x0D, 0x8E, 0xFE, 0x7E, 0x33, 0x19, 0xCC, 0x66, 0x3B, 0x1D, 0x87, 0xC3,
  0x80, 0x3F, 0x7F, 0xE1, 0xC0, 0xC0, 0xE0, 0xE0, 0x78, 0x3C, 0x0E, 0x07,
  0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x8E, 0xFE, 0x3E, 0x00, 0xE0, 0x7C,
  0x1D, 0x83, 0x30, 0x66, 0x0C, 0xE3, 0x8C, 0x61, 0x8C, 0x31, 0x87, 0x70,
  0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0xC1,
  0xF0, 0xE0, 0xD8, 0x70, 0x6C, 0x3C, 0x76, 0x1E, 0x3B, 0x0B, 0x19, 0xCD,
  0x8C, 0x66, 0xC6, 0x33, 0x37, 0x19, 0x9B, 0x8C, 0xCD, 0x87, 0xC6, 0xC1,
  0xE3, 0x60, 0xF0, 0xB0, 0x78, 0x78, 0x3C, 0x38, 0x1C, 0x1C, 0x00, 0x61,
  0xDC, 0x63, 0x38, 0xCC, 0x3B, 0x07, 0xC1, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0xEC, 0x33, 0x0C, 0xE7, 0x19, 0x86, 0xE1, 0xC0, 0xE1, 0xD8, 0x66,
  0x19, 0xCE, 0x33, 0x0C, 0xC3, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFE, 0xFE, 0x06, 0x0E, 0x0C,
  0x1C, 0x18, 0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0xFF, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80,
  0x06, 0x01, 0xC0, 0x3C, 0x0D, 0x81, 0xB0, 0x63, 0x0C, 0x63, 0x06, 0xE0,
  0xE0, 0xFF, 0xFF, 0xF0, 0xE3, 0x8E, 0x7E, 0x7E, 0x47, 0x03, 0x03, 0x3F,
  0x7F, 0xE3, 0xC3, 0xC7, 0xC7, 0xFF, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x7B, 0xFD, 0xE7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xE7, 0xFF, 0x67, 0x80, 0x3E, 0xFD, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC1,
  0xC1, 0x83, 0xF3, 0xE0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x19, 0xED, 0xF7,
  0xC7, 0xE3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x8F, 0xC7, 0x7F, 0x9E,
  0xC0, 0x3C, 0x7E, 0x63, 0xE3, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x61,
  0x7F, 0x3F, 0x1E, 0x7C, 0xC1, 0x83, 0x0F, 0xBF, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x3D, 0xBE, 0xD8, 0xFC, 0x7C, 0x3E,
  0x0F, 0x07, 0x83, 0xC3, 0xF1, 0xF8, 0xEF, 0xB3, 0xD8, 0x0C, 0x0E, 0x07,
  0x47, 0x3F, 0x0F, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x7B, 0xFD,
  0xE7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xC0, 0x7D, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x37, 0x30, 0x07, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0xEC, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC7, 0xC6, 0xCC, 0xDC, 0xD8, 0xF8, 0xF8, 0xFC, 0xCC, 0xCE, 0xC6,
  0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xCE, 0x7B, 0xFD,
  0xFE, 0x38, 0xF8, 0xE3, 0xE3, 0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xE3,
  0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xE3, 0x8C, 0xCF, 0x7F, 0xBC, 0xFC,
  0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x18, 0x3E,
  0x3F, 0x98, 0xDC, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xD8, 0xCF,
  0xE3, 0xE0, 0xCF, 0x7F, 0xBC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xFC, 0xFF, 0xEE, 0xF7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00,
  0x3D, 0xBE, 0xD8, 0xFC, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC3, 0xF1, 0xF8,
  0xEF, 0xB3, 0xD8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xCF, 0x7F,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0x7F, 0xFB, 0x16, 0x0E,
  0x1E, 0x1E, 0x0E, 0x0E, 0x1E, 0x3F, 0xEF, 0x80, 0x30, 0xC3, 0x1F, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xCF, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xD8, 0xEF, 0xB3, 0xD8, 0xE1,
  0xF0, 0xD8, 0xEC, 0x66, 0x31, 0x98, 0xDC, 0x6C, 0x36, 0x0B, 0x07, 0x83,
  0x81, 0xC0, 0xE3, 0x87, 0xC7, 0x1D, 0x8E, 0x33, 0x14, 0x66, 0x6C, 0xCE,
  0xDB, 0x8D, 0xB6, 0x1B, 0x6C, 0x34, 0x58, 0x78, 0xF0, 0xF1, 0xE0, 0xE3,
  0x81, 0xC7, 0x00, 0xE3, 0xB1, 0x8D, 0xC6, 0xC3, 0xE0, 0xE0, 0x70, 0x3C,
  0x3E, 0x1B, 0x1C, 0xCC, 0x6E, 0x38, 0xE1, 0xF0, 0xD8, 0xEC, 0x67, 0x31,
  0x98, 0xDC, 0x6C, 0x36, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0x38, 0x78, 0x38, 0x00, 0xFF, 0xF1, 0xC6, 0x38, 0xC3, 0x1C, 0x63, 0x8C,
  0x3F, 0xFC, 0x1E, 0x3C, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x31, 0xE3, 0x83,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x3C,
  0x38, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0x8C, 0x00, 0xF0, 0xFF,
  0xE3, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 17, 6, 1, -17 },
  { 8, 7, 6, 10, 1, -17 },
  { 14, 11, 17, 11, 0, -17 },
  { 38, 9, 19, 11, 1, -18 },
  { 60, 15, 17, 17, 1, -17 },
  { 92, 11, 17, 12, 1, -17 },
  { 116, 3, 6, 5, 1, -17 },
  { 119, 6, 21, 7, 1, -17 },
  { 135, 5, 21, 7, 1, -17 },
  { 149, 8, 8, 10, 1, -18 },
  { 157, 9, 11, 11, 1, -14 },
  { 170, 3, 6, 6, 1, -3 },
  { 173, 5, 3, 7, 1, -8 },
  { 175, 3, 3, 6, 1, -3 },
  { 177, 9, 17, 9, 0, -17 },
  { 197, 9, 17, 11, 1, -17 },
  { 217, 6, 17, 11, 1, -17 },
  { 230, 8, 17, 11, 1, -17 },
  { 247, 8, 17, 11, 1, -17 },
  { 264, 10, 17, 11, 0, -17 },
  { 286, 9, 17, 11, 1, -17 },
  { 306, 9, 17, 11, 1, -17 },
  { 326, 9, 17, 11, 1, -17 },
  { 346, 9, 17, 11, 1, -17 },
  { 366, 8, 17, 11, 1, -17 },
  { 383, 3, 13, 6, 1, -13 },
  { 388, 3, 16, 6, 1, -13 },
  { 394, 9, 11, 11, 1, -14 },
  { 407, 9, 7, 11, 1, -12 },
  { 415, 9, 11, 11, 1, -14 },
  { 428, 8, 17, 8, 0, -17 },
  { 445, 14, 19, 16, 1, -17 },
  { 479, 11, 17, 11, 0, -17 },
  { 503, 9, 17, 12, 2, -17 },
  { 523, 9, 17, 11, 1, -17 },
  { 543, 10, 17, 13, 2, -17 },
  { 565, 7, 17, 10, 2, -17 },
  { 580, 7, 17, 9, 2, -17 },
  { 595, 11, 17, 13, 1, -17 },
  { 619, 9, 17, 13, 2, -17 },
  { 639, 5, 17, 7, 1, -17 },
  { 650, 5, 22, 6, -1, -17 },
  { 664, 9, 17, 11, 2, -17 },
  { 684, 7, 17, 9, 2, -17 },
  { 699, 14, 17, 18, 2, -17 },
  { 729, 10, 17, 14, 2, -17 },
  { 751, 11, 17, 14, 1, -17 },
  { 775, 8, 17, 11, 2, -17 },
  { 792, 11, 21, 14, 1, -17 },
  { 821, 9, 17, 11, 2, -17 },
  { 841, 8, 17, 10, 1, -17 },
  { 858, 9, 17, 9, 0, -17 },
  { 878, 9, 17, 13, 2, -17 },
  { 898, 11, 17, 11, 0, -17 },
  { 922, 17, 17, 17, 0, -17 },
  { 959, 10, 17, 10, 0, -17 },
  { 981, 10, 17, 10, 0, -17 },
  { 1003, 8, 17, 9, 1, -17 },
  { 1020, 5, 21, 7, 2, -17 },
  { 1034, 9, 17, 9, 0, -17 },
  { 1054, 5, 21, 7, 1, -17 },
  { 1068, 11, 9, 11, 0, -17 },
  { 1081, 10, 2, 10, 0, 2 },
  { 1084, 5, 3, 7, 1, -18 },
  { 1086, 8, 13, 10, 1, -13 },
  { 1099, 9, 18, 11, 1, -18 },
  { 1120, 7, 13, 9, 1, -13 },
  { 1132, 9, 18, 11, 1, -18 },
  { 1153, 8, 13, 10, 1, -13 },
  { 1166, 7, 18, 6, 0, -18 },
  { 1182, 9, 19, 11, 1, -13 },
  { 1204, 9, 18, 11, 1, -18 },
  { 1225, 3, 18, 5, 1, -18 },
  { 1232, 4, 24, 5, 0, -18 },
  { 1244, 8, 18, 10, 2, -18 },
  { 1262, 3, 18, 5, 1, -18 },
  { 1269, 14, 13, 17, 1, -13 },
  { 1292, 9, 13, 11, 1, -13 },
  { 1307, 9, 13, 11, 1, -13 },
  { 1322, 9, 19, 11, 1, -13 },
  { 1344, 9, 19, 11, 1, -13 },
  { 1366, 6, 13, 8, 1, -13 },
  { 1376, 7, 13, 8, 1, -13 },
  { 1388, 6, 16, 7, 0, -16 },
  { 1400, 9, 13, 11, 1, -13 },
  { 1415, 9, 13, 9, 0, -13 },
  { 1430, 15, 13, 15, 0, -13 },
  { 1455, 9, 13, 9, 0, -13 },
  { 1470, 9, 19, 9, 0, -13 },
  { 1492, 6, 13, 8, 1, -13 },
  { 1502, 7, 21, 9, 1, -17 },
  { 1521, 2, 24, 10, 4, -18 },
  { 1527, 7, 21, 9, 1, -17 },
  { 1546, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Medium24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM24PT7B_H_
