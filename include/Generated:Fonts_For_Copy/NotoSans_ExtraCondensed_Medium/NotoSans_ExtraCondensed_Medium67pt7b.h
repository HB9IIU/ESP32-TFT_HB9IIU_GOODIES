#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUM67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUM67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Medium.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Medium67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x18, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xB8, 0x7C, 0xFE, 0x38, 0x08, 0xFC, 0x38,
  0x00, 0xFC, 0x38, 0x00, 0xFC, 0x38, 0x00, 0xFC, 0x38, 0x00, 0xFC, 0x38,
  0x00, 0xFC, 0x38, 0x00, 0xFC, 0x38, 0x00, 0xFE, 0x38, 0x00, 0x7F, 0x38,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3B, 0xFC, 0x00, 0x39, 0xFE, 0x00, 0x38, 0xFE, 0x00, 0x38,
  0x7E, 0x00, 0x38, 0x3F, 0x00, 0x38, 0x3F, 0x00, 0x38, 0x3F, 0x00, 0x38,
  0x3F, 0x00, 0x38, 0x3E, 0x80, 0x38, 0x7E, 0xC0, 0x38, 0xFE, 0xF8, 0x39,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0x03, 0xF0,
  0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE1,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x8F, 0x83, 0xF8, 0x1F, 0x07, 0xE3, 0xE1, 0xFF, 0x07,
  0xC1, 0xF0, 0xF8, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x3F, 0xFC, 0x3E, 0x1F,
  0x1F, 0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE1, 0xFF, 0xE3, 0xE3,
  0xF0, 0xF8, 0x7F, 0xF0, 0xF8, 0xF8, 0x3E, 0x0F, 0xF8, 0x7E, 0x3E, 0x0F,
  0xC1, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x08, 0x07, 0xC3, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x9F,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFC, 0x1F,
  0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0x81, 0xFC, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F,
  0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0xFE,
  0x03, 0xF3, 0xF8, 0xFE, 0x03, 0xFB, 0xF0, 0xFE, 0x01, 0xFF, 0xF0, 0xFC,
  0x01, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xE0, 0xFE,
  0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x10, 0x1F, 0x01, 0x3C, 0x3E, 0x1E, 0x7F, 0x3D, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x1F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x81, 0xF0, 0x3C, 0x00,
  0xC0, 0x70, 0x00, 0x80, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xEF, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E,
  0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x3F,
  0x83, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0x9F, 0xCF, 0xDF, 0xCF, 0xFF, 0xE7,
  0xF7, 0xE3, 0xF9, 0xC1, 0xFC, 0x40, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0x8F, 0xFC, 0x3E, 0x01, 0xFE, 0x18, 0x00, 0xFE, 0x10, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0x87, 0xFC, 0x3C, 0x01, 0xFE, 0x18, 0x00, 0xFE, 0x10,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0xE0, 0x01, 0xFE, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7B, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0xF9,
  0xFC, 0x00, 0x1F, 0x3F, 0x80, 0x07, 0xC7, 0xF0, 0x00, 0xF8, 0xFE, 0x00,
  0x3E, 0x1F, 0xC0, 0x07, 0xC3, 0xF8, 0x01, 0xF0, 0x7F, 0x00, 0x3E, 0x0F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F,
  0x80, 0xFE, 0x01, 0xF0, 0x1F, 0xC0, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x7F,
  0x03, 0xE0, 0x0F, 0xE0, 0x7C, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xE0,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x18, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x80, 0x03, 0xFC, 0xE0,
  0x07, 0xFC, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x0F, 0xFC, 0x18, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x04, 0x00, 0xFC, 0x3F, 0xC0, 0xFC, 0xFF, 0xE0, 0xFC,
  0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFC, 0xFF,
  0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F,
  0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03,
  0xF3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x80,
  0x7E, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x01,
  0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF8,
  0x1F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xE7, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0xC3, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F,
  0x03, 0xFE, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x30, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x1F, 0x8F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7E, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x3F, 0xE7, 0x00, 0xFE, 0x20, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x87, 0xE0,
  0x0F, 0xFC, 0x0F, 0x8F, 0x80, 0x7F, 0xFC, 0x1F, 0x1F, 0x01, 0xFF, 0xF8,
  0x3E, 0x3E, 0x07, 0xFF, 0xF0, 0x7C, 0xF8, 0x0F, 0xC3, 0xE0, 0x7D, 0xF0,
  0x3F, 0x07, 0xC0, 0xFB, 0xE0, 0x7C, 0x0F, 0x81, 0xF7, 0xC1, 0xF8, 0x1F,
  0x03, 0xFF, 0x83, 0xE0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFC, 0x0F, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0xF0, 0x3E, 0x07,
  0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0x81, 0xFF,
  0x81, 0xF0, 0x3F, 0x03, 0xFF, 0x03, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xC0,
  0xFC, 0x0F, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x07, 0xF0, 0x7D,
  0xF0, 0x3E, 0x0F, 0xE0, 0xFB, 0xF0, 0x7E, 0x1F, 0xC3, 0xE7, 0xE0, 0x7E,
  0x7B, 0xCF, 0xC7, 0xC0, 0xFF, 0xE7, 0xFF, 0x0F, 0x80, 0xFF, 0xCF, 0xFE,
  0x1F, 0x00, 0xFF, 0x0F, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0E,
  0x00, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xF0, 0x0F, 0xF9, 0xF8, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0x9F, 0x80, 0x1F, 0xEF, 0xC0,
  0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xF8,
  0x3F, 0xE0, 0x0C, 0x0F, 0xF0, 0x01, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x18, 0x1F, 0xFC, 0x3E,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0x01, 0xFF, 0x87, 0xE0, 0x0F, 0xF8, 0xFC,
  0x00, 0xFF, 0x1F, 0x80, 0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xE7, 0xE0, 0x07, 0xF8, 0xFC,
  0x01, 0xFF, 0x1F, 0x80, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0x81, 0xFF,
  0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x10, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x3F, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0xC0, 0x03, 0xF0, 0xFF, 0x80,
  0x0F, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF0, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x87, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFE, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xDF,
  0xC0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF8, 0x07,
  0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0x80, 0x00,
  0xFF, 0xFF, 0xDF, 0x80, 0x01, 0xF7, 0xFF, 0xBF, 0x00, 0x07, 0xEF, 0xFF,
  0x7E, 0x00, 0x0F, 0xDF, 0xFE, 0x7C, 0x00, 0x1F, 0x3F, 0xFC, 0xFC, 0x00,
  0x7E, 0x7F, 0xF9, 0xF8, 0x00, 0xFC, 0xFF, 0xF3, 0xF0, 0x01, 0xF9, 0xFF,
  0xE3, 0xE0, 0x03, 0xE3, 0xFF, 0xC7, 0xE0, 0x0F, 0xC7, 0xFF, 0x8F, 0xC0,
  0x1F, 0x8F, 0xFF, 0x0F, 0x80, 0x3E, 0x1F, 0xFE, 0x1F, 0x80, 0x7C, 0x3F,
  0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0xF8, 0x7E, 0x03, 0xF0, 0xFF, 0xF0, 0x7C,
  0x07, 0xC1, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0x07,
  0xFF, 0x83, 0xF0, 0x7C, 0x0F, 0xFF, 0x03, 0xF0, 0xF8, 0x1F, 0xFE, 0x07,
  0xE3, 0xF0, 0x3F, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0xF8, 0x0F, 0x8F, 0x80,
  0xFF, 0xF0, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0,
  0x7E, 0xF8, 0x07, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xF8, 0x01, 0xFF, 0xF7, 0xE0,
  0x07, 0xFF, 0xCF, 0xC0, 0x1F, 0xFF, 0x3F, 0x00, 0x7F, 0xFC, 0xFE, 0x01,
  0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x0F, 0xC0, 0x7F,
  0xFC, 0x3F, 0x01, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xC1, 0xF8, 0x1F, 0xFF,
  0x07, 0xF0, 0x7F, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x87, 0xFF, 0xC0,
  0x7E, 0x1F, 0xFF, 0x01, 0xF8, 0x7F, 0xFC, 0x07, 0xF1, 0xFF, 0xF0, 0x0F,
  0xC7, 0xFF, 0xC0, 0x3F, 0x9F, 0xFF, 0x00, 0x7E, 0x7F, 0xFC, 0x01, 0xFD,
  0xFF, 0xF0, 0x03, 0xF7, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0x00, 0x3F, 0xBF,
  0xFC, 0x00, 0x7E, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC,
  0x07, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFC,
  0x03, 0xFC, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x0F, 0xC0, 0xFF, 0xC3, 0xF0, 0x0F, 0xF8, 0xFC, 0x01, 0xFE, 0x3F, 0x00,
  0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x01,
  0xFE, 0x3F, 0x00, 0xFF, 0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0,
  0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07,
  0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x1F, 0xE0, 0x1E, 0x7F, 0x80, 0x08, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFB, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7D, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x7E, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3E, 0x7E, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x01,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x80,
  0x7F, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF0, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xF0,
  0x03, 0xF0, 0x7E, 0x0F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x81, 0xF8, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x7C, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x3E, 0x3F,
  0x80, 0x07, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF0, 0x0F, 0xCF,
  0xC0, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7C, 0x01, 0xF3,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x7D,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xDF,
  0x80, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F,
  0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xF9, 0xFF, 0x83, 0x80,
  0x7F, 0x04, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9,
  0xFF, 0xF7, 0xF3, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xDF, 0x80, 0x7F, 0xBF, 0x81,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFE, 0xFC, 0xFF, 0xF9, 0xF8, 0xFF, 0xE1,
  0xF0, 0xFF, 0x83, 0xE0, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x3E, 0x01, 0xFC, 0x7F, 0xC0, 0xFE, 0x7F, 0xF0,
  0x7E, 0x7F, 0xFC, 0x3F, 0x7F, 0xFF, 0x1F, 0xBF, 0xFF, 0xCF, 0xFC, 0x1F,
  0xE7, 0xFC, 0x07, 0xF3, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F,
  0xEF, 0xF8, 0x0F, 0xE7, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xF1, 0xFB, 0xFF,
  0xF8, 0xFC, 0xFF, 0xF8, 0x7E, 0x3F, 0xF8, 0x3E, 0x0F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xC0, 0xC3, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x13, 0xFC, 0x0E, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0xFE,
  0x0F, 0xFC, 0x7F, 0x0F, 0xFF, 0x3F, 0x8F, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xFB, 0xFC, 0x07, 0xFD, 0xFC, 0x03,
  0xFE, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF9, 0xFE, 0x0F,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x9F, 0x87, 0xFF,
  0x8F, 0xC0, 0xFF, 0x87, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFD,
  0xFF, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x01, 0x1F, 0xE0, 0x1E, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xF3,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xC3, 0xFF, 0xC7, 0xE1, 0xFF, 0xF3,
  0xF1, 0xFF, 0xFD, 0xF9, 0xFF, 0xFE, 0xFC, 0xFF, 0x07, 0xFE, 0xFF, 0x01,
  0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF7, 0xE0, 0x07, 0xFB, 0xF8, 0x07, 0xFD, 0xFE, 0x03,
  0xFE, 0x7F, 0x87, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0xC7, 0xFF,
  0xEF, 0xE1, 0xFF, 0xE7, 0xF0, 0x3F, 0xC3, 0xF8, 0x03, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF2, 0x00, 0x07, 0xF1,
  0xE0, 0x07, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xE0, 0x7F, 0x1F, 0xF0, 0xFC, 0xFF, 0xF1, 0xF9,
  0xFF, 0xF3, 0xF7, 0xFF, 0xF7, 0xEF, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xF8, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x7E,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFE, 0x00, 0xFD, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0x80,
  0xFF, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x7F, 0xC0, 0xFF, 0xC3, 0xF3, 0xFF, 0xC3, 0xFF, 0xC7, 0xE7, 0xFF, 0xCF,
  0xFF, 0xCF, 0xDF, 0xFF, 0x9F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF0, 0xFF, 0xF0, 0xFF, 0x7F, 0xC0, 0xFF, 0xC0, 0xFE, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x7F,
  0xC3, 0xF3, 0xFF, 0xC7, 0xE7, 0xFF, 0xCF, 0xDF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0xF0, 0x3F,
  0x1F, 0xFC, 0x1F, 0x9F, 0xFF, 0x0F, 0xDF, 0xFF, 0xC7, 0xEF, 0xFF, 0xF3,
  0xFF, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F,
  0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xF0, 0x07, 0xF7,
  0xF8, 0x03, 0xFB, 0xFE, 0x03, 0xF9, 0xFF, 0x83, 0xFC, 0xFD, 0xFF, 0xFC,
  0x7E, 0xFF, 0xFE, 0x3F, 0x3F, 0xFE, 0x1F, 0xCF, 0xFE, 0x0F, 0xE3, 0xFE,
  0x07, 0xF0, 0x38, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xC3, 0xFF, 0xC7,
  0xE3, 0xFF, 0xF3, 0xF1, 0xFF, 0xFD, 0xF9, 0xFF, 0xFE, 0xFC, 0xFF, 0x07,
  0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xF7, 0xE0, 0x07, 0xFB, 0xF8, 0x07,
  0xFD, 0xFE, 0x03, 0xFE, 0x7F, 0x87, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xDF, 0xC7, 0xFF, 0xEF, 0xE1, 0xFF, 0xE7, 0xF0, 0x3F, 0xC3, 0xF8, 0x03,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x7C, 0x1F, 0xFE, 0x1F, 0xDF, 0x9F, 0xEF, 0xCF, 0xF7,
  0xEF, 0xFB, 0xF7, 0xFD, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC0,
  0x77, 0xF0, 0x04, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xC0,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x82, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x03, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xEF, 0xE0, 0x7F, 0xDF, 0xE1, 0xFF, 0xBF, 0xFF, 0xFF, 0x3F,
  0xFF, 0x3E, 0x7F, 0xFE, 0x7C, 0x7F, 0xF8, 0xF8, 0x3F, 0xC1, 0xF0, 0x0E,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03,
  0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x7E, 0x01, 0xFF, 0x80, 0x7E,
  0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x7E, 0x01,
  0xFF, 0x80, 0x7E, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x3F, 0x03, 0xE7, 0x80,
  0xFC, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x3F,
  0x03, 0xE7, 0xC0, 0xFC, 0x3F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7,
  0xC1, 0xF8, 0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x1F, 0x87, 0xC3, 0xE1, 0xF8,
  0x1F, 0x87, 0xC3, 0xE1, 0xF8, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xC7,
  0xC3, 0xE3, 0xF0, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0x0F, 0xCF, 0x81, 0xF3,
  0xF0, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x07,
  0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x01,
  0xF7, 0xE0, 0x07, 0xFF, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F,
  0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x4F, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFA, 0x00, 0x1F, 0xFC, 0x80, 0x00, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Medium67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 49, 16, 4, -48 },
  { 50, 19, 17, 27, 4, -48 },
  { 91, 30, 48, 32, 1, -48 },
  { 271, 24, 55, 29, 3, -51 },
  { 436, 42, 50, 47, 2, -49 },
  { 699, 32, 50, 34, 2, -49 },
  { 899, 7, 17, 14, 4, -48 },
  { 914, 15, 59, 20, 3, -48 },
  { 1025, 15, 59, 20, 2, -48 },
  { 1136, 23, 24, 28, 2, -51 },
  { 1205, 25, 32, 29, 2, -40 },
  { 1305, 10, 17, 16, 2, -8 },
  { 1327, 15, 6, 19, 2, -21 },
  { 1339, 8, 10, 16, 4, -9 },
  { 1349, 24, 48, 26, 1, -48 },
  { 1493, 24, 50, 29, 3, -49 },
  { 1643, 17, 48, 29, 4, -48 },
  { 1745, 24, 49, 29, 2, -49 },
  { 1892, 24, 50, 29, 2, -49 },
  { 2042, 27, 48, 29, 1, -48 },
  { 2204, 24, 49, 29, 3, -48 },
  { 2351, 24, 49, 29, 3, -48 },
  { 2498, 25, 48, 29, 2, -48 },
  { 2648, 25, 50, 29, 2, -49 },
  { 2805, 24, 49, 29, 2, -48 },
  { 2952, 8, 37, 16, 4, -36 },
  { 2989, 10, 45, 16, 2, -36 },
  { 3046, 26, 30, 29, 2, -39 },
  { 3144, 25, 19, 29, 2, -33 },
  { 3204, 26, 30, 29, 2, -39 },
  { 3302, 20, 50, 22, 1, -49 },
  { 3427, 39, 54, 45, 3, -48 },
  { 3691, 32, 48, 32, 0, -48 },
  { 3883, 25, 48, 33, 5, -48 },
  { 4033, 26, 50, 31, 3, -49 },
  { 4196, 27, 48, 35, 5, -48 },
  { 4358, 20, 48, 28, 5, -48 },
  { 4478, 19, 48, 26, 5, -48 },
  { 4592, 30, 50, 37, 3, -49 },
  { 4780, 27, 48, 37, 5, -48 },
  { 4942, 15, 48, 20, 2, -48 },
  { 5032, 14, 61, 16, -3, -48 },
  { 5139, 27, 48, 31, 5, -48 },
  { 5301, 19, 48, 26, 5, -48 },
  { 5415, 39, 48, 49, 5, -48 },
  { 5649, 30, 48, 39, 5, -48 },
  { 5829, 32, 50, 38, 3, -49 },
  { 6029, 24, 48, 31, 5, -48 },
  { 6173, 32, 60, 38, 3, -49 },
  { 6413, 26, 48, 32, 5, -48 },
  { 6569, 23, 50, 28, 2, -49 },
  { 6713, 25, 48, 26, 1, -48 },
  { 6863, 27, 49, 36, 4, -48 },
  { 7029, 31, 48, 31, 0, -48 },
  { 7215, 49, 48, 49, 0, -48 },
  { 7509, 28, 48, 28, 0, -48 },
  { 7677, 28, 48, 28, 0, -48 },
  { 7845, 23, 48, 25, 1, -48 },
  { 7983, 14, 59, 21, 5, -48 },
  { 8087, 24, 48, 26, 1, -48 },
  { 8231, 14, 59, 21, 2, -48 },
  { 8335, 29, 27, 31, 1, -48 },
  { 8433, 29, 4, 29, 0, 6 },
  { 8448, 13, 10, 19, 3, -51 },
  { 8465, 23, 38, 29, 2, -37 },
  { 8575, 25, 52, 32, 4, -51 },
  { 8738, 20, 38, 24, 3, -37 },
  { 8833, 25, 52, 32, 3, -51 },
  { 8996, 23, 38, 29, 3, -37 },
  { 9106, 19, 51, 18, 1, -51 },
  { 9228, 25, 53, 32, 3, -37 },
  { 9394, 23, 51, 31, 4, -51 },
  { 9541, 7, 50, 15, 4, -50 },
  { 9585, 12, 66, 15, -1, -50 },
  { 9684, 24, 51, 28, 4, -51 },
  { 9837, 7, 51, 15, 4, -51 },
  { 9882, 39, 37, 47, 4, -37 },
  { 10063, 23, 37, 31, 4, -37 },
  { 10170, 25, 38, 31, 3, -37 },
  { 10289, 25, 53, 32, 4, -37 },
  { 10455, 25, 53, 32, 3, -37 },
  { 10621, 17, 37, 21, 4, -37 },
  { 10700, 19, 38, 23, 2, -37 },
  { 10791, 17, 45, 19, 1, -44 },
  { 10887, 23, 37, 31, 4, -36 },
  { 10994, 26, 36, 26, 0, -36 },
  { 11111, 40, 36, 42, 1, -36 },
  { 11291, 24, 36, 26, 1, -36 },
  { 11399, 26, 52, 26, 0, -36 },
  { 11568, 18, 36, 21, 2, -36 },
  { 11649, 19, 59, 24, 2, -48 },
  { 11790, 6, 67, 28, 11, -51 },
  { 11841, 19, 59, 24, 3, -48 },
  { 11982, 26, 9, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Medium67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Medium67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Medium67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUM67PT7B_H_
