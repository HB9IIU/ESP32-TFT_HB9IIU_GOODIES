#ifndef _ROBOTOMONO_MEDIUMITALIC7PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xC0, 0x37, 0x6F, 0xA0, 0x27, 0x56, 0x96, 0x40, 0xDE,
  0x27, 0x30, 0x66, 0x4B, 0xF0, 0xC0, 0x5A, 0xA9, 0x95, 0x5A, 0x5F, 0x00,
  0x2F, 0x44, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0xC0, 0x75, 0xF9, 0x60, 0x75,
  0x80, 0x69, 0x24, 0xE0, 0x71, 0x61, 0xE0, 0x36, 0x6F, 0x20, 0x74, 0x69,
  0x60, 0x24, 0xE9, 0x60, 0xE5, 0x48, 0x75, 0x69, 0x60, 0xD6, 0xAC, 0x42,
  0x42, 0x80, 0x16, 0xE0, 0x7F, 0x43, 0xE0, 0xE5, 0x48, 0x7B, 0xFF, 0xE0,
  0x22, 0x66, 0x90, 0x75, 0x69, 0xE0, 0x79, 0x89, 0x60, 0x65, 0x99, 0xE0,
  0x74, 0x68, 0xE0, 0x74, 0x78, 0x80, 0x75, 0xB9, 0x60, 0x55, 0x79, 0xA0,
  0x72, 0x24, 0xE0, 0x11, 0x11, 0xE0, 0x5B, 0x19, 0x49, 0x00, 0x49, 0x4E,
  0x57, 0xB9, 0x90, 0x55, 0xBB, 0xA0, 0x79, 0x99, 0x60, 0x75, 0x78, 0x80,
  0x79, 0x99, 0x61, 0x75, 0x7A, 0xB0, 0x74, 0x69, 0x60, 0xE9, 0x48, 0x55,
  0x99, 0x60, 0xB7, 0x68, 0xBB, 0x76, 0xA0, 0x56, 0x26, 0xB0, 0xB7, 0x48,
  0x72, 0x24, 0xF0, 0x5A, 0xA8, 0xA5, 0x40, 0x55, 0x58, 0x7C, 0xE0, 0x80,
  0x61, 0xEE, 0x46, 0x99, 0xE0, 0x69, 0x86, 0x17, 0x99, 0x60, 0x69, 0xE6,
  0x7E, 0x48, 0x79, 0x96, 0xE0, 0x46, 0x99, 0xA0, 0x2C, 0x9E, 0x2C, 0x92,
  0xA0, 0x45, 0xAE, 0xB0, 0x64, 0x9E, 0x5B, 0xDD, 0x69, 0x9A, 0x69, 0x96,
  0x69, 0x9E, 0x80, 0x79, 0x96, 0x20, 0xF2, 0x40, 0x65, 0x2E, 0x5E, 0x4C,
  0x55, 0x96, 0xB7, 0x40, 0xBB, 0xEA, 0x56, 0x6B, 0x95, 0x64, 0x48, 0x72,
  0x4E, 0x6B, 0x24, 0x80, 0x56, 0xA0, 0x55, 0xA0, 0xD2,
};

const GFXglyph RobotoMono_MediumItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 1, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 2, 8, 4, 1, -6 },
  { 22, 3, 3, 4, 1, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 3, 1, 4, 1, -3 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 2, 5, 4, 1, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 3, 5, 4, 1, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 3, 5, 4, 1, -5 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 5, 4, 1, -4 },
  { 62, 4, 3, 4, 0, -4 },
  { 64, 4, 2, 4, 0, -3 },
  { 65, 4, 3, 4, 0, -4 },
  { 67, 3, 5, 4, 1, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 5, 5, 4, 0, -5 },
  { 106, 3, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 6, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 3, 5, 4, 1, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 3, 5, 4, 1, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 3, 5, 4, 1, -5 },
  { 144, 4, 5, 4, 0, -5 },
  { 147, 2, 7, 4, 1, -6 },
  { 149, 2, 5, 4, 1, -5 },
  { 151, 2, 7, 4, 1, -6 },
  { 153, 2, 3, 4, 1, -5 },
  { 154, 3, 1, 4, 0, 0 },
  { 155, 1, 1, 4, 2, -5 },
  { 156, 4, 4, 4, 0, -4 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 4, 4, 4, 0, -4 },
  { 163, 4, 5, 4, 0, -5 },
  { 166, 4, 4, 4, 0, -4 },
  { 168, 3, 5, 4, 1, -5 },
  { 170, 4, 5, 4, 0, -4 },
  { 173, 4, 5, 4, 0, -5 },
  { 176, 3, 5, 4, 0, -5 },
  { 178, 3, 7, 4, 0, -5 },
  { 181, 4, 5, 4, 0, -5 },
  { 184, 3, 5, 4, 0, -5 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 4, 5, 4, 0, -4 },
  { 195, 4, 5, 4, 0, -4 },
  { 198, 3, 4, 4, 1, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 3, 5, 4, 1, -5 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 3, 4, 4, 1, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 4, 6, 4, 0, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 3, 6, 4, 1, -5 },
  { 220, 2, 6, 4, 1, -5 },
  { 222, 2, 6, 4, 1, -5 },
  { 224, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_MediumItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic7pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_MEDIUMITALIC7PT7B_H_
