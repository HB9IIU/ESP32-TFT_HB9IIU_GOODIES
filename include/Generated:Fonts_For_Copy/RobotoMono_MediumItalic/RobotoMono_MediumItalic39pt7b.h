#ifndef _ROBOTOMONO_MEDIUMITALIC39PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x3E, 0x0E, 0x00, 0x78, 0x77, 0x8F,
  0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0xF0, 0xEE, 0x1E, 0xE1, 0xC0, 0x00,
  0x1E, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x70, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x07, 0x0E, 0x00, 0x1C, 0x3C,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0xF0, 0xE0, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x83, 0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0xF8, 0x03, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x38, 0x70, 0x87,
  0x0E, 0x1C, 0xE1, 0xC7, 0xBC, 0x38, 0xE7, 0x8F, 0x38, 0x71, 0xCE, 0x0F,
  0xF9, 0xC0, 0xFE, 0x70, 0x0F, 0x9C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x73, 0xF8, 0x1C, 0xFF, 0x03,
  0xBC, 0xF0, 0xE7, 0x0E, 0x38, 0xE1, 0xCF, 0x1C, 0x38, 0xC3, 0x87, 0x00,
  0x71, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7C, 0x7C, 0x03, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0xF8, 0x01,
  0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x0F, 0x3E, 0xF8, 0x7B, 0xE3, 0xC7, 0x9E, 0x1F, 0x3D, 0xF0,
  0x7F, 0xEF, 0x83, 0xFE, 0x78, 0x0F, 0xF3, 0xE0, 0x7F, 0x1F, 0x01, 0xF0,
  0xFC, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x3F, 0xC7, 0xE0, 0x7B,
  0xDE, 0xE7, 0x3B, 0xDE, 0xE7, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x08, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x40, 0xE0, 0x4C, 0x1C, 0x33, 0xF3, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0E,
  0x70, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0x60,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0x9F, 0x3C, 0xF9,
  0xE1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7B, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0xC7, 0x80, 0x79, 0xF0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x1F, 0xBE, 0x0F, 0xF7, 0xC3,
  0xFE, 0xF9, 0xF7, 0xDE, 0x7C, 0xF3, 0xFE, 0x1E, 0x7F, 0x83, 0xCF, 0xC0,
  0x7B, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03,
  0xE3, 0xE0, 0xF8, 0x7E, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x18, 0x03, 0x80, 0xFC, 0x3F, 0xE7, 0xFF, 0x7F, 0xFB, 0xF7,
  0x9C, 0x3C, 0x81, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0x81, 0xF0,
  0xF0, 0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x83, 0xE1, 0xF0, 0x1F,
  0x1E, 0x01, 0xF1, 0xA0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0x7E, 0x3F, 0x07,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xBC, 0x00, 0x7B, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0xF0,
  0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1F, 0x03, 0xE0,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0xFC,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1C, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF0,
  0x07, 0xCF, 0x00, 0x78, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x7E, 0x3F, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xC7, 0xE7, 0xC0, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xF9, 0xF0,
  0x7C, 0x7E, 0x7F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x7C, 0x1F, 0x0F, 0xC7,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF8, 0x7E, 0x0F,
  0x8F, 0x80, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F,
  0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0x7E, 0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3E, 0x0F, 0x9F, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0x9E, 0x03, 0xE7, 0xC1,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFB, 0xC0, 0x7C, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0x03, 0xE1, 0xFC, 0x7F, 0x1F,
  0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x1F, 0x07, 0xE3, 0xF8, 0x7E, 0x1F, 0x00, 0x01, 0xC0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x78, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x01,
  0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC0, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x7C, 0x07, 0x80, 0x70, 0x3C,
  0x00, 0xE0, 0xE1, 0xE3, 0x87, 0x1F, 0xE6, 0x38, 0xFF, 0x98, 0xE3, 0x8C,
  0x67, 0x1C, 0x31, 0x9C, 0x71, 0xC6, 0x73, 0x87, 0x19, 0x8E, 0x18, 0x6E,
  0x38, 0x63, 0xB9, 0xC3, 0x8E, 0xE7, 0x0E, 0x33, 0x9C, 0x38, 0xCE, 0x71,
  0xC7, 0x38, 0xFF, 0xB8, 0xE3, 0xFF, 0xC3, 0x87, 0x1E, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x08, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E,
  0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xF0, 0x3C,
  0x07, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x78, 0x03, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00,
  0x1F, 0xF0, 0x00, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x87, 0x80, 0x7C, 0x7C, 0x01, 0xE3, 0xE0,
  0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x07, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0x81, 0xFC, 0x3C, 0x03,
  0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x3E, 0x00, 0xF3,
  0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x7C, 0xF8, 0x07, 0x87, 0x80, 0xF8, 0x7E, 0x3F, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C,
  0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xEF, 0x03, 0xFE, 0xF0, 0x3F, 0xEF, 0x07,
  0xFE, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xC7, 0xC0, 0x7C, 0x7F, 0x3F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x83,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78,
  0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0,
  0x1F, 0x07, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7F, 0x3F, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x7E,
  0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1E, 0x3F, 0x00,
  0x1E, 0x7E, 0x00, 0x1E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xBC, 0x00, 0x3F, 0x3E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xE0, 0xF0, 0x03, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7C,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0x78, 0x7B, 0xBD,
  0xE1, 0xEE, 0xE7, 0x8F, 0x3F, 0xBC, 0x3C, 0xFC, 0xF0, 0xF3, 0xF3, 0xC3,
  0xCF, 0xCF, 0x0F, 0x3E, 0x3C, 0x3C, 0xF9, 0xF1, 0xE3, 0xC7, 0x87, 0x87,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3F,
  0x01, 0xE0, 0xFE, 0x03, 0xC1, 0xFC, 0x07, 0x83, 0xF8, 0x1F, 0x07, 0xF8,
  0x3E, 0x0F, 0xF0, 0x7C, 0x1E, 0xE0, 0xF0, 0x7D, 0xE1, 0xE0, 0xFB, 0xC7,
  0xC1, 0xF7, 0x8F, 0x83, 0xE7, 0x1F, 0x07, 0x8F, 0x3C, 0x0F, 0x1E, 0x78,
  0x3E, 0x1C, 0xF0, 0x7C, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xE0, 0xFF, 0x83,
  0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x1F, 0x03, 0xF8, 0x3E, 0x07, 0xF0, 0x7C,
  0x07, 0xE0, 0xF0, 0x0F, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x83, 0xE1,
  0xF0, 0x3E, 0x3E, 0x01, 0xE3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1F,
  0x78, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00,
  0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF8, 0x0F, 0x87, 0x81, 0xF0, 0x7F,
  0x7F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x81, 0xF8, 0x3C,
  0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x01, 0xF8, 0x78, 0x1F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0x83, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF8, 0x0F, 0x87,
  0x81, 0xF0, 0x7F, 0x7F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x02,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xF0, 0x1F, 0x87, 0x80, 0x7C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x3F, 0x1F,
  0x0F, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xE0, 0xF0,
  0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0xC1, 0xE0,
  0x3E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xF1,
  0xE0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0xC0,
  0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x01, 0xF8, 0x3F, 0x9F, 0xC0,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C,
  0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E,
  0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0,
  0x3E, 0x0F, 0x83, 0xE0, 0x7E, 0x7F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8,
  0x3C, 0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00,
  0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x78, 0x7F, 0xC1, 0xE1, 0xEF, 0x07,
  0x87, 0xBC, 0x3E, 0x1E, 0xF0, 0xF8, 0xF3, 0xC3, 0xE3, 0xCF, 0x1F, 0x8F,
  0x3C, 0x7E, 0x3C, 0xF1, 0xF9, 0xE3, 0xCF, 0xE7, 0x8F, 0x3B, 0x9E, 0x3C,
  0xEE, 0xF8, 0xF7, 0xBB, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3F, 0xCF,
  0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x07, 0xC0,
  0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01,
  0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xE3, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x7E, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0xFC, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x3E, 0x07,
  0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEE, 0x03, 0x9E, 0x0F,
  0x3C, 0x3C, 0x78, 0x78, 0x71, 0xE0, 0xE3, 0xC1, 0xEF, 0x03, 0xFC, 0x03,
  0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x3C,
  0x3C, 0x1E, 0x0F, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF0, 0x3E, 0x3C, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xC1, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F,
  0x9E, 0x01, 0xF7, 0xC0, 0x3C, 0xF8, 0x0F, 0x8F, 0x87, 0xF1, 0xFF, 0xFE,
  0x1F, 0xFB, 0xC1, 0xFC, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x3E, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E,
  0x3E, 0x07, 0xCF, 0x80, 0x79, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xF3,
  0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0xE7, 0xF3, 0xFF, 0xFC, 0x7B, 0xFF, 0x0F,
  0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0x07, 0xCF, 0x80, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7B,
  0xE0, 0x3E, 0x78, 0x0F, 0x1F, 0x8F, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x01,
  0xF1, 0xE0, 0x3F, 0xEF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x78, 0x1F, 0x83, 0xF3, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xDE, 0x01, 0xFC, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF0, 0x7C, 0x7C, 0x07, 0x9F, 0x00, 0xF3,
  0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x10, 0x7C, 0x07, 0x0F,
  0xE3, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x1F, 0xF7, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xC7,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF9, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFE, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x08, 0x03, 0xE0, 0x70, 0x3F, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x1F, 0x01, 0xF7, 0xFC, 0x1E, 0xFF,
  0xC1, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0,
  0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x31, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF8,
  0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x3C, 0x1F, 0x81, 0xE1, 0xF8, 0x0F, 0x1F,
  0x80, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xF7, 0xC0, 0x3F, 0x3E, 0x01, 0xF0, 0xF8,
  0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x8F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x78, 0xF0, 0x7F, 0xF7,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3E, 0x3E, 0x7C, 0xF0, 0xF0, 0xF3,
  0xC3, 0xC7, 0xCF, 0x0F, 0x1E, 0x3C, 0x7C, 0x78, 0xF1, 0xE1, 0xE7, 0x87,
  0x87, 0x9E, 0x1E, 0x1E, 0x78, 0x78, 0xF9, 0xE1, 0xE3, 0xC7, 0x8F, 0x0F,
  0x1E, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F, 0x1F, 0x3C,
  0x3C, 0x78, 0xF1, 0xE1, 0xE0, 0x1E, 0x1F, 0x03, 0xCF, 0xF8, 0x7B, 0xFF,
  0x0F, 0xFF, 0xF1, 0xF8, 0x3E, 0x3E, 0x03, 0xCF, 0x80, 0x79, 0xF0, 0x0F,
  0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF0, 0x7C, 0x78, 0x0F, 0x9F, 0x00, 0xF3,
  0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x0F,
  0xC7, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x9F, 0x00,
  0xF7, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0, 0xF0, 0x1F,
  0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0,
  0x3E, 0x3E, 0x07, 0xC3, 0xF9, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7D,
  0xFE, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF1,
  0xE0, 0xFF, 0xBC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x7E, 0x7C, 0x07,
  0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0x78, 0x1F, 0x8F, 0xCF, 0xE1, 0xFF, 0xFC, 0x1F, 0xF7, 0x81, 0xFC, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x1E, 0x1F, 0xC7, 0x9F, 0xF1,
  0xEF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xEF, 0xE3, 0xE0, 0x7C, 0x78, 0x07, 0xCF, 0x00, 0xF9,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F,
  0x83, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1E, 0x01, 0xF3, 0xE0,
  0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C,
  0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x07, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8,
  0x78, 0x1F, 0x87, 0xE7, 0xF8, 0x7F, 0xFF, 0x03, 0xFE, 0xF0, 0x1F, 0xCF,
  0x00, 0xF0, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x7C, 0x78,
  0x07, 0x87, 0x80, 0xF8, 0x7C, 0x0F, 0x03, 0xC1, 0xF0, 0x3C, 0x1E, 0x03,
  0xC3, 0xE0, 0x3C, 0x3C, 0x01, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x7F, 0xC1, 0xC1, 0xEF,
  0x07, 0x07, 0xBC, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xC7, 0xC3, 0xCF, 0x1F,
  0x8E, 0x3C, 0x7E, 0x78, 0xF3, 0xB9, 0xE3, 0xCE, 0xE7, 0x0F, 0x33, 0xBC,
  0x3D, 0xCE, 0xF0, 0xF7, 0x3B, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F,
  0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x0F,
  0x80, 0x78, 0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x1E, 0x03,
  0xE0, 0x3E, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0x79, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xE7, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x03, 0xE0,
  0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xE0, 0x07, 0x83, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xCF, 0x80, 0x03, 0xDF, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x9F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x00, 0x1E, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0x00, 0x43, 0xFE, 0x03, 0xDF, 0xFE, 0x0E, 0x7C, 0xFC, 0x79, 0xC1,
  0xFF, 0xEF, 0x03, 0xFF, 0x04, 0x03, 0xF8, 0x00, 0x03, 0x80,
};

const GFXglyph RobotoMono_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 28, 23, 7, -28 },
  { 33, 12, 9, 23, 7, -29 },
  { 47, 23, 28, 23, 0, -28 },
  { 128, 20, 36, 23, 2, -32 },
  { 218, 19, 28, 23, 2, -28 },
  { 285, 21, 28, 23, 1, -28 },
  { 359, 5, 10, 23, 10, -29 },
  { 366, 13, 40, 23, 6, -31 },
  { 431, 13, 40, 23, 3, -31 },
  { 496, 19, 20, 23, 3, -28 },
  { 544, 19, 20, 23, 2, -23 },
  { 592, 7, 11, 23, 4, -4 },
  { 602, 15, 4, 23, 5, -14 },
  { 610, 6, 6, 23, 7, -6 },
  { 615, 20, 30, 23, 2, -28 },
  { 690, 19, 28, 23, 2, -28 },
  { 757, 13, 28, 23, 5, -28 },
  { 803, 20, 28, 23, 0, -28 },
  { 873, 20, 28, 23, 1, -28 },
  { 943, 21, 28, 23, 0, -28 },
  { 1017, 20, 28, 23, 2, -28 },
  { 1087, 18, 28, 23, 2, -28 },
  { 1150, 20, 28, 23, 3, -28 },
  { 1220, 19, 28, 23, 2, -28 },
  { 1287, 18, 28, 23, 3, -28 },
  { 1350, 10, 22, 23, 7, -22 },
  { 1378, 12, 29, 23, 5, -22 },
  { 1422, 18, 18, 23, 3, -21 },
  { 1463, 19, 12, 23, 2, -18 },
  { 1492, 18, 18, 23, 2, -21 },
  { 1533, 17, 28, 23, 5, -28 },
  { 1593, 22, 28, 23, 1, -28 },
  { 1670, 21, 28, 23, -1, -28 },
  { 1744, 21, 28, 23, 1, -28 },
  { 1818, 20, 28, 23, 2, -28 },
  { 1888, 21, 28, 23, 1, -28 },
  { 1962, 22, 28, 23, 1, -28 },
  { 2039, 22, 28, 23, 1, -28 },
  { 2116, 20, 28, 23, 2, -28 },
  { 2186, 23, 28, 23, 0, -28 },
  { 2267, 21, 28, 23, 1, -28 },
  { 2341, 22, 28, 23, 1, -28 },
  { 2418, 24, 28, 23, 1, -28 },
  { 2502, 18, 28, 23, 1, -28 },
  { 2565, 22, 28, 23, 1, -28 },
  { 2642, 23, 28, 23, 0, -28 },
  { 2723, 20, 28, 23, 2, -28 },
  { 2793, 22, 28, 23, 1, -28 },
  { 2870, 20, 33, 23, 2, -28 },
  { 2953, 21, 28, 23, 1, -28 },
  { 3027, 22, 28, 23, 1, -28 },
  { 3104, 22, 28, 23, 3, -28 },
  { 3181, 21, 28, 23, 2, -28 },
  { 3255, 21, 28, 23, 3, -28 },
  { 3329, 22, 28, 23, 3, -28 },
  { 3406, 26, 28, 23, -1, -28 },
  { 3497, 21, 28, 23, 4, -28 },
  { 3571, 23, 28, 23, 0, -28 },
  { 3652, 14, 38, 23, 5, -32 },
  { 3719, 10, 30, 23, 7, -28 },
  { 3757, 14, 38, 23, 5, -32 },
  { 3824, 15, 15, 23, 4, -28 },
  { 3853, 18, 4, 23, 0, 0 },
  { 3862, 8, 5, 23, 10, -28 },
  { 3867, 19, 21, 23, 1, -21 },
  { 3917, 19, 29, 23, 1, -29 },
  { 3986, 18, 21, 23, 2, -21 },
  { 4034, 21, 29, 23, 2, -29 },
  { 4111, 19, 21, 23, 2, -21 },
  { 4161, 21, 30, 23, 3, -30 },
  { 4240, 21, 29, 23, 1, -21 },
  { 4317, 20, 29, 23, 1, -29 },
  { 4390, 17, 29, 23, 2, -29 },
  { 4452, 18, 37, 23, 1, -29 },
  { 4536, 21, 29, 23, 1, -29 },
  { 4613, 17, 29, 23, 2, -29 },
  { 4675, 22, 21, 23, 0, -21 },
  { 4733, 19, 21, 23, 1, -21 },
  { 4783, 19, 21, 23, 2, -21 },
  { 4833, 20, 29, 23, 0, -21 },
  { 4906, 19, 29, 23, 2, -21 },
  { 4975, 18, 21, 23, 4, -21 },
  { 5023, 19, 21, 23, 2, -21 },
  { 5073, 18, 26, 23, 3, -26 },
  { 5132, 20, 21, 23, 2, -21 },
  { 5185, 20, 21, 23, 3, -21 },
  { 5238, 22, 21, 23, 2, -21 },
  { 5296, 23, 21, 23, 0, -21 },
  { 5357, 24, 29, 23, 0, -21 },
  { 5444, 20, 21, 23, 1, -21 },
  { 5497, 15, 37, 23, 6, -30 },
  { 5567, 8, 36, 23, 7, -28 },
  { 5603, 15, 37, 23, 4, -30 },
  { 5673, 22, 9, 23, 0, -16 },
};

const GFXfont RobotoMono_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic39pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_MEDIUMITALIC39PT7B_H_
