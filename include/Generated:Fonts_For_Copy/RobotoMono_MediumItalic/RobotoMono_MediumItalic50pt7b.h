#ifndef _ROBOTOMONO_MEDIUMITALIC50PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x41, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0xC7, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x78, 0x7C, 0x1C,
  0xF0, 0x3C, 0x3E, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x78, 0xF0, 0x78, 0xF0,
  0xF0, 0x78, 0xF0, 0xF8, 0xF9, 0xE0, 0x7F, 0xF3, 0xC0, 0x7F, 0xE3, 0xC0,
  0x1F, 0xC7, 0x80, 0x02, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF1, 0xF8,
  0x01, 0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xCF, 0xBF, 0x07, 0x9F, 0x0F,
  0x0F, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F,
  0x0C, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xEF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x81, 0xF1, 0xFF, 0xF0, 0x3E, 0x3F, 0x3F, 0x07, 0xCF,
  0xC7, 0xE1, 0xFB, 0xF8, 0x7E, 0x3E, 0x7E, 0x0F, 0xEF, 0xDF, 0x80, 0xFD,
  0xF3, 0xF0, 0x0F, 0xFE, 0x7E, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xF1, 0xF8,
  0x03, 0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFE, 0x03, 0xFF, 0x0F, 0xC0, 0x04,
  0x00, 0x00, 0x3C, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0xFB, 0xEF, 0x3C, 0xF0,
  0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x30,
  0x1E, 0x02, 0x3C, 0x1E, 0x0F, 0x7F, 0x1C, 0x7F, 0x7F, 0xDD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x07, 0xC7, 0x80, 0x0F,
  0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0C,
  0x01, 0xC0, 0x04, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x18, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0x3F, 0x00, 0x7F, 0x3E, 0x00, 0xFF, 0x3E, 0x01, 0xFF, 0x7E, 0x07, 0xFF,
  0x7E, 0x0F, 0xFF, 0x7E, 0x3F, 0xBE, 0x7E, 0x7E, 0x3E, 0x7D, 0xFC, 0x7E,
  0x7F, 0xF0, 0x7E, 0xFF, 0xE0, 0x7E, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0x7C,
  0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3F, 0x01, 0xFF, 0x07,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0x7E, 0x78, 0x7E, 0xC0,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x7E,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x40, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80,
  0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xE1, 0xF0,
  0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC1, 0xF8, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03,
  0xF0, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0x81, 0xFE,
  0x3F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x20, 0x03, 0xE7, 0xFC, 0x0F,
  0xDF, 0xFC, 0x1F, 0x7F, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xC3, 0xF9, 0xFE,
  0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x8F, 0xC0, 0xFE,
  0x1F, 0xE3, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xF8, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0xFC, 0xFC, 0x03, 0xF9, 0xF8,
  0x0F, 0xF3, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF,
  0x7E, 0x03, 0xFC, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0x01, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0x7E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1F, 0x87, 0xF0,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9,
  0xFE, 0x0F, 0xE7, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xE0, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0xE0, 0x78, 0x3F, 0x0E, 0x0F, 0x0F, 0xF8, 0xE0, 0xE1, 0xFF, 0xCF,
  0x1E, 0x3F, 0x38, 0xF1, 0xC3, 0xC3, 0x8F, 0x3C, 0x78, 0x38, 0xF3, 0xC7,
  0x87, 0x8F, 0x38, 0xF0, 0x78, 0xF7, 0x8F, 0x07, 0x0E, 0x78, 0xE0, 0x70,
  0xE7, 0x0E, 0x0F, 0x0E, 0x71, 0xE0, 0xF0, 0xEF, 0x1E, 0x0E, 0x0E, 0xF1,
  0xE0, 0xE1, 0xCF, 0x1E, 0x1E, 0x1C, 0xF1, 0xE1, 0xE3, 0x8F, 0x1E, 0x7E,
  0x38, 0xF0, 0xFF, 0xFF, 0x0F, 0x0F, 0xEF, 0xF0, 0x70, 0x7C, 0x7C, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x80, 0x01, 0xF8, 0x78, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF9, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7E, 0x03, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xC1, 0xFF,
  0xDF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x1F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC1,
  0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0x01,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F,
  0xE0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC7, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0xF9, 0xF0, 0x1F, 0xFE, 0xFC, 0x07,
  0xFF, 0xBF, 0x01, 0xFF, 0xEF, 0xC0, 0x7F, 0xFB, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC3, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x03,
  0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x7F,
  0x00, 0x0F, 0x81, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xE7, 0xF0, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0xFC, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7D, 0xE3, 0xFF, 0x03, 0xEF,
  0x1F, 0xF8, 0x1F, 0x79, 0xF7, 0xC0, 0xFB, 0xCF, 0xBE, 0x07, 0xDE, 0xF9,
  0xF0, 0x7E, 0xF7, 0xDF, 0x83, 0xE7, 0xBC, 0xF8, 0x1F, 0x3F, 0xE7, 0xC0,
  0xF8, 0xFE, 0x3E, 0x07, 0xC7, 0xF1, 0xF0, 0x3E, 0x3F, 0x1F, 0x83, 0xF1,
  0xF8, 0xFC, 0x1F, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xC3, 0xC1,
  0xF0, 0x3E, 0x1E, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07,
  0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF8, 0x03, 0xE0, 0xFF, 0x80,
  0x7E, 0x0F, 0xFC, 0x07, 0xE0, 0xFF, 0xC0, 0x7E, 0x0F, 0xFC, 0x07, 0xE0,
  0xFF, 0xE0, 0x7E, 0x0F, 0xBE, 0x07, 0xC1, 0xFB, 0xE0, 0xFC, 0x1F, 0x9E,
  0x0F, 0xC1, 0xF9, 0xF0, 0xFC, 0x1F, 0x9F, 0x0F, 0xC1, 0xF9, 0xF0, 0xF8,
  0x1F, 0x0F, 0x9F, 0x83, 0xF0, 0xF9, 0xF8, 0x3F, 0x0F, 0x9F, 0x83, 0xF0,
  0x79, 0xF8, 0x3F, 0x07, 0xDF, 0x83, 0xF0, 0x7D, 0xF0, 0x3E, 0x07, 0xFF,
  0x07, 0xE0, 0x3F, 0xF0, 0x7E, 0x03, 0xFF, 0x07, 0xE0, 0x3F, 0xF0, 0x7E,
  0x01, 0xFF, 0x07, 0xC0, 0x1F, 0xE0, 0x7C, 0x01, 0xFE, 0x0F, 0xC0, 0x1F,
  0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFE,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x3F, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3E, 0x01,
  0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0xC0, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07,
  0xF0, 0x1F, 0x80, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xFE,
  0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0x81, 0xFB,
  0xF0, 0x7C, 0x0F, 0x9F, 0x83, 0xE0, 0x7C, 0xF8, 0x1F, 0x07, 0xE7, 0xC1,
  0xF8, 0x3F, 0x3E, 0x0F, 0xC1, 0xF1, 0xF0, 0x7E, 0x0F, 0x8F, 0x87, 0xF0,
  0xFC, 0x7C, 0x3F, 0x87, 0xC3, 0xE1, 0xFC, 0x3E, 0x1F, 0x0F, 0xE1, 0xF0,
  0xF8, 0xFF, 0x1F, 0x87, 0xC7, 0xF8, 0xF8, 0x3E, 0x3F, 0xC7, 0xC1, 0xF3,
  0xFE, 0x3E, 0x0F, 0x9E, 0xF3, 0xE0, 0x7C, 0xF7, 0x9F, 0x03, 0xEF, 0xBC,
  0xF8, 0x1F, 0x79, 0xEF, 0xC0, 0xFB, 0xCF, 0x7C, 0x07, 0xFE, 0x7B, 0xE0,
  0x3F, 0xE3, 0xDF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F,
  0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFE,
  0x7C, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03,
  0xE3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03,
  0xE7, 0xE0, 0x1E, 0xFC, 0x01, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0x83,
  0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0x80, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xFD, 0xF8,
  0x0F, 0xF0, 0xF8, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0x07,
  0xF0, 0x1F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xF0, 0x03,
  0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x7F, 0x80,
  0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xBF, 0xFE, 0x0F, 0xCF,
  0xFE, 0x07, 0xE3, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x3F, 0x8F, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F,
  0xC3, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0xF9,
  0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFF, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF9, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0x80, 0x0F, 0xF1,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0x9F, 0x80, 0x07, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0x01, 0xF8,
  0x03, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x20, 0x1F, 0xFC, 0xF8, 0x07, 0xFF, 0xDF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF,
  0x80, 0x0F, 0xF1, 0xF0, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x40,
  0x03, 0xF0, 0x0C, 0x00, 0x7E, 0x03, 0xC0, 0x3F, 0x80, 0xFE, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7F, 0xC0, 0x7E, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xC7, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F,
  0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x02, 0x07, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x07, 0xC0, 0x1F, 0xE0, 0xFC,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x00, 0xF8, 0x3F, 0x80, 0x0F, 0x87, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x1F,
  0xBF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x3E, 0xFE, 0x7F, 0x01,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xE3,
  0xF8, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x87, 0xE1,
  0xF8, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x3E, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE3, 0xFE,
  0x03, 0xF7, 0xFF, 0x81, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x81,
  0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0,
  0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7F, 0x01,
  0xFC, 0x3F, 0x87, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xFC, 0x3F,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0x00, 0xFC,
  0x7F, 0xC0, 0x1F, 0x81, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xDF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF0, 0x0F, 0xF3, 0xF0, 0x00, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x41, 0xFC, 0x1F, 0x0F, 0xFC, 0x3E, 0x7F, 0xF8,
  0x7D, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFE, 0x01, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x8E, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x1F,
  0x80, 0x1F, 0x8F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80,
  0x3F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFB, 0xF0, 0x3F, 0xF9, 0xF0, 0x07, 0xF8, 0xF8, 0x00, 0x60, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x0F,
  0xC7, 0xC0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x7C, 0x03,
  0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x1E,
  0x03, 0xFF, 0x03, 0xC0, 0xFF, 0xE0, 0xF8, 0x1F, 0x7C, 0x1F, 0x03, 0xEF,
  0x83, 0xF0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8,
  0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0x1F, 0xE3, 0xE3, 0xE7, 0xBC, 0xF8, 0x7C,
  0xF7, 0x9F, 0x0F, 0x9C, 0xF3, 0xE1, 0xF7, 0x9E, 0x78, 0x3E, 0xF3, 0xDF,
  0x07, 0xDC, 0x7B, 0xC0, 0xFF, 0x8F, 0x78, 0x1E, 0xE1, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0C, 0x1F, 0xFC,
  0x00, 0xF3, 0xFF, 0xF0, 0x1F, 0x3F, 0xFF, 0x83, 0xE7, 0xE3, 0xFE, 0x7E,
  0x78, 0x0F, 0xFF, 0xC7, 0x80, 0x7F, 0xFC, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x18, 0x00,
};

const GFXglyph RobotoMono_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 12, 36, 29, 9, -36 },
  { 55, 16, 13, 29, 9, -38 },
  { 81, 30, 36, 29, 0, -36 },
  { 216, 26, 46, 29, 2, -41 },
  { 366, 24, 37, 29, 3, -36 },
  { 477, 27, 37, 29, 1, -36 },
  { 602, 6, 13, 29, 13, -38 },
  { 612, 17, 51, 29, 8, -40 },
  { 721, 17, 51, 29, 4, -40 },
  { 830, 24, 25, 29, 4, -36 },
  { 905, 25, 25, 29, 2, -29 },
  { 984, 10, 15, 29, 5, -6 },
  { 1003, 20, 5, 29, 6, -18 },
  { 1016, 8, 9, 29, 9, -8 },
  { 1025, 26, 39, 29, 2, -36 },
  { 1152, 24, 37, 29, 3, -36 },
  { 1263, 16, 36, 29, 6, -36 },
  { 1335, 26, 36, 29, 0, -36 },
  { 1452, 26, 37, 29, 1, -36 },
  { 1573, 25, 36, 29, 1, -36 },
  { 1686, 26, 37, 29, 3, -36 },
  { 1807, 23, 37, 29, 2, -36 },
  { 1914, 25, 36, 29, 4, -36 },
  { 2027, 25, 37, 29, 2, -36 },
  { 2143, 23, 36, 29, 4, -36 },
  { 2247, 11, 30, 29, 10, -29 },
  { 2289, 15, 38, 29, 7, -29 },
  { 2361, 23, 23, 29, 4, -27 },
  { 2428, 24, 15, 29, 3, -23 },
  { 2473, 24, 23, 29, 2, -27 },
  { 2542, 22, 36, 29, 6, -36 },
  { 2641, 28, 35, 29, 1, -35 },
  { 2764, 27, 36, 29, -1, -36 },
  { 2886, 28, 36, 29, 1, -36 },
  { 3012, 27, 37, 29, 2, -36 },
  { 3137, 27, 36, 29, 1, -36 },
  { 3259, 29, 36, 29, 1, -36 },
  { 3390, 29, 36, 29, 1, -36 },
  { 3521, 26, 37, 29, 2, -36 },
  { 3642, 28, 36, 29, 1, -36 },
  { 3768, 26, 36, 29, 2, -36 },
  { 3885, 27, 37, 29, 2, -36 },
  { 4010, 31, 36, 29, 1, -36 },
  { 4150, 24, 36, 29, 1, -36 },
  { 4258, 29, 36, 29, 1, -36 },
  { 4389, 28, 36, 29, 1, -36 },
  { 4515, 26, 37, 29, 2, -36 },
  { 4636, 28, 36, 29, 1, -36 },
  { 4762, 26, 42, 29, 2, -36 },
  { 4899, 28, 36, 29, 1, -36 },
  { 5025, 27, 37, 29, 2, -36 },
  { 5150, 28, 36, 29, 4, -36 },
  { 5276, 28, 37, 29, 2, -36 },
  { 5406, 27, 36, 29, 4, -36 },
  { 5528, 29, 36, 29, 3, -36 },
  { 5659, 33, 36, 29, -1, -36 },
  { 5808, 27, 36, 29, 5, -36 },
  { 5930, 29, 36, 29, 0, -36 },
  { 6061, 18, 49, 29, 6, -41 },
  { 6172, 12, 39, 29, 9, -36 },
  { 6231, 18, 49, 29, 6, -41 },
  { 6342, 20, 19, 29, 5, -36 },
  { 6390, 23, 5, 29, 0, 0 },
  { 6405, 10, 7, 29, 13, -36 },
  { 6414, 24, 28, 29, 2, -27 },
  { 6498, 25, 39, 29, 1, -38 },
  { 6620, 23, 28, 29, 3, -27 },
  { 6701, 27, 39, 29, 2, -38 },
  { 6833, 25, 28, 29, 2, -27 },
  { 6921, 27, 39, 29, 4, -39 },
  { 7053, 27, 37, 29, 1, -27 },
  { 7178, 25, 38, 29, 1, -38 },
  { 7297, 22, 37, 29, 2, -37 },
  { 7399, 23, 48, 29, 1, -37 },
  { 7537, 28, 38, 29, 1, -38 },
  { 7670, 23, 38, 29, 2, -38 },
  { 7780, 29, 27, 29, -1, -27 },
  { 7878, 25, 27, 29, 1, -27 },
  { 7963, 24, 28, 29, 2, -27 },
  { 8047, 27, 37, 29, -1, -27 },
  { 8172, 24, 37, 29, 3, -27 },
  { 8283, 23, 27, 29, 5, -27 },
  { 8361, 24, 28, 29, 2, -27 },
  { 8445, 23, 34, 29, 4, -33 },
  { 8543, 25, 27, 29, 3, -26 },
  { 8628, 25, 26, 29, 4, -26 },
  { 8710, 27, 26, 29, 3, -26 },
  { 8798, 29, 26, 29, 0, -26 },
  { 8893, 31, 37, 29, 0, -26 },
  { 9037, 27, 26, 29, 1, -26 },
  { 9125, 20, 48, 29, 7, -39 },
  { 9245, 11, 46, 29, 9, -36 },
  { 9309, 19, 48, 29, 5, -39 },
  { 9423, 28, 11, 29, 0, -20 },
};

const GFXfont RobotoMono_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic50pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_MEDIUMITALIC50PT7B_H_
