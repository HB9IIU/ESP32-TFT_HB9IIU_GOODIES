#ifndef _ROBOTOMONO_MEDIUMITALIC57PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7E,
  0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7,
  0x81, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0x7F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC1,
  0xF0, 0x10, 0x7C, 0x1F, 0x03, 0x87, 0x81, 0xF0, 0x7C, 0x78, 0x1F, 0x07,
  0x87, 0x81, 0xF0, 0xF8, 0x78, 0x1F, 0x1F, 0x07, 0x81, 0xE1, 0xE0, 0x7C,
  0x3E, 0x3C, 0x07, 0xE7, 0xE7, 0xC0, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0x8F,
  0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x38, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x07, 0x8F, 0xFC,
  0x00, 0xF9, 0xFF, 0xE0, 0x1F, 0x3F, 0xFE, 0x01, 0xE3, 0xE3, 0xE0, 0x3C,
  0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x78, 0x1F, 0x0F, 0x07, 0x81,
  0xF1, 0xF0, 0xF8, 0x1F, 0x0E, 0x0F, 0x81, 0xE0, 0x20, 0xF8, 0x1E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0x1F, 0xEF, 0xE0, 0x7E, 0x7F, 0x8F, 0xE0,
  0xF8, 0xFE, 0x0F, 0xC3, 0xF3, 0xF8, 0x1F, 0xC7, 0xE7, 0xF0, 0x1F, 0xDF,
  0x8F, 0xC0, 0x3F, 0xFF, 0x3F, 0x80, 0x3F, 0xFC, 0x7F, 0x00, 0x7F, 0xF8,
  0xFE, 0x00, 0x7F, 0xE1, 0xFC, 0x00, 0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0x83, 0xF8, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x7D, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x79, 0xF3,
  0xE7, 0xCF, 0x9E, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x0F, 0x80, 0x47,
  0x81, 0xE0, 0x39, 0xFC, 0x3C, 0x3F, 0xBF, 0xE7, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x0F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xC0,
  0x02, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x03, 0x80, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C,
  0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x04, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF3, 0xF8, 0x03, 0xFF, 0x3F,
  0x80, 0x7F, 0xF3, 0xF0, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xE3, 0xF0, 0x7F,
  0x7E, 0x3F, 0x1F, 0xC7, 0xE7, 0xF3, 0xF8, 0xFE, 0x7F, 0xFE, 0x0F, 0xE7,
  0xFF, 0xC0, 0xFE, 0x7F, 0xF8, 0x0F, 0xC7, 0xFE, 0x00, 0xFC, 0x7F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x38, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xF3, 0xF3, 0xF0, 0x7E, 0x70, 0x1F, 0xC8, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x03, 0xF7, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x1E, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x7F, 0xE0, 0x3F, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0x9F,
  0xE0, 0x0F, 0xEF, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xF0, 0xFE, 0x07, 0xF8,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0x83, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0x8F, 0xF0, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xF3, 0xF8, 0x0F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0x9F, 0x80, 0x1E,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0x81, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03,
  0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F,
  0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE1, 0xFF, 0x9F, 0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x7C, 0x1E, 0x07, 0xC1, 0xFF, 0x0E, 0x0F,
  0x87, 0xFF, 0x8F, 0x0F, 0x0F, 0xFF, 0x8F, 0x1F, 0x0F, 0x87, 0x8F, 0x1E,
  0x1F, 0x07, 0x0F, 0x1E, 0x1E, 0x0F, 0x0F, 0x3C, 0x3E, 0x0F, 0x0F, 0x3C,
  0x3C, 0x0F, 0x0F, 0x3C, 0x7C, 0x0E, 0x0E, 0x78, 0x78, 0x1E, 0x0E, 0x78,
  0x78, 0x1E, 0x0E, 0x78, 0x78, 0x1E, 0x1E, 0x78, 0xF8, 0x1C, 0x1E, 0x78,
  0xF8, 0x3C, 0x1C, 0x78, 0xF0, 0x3C, 0x1C, 0xF8, 0xF0, 0x3C, 0x3C, 0xF0,
  0xF8, 0x7C, 0x38, 0xF0, 0xF8, 0xFC, 0x78, 0xF8, 0x7F, 0xFC, 0xF0, 0x78,
  0x7F, 0xFF, 0xF0, 0x78, 0x7F, 0xBF, 0xE0, 0x78, 0x3F, 0x1F, 0x80, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFE, 0x03,
  0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFC, 0x07,
  0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x81, 0xFC, 0x03,
  0xFE, 0x03, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0xE7, 0xE0, 0x1F,
  0xFF, 0x9F, 0x80, 0x7F, 0xFE, 0x7E, 0x01, 0xFF, 0xF1, 0xF8, 0x07, 0xFF,
  0xCF, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0x80,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x07,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x07,
  0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFC, 0x00,
  0x01, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xEF,
  0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF1, 0xF7, 0xE0, 0x3E, 0xF8, 0xFB,
  0xF0, 0x3F, 0x3C, 0xF9, 0xF8, 0x1F, 0x9E, 0x7C, 0xFC, 0x0F, 0xCF, 0xFC,
  0xFC, 0x07, 0xE7, 0xFE, 0x7E, 0x03, 0xF3, 0xFF, 0x3F, 0x03, 0xF1, 0xFF,
  0x1F, 0x81, 0xF8, 0xFF, 0x8F, 0xC0, 0xFC, 0x7F, 0x8F, 0xE0, 0x7E, 0x1F,
  0xC7, 0xE0, 0x3F, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE1, 0xF8, 0x1F, 0xC3,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xE0, 0xF0, 0x7E, 0x03, 0xF0,
  0x78, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xFC,
  0x00, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0x01, 0xFF,
  0xC0, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xC0, 0x7F,
  0xFC, 0x07, 0xE0, 0x3F, 0xBE, 0x03, 0xF0, 0x1F, 0xDF, 0x03, 0xF8, 0x0F,
  0xEF, 0xC1, 0xFC, 0x07, 0xE7, 0xE0, 0xFE, 0x03, 0xF1, 0xF0, 0x7E, 0x03,
  0xF8, 0xFC, 0x3F, 0x01, 0xFC, 0x7E, 0x3F, 0x80, 0xFE, 0x1F, 0x1F, 0xC0,
  0x7E, 0x0F, 0x8F, 0xE0, 0x3F, 0x07, 0xE7, 0xF0, 0x1F, 0x83, 0xF3, 0xF0,
  0x1F, 0xC0, 0xF9, 0xF8, 0x0F, 0xE0, 0x7D, 0xFC, 0x07, 0xF0, 0x3F, 0xFE,
  0x03, 0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x81, 0xFC, 0x03, 0xFF,
  0x80, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x3F,
  0xF0, 0x1F, 0x80, 0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x03,
  0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0xFE, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F,
  0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xFF,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x63,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x3F, 0x7E, 0x03, 0xE0, 0x3F, 0x7E, 0x07, 0xE0, 0x7F, 0x7E, 0x07, 0xE0,
  0x7E, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xE0, 0x7E, 0x7E, 0x0F, 0xE0,
  0xFC, 0x7E, 0x0F, 0xE0, 0xFC, 0x7E, 0x1F, 0xE0, 0xFC, 0x7E, 0x1F, 0xE0,
  0xFC, 0x7C, 0x1F, 0xE1, 0xF8, 0x7C, 0x3F, 0xE1, 0xF8, 0x7C, 0x3F, 0xE1,
  0xF8, 0x7C, 0x3F, 0xE3, 0xF0, 0x7C, 0x3F, 0xE3, 0xF0, 0x7C, 0x7F, 0xE3,
  0xF0, 0x7C, 0x7F, 0xE3, 0xF0, 0xFC, 0x7B, 0xE7, 0xE0, 0xFC, 0xFB, 0xE7,
  0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xF3, 0xE7, 0xC0, 0xFD, 0xF3, 0xEF,
  0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFF, 0xE3, 0xEF,
  0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF,
  0x3F, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x7F,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0,
  0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C,
  0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF0, 0x01,
  0xF0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xCF,
  0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03,
  0xFC, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFB, 0xF0, 0x3F, 0xFE, 0x7F, 0x01, 0xFF, 0x0F,
  0xE0, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x07, 0x80, 0x03, 0xF9, 0xFF, 0x80, 0x1F, 0xDF, 0xFE, 0x00, 0xFD,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0xE0,
  0x3F, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x03, 0xF0, 0x03, 0xFF, 0x1F,
  0xC0, 0x1F, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0x7F, 0xC7,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x7E, 0x3F, 0xC0, 0x0F, 0xC7,
  0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x60, 0x7F, 0x80, 0x1E, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFB, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xE3, 0xF0, 0x07, 0xFF,
  0xCF, 0xC0, 0x3F, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x0E,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x07,
  0xF0, 0x0E, 0x00, 0x3F, 0xC0, 0x7C, 0x01, 0xFE, 0x03, 0xFF, 0x3F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x03, 0xF8, 0xFF, 0xC0, 0x1F,
  0x8F, 0xFF, 0x00, 0xFC, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x60, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x07, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0xF0,
  0x07, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xC7, 0xF8, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x3F, 0xE3, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0xC0,
  0x7E, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x30, 0x03, 0xF3, 0xF8, 0xFF,
  0x01, 0xFB, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x87,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0x0F, 0xFC, 0x01, 0xF8, 0xFF, 0xF0, 0x0F,
  0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xF1, 0xFF, 0x80, 0x07, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFB, 0xFF,
  0xF8, 0x03, 0xF3, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0x00, 0x1F, 0xC0, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xFE, 0x3F, 0x01, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFC, 0x01, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xF7, 0xE0, 0x07, 0xFC, 0x7E, 0x00, 0x06, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFE, 0x1F, 0xFC, 0x1F, 0x8F,
  0xFF, 0x83, 0xF3, 0xFF, 0xE0, 0x7E, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x04, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0x87, 0xF8, 0x07, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0x9F, 0xE0, 0x0F, 0xF1, 0xFF, 0x9F, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x18, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF,
  0xC0, 0x3F, 0xFE, 0x7E, 0x01, 0xFF, 0xE3, 0xF0, 0x03, 0xFE, 0x3F, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x9F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80,
  0xFF, 0xF0, 0x1F, 0x01, 0xF7, 0xE0, 0x7E, 0x07, 0xEF, 0xC0, 0xFC, 0x0F,
  0xDF, 0x83, 0xF8, 0x1F, 0x3F, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0xFC,
  0xFC, 0x3F, 0xC1, 0xF1, 0xF8, 0x7F, 0x87, 0xE3, 0xF0, 0xFF, 0x0F, 0xC3,
  0xE3, 0xDE, 0x1F, 0x07, 0xC7, 0xBC, 0x7E, 0x0F, 0x9F, 0x78, 0xFC, 0x1F,
  0x3C, 0xF1, 0xF0, 0x3E, 0x79, 0xE7, 0xE0, 0x7D, 0xF3, 0xCF, 0x80, 0xFB,
  0xC7, 0x9F, 0x01, 0xF7, 0x8F, 0x3E, 0x03, 0xFE, 0x0E, 0xF8, 0x07, 0xFC,
  0x1D, 0xF0, 0x0F, 0xF8, 0x3B, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x07,
  0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x04, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x1F, 0x3F, 0xFF, 0xC0,
  0x3E, 0x3F, 0xFF, 0xE0, 0x7E, 0x7E, 0x0F, 0xFD, 0xFE, 0x7C, 0x07, 0xFF,
  0xFC, 0x7C, 0x01, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_MediumItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 14, 41, 33, 10, -41 },
  { 73, 18, 14, 33, 10, -43 },
  { 105, 34, 41, 33, 0, -41 },
  { 280, 29, 53, 33, 3, -47 },
  { 473, 28, 42, 33, 3, -41 },
  { 620, 31, 42, 33, 1, -41 },
  { 783, 7, 15, 33, 15, -43 },
  { 797, 19, 58, 33, 9, -45 },
  { 935, 19, 58, 33, 5, -45 },
  { 1073, 27, 29, 33, 5, -41 },
  { 1171, 28, 30, 33, 3, -34 },
  { 1276, 12, 17, 33, 5, -6 },
  { 1302, 22, 6, 33, 7, -21 },
  { 1319, 9, 10, 33, 10, -9 },
  { 1331, 29, 44, 33, 3, -41 },
  { 1491, 28, 42, 33, 3, -41 },
  { 1638, 19, 41, 33, 7, -41 },
  { 1736, 30, 41, 33, 0, -41 },
  { 1890, 30, 42, 33, 1, -41 },
  { 2048, 29, 41, 33, 1, -41 },
  { 2197, 30, 42, 33, 3, -41 },
  { 2355, 26, 42, 33, 3, -41 },
  { 2492, 29, 41, 33, 4, -41 },
  { 2641, 29, 42, 33, 2, -41 },
  { 2794, 25, 41, 33, 5, -41 },
  { 2923, 13, 34, 33, 11, -33 },
  { 2979, 17, 44, 33, 8, -33 },
  { 3073, 26, 26, 33, 4, -31 },
  { 3158, 28, 17, 33, 3, -26 },
  { 3218, 27, 27, 33, 2, -31 },
  { 3310, 25, 41, 33, 7, -41 },
  { 3439, 32, 40, 33, 1, -40 },
  { 3599, 32, 41, 33, -2, -41 },
  { 3763, 32, 41, 33, 1, -41 },
  { 3927, 31, 42, 33, 2, -41 },
  { 4090, 31, 41, 33, 1, -41 },
  { 4249, 33, 41, 33, 1, -41 },
  { 4419, 32, 41, 33, 2, -41 },
  { 4583, 30, 42, 33, 2, -41 },
  { 4741, 33, 41, 33, 1, -41 },
  { 4911, 30, 41, 33, 2, -41 },
  { 5065, 31, 42, 33, 2, -41 },
  { 5228, 36, 41, 33, 1, -41 },
  { 5413, 26, 41, 33, 2, -41 },
  { 5547, 33, 41, 33, 1, -41 },
  { 5717, 33, 41, 33, 1, -41 },
  { 5887, 30, 42, 33, 2, -41 },
  { 6045, 31, 41, 33, 2, -41 },
  { 6204, 30, 48, 33, 2, -41 },
  { 6384, 32, 41, 33, 1, -41 },
  { 6548, 31, 42, 33, 2, -41 },
  { 6711, 32, 41, 33, 4, -41 },
  { 6875, 31, 42, 33, 3, -41 },
  { 7038, 31, 41, 33, 5, -41 },
  { 7197, 32, 41, 33, 4, -41 },
  { 7361, 37, 41, 33, -1, -41 },
  { 7551, 31, 41, 33, 5, -41 },
  { 7710, 33, 41, 33, 0, -41 },
  { 7880, 20, 56, 33, 7, -47 },
  { 8020, 13, 44, 33, 11, -41 },
  { 8092, 20, 56, 33, 7, -47 },
  { 8232, 22, 22, 33, 6, -41 },
  { 8293, 26, 5, 33, 0, 0 },
  { 8310, 11, 7, 33, 15, -41 },
  { 8320, 27, 32, 33, 2, -31 },
  { 8428, 29, 44, 33, 1, -43 },
  { 8588, 27, 32, 33, 3, -31 },
  { 8696, 30, 44, 33, 3, -43 },
  { 8861, 27, 32, 33, 3, -31 },
  { 8969, 30, 44, 33, 5, -44 },
  { 9134, 30, 43, 33, 1, -31 },
  { 9296, 29, 43, 33, 1, -43 },
  { 9452, 25, 42, 33, 3, -42 },
  { 9584, 26, 54, 33, 1, -42 },
  { 9760, 32, 43, 33, 1, -43 },
  { 9932, 26, 43, 33, 2, -43 },
  { 10072, 33, 31, 33, -1, -31 },
  { 10200, 29, 31, 33, 1, -31 },
  { 10313, 28, 32, 33, 2, -31 },
  { 10425, 31, 43, 33, -1, -31 },
  { 10592, 28, 43, 33, 3, -31 },
  { 10743, 27, 31, 33, 5, -31 },
  { 10848, 27, 32, 33, 3, -31 },
  { 10956, 25, 38, 33, 5, -37 },
  { 11075, 29, 31, 33, 3, -30 },
  { 11188, 29, 30, 33, 4, -30 },
  { 11297, 31, 30, 33, 3, -30 },
  { 11414, 33, 30, 33, 0, -30 },
  { 11538, 35, 42, 33, 0, -30 },
  { 11722, 30, 30, 33, 1, -30 },
  { 11835, 22, 55, 33, 8, -45 },
  { 11987, 13, 52, 33, 10, -41 },
  { 12072, 22, 54, 33, 5, -44 },
  { 12221, 32, 12, 33, 0, -23 },
};

const GFXfont RobotoMono_MediumItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic57pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_MEDIUMITALIC57PT7B_H_
