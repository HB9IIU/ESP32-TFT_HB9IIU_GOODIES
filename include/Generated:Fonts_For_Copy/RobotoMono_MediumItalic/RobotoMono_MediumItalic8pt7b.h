#ifndef _ROBOTOMONO_MEDIUMITALIC8PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0x74, 0x29, 0x9E, 0xAE, 0x50, 0x11, 0x94, 0x83, 0x49,
  0xC8, 0x4B, 0x62, 0x73, 0x22, 0x98, 0xDB, 0x78, 0xC0, 0x2A, 0x49, 0x22,
  0x55, 0x5A, 0x5D, 0x50, 0x22, 0xF2, 0xC0, 0xE0, 0xC0, 0x11, 0x22, 0x4C,
  0x35, 0x57, 0x96, 0x39, 0x24, 0x80, 0x35, 0x12, 0x4F, 0x35, 0x13, 0x96,
  0x13, 0x55, 0xF2, 0x3A, 0x18, 0x29, 0x30, 0x34, 0x69, 0x96, 0xF2, 0x24,
  0x88, 0x35, 0x57, 0x97, 0x76, 0xF3, 0x80, 0x90, 0x41, 0x80, 0x71, 0x80,
  0x70, 0xF0, 0x61, 0xE0, 0x74, 0xA1, 0x80, 0x33, 0x77, 0xDF, 0x30, 0x23,
  0x55, 0xF9, 0x72, 0x54, 0xE9, 0x78, 0x32, 0x61, 0x09, 0x38, 0x65, 0x59,
  0x9E, 0x7A, 0x10, 0xE8, 0x78, 0x7A, 0x10, 0xE8, 0x40, 0x32, 0x51, 0x69,
  0x38, 0x4A, 0x55, 0x69, 0x48, 0x79, 0x08, 0x42, 0x78, 0x08, 0x84, 0x29,
  0x30, 0x4A, 0x98, 0xC9, 0x48, 0x44, 0x44, 0x8F, 0x4A, 0xDD, 0x69, 0x48,
  0x4A, 0x5D, 0x6B, 0x48, 0x32, 0xA3, 0x29, 0x30, 0x72, 0x52, 0xE8, 0x40,
  0x32, 0xA3, 0x29, 0x30, 0x40, 0x72, 0x54, 0xC9, 0x48, 0x32, 0x50, 0x69,
  0x38, 0xF4, 0x44, 0x4C, 0x4A, 0x55, 0x29, 0x30, 0x9A, 0xAA, 0xCC, 0xDD,
  0xDA, 0xAA, 0x4A, 0x88, 0x45, 0x48, 0x9A, 0xA4, 0x4C, 0x78, 0x88, 0x44,
  0x78, 0x69, 0x25, 0x26, 0x95, 0x50, 0x64, 0xA4, 0x96, 0x4E, 0x80, 0xF0,
  0xC0, 0x77, 0x9F, 0x44, 0x75, 0x9F, 0x78, 0x87, 0x08, 0x9D, 0x29, 0x38,
  0x7F, 0x87, 0x74, 0xE4, 0x88, 0x79, 0x97, 0x96, 0x44, 0x75, 0x99, 0x30,
  0x62, 0x2F, 0x11, 0x62, 0x22, 0x2C, 0x42, 0x54, 0xCE, 0x48, 0x72, 0x22,
  0x2F, 0x7B, 0xBD, 0x75, 0x99, 0x79, 0x96, 0x75, 0x9E, 0x88, 0x79, 0x97,
  0x12, 0xF2, 0x40, 0x76, 0x97, 0x5E, 0x46, 0x55, 0x97, 0xBA, 0xCC, 0xAD,
  0x9C, 0xC0, 0x59, 0x19, 0x20, 0x5A, 0x98, 0x44, 0x40, 0x72, 0x4F, 0x29,
  0x44, 0x90, 0x55, 0x5A, 0x49, 0x14, 0xA0, 0xF0,
};

const GFXglyph RobotoMono_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 1, -6 },
  { 3, 3, 2, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 4, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -6 },
  { 21, 3, 8, 5, 1, -6 },
  { 24, 2, 8, 5, 1, -6 },
  { 26, 3, 4, 5, 1, -6 },
  { 28, 4, 4, 5, 0, -5 },
  { 30, 1, 2, 5, 1, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 2, 1, 5, 1, -1 },
  { 33, 4, 6, 5, 0, -6 },
  { 36, 4, 6, 5, 0, -6 },
  { 39, 3, 6, 5, 1, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 4, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 3, 6, 5, 1, -6 },
  { 67, 1, 4, 5, 2, -4 },
  { 68, 2, 5, 5, 1, -4 },
  { 70, 3, 3, 5, 1, -4 },
  { 72, 4, 3, 5, 0, -4 },
  { 74, 4, 3, 5, 0, -4 },
  { 76, 3, 6, 5, 1, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 4, 6, 5, 0, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 5, 6, 5, 0, -6 },
  { 94, 4, 6, 5, 0, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 4, 6, 5, 0, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 5, 6, 5, 0, -6 },
  { 136, 5, 6, 5, 0, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 5, 7, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 4, 6, 5, 1, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 4, 6, 5, 1, -6 },
  { 167, 4, 6, 5, 1, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 4, 6, 5, 1, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 3, 8, 5, 1, -7 },
  { 184, 2, 6, 5, 1, -6 },
  { 186, 3, 8, 5, 1, -7 },
  { 189, 3, 3, 5, 1, -6 },
  { 191, 4, 1, 5, 0, 0 },
  { 192, 2, 1, 5, 2, -6 },
  { 193, 4, 4, 5, 0, -4 },
  { 195, 4, 6, 5, 0, -6 },
  { 198, 4, 4, 5, 0, -4 },
  { 200, 5, 6, 5, 0, -6 },
  { 204, 4, 4, 5, 0, -4 },
  { 206, 4, 6, 5, 1, -6 },
  { 209, 4, 6, 5, 0, -4 },
  { 212, 4, 6, 5, 0, -6 },
  { 215, 4, 6, 5, 0, -6 },
  { 218, 4, 8, 5, 0, -6 },
  { 222, 5, 6, 5, 0, -6 },
  { 226, 4, 6, 5, 0, -6 },
  { 229, 4, 4, 5, 0, -4 },
  { 231, 4, 4, 5, 0, -4 },
  { 233, 4, 4, 5, 0, -4 },
  { 235, 4, 6, 5, 0, -4 },
  { 238, 4, 6, 5, 0, -4 },
  { 241, 3, 4, 5, 1, -4 },
  { 243, 4, 4, 5, 0, -4 },
  { 245, 3, 5, 5, 1, -5 },
  { 247, 4, 4, 5, 0, -4 },
  { 249, 4, 4, 5, 1, -4 },
  { 251, 5, 4, 5, 0, -4 },
  { 254, 5, 4, 5, 0, -4 },
  { 257, 5, 6, 5, 0, -4 },
  { 261, 4, 4, 5, 0, -4 },
  { 263, 3, 7, 5, 1, -6 },
  { 266, 2, 8, 5, 1, -6 },
  { 268, 3, 7, 5, 1, -6 },
  { 271, 4, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic8pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_MEDIUMITALIC8PT7B_H_
