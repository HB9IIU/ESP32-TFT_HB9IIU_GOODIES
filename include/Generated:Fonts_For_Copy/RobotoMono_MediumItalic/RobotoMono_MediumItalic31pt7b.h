#ifndef _ROBOTOMONO_MEDIUMITALIC31PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7,
  0x8E, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x8F, 0x1C, 0x00, 0x63, 0xB1, 0xF8,
  0xFC, 0x6E, 0x36, 0x1B, 0x1C, 0x00, 0x71, 0x80, 0x18, 0xE0, 0x0E, 0x38,
  0x03, 0x0C, 0x00, 0xC7, 0x00, 0x71, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC0, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x06, 0x38, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x8E, 0x00,
  0xE3, 0x80, 0x30, 0xC0, 0x1C, 0x70, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C,
  0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0x8C, 0x27, 0x18,
  0xEE, 0x31, 0x98, 0x67, 0x39, 0xDC, 0x7F, 0x30, 0x7C, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xDF, 0x83, 0x7F, 0x0E, 0xE7, 0x39,
  0x8E, 0xE7, 0x1C, 0x8E, 0x38, 0x1C, 0x60, 0x1F, 0xC0, 0x1F, 0x00, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x0E, 0x3C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E,
  0x38, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0xC7, 0x79, 0xC7, 0xF1, 0xEF, 0xF0, 0xEE, 0xE0, 0xFE, 0xE0, 0x7C, 0xF0,
  0x78, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x9E, 0x77, 0x76, 0xEE, 0xEC, 0x00,
  0x40, 0x30, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x20, 0x04, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x02, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x43, 0x87, 0xCC, 0xFF, 0xFF, 0xCF,
  0xFE, 0x07, 0x80, 0x3E, 0x01, 0xDC, 0x0E, 0x70, 0x78, 0xE3, 0xC3, 0xC2,
  0x04, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x83, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1C, 0xF3,
  0xCF, 0x38, 0xE7, 0x9C, 0xE1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x31,
  0xEF, 0xDE, 0x78, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE3, 0xC1,
  0xE7, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x7E, 0xE1, 0xFD, 0xCF, 0x77,
  0xBC, 0xEF, 0xE1, 0xDF, 0x87, 0xBC, 0x0F, 0x70, 0x1E, 0xE0, 0x39, 0xE0,
  0xF3, 0xC3, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xC1, 0xF1,
  0xFF, 0xFE, 0xFF, 0xB8, 0xE8, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C,
  0x07, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x01, 0xEE, 0x03, 0xDE, 0x03, 0x9E, 0x07,
  0x1C, 0x0E, 0x1C, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x3C, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x10,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xE0, 0x38, 0xE0,
  0x78, 0xF0, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x7C, 0x03,
  0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x60,
  0x3B, 0xF8, 0xFF, 0xF1, 0xF9, 0xF3, 0xC1, 0xE7, 0x81, 0xEE, 0x03, 0xDC,
  0x07, 0xB8, 0x0E, 0x70, 0x1C, 0xF0, 0x79, 0xE1, 0xE1, 0xFF, 0xC1, 0xFF,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C,
  0x0F, 0x1C, 0x0E, 0x1E, 0x1E, 0x0F, 0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x3C,
  0x3C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x78,
  0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0xE1, 0xFF,
  0x8F, 0x0F, 0x78, 0x1D, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0,
  0x77, 0x83, 0xDF, 0x1F, 0x3F, 0xFC, 0x7F, 0xE0, 0xF3, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7E, 0x0F, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x0C, 0x7C,
  0xF9, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E, 0x7C,
  0xF9, 0xE0, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07,
  0x03, 0x83, 0x83, 0xC0, 0x40, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x3C, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0x20,
  0x00, 0x30, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xF8, 0x07, 0xC0, 0x1C,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0x07,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xE3, 0x81, 0xC0,
  0x61, 0xC0, 0x31, 0xCF, 0xCC, 0xCF, 0xE6, 0xE6, 0x33, 0x67, 0x19, 0xF3,
  0x18, 0xF3, 0x8C, 0x79, 0xC6, 0x6C, 0xC7, 0x36, 0x63, 0x1B, 0x33, 0x99,
  0x9F, 0xFC, 0xC7, 0x3C, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x08, 0x03, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x01, 0xE7,
  0x00, 0xE3, 0x80, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x38, 0x3F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x1E, 0x03, 0x8F, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F,
  0x80, 0x3C, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x81, 0xE1, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0x81, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x71,
  0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0xF0,
  0x1E, 0x38, 0x0E, 0x1E, 0x0F, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xC3, 0xE1, 0xE0, 0x70, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1C, 0x70, 0x1E, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x71, 0xE0,
  0x3C, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x1F, 0xEF, 0x0F, 0xF7, 0x87, 0xF3, 0xC0, 0x39, 0xE0, 0x1C, 0x70, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x0F,
  0x01, 0xC3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0x87, 0x80,
  0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0E, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x3C, 0x07,
  0x80, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x1E, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x1E,
  0x03, 0xE3, 0xC0, 0xF8, 0x78, 0x3E, 0x0E, 0x0F, 0x81, 0xC3, 0xE0, 0x78,
  0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x07, 0x78, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0x83,
  0x80, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0E, 0x01,
  0xE1, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xE1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3B, 0x3F, 0x87, 0x67, 0xE0,
  0xED, 0xDC, 0x1D, 0xBB, 0x83, 0xBE, 0x70, 0xF7, 0xCE, 0x1E, 0xF3, 0xC3,
  0x9E, 0x70, 0x71, 0x8E, 0x0E, 0x31, 0xC1, 0xC0, 0x38, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x3C, 0x00,
  0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E, 0x0F, 0x1F, 0x83, 0x87,
  0xE0, 0xE1, 0xFC, 0x38, 0x77, 0x1E, 0x1D, 0xC7, 0x87, 0x71, 0xE3, 0xCE,
  0x70, 0xF3, 0x9C, 0x3C, 0xEF, 0x0E, 0x1F, 0xC3, 0x87, 0xF1, 0xE1, 0xFC,
  0x78, 0x7E, 0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xC0, 0xF8, 0x70, 0x3E, 0x3C,
  0x07, 0x80, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F, 0x1C, 0x0F,
  0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E,
  0x70, 0x3C, 0x78, 0x7C, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xF1, 0xC0, 0x78, 0xE0, 0x3C, 0x70,
  0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8E, 0x0F, 0xC7, 0xFF, 0xC3,
  0xFF, 0x83, 0xFC, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x38, 0xE0, 0x1C,
  0xF0, 0x0F, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEF, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1C, 0xF0, 0x1E, 0x38, 0x1E, 0x1E,
  0x1F, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0x81, 0xE1, 0xC0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F,
  0x1C, 0x0F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x03, 0xC7, 0x81, 0xC1,
  0xC0, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x1C, 0x3C, 0x0F, 0x1E, 0x07, 0x8E,
  0x03, 0xC7, 0x00, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC1,
  0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x79,
  0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE3,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x0F,
  0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0,
  0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x3C, 0x1E, 0x1E, 0x1E, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x78, 0x78, 0x78, 0xF0,
  0x78, 0xF0, 0x79, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x70, 0xC3, 0xDC, 0x70, 0xE7, 0x1C, 0x39, 0xC7, 0x1E, 0x73, 0xC7, 0x1C,
  0xF1, 0xC7, 0x3C, 0x73, 0xDF, 0x38, 0xF7, 0xCE, 0x3D, 0xB3, 0x8E, 0xED,
  0xE3, 0xBB, 0x70, 0xEC, 0xDC, 0x3B, 0x37, 0x0F, 0xCF, 0xC3, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x3C, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF3, 0x80, 0x0F, 0x1E, 0x00, 0xF8,
  0x70, 0x07, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xC0,
  0xF0, 0x0F, 0xF8, 0x07, 0x9C, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC1, 0xC3,
  0xC0, 0xE1, 0xE0, 0x79, 0xE0, 0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x80, 0x0F, 0xE1, 0xFC, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x7F, 0x0F, 0xC1, 0xF8, 0x00, 0xE1, 0xC3, 0x87, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xE1, 0xC3, 0x87, 0x0F, 0xE1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xC6, 0x38, 0x73,
  0x87, 0x70, 0x7F, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xE3,
  0x87, 0x01, 0xC0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xE0, 0x03,
  0xC0, 0x07, 0x83, 0xFE, 0x3F, 0xFC, 0xFC, 0x39, 0xE0, 0xF7, 0x81, 0xEF,
  0x03, 0xDE, 0x0F, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0x3C, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x38, 0x1F, 0xFC,
  0x3F, 0xFC, 0x7E, 0x7C, 0xF0, 0x79, 0xC0, 0xF3, 0x80, 0xEF, 0x01, 0xDE,
  0x03, 0xBC, 0x0F, 0x70, 0x1E, 0xE0, 0x39, 0xC0, 0xF7, 0xC3, 0xEF, 0xFF,
  0x9D, 0xFE, 0x39, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9F,
  0x78, 0x3D, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x3B, 0xC1, 0xE7, 0xFF, 0x1F, 0xF8, 0x1F, 0xC0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x03,
  0x1E, 0x1F, 0xDE, 0x3F, 0xFE, 0x7C, 0x7C, 0x78, 0x3C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x78, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0x70, 0x00, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF9, 0xF3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xBF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFD, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x8F, 0x03, 0x0F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0xF7, 0x1F, 0xFF, 0x1F,
  0x3F, 0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70,
  0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xB8, 0x00, 0x38, 0x00, 0x78, 0x40, 0xF0, 0xF3, 0xF0, 0xFF,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x1C, 0x1E, 0xFE, 0x3F, 0xFC, 0x7E, 0x7C,
  0xF0, 0x79, 0xC0, 0x73, 0x80, 0xEF, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x70,
  0x1E, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x03, 0xDC, 0x07, 0xB8, 0x0F,
  0x00, 0x00, 0x30, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x08, 0xF8, 0x3F, 0xC0, 0xFE, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x02, 0x78, 0x3E, 0x3C, 0x3E, 0x1E, 0x3E, 0x0E, 0x3E, 0x07, 0x3C,
  0x03, 0xBC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x3C,
  0xF0, 0x1C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0x81, 0xE3, 0x80, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x05, 0xC6, 0x1D, 0xF7, 0xCF, 0xFF, 0xE7,
  0xBE, 0x73, 0x8E, 0x39, 0xC7, 0x1D, 0xE3, 0x8E, 0xF3, 0xC7, 0x71, 0xC7,
  0xB8, 0xE3, 0x9C, 0x71, 0xCE, 0x38, 0xEF, 0x1C, 0x77, 0x9E, 0x3B, 0x8E,
  0x3D, 0xC7, 0x1C, 0xE3, 0x8E, 0x00, 0x00, 0x70, 0x7B, 0xF8, 0xEF, 0xF1,
  0xF9, 0xF3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x0F, 0x78, 0x1E, 0xF0,
  0x3D, 0xC0, 0x7B, 0x80, 0xEF, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1E,
  0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xEF,
  0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xF7, 0x03, 0xCF, 0x07, 0x8F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x70,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0x9F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x07,
  0x3C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x1E,
  0x7C, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0x73, 0xF0, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xBC,
  0xFF, 0xFB, 0xE3, 0xE7, 0x83, 0xDE, 0x03, 0xBC, 0x0F, 0x70, 0x1E, 0xE0,
  0x3D, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9E, 0x1F, 0x3F, 0xFE,
  0x3F, 0xF8, 0x3F, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x00, 0x38, 0x77, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x0F, 0xF0, 0x7F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xCF, 0x00, 0x0F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xEF, 0x01, 0xCE, 0x07,
  0x9F, 0x3F, 0x1F, 0xFC, 0x1F, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC1, 0xFF, 0xFB, 0xFF, 0xE0, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x7F, 0x81, 0xFF, 0x03, 0xF8, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73,
  0x80, 0xE7, 0x83, 0xCF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0xB8, 0xF0,
  0x0F, 0x70, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x38, 0x78, 0x38,
  0x70, 0x38, 0xF0, 0x3C, 0xE0, 0x1D, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0xE1, 0x87, 0xF1, 0xC3, 0xB8,
  0xE1, 0xDC, 0x79, 0xCE, 0x7C, 0xE7, 0x3E, 0x73, 0xBF, 0x71, 0xDB, 0xB8,
  0xED, 0xDC, 0x7E, 0xFC, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87,
  0x83, 0xC3, 0x81, 0xC1, 0xC0, 0x1E, 0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0,
  0x1E, 0x78, 0x07, 0xBC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1E, 0x3C, 0x0F, 0x07,
  0x07, 0x81, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xE3, 0x80, 0x78, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0x78, 0xE0,
  0x0F, 0x3C, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x60, 0x1F, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1C, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x0C,
  0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x1C,
  0x38, 0x60, 0xC1, 0x87, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x1F, 0x00, 0xF0, 0x3F, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xE0,
  0x08, 0x00, 0x1F, 0x01, 0x1F, 0xC0, 0xDF, 0xF8, 0xEC, 0x3F, 0xEE, 0x0F,
  0xF0, 0x01, 0xF0,
};

const GFXglyph RobotoMono_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 7, 22, 18, 6, -22 },
  { 21, 9, 7, 18, 6, -23 },
  { 29, 18, 22, 18, 0, -22 },
  { 79, 16, 29, 18, 2, -26 },
  { 137, 15, 22, 18, 2, -22 },
  { 179, 16, 22, 18, 1, -22 },
  { 223, 4, 8, 18, 8, -23 },
  { 227, 10, 32, 18, 5, -25 },
  { 267, 11, 32, 18, 2, -25 },
  { 311, 14, 15, 18, 3, -22 },
  { 338, 16, 16, 18, 1, -18 },
  { 370, 6, 10, 18, 3, -4 },
  { 378, 12, 3, 18, 4, -11 },
  { 383, 6, 5, 18, 5, -5 },
  { 387, 16, 24, 18, 1, -22 },
  { 435, 15, 22, 18, 2, -22 },
  { 477, 10, 22, 18, 4, -22 },
  { 505, 16, 22, 18, 0, -22 },
  { 549, 16, 22, 18, 1, -22 },
  { 593, 16, 22, 18, 0, -22 },
  { 637, 16, 22, 18, 2, -22 },
  { 681, 15, 22, 18, 1, -22 },
  { 723, 16, 22, 18, 2, -22 },
  { 767, 16, 22, 18, 1, -22 },
  { 811, 14, 22, 18, 2, -22 },
  { 850, 7, 18, 18, 6, -18 },
  { 866, 9, 24, 18, 4, -18 },
  { 893, 14, 14, 18, 2, -17 },
  { 918, 15, 9, 18, 2, -14 },
  { 935, 15, 15, 18, 1, -17 },
  { 964, 13, 22, 18, 4, -22 },
  { 1000, 17, 22, 18, 1, -22 },
  { 1047, 17, 22, 18, -1, -22 },
  { 1094, 17, 22, 18, 1, -22 },
  { 1141, 17, 22, 18, 1, -22 },
  { 1188, 17, 22, 18, 0, -22 },
  { 1235, 17, 22, 18, 1, -22 },
  { 1282, 18, 22, 18, 1, -22 },
  { 1332, 17, 22, 18, 1, -22 },
  { 1379, 18, 22, 18, 0, -22 },
  { 1429, 17, 22, 18, 1, -22 },
  { 1476, 17, 22, 18, 1, -22 },
  { 1523, 19, 22, 18, 1, -22 },
  { 1576, 14, 22, 18, 1, -22 },
  { 1615, 19, 22, 18, 0, -22 },
  { 1668, 18, 22, 18, 0, -22 },
  { 1718, 16, 22, 18, 1, -22 },
  { 1762, 17, 22, 18, 1, -22 },
  { 1809, 17, 26, 18, 1, -22 },
  { 1865, 17, 22, 18, 1, -22 },
  { 1912, 17, 22, 18, 1, -22 },
  { 1959, 18, 22, 18, 2, -22 },
  { 2009, 17, 22, 18, 1, -22 },
  { 2056, 16, 22, 18, 3, -22 },
  { 2100, 18, 22, 18, 2, -22 },
  { 2150, 21, 22, 18, -1, -22 },
  { 2208, 17, 22, 18, 3, -22 },
  { 2255, 18, 22, 18, 0, -22 },
  { 2305, 11, 30, 18, 4, -25 },
  { 2347, 7, 24, 18, 6, -22 },
  { 2368, 11, 30, 18, 4, -25 },
  { 2410, 12, 12, 18, 3, -22 },
  { 2428, 14, 3, 18, 0, 0 },
  { 2434, 6, 4, 18, 8, -22 },
  { 2437, 15, 17, 18, 1, -17 },
  { 2469, 15, 23, 18, 1, -23 },
  { 2513, 14, 17, 18, 2, -17 },
  { 2543, 16, 23, 18, 2, -23 },
  { 2589, 15, 17, 18, 1, -17 },
  { 2621, 16, 24, 18, 3, -24 },
  { 2669, 16, 24, 18, 1, -17 },
  { 2717, 15, 23, 18, 1, -23 },
  { 2761, 14, 23, 18, 1, -23 },
  { 2802, 14, 30, 18, 1, -23 },
  { 2855, 17, 23, 18, 1, -23 },
  { 2904, 14, 23, 18, 1, -23 },
  { 2945, 17, 17, 18, 0, -17 },
  { 2982, 15, 17, 18, 1, -17 },
  { 3014, 15, 17, 18, 1, -17 },
  { 3046, 16, 23, 18, 0, -17 },
  { 3092, 15, 23, 18, 2, -17 },
  { 3136, 14, 17, 18, 3, -17 },
  { 3166, 15, 17, 18, 1, -17 },
  { 3198, 14, 20, 18, 3, -20 },
  { 3233, 15, 16, 18, 2, -16 },
  { 3263, 16, 16, 18, 2, -16 },
  { 3295, 17, 16, 18, 2, -16 },
  { 3329, 18, 16, 18, 0, -16 },
  { 3365, 19, 23, 18, 0, -16 },
  { 3420, 16, 16, 18, 1, -16 },
  { 3452, 12, 29, 18, 5, -24 },
  { 3496, 7, 28, 18, 5, -22 },
  { 3521, 12, 30, 18, 3, -24 },
  { 3566, 17, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic31pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_MEDIUMITALIC31PT7B_H_
