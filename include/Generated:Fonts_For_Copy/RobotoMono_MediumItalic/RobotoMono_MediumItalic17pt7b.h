#ifndef _ROBOTOMONO_MEDIUMITALIC17PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x66, 0x00, 0xCC, 0x4A, 0x77, 0xB0, 0x04, 0xC3,
  0x20, 0x98, 0xFF, 0x7F, 0xC4, 0xC1, 0x23, 0xFE, 0xFF, 0x89, 0x06, 0xC1,
  0x20, 0x04, 0x02, 0x07, 0xC6, 0x66, 0x33, 0x0D, 0xC0, 0x78, 0x1E, 0x03,
  0xB0, 0xD8, 0x6E, 0xE3, 0xE0, 0x40, 0x60, 0x70, 0xDB, 0x9A, 0xD6, 0x74,
  0x08, 0x10, 0x3F, 0x29, 0x49, 0x09, 0x0E, 0x0E, 0x06, 0xC3, 0x30, 0xCC,
  0x1E, 0x07, 0x03, 0xCD, 0xB2, 0xC7, 0xB1, 0xC6, 0xF1, 0xF6, 0x69, 0x2C,
  0x08, 0xC4, 0x66, 0x33, 0x18, 0xC6, 0x21, 0x08, 0x43, 0x08, 0x61, 0x00,
  0x10, 0x41, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x18, 0x63, 0x08,
  0x62, 0x00, 0x18, 0x18, 0x92, 0xFF, 0x38, 0x38, 0x48, 0xCC, 0x0C, 0x08,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x10, 0x30, 0x6D, 0xE8, 0xFF, 0xF8, 0x5F,
  0x80, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x00, 0x1E, 0x33, 0x63, 0x63, 0x67, 0xCF, 0xF3, 0xE3,
  0xC2, 0xC6, 0x6E, 0x7C, 0x0D, 0xEF, 0xA6, 0x18, 0x61, 0x8C, 0x30, 0xC3,
  0x0C, 0x1F, 0x1D, 0xD8, 0x6C, 0x30, 0x30, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x3F, 0xDF, 0xE0, 0x1F, 0x1D, 0xCC, 0x60, 0x30, 0x38, 0x70, 0x7C, 0x06,
  0x03, 0x61, 0x9D, 0xC7, 0x80, 0x03, 0x81, 0xC1, 0xC1, 0xE1, 0xB1, 0x98,
  0x8C, 0xC6, 0xFF, 0x83, 0x01, 0x80, 0xC0, 0x3F, 0x9F, 0x88, 0x0C, 0x07,
  0xC3, 0xF0, 0x1C, 0x06, 0x03, 0x63, 0x3B, 0x8F, 0x80, 0x0E, 0x3E, 0x30,
  0x60, 0x5C, 0xFE, 0xC6, 0xC3, 0xC2, 0xC6, 0xEE, 0x7C, 0x7F, 0xBF, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00, 0x1E,
  0x33, 0x63, 0x63, 0x63, 0x3E, 0x7E, 0xC6, 0xC3, 0xC6, 0xEE, 0x7C, 0x3E,
  0x77, 0x63, 0x43, 0xC3, 0xE3, 0x7F, 0x3A, 0x06, 0x0C, 0x78, 0x70, 0x27,
  0x30, 0x00, 0x04, 0xEE, 0x18, 0xC6, 0x00, 0x00, 0x00, 0x31, 0x98, 0xCC,
  0x00, 0x03, 0x0F, 0x7C, 0xE0, 0xF0, 0x3E, 0x0E, 0x02, 0x7F, 0x7F, 0x00,
  0x00, 0xFF, 0x40, 0x78, 0x1E, 0x07, 0x1E, 0xF8, 0xE0, 0x80, 0x3E, 0xCF,
  0x18, 0x30, 0x63, 0x8E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x0F, 0x06, 0x22,
  0x2D, 0xBD, 0x5A, 0x54, 0x95, 0x2B, 0x4A, 0xDF, 0x90, 0x06, 0x20, 0xF0,
  0x03, 0x00, 0xC0, 0x70, 0x1E, 0x0D, 0x83, 0x61, 0x98, 0x66, 0x3F, 0x8C,
  0x26, 0x0F, 0x83, 0x3F, 0x0F, 0xE3, 0x0C, 0xC3, 0x31, 0x9F, 0xC7, 0xF1,
  0x86, 0x61, 0x98, 0x67, 0xF3, 0xF8, 0x1E, 0x19, 0x98, 0x78, 0x3C, 0x06,
  0x03, 0x01, 0x80, 0xC3, 0x63, 0x3B, 0x8F, 0x80, 0x3E, 0x0F, 0xC3, 0x18,
  0xC6, 0x31, 0x98, 0x66, 0x19, 0x86, 0x61, 0x98, 0xCF, 0xE3, 0xF0, 0x3F,
  0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x07,
  0xF3, 0xFC, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x0F, 0xE7, 0xF1, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x80, 0x1E, 0x19, 0x98, 0x78, 0x0C, 0x06, 0x03,
  0x3D, 0x86, 0xC3, 0x61, 0xBB, 0xCF, 0x80, 0x30, 0xCC, 0x33, 0x0C, 0xC6,
  0x61, 0x9F, 0xE7, 0xF9, 0x86, 0x61, 0x98, 0xCC, 0x33, 0x0C, 0x3F, 0xBF,
  0x83, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x3F, 0x9F, 0xC0,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xC6, 0x63, 0x3B,
  0x8F, 0x00, 0x30, 0xE6, 0x38, 0xCE, 0x1B, 0x83, 0xE0, 0xF8, 0x1F, 0x83,
  0xB0, 0x66, 0x0C, 0x61, 0x8C, 0x60, 0xC0, 0x38, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x39, 0xCE, 0x73, 0xBC, 0xAF,
  0x2A, 0x9B, 0xE6, 0xD9, 0xB6, 0x61, 0x90, 0x6C, 0x13, 0x0C, 0x30, 0xCE,
  0x33, 0x8C, 0xE6, 0x6D, 0x9B, 0x66, 0xD9, 0x96, 0x67, 0x99, 0xCC, 0x33,
  0x0C, 0x1E, 0x1B, 0x98, 0xD8, 0x2C, 0x1E, 0x1B, 0x0D, 0x86, 0xC3, 0x63,
  0x3F, 0x8F, 0x80, 0x3F, 0x0F, 0xE3, 0x0C, 0xC3, 0x30, 0xCC, 0x67, 0xF1,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x1E, 0x1B, 0x98, 0xD8, 0x3C, 0x1E,
  0x0B, 0x0D, 0x86, 0xC3, 0x63, 0x3F, 0x8F, 0x80, 0x70, 0x10, 0x3F, 0x0F,
  0xE3, 0x0C, 0xC3, 0x31, 0x98, 0xE7, 0xF1, 0x98, 0x63, 0x18, 0xC6, 0x33,
  0x0E, 0x3E, 0x39, 0x98, 0x6C, 0x06, 0x01, 0xE0, 0x78, 0x06, 0xC3, 0x61,
  0xBB, 0x8F, 0x80, 0x7F, 0xFF, 0xE0, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x61, 0xB0, 0xD8, 0x6C, 0x24, 0x36,
  0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x3B, 0x8F, 0x80, 0xC3, 0xE1, 0xB1, 0x98,
  0xCC, 0x66, 0x63, 0x30, 0xB0, 0x78, 0x38, 0x1C, 0x0C, 0x00, 0xCC, 0xF3,
  0x2C, 0xDB, 0x76, 0xDD, 0x37, 0xCF, 0xF3, 0xBC, 0xEE, 0x3B, 0x8C, 0xE3,
  0x30, 0x30, 0xE6, 0x38, 0x66, 0x0D, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x36, 0x0E, 0x61, 0x8C, 0x61, 0xC0, 0xC3, 0xE1, 0xB1, 0x8D, 0xC6, 0xC3,
  0xC0, 0xE0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x00, 0x3F, 0xCF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFB, 0xFC, 0x1C,
  0xF3, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x3C, 0xF0,
  0xCC, 0x46, 0x66, 0x62, 0x23, 0x33, 0x30, 0x1C, 0xF0, 0xC3, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x3C, 0xF0, 0x18, 0x63, 0xDB, 0x6F,
  0x10, 0xFF, 0xFE, 0xCC, 0x3E, 0x66, 0x43, 0x03, 0x7E, 0xC6, 0xC6, 0xCE,
  0xF6, 0x18, 0x18, 0x0C, 0x06, 0x03, 0xF1, 0xDC, 0xC6, 0xC3, 0x61, 0xB0,
  0xD8, 0xCE, 0xED, 0xE0, 0x3E, 0x76, 0x63, 0xC0, 0xC0, 0xC0, 0xC6, 0xEE,
  0x7C, 0x01, 0x80, 0xC0, 0x60, 0x63, 0xF3, 0xBB, 0x8D, 0x86, 0xC3, 0x63,
  0x31, 0x9D, 0xC7, 0xE0, 0x3E, 0x76, 0x63, 0xC3, 0xFF, 0xC0, 0xC2, 0xEE,
  0x7C, 0x0F, 0x8F, 0x8C, 0x06, 0x0F, 0xE7, 0xF0, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x00, 0x1F, 0x9D, 0xDC, 0x6C, 0x36, 0x1B, 0x19, 0x8C,
  0xEE, 0x3F, 0x01, 0x91, 0x9F, 0x81, 0x00, 0x18, 0x18, 0x0C, 0x06, 0x03,
  0xF1, 0xDC, 0x86, 0xC3, 0x61, 0xB0, 0xD8, 0xCC, 0x6C, 0x30, 0x0E, 0x08,
  0x03, 0xE7, 0xC1, 0x86, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x03, 0x03, 0x00,
  0x1F, 0x1E, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x1C, 0x78,
  0xE0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x31, 0xCC, 0xC2, 0xE1, 0xF0, 0x7C,
  0x1F, 0x86, 0x61, 0x9C, 0xC3, 0x00, 0x3E, 0x78, 0x30, 0x60, 0xC1, 0x83,
  0x0C, 0x18, 0x30, 0x67, 0xFF, 0xE0, 0x7F, 0xBF, 0xDB, 0x2D, 0xB4, 0xDE,
  0x6F, 0x27, 0xB3, 0xD9, 0x00, 0x3F, 0x1D, 0xCC, 0x6C, 0x36, 0x1B, 0x0D,
  0x8C, 0xC6, 0xC3, 0x00, 0x3E, 0x76, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xEE,
  0x7C, 0x3F, 0x1D, 0x88, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xEE, 0xDE, 0x60,
  0x30, 0x18, 0x00, 0x3F, 0x77, 0xE3, 0xC3, 0xC3, 0xC6, 0xC6, 0xEE, 0x7E,
  0x06, 0x04, 0x0C, 0x6F, 0x7E, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x3E, 0x77, 0x63, 0x60, 0x3C, 0x06, 0xC2, 0xE6, 0x7C, 0x18, 0x18, 0x7F,
  0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x1E, 0x63, 0x63, 0x63, 0xC3,
  0xC3, 0xC2, 0xC6, 0xEE, 0x7E, 0xC1, 0xB1, 0x98, 0xCC, 0xC6, 0x41, 0x60,
  0xA0, 0x70, 0x30, 0x00, 0xC9, 0xEC, 0xF6, 0x5B, 0x6F, 0xB7, 0x53, 0xB9,
  0x9C, 0xCC, 0x00, 0x31, 0xCC, 0xE1, 0xB0, 0x78, 0x0C, 0x07, 0x83, 0x61,
  0x8C, 0xE3, 0x80, 0x60, 0xCC, 0x73, 0x18, 0xCC, 0x33, 0x05, 0x81, 0xE0,
  0x70, 0x18, 0x06, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFF, 0x00, 0x06, 0x18, 0x20, 0xC1, 0x83,
  0x0C, 0x30, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x33, 0x22, 0x22,
  0x66, 0x44, 0x44, 0xCC, 0x80, 0x30, 0x41, 0x86, 0x10, 0x41, 0x87, 0x1C,
  0xC3, 0x08, 0x61, 0x8C, 0x20, 0x30, 0x3C, 0x73, 0xE0, 0x60,
};

const GFXglyph RobotoMono_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 4, 10, 3, -13 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 9, 16, 10, 1, -14 },
  { 43, 8, 12, 10, 1, -12 },
  { 55, 10, 12, 10, 0, -12 },
  { 70, 3, 5, 10, 4, -13 },
  { 72, 5, 18, 10, 3, -14 },
  { 84, 6, 18, 10, 1, -14 },
  { 98, 8, 8, 10, 2, -12 },
  { 106, 8, 9, 10, 1, -10 },
  { 115, 3, 5, 10, 2, -2 },
  { 117, 7, 2, 10, 2, -6 },
  { 119, 3, 3, 10, 3, -3 },
  { 121, 9, 13, 10, 1, -12 },
  { 136, 8, 12, 10, 1, -12 },
  { 148, 6, 12, 10, 2, -12 },
  { 157, 9, 12, 10, 0, -12 },
  { 171, 9, 12, 10, 0, -12 },
  { 185, 9, 12, 10, 0, -12 },
  { 199, 9, 12, 10, 1, -12 },
  { 213, 8, 12, 10, 1, -12 },
  { 225, 9, 12, 10, 1, -12 },
  { 239, 8, 12, 10, 1, -12 },
  { 251, 8, 12, 10, 1, -12 },
  { 263, 4, 10, 10, 3, -10 },
  { 268, 5, 13, 10, 2, -10 },
  { 277, 8, 8, 10, 1, -9 },
  { 285, 8, 5, 10, 1, -8 },
  { 290, 8, 8, 10, 1, -9 },
  { 298, 7, 12, 10, 2, -12 },
  { 309, 10, 12, 10, 0, -12 },
  { 324, 10, 12, 10, -1, -12 },
  { 339, 10, 12, 10, 0, -12 },
  { 354, 9, 12, 10, 1, -12 },
  { 368, 10, 12, 10, 0, -12 },
  { 383, 10, 12, 10, 0, -12 },
  { 398, 10, 12, 10, 0, -12 },
  { 413, 9, 12, 10, 1, -12 },
  { 427, 10, 12, 10, 0, -12 },
  { 442, 9, 12, 10, 1, -12 },
  { 456, 9, 12, 10, 1, -12 },
  { 470, 11, 12, 10, 0, -12 },
  { 487, 8, 12, 10, 0, -12 },
  { 499, 10, 12, 10, 0, -12 },
  { 514, 10, 12, 10, 0, -12 },
  { 529, 9, 12, 10, 1, -12 },
  { 543, 10, 12, 10, 0, -12 },
  { 558, 9, 14, 10, 1, -12 },
  { 574, 10, 12, 10, 0, -12 },
  { 589, 9, 12, 10, 1, -12 },
  { 603, 10, 12, 10, 1, -12 },
  { 618, 9, 12, 10, 1, -12 },
  { 632, 9, 12, 10, 2, -12 },
  { 646, 10, 12, 10, 1, -12 },
  { 661, 11, 12, 10, 0, -12 },
  { 678, 9, 12, 10, 2, -12 },
  { 692, 10, 12, 10, 0, -12 },
  { 707, 6, 17, 10, 2, -14 },
  { 720, 4, 13, 10, 3, -12 },
  { 727, 6, 17, 10, 2, -14 },
  { 740, 6, 6, 10, 2, -12 },
  { 745, 8, 2, 10, 0, 0 },
  { 747, 3, 2, 10, 5, -12 },
  { 748, 8, 9, 10, 1, -9 },
  { 757, 9, 13, 10, 0, -13 },
  { 772, 8, 9, 10, 1, -9 },
  { 781, 9, 13, 10, 1, -13 },
  { 796, 8, 9, 10, 1, -9 },
  { 805, 9, 13, 10, 2, -13 },
  { 820, 9, 13, 10, 0, -9 },
  { 835, 9, 13, 10, 0, -13 },
  { 850, 7, 12, 10, 1, -12 },
  { 861, 8, 16, 10, 0, -12 },
  { 877, 10, 13, 10, 0, -13 },
  { 894, 7, 13, 10, 1, -13 },
  { 906, 9, 9, 10, 0, -9 },
  { 917, 9, 9, 10, 0, -9 },
  { 928, 8, 9, 10, 1, -9 },
  { 937, 9, 12, 10, 0, -9 },
  { 951, 8, 12, 10, 1, -9 },
  { 963, 8, 9, 10, 2, -9 },
  { 972, 8, 9, 10, 1, -9 },
  { 981, 8, 11, 10, 1, -11 },
  { 992, 8, 9, 10, 1, -9 },
  { 1001, 9, 9, 10, 1, -9 },
  { 1012, 9, 9, 10, 1, -9 },
  { 1023, 10, 9, 10, 0, -9 },
  { 1035, 10, 13, 10, 0, -9 },
  { 1052, 9, 9, 10, 0, -9 },
  { 1063, 7, 16, 10, 2, -13 },
  { 1077, 4, 15, 10, 3, -12 },
  { 1085, 6, 16, 10, 2, -13 },
  { 1097, 9, 4, 10, 0, -7 },
};

const GFXfont RobotoMono_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic17pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_MEDIUMITALIC17PT7B_H_
