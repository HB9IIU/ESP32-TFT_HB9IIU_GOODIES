#ifndef _ROBOTOMONO_MEDIUMITALIC29PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3,
  0x8F, 0x00, 0x00, 0x00, 0xC3, 0xC7, 0x87, 0x00, 0x71, 0xB9, 0xDC, 0xEC,
  0x76, 0x33, 0x1B, 0x8C, 0x00, 0x63, 0x00, 0x71, 0x80, 0x31, 0xC0, 0x38,
  0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x83,
  0x8C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0xE3, 0x07, 0xFF, 0xF3, 0xFF, 0xF8,
  0x38, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x38, 0x07, 0x18,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0x80, 0x7F, 0xC1, 0xFF,
  0x87, 0x87, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x39, 0xC0,
  0x73, 0x81, 0xE7, 0x83, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x3C, 0x01, 0xF8, 0x0E, 0x60, 0x31, 0xC6, 0xC7,
  0x33, 0x19, 0xCC, 0x66, 0x3F, 0xB0, 0x7D, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x60, 0x37, 0xE1, 0xB9, 0x8E, 0xC7, 0x33, 0x1D, 0x8C, 0x70,
  0x31, 0x80, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x71,
  0xC1, 0xC3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x78, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xFC, 0x77, 0xB8, 0xFE, 0x79, 0xF8, 0x77, 0xF0, 0xFE, 0xE0,
  0xF9, 0xC0, 0xF3, 0xEF, 0xE3, 0xFF, 0xC3, 0xFB, 0xC0, 0x37, 0x77, 0x66,
  0x6E, 0x00, 0x81, 0xC1, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x01, 0x80, 0x40, 0x04,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x83, 0xC0, 0x60, 0x20,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x04, 0x30, 0xF9, 0x9F, 0xFF,
  0xE7, 0xFE, 0x0F, 0x00, 0xF8, 0x0E, 0xE0, 0xF3, 0x8F, 0x1C, 0x30, 0x70,
  0x02, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x1F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFC, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0xE3, 0x8E, 0x71, 0xCE,
  0x30, 0x7F, 0xFF, 0xFF, 0x77, 0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x3D,
  0xE0, 0xF7, 0x01, 0xDC, 0x0F, 0x70, 0xFF, 0xC7, 0xEF, 0x7B, 0xBB, 0xCE,
  0xFC, 0x3B, 0xE0, 0xEE, 0x07, 0xB8, 0x1C, 0xE0, 0x73, 0x83, 0xC7, 0xBE,
  0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x81, 0xC7, 0xFF, 0xFF, 0xF7, 0x3A, 0x1C,
  0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1,
  0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x78, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x70, 0x1C, 0xE0, 0x79, 0xE0, 0xE3, 0xF7, 0xC3, 0xFF, 0x03, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x77, 0x01, 0xCE, 0x07, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC3, 0x83,
  0x8E, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x80, 0x1F, 0xF0, 0x3F, 0xF8,
  0x3C, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C,
  0x70, 0x38, 0x70, 0x78, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x38,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x70,
  0x3F, 0xF1, 0xFF, 0xE7, 0xC7, 0x9E, 0x0E, 0x70, 0x3D, 0xC0, 0xFF, 0x03,
  0xDC, 0x0E, 0x70, 0x39, 0xE1, 0xE3, 0xDF, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC1,
  0xE3, 0x83, 0xCF, 0x07, 0x8E, 0x0E, 0x1E, 0x3C, 0x1F, 0xF0, 0x3F, 0x80,
  0xFF, 0x83, 0x87, 0x8E, 0x07, 0x1C, 0x0F, 0x78, 0x1C, 0xF0, 0x38, 0xE0,
  0xF1, 0xF7, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC,
  0x1E, 0xFB, 0xF3, 0xFF, 0x8F, 0xB8, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x3E,
  0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x00, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF3, 0xCF, 0x3C, 0x0F, 0x07, 0xC3, 0xE1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x3E, 0x07,
  0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xC0, 0x06, 0x00, 0x08, 0x7F, 0xFD, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x20, 0x00, 0xE0, 0x03, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x03, 0xF8, 0x7F,
  0x87, 0xF0, 0x1F, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x0F, 0x83, 0xFE, 0x7F,
  0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x40, 0x03, 0xF8, 0x07, 0xFC, 0x0C, 0x0E,
  0x18, 0x06, 0x31, 0xF2, 0x33, 0xF3, 0x67, 0x33, 0x66, 0x33, 0xCC, 0x63,
  0xCC, 0x62, 0xCC, 0x66, 0xCC, 0x66, 0xCC, 0xC4, 0xCF, 0xEC, 0xCF, 0x78,
  0xC2, 0x30, 0xE0, 0x00, 0x70, 0x40, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xDC,
  0x01, 0xDC, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x8E, 0x07, 0x0E, 0x0F, 0x0E,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x0F,
  0x70, 0x0F, 0xF0, 0x07, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x1C, 0x1E,
  0x3C, 0x0E, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x3C, 0x3F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xF8, 0x70, 0x3C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C,
  0xF0, 0x3C, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xF0,
  0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0F,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x70, 0x3C, 0x70, 0x78, 0x7D, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x1E, 0x3E,
  0x1E, 0x0E, 0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07,
  0x3C, 0x07, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x1E,
  0x78, 0x3C, 0x70, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF8, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF0,
  0x07, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x01,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0xFE, 0xF1, 0xFC,
  0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x3C, 0x7F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xE0, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xE3, 0xC0,
  0xF1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x0F, 0x1F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x78,
  0xF0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x8F, 0x03,
  0xC0, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x03, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xE0,
  0x38, 0xE0, 0x78, 0xF0, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x1C,
  0x07, 0xC7, 0x03, 0xE1, 0xC0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x0F, 0x1E,
  0x03, 0x8F, 0x00, 0xE7, 0x80, 0x3B, 0xC0, 0x0F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x0E, 0x03, 0xC3, 0xC0, 0xF0,
  0x70, 0x3C, 0x1E, 0x0E, 0x07, 0x83, 0x80, 0xF0, 0xE0, 0x3C, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x07,
  0x87, 0x83, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xFC, 0xDC, 0x7E,
  0xFC, 0x3F, 0x6E, 0x1D, 0xF7, 0x1C, 0xF3, 0x8E, 0x79, 0xC7, 0x3D, 0xC3,
  0x9C, 0xE1, 0xCE, 0x70, 0xE6, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x38, 0x0E,
  0x1C, 0x07, 0x0E, 0x03, 0x8F, 0x01, 0xC0, 0x0E, 0x03, 0x87, 0x81, 0xC3,
  0xC1, 0xE3, 0xE0, 0xF1, 0xF0, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x1E,
  0x3D, 0x8F, 0x1E, 0xE7, 0x8F, 0x73, 0x87, 0x19, 0xC3, 0x8E, 0xE1, 0xC7,
  0xF1, 0xE3, 0xF8, 0xF0, 0xF8, 0x70, 0x7C, 0x38, 0x3E, 0x1C, 0x0F, 0x0E,
  0x07, 0x8F, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE3,
  0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0x70, 0x38,
  0xE0, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1C, 0x1E, 0x1C, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x0F,
  0x38, 0x0E, 0x38, 0x1E, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7,
  0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0x78, 0x1E, 0xF0, 0x38, 0xE0, 0xF1,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0x10, 0x1F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1C, 0x1E, 0x3C, 0x0E, 0x3C,
  0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x3E, 0x7F, 0xFC, 0x7F,
  0xF0, 0x7F, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70, 0x70, 0xF0, 0x70, 0xF0,
  0x78, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0x01, 0xF0, 0x07, 0xFC, 0x1F,
  0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1C, 0xE0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x3C, 0xF0, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x03, 0x9E, 0x0F,
  0x3C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07,
  0x3C, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x71, 0xC7, 0x71, 0xC7, 0xE3, 0xC7, 0xE3,
  0xCE, 0xE3, 0xCE, 0xE3, 0xCE, 0xE7, 0xCE, 0xE7, 0xDC, 0xE7, 0xDC, 0xEF,
  0xDC, 0xED, 0xD8, 0xED, 0xF8, 0xFD, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0, 0xF9,
  0xF0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x1C, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x70, 0x07,
  0x1E, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x79,
  0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x07, 0x0F, 0x80,
  0xF0, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3C, 0x70, 0x3C, 0x70, 0x78, 0x78,
  0x70, 0x38, 0xF0, 0x39, 0xE0, 0x39, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x9F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x0F, 0xC3, 0xF0, 0xFC, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C,
  0x38, 0x70, 0xE1, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE1,
  0xC3, 0x80, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0,
  0xFC, 0x3B, 0x87, 0x31, 0xC6, 0x38, 0xEE, 0x1F, 0xC3, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE3, 0x8C, 0x70, 0x01, 0x80, 0x3F, 0xC1, 0xFF, 0x8F,
  0x0E, 0x38, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xFE, 0x3F, 0xF9, 0xE0, 0xEF,
  0x03, 0xB8, 0x1E, 0xF0, 0x7B, 0xEF, 0xC7, 0xFF, 0x0F, 0xDE, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xCC, 0x0E, 0xFC,
  0x3F, 0xF8, 0xF9, 0xF3, 0x83, 0xCE, 0x07, 0x78, 0x1D, 0xC0, 0x77, 0x01,
  0xDC, 0x07, 0x70, 0x3F, 0xC0, 0xEF, 0x07, 0xBF, 0x7C, 0xFF, 0xE3, 0xBF,
  0x00, 0x03, 0x00, 0x7F, 0x0F, 0xFC, 0xF8, 0xF7, 0x03, 0xF8, 0x1F, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xEE, 0x0F, 0x7D, 0xF1,
  0xFF, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x03, 0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x7C, 0x38,
  0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0,
  0x38, 0x70, 0x38, 0x70, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0x70, 0x01,
  0x80, 0x1F, 0xC1, 0xFF, 0x8F, 0x8F, 0x3C, 0x1D, 0xE0, 0x77, 0x01, 0xDF,
  0xFF, 0x7F, 0xFF, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x31, 0xFB, 0xE3,
  0xFF, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0x90, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xF7, 0x0F, 0xFF, 0x1F, 0x1F, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xB8, 0x00, 0x38, 0x20, 0x78, 0x60, 0x70, 0xFF,
  0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC6, 0x0E, 0xFE, 0x3F, 0xFC, 0xF8, 0xF3, 0x81,
  0xDE, 0x07, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x70, 0x3B, 0xC0,
  0xEF, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x81, 0xE0, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0xFF, 0x07,
  0xF0, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x01, 0x3C, 0x3E, 0x38, 0x7C, 0x38, 0xF8, 0x39,
  0xE0, 0x3B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x79,
  0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x78, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x01,
  0x8C, 0x3F, 0xDE, 0x3F, 0xFF, 0x39, 0xE7, 0x39, 0xC7, 0x79, 0xC7, 0x71,
  0xC7, 0x71, 0xC7, 0x71, 0xCE, 0x71, 0xCE, 0x73, 0x8E, 0xE3, 0x8E, 0xE3,
  0x8E, 0xE3, 0x8E, 0xE3, 0x9C, 0xE7, 0x9C, 0x00, 0x60, 0xEF, 0xE3, 0xFF,
  0xCF, 0x8F, 0x38, 0x1D, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x3D, 0xC0,
  0xF7, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0x80, 0xEE, 0x07, 0xB8, 0x1E, 0x01,
  0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x1F, 0x38, 0x3D, 0xE0, 0x77, 0x01, 0xDC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0E, 0x70, 0x79, 0xF7, 0xC3,
  0xFE, 0x07, 0xF0, 0x00, 0x60, 0x3B, 0xF0, 0x7F, 0xF0, 0xF9, 0xF1, 0xC1,
  0xE7, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x7B,
  0xC0, 0xE7, 0x83, 0xCF, 0xDF, 0x1F, 0xFC, 0x3B, 0xF0, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1F,
  0xDC, 0x7F, 0xF9, 0xF1, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x1E,
  0x70, 0x3D, 0xE0, 0x73, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8F, 0xBF, 0x0F,
  0xFC, 0x0F, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x71, 0xCF, 0xCE, 0xFE, 0x7F, 0xF3, 0xE0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F,
  0x38, 0x1C, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x03,
  0xBC, 0x0E, 0xF0, 0x39, 0xE3, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x1F, 0xFF, 0x7F, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3F,
  0xE0, 0xFF, 0x03, 0xF0, 0x78, 0x1D, 0xC0, 0xF7, 0x03, 0xDC, 0x0E, 0x70,
  0x3B, 0xC0, 0xEF, 0x03, 0xB8, 0x1E, 0xE0, 0x7B, 0x81, 0xCE, 0x07, 0x38,
  0x3C, 0xFF, 0xF1, 0xFD, 0xC3, 0xEE, 0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xC0,
  0xE3, 0x83, 0xC7, 0x07, 0x07, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xC0,
  0x73, 0x80, 0x6E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0xE3, 0x8F, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x9C, 0xE7, 0x9C, 0xCD, 0x98,
  0xCD, 0xB8, 0xDD, 0xB8, 0xD9, 0xB0, 0xD9, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0,
  0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0x1E, 0x0F, 0x87, 0x07, 0x03, 0xC7,
  0x80, 0xE7, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x03, 0xCF, 0x03, 0xC3, 0x83, 0xC1, 0xE3,
  0xC0, 0x78, 0x3C, 0x07, 0xC7, 0x01, 0xE1, 0xC0, 0xF0, 0x70, 0x38, 0x1E,
  0x1E, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0F, 0x70, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x20, 0x1C, 0x07, 0x81,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01,
  0xE1, 0xF0, 0x3C, 0x07, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x3C, 0x03, 0x00, 0x0E, 0x18,
  0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18,
  0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x00, 0x08, 0x01,
  0xC0, 0x78, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x3F, 0x0F, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x60,
  0x00, 0x0C, 0x00, 0x3F, 0x03, 0x7F, 0x87, 0x73, 0xEF, 0xE1, 0xFE, 0x40,
  0x7C, 0x00, 0x10,
};

const GFXglyph RobotoMono_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 21, 17, 5, -21 },
  { 20, 9, 7, 17, 5, -22 },
  { 28, 17, 21, 17, 0, -21 },
  { 73, 15, 27, 17, 1, -24 },
  { 124, 14, 21, 17, 2, -21 },
  { 161, 15, 21, 17, 1, -21 },
  { 201, 4, 8, 17, 7, -22 },
  { 205, 9, 30, 17, 5, -23 },
  { 239, 10, 30, 17, 2, -23 },
  { 277, 13, 15, 17, 3, -21 },
  { 302, 15, 15, 17, 1, -17 },
  { 331, 6, 8, 17, 3, -3 },
  { 337, 12, 2, 17, 3, -10 },
  { 340, 5, 4, 17, 5, -4 },
  { 343, 15, 23, 17, 1, -21 },
  { 387, 14, 21, 17, 2, -21 },
  { 424, 9, 21, 17, 4, -21 },
  { 448, 15, 21, 17, 0, -21 },
  { 488, 15, 21, 17, 1, -21 },
  { 528, 15, 21, 17, 0, -21 },
  { 568, 16, 21, 17, 1, -21 },
  { 610, 14, 21, 17, 1, -21 },
  { 647, 15, 21, 17, 2, -21 },
  { 687, 15, 21, 17, 1, -21 },
  { 727, 13, 21, 17, 2, -21 },
  { 762, 6, 16, 17, 6, -16 },
  { 774, 9, 21, 17, 4, -16 },
  { 798, 13, 14, 17, 2, -16 },
  { 821, 14, 8, 17, 2, -13 },
  { 835, 14, 14, 17, 1, -16 },
  { 860, 12, 21, 17, 4, -21 },
  { 892, 16, 21, 17, 1, -21 },
  { 934, 16, 21, 17, -1, -21 },
  { 976, 16, 21, 17, 1, -21 },
  { 1018, 16, 21, 17, 1, -21 },
  { 1060, 16, 21, 17, 0, -21 },
  { 1102, 16, 21, 17, 1, -21 },
  { 1144, 16, 21, 17, 1, -21 },
  { 1186, 16, 21, 17, 1, -21 },
  { 1228, 17, 21, 17, 0, -21 },
  { 1273, 15, 21, 17, 1, -21 },
  { 1313, 16, 21, 17, 1, -21 },
  { 1355, 18, 21, 17, 1, -21 },
  { 1403, 13, 21, 17, 1, -21 },
  { 1438, 17, 21, 17, 0, -21 },
  { 1483, 17, 21, 17, 0, -21 },
  { 1528, 15, 21, 17, 1, -21 },
  { 1568, 16, 21, 17, 1, -21 },
  { 1610, 15, 25, 17, 1, -21 },
  { 1657, 16, 21, 17, 1, -21 },
  { 1699, 16, 21, 17, 1, -21 },
  { 1741, 16, 21, 17, 2, -21 },
  { 1783, 16, 21, 17, 1, -21 },
  { 1825, 15, 21, 17, 3, -21 },
  { 1865, 16, 21, 17, 2, -21 },
  { 1907, 19, 21, 17, -1, -21 },
  { 1957, 16, 21, 17, 3, -21 },
  { 1999, 17, 21, 17, 0, -21 },
  { 2044, 10, 29, 17, 4, -24 },
  { 2081, 7, 23, 17, 5, -21 },
  { 2102, 11, 29, 17, 3, -24 },
  { 2142, 11, 11, 17, 3, -21 },
  { 2158, 13, 3, 17, 0, 0 },
  { 2163, 5, 4, 17, 8, -21 },
  { 2166, 14, 16, 17, 1, -16 },
  { 2194, 14, 22, 17, 1, -22 },
  { 2233, 13, 16, 17, 2, -16 },
  { 2259, 16, 22, 17, 1, -22 },
  { 2303, 14, 16, 17, 1, -16 },
  { 2331, 15, 22, 17, 3, -22 },
  { 2373, 16, 22, 17, 0, -16 },
  { 2417, 14, 22, 17, 1, -22 },
  { 2456, 13, 21, 17, 1, -21 },
  { 2491, 13, 27, 17, 1, -21 },
  { 2535, 16, 22, 17, 1, -22 },
  { 2579, 13, 22, 17, 1, -22 },
  { 2615, 16, 16, 17, 0, -16 },
  { 2647, 14, 16, 17, 1, -16 },
  { 2675, 14, 16, 17, 1, -16 },
  { 2703, 15, 22, 17, 0, -16 },
  { 2745, 15, 22, 17, 1, -16 },
  { 2787, 13, 16, 17, 3, -16 },
  { 2813, 14, 16, 17, 1, -16 },
  { 2841, 13, 19, 17, 3, -19 },
  { 2872, 14, 15, 17, 2, -15 },
  { 2899, 15, 15, 17, 2, -15 },
  { 2928, 16, 15, 17, 2, -15 },
  { 2958, 17, 15, 17, 0, -15 },
  { 2990, 18, 21, 17, 0, -15 },
  { 3038, 15, 15, 17, 1, -15 },
  { 3067, 11, 28, 17, 4, -23 },
  { 3106, 7, 27, 17, 5, -21 },
  { 3130, 11, 28, 17, 3, -23 },
  { 3169, 16, 7, 17, 0, -12 },
};

const GFXfont RobotoMono_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic29pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_MEDIUMITALIC29PT7B_H_
