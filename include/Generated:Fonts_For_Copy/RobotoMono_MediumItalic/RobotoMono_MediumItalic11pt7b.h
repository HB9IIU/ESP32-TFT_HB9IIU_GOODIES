#ifndef _ROBOTOMONO_MEDIUMITALIC11PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x25, 0x04, 0xB4, 0x14, 0x57, 0xCA, 0x2B, 0xF5, 0x34, 0x13,
  0x93, 0x96, 0x18, 0x73, 0xF2, 0x00, 0xC5, 0x74, 0xC2, 0x3E, 0xA7, 0x38,
  0xA2, 0x8C, 0x77, 0x5C, 0x9F, 0xE0, 0x25, 0x69, 0x24, 0x91, 0x00, 0x42,
  0x23, 0x33, 0x22, 0x24, 0x88, 0x31, 0x3E, 0x4D, 0x28, 0x21, 0x3E, 0xC4,
  0x00, 0x58, 0xF8, 0xB0, 0x08, 0x84, 0x42, 0x21, 0x10, 0x80, 0x72, 0x63,
  0x3F, 0xCE, 0x5C, 0x17, 0xB2, 0x22, 0x26, 0x39, 0xB4, 0xC2, 0x10, 0x84,
  0x3E, 0x39, 0xB0, 0x46, 0x38, 0x2C, 0x9C, 0x0C, 0x61, 0x8A, 0x4B, 0xF1,
  0x84, 0x7A, 0x11, 0xE1, 0x8E, 0x5E, 0x33, 0x31, 0xE9, 0xCE, 0x5C, 0xF8,
  0x44, 0x22, 0x31, 0x10, 0x38, 0x96, 0x4E, 0x79, 0x34, 0x9E, 0x76, 0xE3,
  0x1F, 0x88, 0xDC, 0x4C, 0x01, 0xB0, 0x4C, 0x00, 0x34, 0x80, 0x0B, 0xA0,
  0xC1, 0x00, 0xF8, 0x3E, 0x40, 0xC0, 0xCE, 0xC0, 0x76, 0x42, 0x22, 0x10,
  0x0C, 0x18, 0x95, 0xEB, 0xAE, 0xF8, 0x1C, 0x18, 0x63, 0x8A, 0x69, 0xEC,
  0xA3, 0x39, 0x94, 0x5F, 0x4D, 0x1C, 0xFE, 0x39, 0x94, 0x50, 0x43, 0x14,
  0x9E, 0x79, 0xB4, 0x51, 0x45, 0x3C, 0xBC, 0x3E, 0xC1, 0x83, 0xC7, 0x88,
  0x10, 0x7C, 0x3E, 0xC1, 0x82, 0x27, 0x88, 0x10, 0x60, 0x39, 0x94, 0x50,
  0x5F, 0x34, 0xDE, 0x65, 0x14, 0x5F, 0x7D, 0x3C, 0xA2, 0x3C, 0x41, 0x04,
  0x10, 0xC3, 0x3E, 0x04, 0x10, 0x41, 0x0C, 0x3C, 0x9C, 0x26, 0xD9, 0x63,
  0x87, 0x0B, 0x32, 0x66, 0x23, 0x18, 0x84, 0x21, 0x1F, 0x66, 0xD9, 0xB3,
  0xA5, 0x4B, 0xB2, 0x44, 0x65, 0x96, 0x55, 0x5D, 0x7D, 0xA2, 0x39, 0x94,
  0x51, 0x47, 0x34, 0x9C, 0x39, 0x96, 0x51, 0x79, 0x04, 0x30, 0x39, 0x94,
  0x51, 0x47, 0x14, 0x9E, 0x0C, 0x39, 0x94, 0x51, 0x79, 0x6C, 0xB3, 0x39,
  0x94, 0x0C, 0x18, 0x1C, 0xDE, 0xFC, 0x82, 0x08, 0x21, 0x86, 0x10, 0xCF,
  0x28, 0xA2, 0x8A, 0x69, 0x38, 0x8E, 0x2D, 0xB4, 0x51, 0x86, 0x18, 0xA6,
  0xBA, 0xBA, 0xEB, 0x49, 0x24, 0x66, 0x48, 0xA1, 0xC3, 0x07, 0x12, 0x66,
  0x8F, 0x25, 0x94, 0x61, 0x86, 0x10, 0x7C, 0x10, 0x84, 0x31, 0x84, 0x7E,
  0x32, 0x26, 0x64, 0x44, 0x44, 0xE0, 0x93, 0x24, 0x92, 0x20, 0x31, 0x13,
  0x32, 0x22, 0x22, 0xE0, 0x33, 0x5D, 0xF8, 0x90, 0x39, 0x33, 0x92, 0xC9,
  0xE0, 0x21, 0x85, 0x9B, 0x4D, 0x34, 0xBE, 0x76, 0xE1, 0x09, 0x78, 0x08,
  0x5B, 0xB9, 0xCA, 0x5E, 0x76, 0xE3, 0xE9, 0x78, 0x00, 0xF2, 0x3E, 0x61,
  0x84, 0x10, 0x40, 0x35, 0xB4, 0xD3, 0x49, 0xE0, 0xBC, 0x21, 0x85, 0x9B,
  0x4D, 0x3C, 0xB2, 0x30, 0xF2, 0x22, 0x2F, 0x08, 0x0E, 0x31, 0x88, 0x42,
  0x17, 0x00, 0x21, 0x84, 0xD6, 0x71, 0xC5, 0xB3, 0x38, 0xC4, 0x21, 0x08,
  0x5F, 0x7D, 0x5D, 0x6D, 0xAE, 0xA0, 0x59, 0xB4, 0xD3, 0xCB, 0x20, 0x39,
  0x34, 0x53, 0x49, 0xE0, 0x59, 0xB4, 0xD3, 0x4B, 0xE8, 0x20, 0x6E, 0xE7,
  0x29, 0x78, 0x46, 0x5B, 0x51, 0x8C, 0x40, 0x74, 0xF0, 0x69, 0x78, 0x27,
  0xD8, 0x84, 0x21, 0xC0, 0xCC, 0x67, 0x39, 0x78, 0x8C, 0xF4, 0xE6, 0x30,
  0xAE, 0xAE, 0xBC, 0xB2, 0xC0, 0x44, 0xA3, 0x0C, 0x7B, 0x30, 0x46, 0x89,
  0xA1, 0xC3, 0x06, 0x08, 0x60, 0x7C, 0x21, 0x0C, 0x63, 0xE0, 0x12, 0x26,
  0x48, 0xC4, 0x44, 0x40, 0x55, 0x5A, 0xA0, 0x42, 0x22, 0x21, 0x26, 0x44,
  0x80, 0xF6, 0x60,
};

const GFXglyph RobotoMono_MediumItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 8, 6, 2, -8 },
  { 4, 3, 2, 6, 2, -8 },
  { 5, 6, 8, 6, 0, -8 },
  { 11, 5, 10, 6, 1, -9 },
  { 18, 5, 8, 6, 1, -8 },
  { 23, 6, 8, 6, 0, -8 },
  { 29, 1, 3, 6, 3, -8 },
  { 30, 3, 11, 6, 2, -9 },
  { 35, 4, 12, 6, 1, -9 },
  { 41, 5, 6, 6, 1, -8 },
  { 45, 5, 5, 6, 1, -6 },
  { 49, 2, 3, 6, 1, -1 },
  { 50, 5, 1, 6, 1, -4 },
  { 51, 2, 2, 6, 2, -2 },
  { 52, 5, 9, 6, 1, -8 },
  { 58, 5, 8, 6, 1, -8 },
  { 63, 4, 8, 6, 1, -8 },
  { 67, 6, 8, 6, 0, -8 },
  { 73, 6, 8, 6, 0, -8 },
  { 79, 6, 8, 6, 0, -8 },
  { 85, 5, 8, 6, 1, -8 },
  { 90, 5, 8, 6, 1, -8 },
  { 95, 5, 8, 6, 1, -8 },
  { 100, 6, 8, 6, 0, -8 },
  { 106, 5, 8, 6, 1, -8 },
  { 111, 3, 7, 6, 2, -7 },
  { 114, 3, 9, 6, 2, -7 },
  { 118, 5, 5, 6, 1, -6 },
  { 122, 5, 3, 6, 1, -5 },
  { 124, 6, 5, 6, 0, -6 },
  { 128, 5, 8, 6, 1, -8 },
  { 133, 6, 8, 6, 0, -8 },
  { 139, 6, 8, 6, 0, -8 },
  { 145, 6, 8, 6, 0, -8 },
  { 151, 6, 8, 6, 0, -8 },
  { 157, 6, 8, 6, 0, -8 },
  { 163, 7, 8, 6, 0, -8 },
  { 170, 7, 8, 6, 0, -8 },
  { 177, 6, 8, 6, 0, -8 },
  { 183, 6, 8, 6, 0, -8 },
  { 189, 6, 8, 6, 0, -8 },
  { 195, 6, 8, 6, 0, -8 },
  { 201, 7, 8, 6, 0, -8 },
  { 208, 5, 8, 6, 0, -8 },
  { 213, 7, 8, 6, 0, -8 },
  { 220, 6, 8, 6, 0, -8 },
  { 226, 6, 8, 6, 0, -8 },
  { 232, 6, 8, 6, 0, -8 },
  { 238, 6, 9, 6, 0, -8 },
  { 245, 6, 8, 6, 0, -8 },
  { 251, 6, 8, 6, 0, -8 },
  { 257, 6, 8, 6, 1, -8 },
  { 263, 6, 8, 6, 1, -8 },
  { 269, 6, 8, 6, 1, -8 },
  { 275, 6, 8, 6, 1, -8 },
  { 281, 7, 8, 6, 0, -8 },
  { 288, 6, 8, 6, 1, -8 },
  { 294, 6, 8, 6, 0, -8 },
  { 300, 4, 11, 6, 1, -9 },
  { 306, 3, 9, 6, 2, -8 },
  { 310, 4, 11, 6, 1, -9 },
  { 316, 4, 4, 6, 1, -8 },
  { 318, 5, 1, 6, 0, 0 },
  { 319, 2, 2, 6, 3, -8 },
  { 320, 6, 6, 6, 0, -6 },
  { 325, 6, 8, 6, 0, -8 },
  { 331, 5, 6, 6, 1, -6 },
  { 335, 5, 8, 6, 1, -8 },
  { 340, 5, 6, 6, 1, -6 },
  { 344, 6, 9, 6, 1, -9 },
  { 351, 6, 8, 6, 0, -6 },
  { 357, 6, 8, 6, 0, -8 },
  { 363, 4, 8, 6, 1, -8 },
  { 367, 5, 10, 6, 0, -8 },
  { 374, 6, 8, 6, 0, -8 },
  { 380, 5, 8, 6, 0, -8 },
  { 385, 6, 6, 6, 0, -6 },
  { 390, 6, 6, 6, 0, -6 },
  { 395, 6, 6, 6, 0, -6 },
  { 400, 6, 8, 6, 0, -6 },
  { 406, 5, 8, 6, 1, -6 },
  { 411, 5, 6, 6, 1, -6 },
  { 415, 5, 6, 6, 1, -6 },
  { 419, 5, 7, 6, 1, -7 },
  { 424, 5, 6, 6, 1, -6 },
  { 428, 5, 6, 6, 1, -6 },
  { 432, 6, 6, 6, 1, -6 },
  { 437, 6, 6, 6, 0, -6 },
  { 442, 7, 8, 6, 0, -6 },
  { 449, 6, 6, 6, 0, -6 },
  { 454, 4, 11, 6, 2, -9 },
  { 460, 2, 10, 6, 2, -8 },
  { 463, 4, 11, 6, 1, -9 },
  { 469, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_MediumItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic11pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_MEDIUMITALIC11PT7B_H_
