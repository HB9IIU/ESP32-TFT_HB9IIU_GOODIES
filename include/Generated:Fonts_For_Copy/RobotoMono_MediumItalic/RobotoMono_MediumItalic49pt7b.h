#ifndef _ROBOTOMONO_MEDIUMITALIC49PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81,
  0xE0, 0x00, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0xFB, 0xC1, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83,
  0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x01, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x07,
  0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xF0,
  0x1F, 0xC0, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x78,
  0x78, 0x10, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x78, 0xF0,
  0x78, 0xF0, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0x7F, 0xF3, 0xC0, 0x7F,
  0xE3, 0x80, 0x3F, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x01, 0xE7, 0xF8, 0x03, 0xCF, 0xFC, 0x03, 0xCF, 0xFE, 0x07,
  0x9E, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C,
  0x3C, 0x1E, 0x18, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF8, 0x0F, 0x87, 0xFF, 0x81, 0xE1, 0xFF, 0xF0, 0x7C, 0x7E, 0x3F,
  0x0F, 0x9F, 0xC7, 0xE1, 0xF3, 0xF0, 0x7E, 0x7C, 0xFC, 0x07, 0xEF, 0x9F,
  0x80, 0xFF, 0xE3, 0xF0, 0x0F, 0xFC, 0x7E, 0x01, 0xFF, 0x0F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xE7, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0x20, 0x00,
  0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0xBE, 0xF3, 0xCF, 0x3C, 0xE0, 0x00,
  0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x01, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x18, 0x0E,
  0x03, 0x3C, 0x1C, 0x3E, 0xFF, 0x39, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xEF, 0x00, 0x0F, 0x9E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x03,
  0xF0, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0x00, 0xF0, 0x04, 0x01, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x5F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x87, 0xC7,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0x87,
  0x80, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF1, 0xFC,
  0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0xFF,
  0x7E, 0x01, 0xFE, 0x7E, 0x07, 0xFE, 0x7E, 0x0F, 0xFE, 0x7E, 0x3F, 0xFE,
  0x7C, 0x7E, 0x7E, 0x7C, 0xFC, 0x7E, 0x7F, 0xF0, 0x7E, 0xFF, 0xE0, 0x7C,
  0xFF, 0x80, 0x7C, 0xFF, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x03, 0xF0,
  0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0x00, 0x7F, 0x03, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFC, 0x7E, 0xE0, 0x7C, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0x81,
  0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F,
  0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFE,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x81,
  0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x20, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x7F,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x07, 0xEF, 0xFC, 0x0F, 0xBF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x03, 0xF3,
  0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F,
  0xC7, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE1,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xE7, 0xF0, 0xFE, 0x07,
  0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xF0, 0xFF,
  0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xF7, 0xC0, 0xFF, 0x9F, 0x00,
  0x70, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7E, 0x00, 0x80, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x17, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0xFF,
  0x3F, 0x81, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x0F, 0x07,
  0xF0, 0xE1, 0xE1, 0xFF, 0x1C, 0x78, 0x7F, 0xE3, 0x8E, 0x1F, 0x1C, 0x73,
  0xC7, 0x87, 0x8E, 0x78, 0xF0, 0xE1, 0xCE, 0x3C, 0x1C, 0x3B, 0xC7, 0x83,
  0x87, 0x78, 0xE0, 0xF0, 0xEE, 0x3C, 0x1C, 0x1D, 0xC7, 0x83, 0x87, 0x78,
  0xF0, 0x70, 0xEF, 0x1E, 0x1E, 0x1D, 0xE3, 0xC3, 0xC3, 0x3C, 0x78, 0x70,
  0xE7, 0x8F, 0x1E, 0x3C, 0xF1, 0xFF, 0xFF, 0x1E, 0x1F, 0xFF, 0xC1, 0xC3,
  0xF3, 0xF0, 0x38, 0x10, 0x18, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x20, 0x00, 0xFC, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF0, 0x03, 0xF8,
  0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07,
  0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0x80, 0x7F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFC, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F,
  0x03, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xF0, 0x3F, 0xC0, 0x7C, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1,
  0xF8, 0x03, 0xF8, 0x7C, 0x01, 0xFC, 0x1F, 0x01, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0xFF,
  0x01, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xE7, 0xC0, 0x7F, 0xF3, 0xF0, 0x1F,
  0xFC, 0xFC, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xFC, 0x3F,
  0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xC0, 0x07, 0xF0,
  0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0x3F, 0x80, 0x07,
  0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0xF8, 0xFE, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFC,
  0x00, 0x07, 0xF8, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xBE,
  0x0F, 0xBC, 0xFB, 0xE0, 0xFB, 0xCF, 0x7C, 0x0F, 0xBD, 0xF7, 0xC1, 0xF3,
  0xDE, 0x7C, 0x1F, 0x3F, 0xE7, 0xC1, 0xF3, 0xFC, 0x7C, 0x1F, 0x3F, 0xCF,
  0xC1, 0xF3, 0xF8, 0xF8, 0x1F, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x0F, 0x83, 0xE1, 0xF1, 0xF8, 0x3E, 0x1E, 0x1F, 0x83, 0xE1, 0xE1,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0,
  0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07,
  0xF0, 0x03, 0xE0, 0x7F, 0x00, 0x3E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x80,
  0x7E, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0x80, 0x7E, 0x0F, 0xFC, 0x07, 0xC0,
  0xFF, 0xC0, 0x7C, 0x0F, 0xFC, 0x0F, 0xC0, 0xFB, 0xC0, 0xFC, 0x1F, 0xBE,
  0x0F, 0xC1, 0xFB, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F, 0x81, 0xF9, 0xE1, 0xF8,
  0x1F, 0x1F, 0x1F, 0x81, 0xF1, 0xF1, 0xF8, 0x3F, 0x0F, 0x1F, 0x83, 0xF0,
  0xF9, 0xF8, 0x3F, 0x0F, 0x9F, 0x03, 0xF0, 0xFB, 0xF0, 0x3E, 0x07, 0xBF,
  0x03, 0xE0, 0x7F, 0xF0, 0x7E, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0x7E,
  0x03, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7C, 0x03, 0xFE, 0x0F, 0xC0, 0x1F,
  0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF0,
  0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xF8, 0x01, 0xFC,
  0x0F, 0x80, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE1, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0xFF,
  0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xFC, 0x3F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE3, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x3F,
  0x7C, 0x0F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1,
  0xF8, 0x7E, 0x7C, 0x3F, 0x87, 0xC7, 0xC3, 0xF8, 0x7C, 0x7C, 0x3F, 0x87,
  0xC7, 0xC7, 0xF8, 0xF8, 0x7C, 0x7F, 0x8F, 0x87, 0xC7, 0xF8, 0xF8, 0x7C,
  0x7F, 0x9F, 0x87, 0xCF, 0x79, 0xF0, 0x7C, 0xF7, 0x9F, 0x07, 0xCF, 0x79,
  0xF0, 0x7D, 0xE7, 0xBE, 0x07, 0xDE, 0x7B, 0xE0, 0x7D, 0xE7, 0xBE, 0x07,
  0xFC, 0x7B, 0xE0, 0x7B, 0xC7, 0xFC, 0x07, 0xBC, 0x7F, 0xC0, 0x7F, 0xC7,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x83,
  0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xE3,
  0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x7C, 0x03, 0xEF, 0x80,
  0x78, 0xF0, 0x1F, 0x1E, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0x87,
  0xC0, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x07, 0x80,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xE0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0xC1, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFD, 0xF8, 0x1F, 0xE3, 0xF0,
  0x02, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF9, 0xFE, 0x00, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xF3, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x87,
  0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE3, 0xF0, 0x03,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xBF, 0xFC, 0x0F, 0x87, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFE, 0x3F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x3F, 0x00,
  0x3E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x8F,
  0xC0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0x8F, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83,
  0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x8F, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFE, 0x7C, 0x00, 0x7F, 0x9F,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x30, 0x7F, 0x00, 0x78, 0x3F, 0xC3, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0x10, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x3F, 0xFB,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xF8,
  0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x02, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x20, 0x01, 0xF8, 0x0C, 0x00, 0xFC, 0x07, 0x80, 0x7F, 0x03, 0xF8,
  0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0xFF, 0x00, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3E,
  0xFF, 0xFC, 0x1F, 0xF9, 0xFE, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0x07, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x3F, 0x80, 0x7C, 0x0F, 0xE0, 0x0F, 0x83, 0xF8, 0x01, 0xF0, 0xFE,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xDF, 0x87, 0xC0, 0x7B, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xEF, 0xF3, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0,
  0xF8, 0x7C, 0x1F, 0x1F, 0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0x1F, 0x1F, 0x07,
  0xC3, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E,
  0x3F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xE3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0x7E, 0x1F, 0x07,
  0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7C,
  0x3F, 0x0F, 0x8F, 0xC3, 0xE0, 0xF8, 0x07, 0xC7, 0xF8, 0x07, 0xC7, 0xFE,
  0x03, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF1, 0xFC, 0x1F, 0xC0, 0x7E, 0x3F, 0x80,
  0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7C, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xF3, 0xFC, 0x00, 0x7C, 0xFF, 0xC0, 0x0F, 0xBF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0,
  0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x3F, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F,
  0xF8, 0x07, 0xE3, 0xFC, 0x00, 0xFC, 0x0C, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0x81, 0xFF, 0xEF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x3F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0xF8,
  0x00, 0x20, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x87, 0xFC, 0x3E,
  0x3F, 0xF0, 0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xF0,
  0x61, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7F,
  0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x38, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00,
  0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x07, 0xF8, 0x7F, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF0,
  0x3F, 0xF9, 0xF0, 0x0F, 0xF1, 0xF0, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3E, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0x1F, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x07, 0xFF, 0x03, 0xC0, 0xFB, 0xE0, 0xF8,
  0x1F, 0x7C, 0x1F, 0x07, 0xCF, 0x83, 0xE0, 0xF9, 0xF0, 0xFC, 0x1F, 0x3E,
  0x1F, 0x87, 0xC7, 0xC7, 0xF0, 0xF8, 0xF8, 0xFE, 0x1F, 0x1F, 0x1D, 0xC7,
  0xC3, 0xE7, 0xB8, 0xF8, 0x7C, 0xF7, 0x1E, 0x0F, 0x9C, 0xE7, 0xC1, 0xE7,
  0x9C, 0xF8, 0x3C, 0xE3, 0x9E, 0x07, 0xBC, 0x73, 0xC0, 0xF7, 0x8E, 0xF8,
  0x1E, 0xE1, 0xDE, 0x03, 0xFC, 0x3B, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x00, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x00, 0xF3, 0xFF, 0xF0, 0x3E,
  0xFC, 0x7F, 0x8F, 0x9F, 0x07, 0xFF, 0xF3, 0xC0, 0x3F, 0xFC, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph RobotoMono_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 35, 29, 9, -35 },
  { 50, 15, 12, 29, 9, -37 },
  { 73, 29, 35, 29, 0, -35 },
  { 200, 26, 45, 29, 2, -40 },
  { 347, 24, 36, 29, 3, -35 },
  { 455, 27, 36, 29, 1, -35 },
  { 577, 6, 13, 29, 13, -37 },
  { 587, 16, 50, 29, 8, -39 },
  { 687, 17, 50, 29, 4, -39 },
  { 794, 23, 24, 29, 4, -35 },
  { 863, 25, 26, 29, 2, -29 },
  { 945, 9, 15, 29, 5, -6 },
  { 962, 19, 5, 29, 6, -18 },
  { 974, 8, 8, 29, 9, -7 },
  { 982, 25, 38, 29, 2, -35 },
  { 1101, 24, 36, 29, 3, -35 },
  { 1209, 16, 35, 29, 6, -35 },
  { 1279, 26, 35, 29, 0, -35 },
  { 1393, 25, 36, 29, 1, -35 },
  { 1506, 25, 35, 29, 1, -35 },
  { 1616, 26, 36, 29, 2, -35 },
  { 1733, 23, 36, 29, 2, -35 },
  { 1837, 25, 35, 29, 4, -35 },
  { 1947, 25, 36, 29, 2, -35 },
  { 2060, 22, 35, 29, 4, -35 },
  { 2157, 12, 28, 29, 9, -27 },
  { 2199, 14, 36, 29, 7, -27 },
  { 2262, 23, 22, 29, 3, -26 },
  { 2326, 24, 15, 29, 3, -23 },
  { 2371, 23, 22, 29, 2, -26 },
  { 2435, 21, 35, 29, 6, -35 },
  { 2527, 27, 35, 29, 1, -35 },
  { 2646, 26, 35, 29, -1, -35 },
  { 2760, 27, 35, 29, 1, -35 },
  { 2879, 26, 36, 29, 2, -35 },
  { 2996, 26, 35, 29, 1, -35 },
  { 3110, 28, 35, 29, 1, -35 },
  { 3233, 28, 35, 29, 1, -35 },
  { 3356, 26, 36, 29, 2, -35 },
  { 3473, 28, 35, 29, 1, -35 },
  { 3596, 26, 35, 29, 2, -35 },
  { 3710, 27, 36, 29, 2, -35 },
  { 3832, 31, 35, 29, 1, -35 },
  { 3968, 23, 35, 29, 1, -35 },
  { 4069, 28, 35, 29, 1, -35 },
  { 4192, 28, 35, 29, 1, -35 },
  { 4315, 26, 36, 29, 2, -35 },
  { 4432, 28, 35, 29, 1, -35 },
  { 4555, 26, 41, 29, 2, -35 },
  { 4689, 27, 35, 29, 1, -35 },
  { 4808, 26, 36, 29, 2, -35 },
  { 4925, 27, 35, 29, 4, -35 },
  { 5044, 27, 36, 29, 2, -35 },
  { 5166, 27, 35, 29, 4, -35 },
  { 5285, 28, 35, 29, 3, -35 },
  { 5408, 32, 35, 29, -1, -35 },
  { 5548, 26, 35, 29, 5, -35 },
  { 5662, 29, 35, 29, 0, -35 },
  { 5789, 17, 48, 29, 6, -40 },
  { 5891, 12, 38, 29, 9, -35 },
  { 5948, 17, 48, 29, 6, -40 },
  { 6050, 19, 19, 29, 5, -35 },
  { 6096, 22, 5, 29, 0, 0 },
  { 6110, 9, 6, 29, 13, -35 },
  { 6117, 23, 27, 29, 2, -26 },
  { 6195, 25, 38, 29, 1, -37 },
  { 6314, 23, 27, 29, 3, -26 },
  { 6392, 27, 38, 29, 2, -37 },
  { 6521, 24, 27, 29, 2, -26 },
  { 6602, 26, 38, 29, 4, -38 },
  { 6726, 26, 36, 29, 1, -26 },
  { 6843, 25, 37, 29, 1, -37 },
  { 6959, 22, 36, 29, 2, -36 },
  { 7058, 22, 47, 29, 1, -36 },
  { 7188, 27, 37, 29, 1, -37 },
  { 7313, 22, 37, 29, 2, -37 },
  { 7415, 28, 26, 29, -1, -26 },
  { 7506, 25, 26, 29, 1, -26 },
  { 7588, 24, 27, 29, 2, -26 },
  { 7669, 27, 36, 29, -1, -26 },
  { 7791, 25, 36, 29, 2, -26 },
  { 7904, 22, 26, 29, 5, -26 },
  { 7976, 24, 27, 29, 2, -26 },
  { 8057, 22, 33, 29, 4, -32 },
  { 8148, 24, 27, 29, 3, -26 },
  { 8229, 24, 26, 29, 4, -26 },
  { 8307, 27, 26, 29, 3, -26 },
  { 8395, 29, 26, 29, 0, -26 },
  { 8490, 30, 37, 29, 0, -26 },
  { 8629, 26, 26, 29, 1, -26 },
  { 8714, 19, 47, 29, 7, -38 },
  { 8826, 10, 45, 29, 9, -35 },
  { 8883, 19, 47, 29, 4, -38 },
  { 8995, 27, 11, 29, 0, -20 },
};

const GFXfont RobotoMono_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic49pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_MEDIUMITALIC49PT7B_H_
