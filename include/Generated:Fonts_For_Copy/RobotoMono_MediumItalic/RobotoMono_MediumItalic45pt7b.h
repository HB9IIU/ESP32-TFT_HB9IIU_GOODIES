#ifndef _ROBOTOMONO_MEDIUMITALIC45PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x3C, 0x3C, 0xF0,
  0xF3, 0x83, 0xDE, 0x0E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x1E, 0x70,
  0x73, 0xC1, 0xCF, 0x0F, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0xF0,
  0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x01,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x3C,
  0x3C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x01,
  0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE7, 0xE0,
  0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x33, 0xC3, 0xC3,
  0xDE, 0x1E, 0x1C, 0xE0, 0xF1, 0xC7, 0x87, 0x9E, 0x3C, 0x79, 0xE1, 0xFF,
  0xCE, 0x07, 0xFC, 0xF0, 0x1F, 0xCF, 0x00, 0x30, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC3, 0x00, 0x3C,
  0xFE, 0x01, 0xCF, 0xF8, 0x1E, 0xFF, 0xE1, 0xE7, 0x8F, 0x0E, 0x38, 0x38,
  0xF3, 0xC1, 0xCF, 0x1E, 0x0E, 0x70, 0xF0, 0xF0, 0x87, 0x87, 0x80, 0x3C,
  0x3C, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xF1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xC7, 0xE0, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0x1F, 0xFE, 0x0F, 0x3F, 0x3E, 0x1F,
  0x7E, 0x3F, 0x1F, 0x7C, 0x1F, 0x3E, 0xFC, 0x0F, 0xBE, 0xF8, 0x0F, 0xFC,
  0xF8, 0x07, 0xFC, 0xF8, 0x07, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0xFC, 0x0F, 0xF8, 0x7E,
  0x3C, 0xF3, 0xCF, 0x3D, 0xE7, 0x9E, 0x79, 0xE7, 0x3C, 0x00, 0x04, 0x00,
  0x1C, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x80, 0xE0, 0x6F, 0x07, 0x0F,
  0x7E, 0x7B, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xF3, 0x80, 0x0F, 0x1E, 0x00,
  0xF8, 0xF8, 0x0F, 0x83, 0xC0, 0xF8, 0x1F, 0x01, 0x80, 0x70, 0x04, 0x02,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xF1,
  0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x1F, 0x1F, 0x03, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xE0, 0xF8, 0x7E,
  0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0xBE, 0x03, 0xFD, 0xF0, 0x3F, 0xEF, 0x87,
  0xFF, 0x7C, 0x7C, 0xFF, 0xEF, 0xCF, 0xFE, 0xF8, 0x7D, 0xFF, 0x83, 0xEF,
  0xF0, 0x1F, 0x7F, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC1, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBF, 0x3E, 0xE0, 0xFA, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0xFE,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xC7, 0xF0, 0x2F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x7E, 0x03, 0xEF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xF0, 0xFE, 0x7F, 0x03, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x01, 0xF8, 0x7C, 0x1F, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xFC, 0x1F, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xBC, 0x0F, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x07,
  0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x80, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x8F, 0xC0, 0x3E, 0x00, 0xE0, 0x3E, 0x00,
  0x38, 0x1E, 0x00, 0x1C, 0x1E, 0x1F, 0x86, 0x1E, 0x1F, 0xF3, 0x8E, 0x1F,
  0xF1, 0xCF, 0x1E, 0x38, 0xE7, 0x1E, 0x1C, 0x73, 0x8E, 0x0E, 0x3B, 0xCF,
  0x0E, 0x1D, 0xC7, 0x07, 0x0E, 0xE3, 0x83, 0x86, 0x71, 0xC1, 0xC7, 0x79,
  0xE1, 0xC3, 0xB8, 0xF0, 0xE1, 0xDC, 0x78, 0x70, 0xCE, 0x3C, 0x78, 0xE7,
  0x1E, 0x7C, 0xE3, 0x87, 0xFF, 0xF1, 0xE3, 0xF7, 0xF0, 0x70, 0xF1, 0xF0,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x60,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7C,
  0x1F, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1,
  0xF0, 0x07, 0xE0, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x0F,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0x0F, 0x81,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xC3, 0xFC, 0x0F,
  0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x3E,
  0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7C,
  0x03, 0xF0, 0x7C, 0x07, 0xF0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x0F, 0xFC, 0xF8, 0x0F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xFC,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x08, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x7C,
  0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xC0, 0x7F,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x3F, 0x80, 0x01, 0xF7, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3,
  0xFE, 0x0F, 0x71, 0xFF, 0x87, 0xDC, 0x7B, 0xC1, 0xF7, 0xBE, 0xF0, 0x7D,
  0xEF, 0x7C, 0x1F, 0x7F, 0xDF, 0x07, 0x9F, 0xE7, 0xC1, 0xE7, 0xF9, 0xE0,
  0xF9, 0xFC, 0x78, 0x3E, 0x3F, 0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xE3, 0xE3,
  0xE0, 0xF8, 0xF0, 0xF8, 0x3C, 0x3C, 0x3C, 0x1F, 0x0E, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0x7C,
  0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xFC,
  0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3E, 0xF0, 0x7E, 0x07, 0xDE, 0x0F, 0xC0,
  0xFB, 0xE1, 0xF0, 0x1F, 0x3C, 0x3E, 0x03, 0xE7, 0x87, 0xC0, 0xFC, 0xF8,
  0xF8, 0x1F, 0x1F, 0x3F, 0x03, 0xE1, 0xE7, 0xC0, 0x7C, 0x3C, 0xF8, 0x0F,
  0x87, 0xDF, 0x03, 0xF0, 0x7B, 0xE0, 0x7E, 0x0F, 0x7C, 0x0F, 0x81, 0xFF,
  0x81, 0xF0, 0x3F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x81, 0xF8,
  0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x03, 0xF0,
  0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC1, 0xF8, 0x0F,
  0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F,
  0x83, 0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7C,
  0x01, 0xFC, 0x3E, 0x07, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0xC1, 0xF8, 0x0F,
  0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7C, 0x0F,
  0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF0,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x03,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x01,
  0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x1E, 0x0F,
  0xDF, 0x07, 0x83, 0xE7, 0xC3, 0xE0, 0xF9, 0xE0, 0xF8, 0x3E, 0x78, 0x3E,
  0x1F, 0x1E, 0x1F, 0x87, 0xC7, 0x87, 0xE1, 0xF1, 0xE1, 0xF8, 0x78, 0x78,
  0xFE, 0x3E, 0x1E, 0x3F, 0x8F, 0x87, 0x8F, 0xE3, 0xE1, 0xE3, 0xF8, 0xF0,
  0x79, 0xFE, 0x7C, 0x1E, 0x7F, 0x9F, 0x07, 0x9D, 0xE7, 0x83, 0xEF, 0x7B,
  0xE0, 0xFB, 0xDE, 0xF8, 0x3E, 0xE7, 0xBE, 0x0F, 0xF9, 0xEF, 0x03, 0xFE,
  0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00,
  0x7C, 0x0F, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x01,
  0xF1, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x08, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x08,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F,
  0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC3, 0xC3, 0xE1, 0xE3,
  0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x3E, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x7C,
  0x3E, 0x1E, 0x0F, 0x07, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x80, 0xFC, 0xF8, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x8F, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x3F, 0x80, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xEF, 0x83, 0xFC, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x7F, 0x00, 0x7D, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xF8, 0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF9, 0xF8, 0x03,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xF9, 0xFF, 0x81, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xC3, 0xF8, 0x7E,
  0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x1E, 0x7E, 0x00, 0x79, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x3E, 0x1F, 0x81, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x7E, 0x03, 0xFF, 0x7C, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xC3, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFB, 0xE0, 0x0F, 0xF3, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F,
  0xC3, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x1F, 0x7E, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x01, 0x07, 0xE0, 0x0C, 0x1F, 0xC0, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x3F, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFD, 0xF0,
  0x07, 0xF9, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x20, 0x03, 0xE0,
  0x70, 0x07, 0xE0, 0x78, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x3F, 0x80, 0x7C, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xEF, 0xFF, 0x87, 0xF8,
  0x7F, 0x0F, 0xE0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x7E,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xE1, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0,
  0x7C, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3E, 0x1F, 0xC0, 0x1F, 0x1F, 0xC0,
  0x0F, 0x9F, 0xC0, 0x07, 0xDF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x9F, 0x1F, 0x03, 0xEF,
  0xEF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xCF, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87,
  0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3E, 0x3E, 0x1F,
  0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xC1, 0xE3, 0xE1, 0xF0,
  0xF8, 0x0F, 0x8F, 0xE0, 0x1F, 0x7F, 0xE0, 0x3D, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3F,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x9F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xC3, 0xF0,
  0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFD, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xC7,
  0xC0, 0x3E, 0x1F, 0x83, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xF0, 0x03, 0xEF,
  0xFC, 0x03, 0xDF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xE0,
  0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3E, 0x3F, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x3E, 0x07, 0xFE, 0x78, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x3F,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0xF8,
  0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x7F, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFE, 0xF8, 0x07, 0xF9, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x87, 0xF8,
  0x7C, 0xFF, 0xC3, 0xEF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8,
  0x08, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F,
  0x81, 0xF8, 0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x08, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x3E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3F, 0x07, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0x7C,
  0x07, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x78,
  0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x03, 0xC7,
  0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x1E,
  0xF0, 0x7C, 0x3E, 0xF0, 0xFC, 0x3E, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x7C,
  0xF1, 0xFC, 0x7C, 0xF1, 0xDC, 0x78, 0xF1, 0xDC, 0xF8, 0xF3, 0xDC, 0xF0,
  0xF3, 0x9C, 0xF0, 0xF7, 0x9C, 0xF0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0,
  0xFF, 0x1D, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x0F,
  0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x30, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xF8, 0x01, 0xCF, 0xFE, 0x01, 0xE7, 0xFF, 0x80, 0xF7, 0xEF, 0xF0,
  0xF3, 0xC1, 0xFF, 0xF9, 0xC0, 0x3F, 0xF9, 0xE0, 0x0F, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x30, 0x00,
};

const GFXglyph RobotoMono_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 32, 26, 8, -32 },
  { 45, 14, 11, 26, 8, -34 },
  { 65, 27, 32, 26, 0, -32 },
  { 173, 23, 42, 26, 2, -37 },
  { 294, 21, 33, 26, 3, -33 },
  { 381, 24, 33, 26, 1, -33 },
  { 480, 6, 12, 26, 11, -34 },
  { 489, 15, 46, 26, 7, -36 },
  { 576, 15, 46, 26, 4, -36 },
  { 663, 21, 22, 26, 4, -32 },
  { 721, 22, 24, 26, 2, -27 },
  { 787, 9, 13, 26, 4, -5 },
  { 802, 18, 4, 26, 5, -16 },
  { 811, 7, 7, 26, 8, -7 },
  { 818, 23, 35, 26, 2, -32 },
  { 919, 21, 34, 26, 3, -33 },
  { 1009, 14, 32, 26, 6, -32 },
  { 1065, 24, 32, 26, 0, -32 },
  { 1161, 23, 32, 26, 1, -32 },
  { 1253, 24, 32, 26, 0, -32 },
  { 1349, 24, 33, 26, 2, -32 },
  { 1448, 21, 33, 26, 2, -32 },
  { 1535, 23, 32, 26, 3, -32 },
  { 1627, 23, 32, 26, 2, -32 },
  { 1719, 20, 32, 26, 4, -32 },
  { 1799, 10, 26, 26, 9, -26 },
  { 1832, 14, 34, 26, 6, -26 },
  { 1892, 21, 20, 26, 3, -24 },
  { 1945, 23, 14, 26, 2, -21 },
  { 1986, 21, 20, 26, 2, -24 },
  { 2039, 19, 33, 26, 6, -33 },
  { 2118, 25, 32, 26, 1, -32 },
  { 2218, 24, 32, 26, -1, -32 },
  { 2314, 25, 32, 26, 1, -32 },
  { 2414, 24, 34, 26, 2, -33 },
  { 2516, 24, 32, 26, 1, -32 },
  { 2612, 26, 32, 26, 1, -32 },
  { 2716, 26, 32, 26, 1, -32 },
  { 2820, 24, 33, 26, 2, -32 },
  { 2919, 27, 32, 26, 0, -32 },
  { 3027, 24, 32, 26, 2, -32 },
  { 3123, 25, 32, 26, 1, -32 },
  { 3223, 28, 32, 26, 1, -32 },
  { 3335, 21, 32, 26, 1, -32 },
  { 3419, 26, 32, 26, 1, -32 },
  { 3523, 27, 32, 26, 0, -32 },
  { 3631, 23, 32, 26, 2, -32 },
  { 3723, 25, 32, 26, 1, -32 },
  { 3823, 23, 38, 26, 2, -32 },
  { 3933, 25, 32, 26, 1, -32 },
  { 4033, 25, 32, 26, 1, -32 },
  { 4133, 26, 32, 26, 3, -32 },
  { 4237, 25, 33, 26, 2, -32 },
  { 4341, 24, 32, 26, 4, -32 },
  { 4437, 26, 32, 26, 3, -32 },
  { 4541, 29, 32, 26, -1, -32 },
  { 4657, 25, 32, 26, 4, -32 },
  { 4757, 26, 32, 26, 0, -32 },
  { 4861, 16, 44, 26, 6, -37 },
  { 4949, 11, 35, 26, 8, -32 },
  { 4998, 16, 44, 26, 5, -37 },
  { 5086, 17, 17, 26, 5, -32 },
  { 5123, 20, 4, 26, 0, 0 },
  { 5133, 8, 7, 26, 12, -33 },
  { 5140, 21, 24, 26, 2, -24 },
  { 5203, 23, 34, 26, 1, -34 },
  { 5301, 22, 25, 26, 2, -24 },
  { 5370, 24, 34, 26, 2, -34 },
  { 5472, 22, 24, 26, 2, -24 },
  { 5538, 24, 35, 26, 4, -35 },
  { 5643, 24, 33, 26, 1, -24 },
  { 5742, 23, 34, 26, 1, -34 },
  { 5840, 20, 33, 26, 2, -33 },
  { 5923, 20, 43, 26, 1, -33 },
  { 6031, 25, 34, 26, 1, -34 },
  { 6138, 20, 34, 26, 2, -34 },
  { 6223, 26, 24, 26, -1, -24 },
  { 6301, 23, 24, 26, 1, -24 },
  { 6370, 22, 25, 26, 2, -24 },
  { 6439, 24, 33, 26, -1, -24 },
  { 6538, 23, 33, 26, 2, -24 },
  { 6633, 21, 24, 26, 4, -24 },
  { 6696, 22, 24, 26, 2, -24 },
  { 6762, 20, 30, 26, 4, -30 },
  { 6837, 22, 25, 26, 3, -24 },
  { 6906, 23, 24, 26, 3, -24 },
  { 6975, 24, 24, 26, 3, -24 },
  { 7047, 26, 24, 26, 0, -24 },
  { 7125, 28, 34, 26, 0, -24 },
  { 7244, 24, 24, 26, 1, -24 },
  { 7316, 17, 43, 26, 7, -35 },
  { 7408, 10, 41, 26, 8, -32 },
  { 7460, 18, 43, 26, 4, -35 },
  { 7557, 25, 10, 26, 0, -18 },
};

const GFXfont RobotoMono_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic45pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_MEDIUMITALIC45PT7B_H_
