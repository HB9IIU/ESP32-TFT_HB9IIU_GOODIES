#ifndef _ROBOTOMONO_MEDIUMITALIC18PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x19, 0x8C, 0x60, 0x01, 0xCC, 0x00, 0x6D, 0x34,
  0xB2, 0xC8, 0x06, 0x40, 0x98, 0x12, 0x06, 0x43, 0xFE, 0xB2, 0x06, 0xC0,
  0x98, 0xFF, 0x86, 0xC0, 0x90, 0x32, 0x04, 0xC0, 0x06, 0x03, 0x07, 0xC7,
  0xF3, 0x1B, 0x0D, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xD8, 0x6C, 0x37, 0xF9,
  0xF0, 0x20, 0x10, 0x00, 0x70, 0x6C, 0x32, 0x5B, 0x4F, 0x63, 0x20, 0x20,
  0x30, 0x37, 0x16, 0xD2, 0x61, 0x20, 0xF0, 0x0F, 0x07, 0xC1, 0x98, 0x44,
  0x1B, 0x07, 0x81, 0xC0, 0xF3, 0x66, 0xF9, 0xEE, 0x39, 0xFE, 0x3D, 0xC0,
  0xFE, 0x80, 0x0C, 0x63, 0x0C, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x10, 0x60, 0x80, 0x10, 0x10, 0x30, 0x60, 0x40, 0x81, 0x82, 0x0C,
  0x18, 0x30, 0x60, 0x83, 0x04, 0x18, 0x61, 0x80, 0x08, 0x08, 0x18, 0xDB,
  0x7F, 0x38, 0x68, 0xCC, 0x44, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xF8,
  0x60, 0x30, 0x18, 0x1C, 0x00, 0x6D, 0xEC, 0xFE, 0x7F, 0x80, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x00, 0x1E, 0x1F, 0x9C, 0x6C, 0x36, 0x3B, 0x3F, 0x7F, 0xE6, 0xE3,
  0x61, 0xB1, 0xCF, 0xC7, 0xC0, 0x04, 0xF7, 0xF3, 0x18, 0x61, 0x86, 0x18,
  0xE3, 0x0C, 0x30, 0x0F, 0x1F, 0xCC, 0x6C, 0x30, 0x18, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1F, 0xFF, 0xF0, 0x0F, 0x07, 0xE3, 0x1C, 0xC3, 0x01,
  0x80, 0xE0, 0xE0, 0x0C, 0x01, 0xA0, 0x66, 0x39, 0xFC, 0x3E, 0x00, 0x01,
  0x81, 0xC1, 0xE0, 0xF0, 0xD8, 0xD8, 0xCC, 0xC6, 0x7F, 0xFF, 0xC1, 0xC0,
  0xC0, 0x60, 0x1F, 0x9F, 0xCC, 0x06, 0x06, 0x03, 0xF1, 0x9C, 0x06, 0x03,
  0x01, 0xB0, 0xDF, 0xC7, 0xC0, 0x07, 0x1E, 0x38, 0x70, 0x60, 0xDE, 0xE7,
  0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x7C, 0x7F, 0xDF, 0xE0, 0x18, 0x0C, 0x07,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x00, 0x1E,
  0x1F, 0x9C, 0x6C, 0x36, 0x39, 0xB8, 0xF8, 0xCE, 0xC3, 0x61, 0xB0, 0xDF,
  0xC7, 0xC0, 0x1E, 0x1F, 0x98, 0xCC, 0x66, 0x1F, 0x19, 0x8C, 0xFE, 0x3B,
  0x03, 0x03, 0x8F, 0x87, 0x00, 0x31, 0xCC, 0x00, 0x00, 0x0C, 0xE3, 0x00,
  0x11, 0xCE, 0x00, 0x00, 0x00, 0x63, 0x19, 0x8C, 0x00, 0x00, 0x81, 0x87,
  0xCF, 0x0C, 0x03, 0xC0, 0x7C, 0x0C, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xEF, 0xF0, 0x40, 0x70, 0x7C, 0x0F, 0x03, 0x1E, 0xF8, 0xC0, 0x80, 0x3E,
  0x7F, 0xE3, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x00, 0x00, 0x70, 0x70,
  0x07, 0x07, 0xE1, 0x04, 0x9D, 0x6D, 0x56, 0x55, 0x35, 0x49, 0xD2, 0xD7,
  0xE4, 0x01, 0x88, 0x3E, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x83,
  0x60, 0xC8, 0x63, 0x1F, 0xCF, 0xF3, 0x0D, 0x83, 0xE0, 0xC0, 0x1F, 0x0F,
  0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0xE7, 0xF1, 0x86, 0x60, 0xD8, 0x76, 0x19,
  0xFE, 0xFE, 0x00, 0x1E, 0x1F, 0x98, 0x6C, 0x3C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x61, 0xB0, 0xDF, 0xC7, 0xC0, 0x3E, 0x0F, 0xE3, 0x18, 0xC3, 0x30,
  0xCC, 0x36, 0x0D, 0x83, 0x61, 0xD8, 0x66, 0x31, 0xFC, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xE3, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0F, 0xE3, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x1E,
  0x1F, 0xDC, 0x6C, 0x3C, 0x06, 0x03, 0x01, 0x9F, 0xC3, 0x61, 0xB0, 0xCF,
  0xE3, 0xE0, 0x30, 0x66, 0x18, 0xC3, 0x18, 0x63, 0x0C, 0xE1, 0x9F, 0xF3,
  0x0C, 0x61, 0x8C, 0x31, 0x86, 0x60, 0xCC, 0x30, 0x3F, 0x9F, 0xC3, 0x01,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1F, 0xCF, 0xE0, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x30, 0xCC,
  0x73, 0xF8, 0x7C, 0x00, 0x18, 0x73, 0x0C, 0x31, 0xC3, 0x38, 0x37, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x30, 0x63, 0x06, 0x18, 0xE1, 0xC0,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0x38, 0xE7, 0x1C, 0xE7, 0x1C, 0xE3, 0xBC, 0x5D, 0x9B, 0xB3, 0x66,
  0x6D, 0x8C, 0x31, 0x86, 0x60, 0xCC, 0x18, 0x38, 0xE7, 0x18, 0xE3, 0x1C,
  0x63, 0xCC, 0x79, 0x99, 0x73, 0x3C, 0x67, 0x8C, 0xF1, 0x8E, 0x71, 0xCC,
  0x30, 0x1E, 0x1F, 0x9C, 0x6C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1,
  0xB1, 0xDF, 0xC7, 0xC0, 0x1F, 0x07, 0xF8, 0xC3, 0x18, 0x73, 0x0C, 0x61,
  0x8F, 0xF3, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x1E, 0x1F,
  0x9C, 0x6C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xB0, 0xDF, 0xC7,
  0xE0, 0x38, 0x0C, 0x1F, 0x0F, 0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0xF9,
  0xFC, 0x63, 0x18, 0xC6, 0x31, 0x8E, 0xE1, 0x80, 0x1E, 0x1F, 0xD8, 0x6C,
  0x36, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0x61, 0xF0, 0xDF, 0xE7, 0xE0, 0x7F,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x00, 0x60, 0xD8, 0x66, 0x19, 0x86, 0x61, 0x98, 0x6C,
  0x1B, 0x0C, 0xC3, 0x30, 0xCC, 0x73, 0xF8, 0x7C, 0x00, 0xC1, 0xE1, 0xF0,
  0xD8, 0x6C, 0x66, 0x31, 0xB0, 0xD8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x00,
  0x44, 0xD3, 0x34, 0xCF, 0x32, 0xDD, 0xB7, 0x6D, 0x5B, 0xD4, 0xF7, 0x39,
  0xCE, 0x63, 0x98, 0xC6, 0x00, 0x30, 0x67, 0x18, 0x67, 0x0C, 0xC0, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1F, 0x06, 0x61, 0xCC, 0x30, 0xCC, 0x18, 0xC1,
  0xF0, 0xEE, 0x31, 0x98, 0x66, 0x1B, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x00, 0x3F, 0xE7, 0xF8, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x7F, 0xCF, 0xF8, 0x1E, 0x38,
  0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0xF1, 0xE0, 0xC2, 0x18, 0xC6, 0x31, 0x84, 0x31, 0x8C, 0x61, 0x0C, 0x1E,
  0x38, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C,
  0x18, 0xF1, 0xE0, 0x08, 0x38, 0x71, 0xE6, 0x4C, 0xF1, 0x80, 0xFF, 0xFF,
  0xCC, 0x1C, 0x7F, 0x63, 0x03, 0x3F, 0xFF, 0xC3, 0xC6, 0xFE, 0x7E, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x61, 0xFC, 0xC6, 0x63, 0x61, 0xB0, 0xD8, 0x6C,
  0x37, 0xF6, 0xF0, 0x1C, 0x3F, 0x63, 0xE3, 0xC0, 0xC0, 0xC0, 0xC3, 0x7E,
  0x7C, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x19, 0x8F, 0xE6, 0x3B, 0x8C, 0xC3,
  0x30, 0xCC, 0x33, 0x1C, 0xFE, 0x1F, 0x80, 0x0C, 0x1F, 0x98, 0xDC, 0x2F,
  0xF7, 0xFB, 0x01, 0x84, 0x7F, 0x1F, 0x00, 0x07, 0x8F, 0xC6, 0x03, 0x0F,
  0xF7, 0xF8, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x0C,
  0xC7, 0xF3, 0x1D, 0xC6, 0x61, 0x98, 0x66, 0x19, 0x86, 0x7F, 0x8F, 0xC0,
  0x31, 0x1C, 0xFE, 0x0E, 0x00, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x31, 0xFC,
  0xC6, 0x63, 0x61, 0xB0, 0xD8, 0x6C, 0x36, 0x1F, 0x18, 0x06, 0x06, 0x00,
  0x3C, 0x7C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0xFF, 0xFF, 0x03, 0x01,
  0xC0, 0x03, 0xE1, 0xF0, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0xF0, 0xF0, 0x00, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0xCC, 0x63, 0x70, 0xF8, 0x7C, 0x1F, 0x07, 0x61, 0x9C, 0x63, 0x38, 0xE0,
  0x3E, 0x3E, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0xFF, 0xFF, 0x6D, 0x9F, 0xF6, 0x6D, 0xB3, 0x6C, 0xD3, 0x3C, 0xCB, 0x36,
  0xC9, 0xB6, 0x60, 0x33, 0x1F, 0xCC, 0x66, 0x36, 0x1B, 0x0D, 0x86, 0xC3,
  0x61, 0xF1, 0x80, 0x1C, 0x1F, 0x98, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86,
  0xFE, 0x3E, 0x00, 0x36, 0x1F, 0xCC, 0x66, 0x36, 0x1B, 0x0D, 0x86, 0xC7,
  0x7F, 0x3F, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x19, 0x9F, 0xD8, 0xFC, 0x6C,
  0x36, 0x1B, 0x0D, 0x86, 0xFE, 0x3F, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x67,
  0x7F, 0x79, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1C, 0x1F, 0x98,
  0xCC, 0x17, 0x81, 0xF0, 0x1D, 0x86, 0xE7, 0x3E, 0x00, 0x38, 0x30, 0xFF,
  0xFE, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x7C, 0x3C, 0x61, 0xB0, 0xD8,
  0x6C, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xFF, 0x3F, 0x00, 0xC1, 0xB0, 0xD8,
  0xCC, 0x66, 0x61, 0x30, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0xCC, 0xF3, 0x3D,
  0xDB, 0x76, 0xDD, 0x3F, 0xCE, 0x73, 0x98, 0xE6, 0x31, 0x80, 0x30, 0xE6,
  0x38, 0x6E, 0x0D, 0x80, 0xE0, 0x1C, 0x07, 0x81, 0x98, 0x73, 0x1C, 0x30,
  0x60, 0x66, 0x18, 0xC3, 0x18, 0xC3, 0x38, 0x36, 0x07, 0x80, 0xF0, 0x1C,
  0x01, 0x80, 0x60, 0x18, 0x0F, 0x01, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x38,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xBF, 0xE0, 0x06, 0x18, 0x60,
  0xC1, 0x86, 0x0C, 0x38, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x30,
  0x11, 0x33, 0x22, 0x22, 0x66, 0x64, 0x44, 0x4C, 0xC0, 0x30, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x0E, 0x30, 0xC1, 0x83, 0x06, 0x18, 0x30, 0xC0,
  0x78, 0x5F, 0x3C, 0x78, 0x0C,
};

const GFXglyph RobotoMono_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 6, 5, 11, 3, -14 },
  { 14, 11, 13, 11, 0, -13 },
  { 32, 9, 17, 11, 1, -15 },
  { 52, 9, 13, 11, 1, -13 },
  { 67, 10, 13, 11, 0, -13 },
  { 84, 2, 5, 11, 5, -14 },
  { 86, 6, 18, 11, 3, -14 },
  { 100, 7, 18, 11, 1, -14 },
  { 116, 8, 9, 11, 2, -13 },
  { 125, 9, 10, 11, 1, -11 },
  { 137, 3, 5, 11, 2, -2 },
  { 139, 7, 1, 11, 2, -6 },
  { 140, 3, 3, 11, 3, -3 },
  { 142, 9, 14, 11, 1, -13 },
  { 158, 9, 13, 11, 1, -13 },
  { 173, 6, 13, 11, 2, -13 },
  { 183, 9, 13, 11, 0, -13 },
  { 198, 10, 13, 11, 0, -13 },
  { 215, 9, 13, 11, 0, -13 },
  { 230, 9, 13, 11, 1, -13 },
  { 245, 8, 13, 11, 1, -13 },
  { 258, 10, 13, 11, 1, -13 },
  { 275, 9, 13, 11, 1, -13 },
  { 290, 9, 13, 11, 1, -13 },
  { 305, 5, 10, 11, 3, -10 },
  { 312, 5, 13, 11, 3, -10 },
  { 321, 9, 9, 11, 1, -10 },
  { 332, 9, 5, 11, 1, -8 },
  { 338, 8, 9, 11, 1, -10 },
  { 347, 8, 13, 11, 2, -13 },
  { 360, 10, 13, 11, 0, -13 },
  { 377, 10, 13, 11, -1, -13 },
  { 394, 10, 13, 11, 0, -13 },
  { 411, 9, 13, 11, 1, -13 },
  { 426, 10, 13, 11, 0, -13 },
  { 443, 11, 13, 11, 0, -13 },
  { 461, 11, 13, 11, 0, -13 },
  { 479, 9, 13, 11, 1, -13 },
  { 494, 11, 13, 11, 0, -13 },
  { 512, 9, 13, 11, 1, -13 },
  { 527, 10, 13, 11, 1, -13 },
  { 544, 12, 13, 11, 0, -13 },
  { 564, 8, 13, 11, 1, -13 },
  { 577, 11, 13, 11, 0, -13 },
  { 595, 11, 13, 11, 0, -13 },
  { 613, 9, 13, 11, 1, -13 },
  { 628, 11, 13, 11, 0, -13 },
  { 646, 9, 15, 11, 1, -13 },
  { 663, 10, 13, 11, 0, -13 },
  { 680, 9, 13, 11, 1, -13 },
  { 695, 10, 13, 11, 1, -13 },
  { 712, 10, 13, 11, 1, -13 },
  { 729, 9, 13, 11, 2, -13 },
  { 744, 10, 13, 11, 1, -13 },
  { 761, 11, 13, 11, 0, -13 },
  { 779, 10, 13, 11, 2, -13 },
  { 796, 11, 13, 11, 0, -13 },
  { 814, 7, 18, 11, 2, -15 },
  { 830, 5, 14, 11, 3, -13 },
  { 839, 7, 18, 11, 2, -15 },
  { 855, 7, 7, 11, 2, -13 },
  { 862, 8, 2, 11, 0, 0 },
  { 864, 3, 2, 11, 5, -13 },
  { 865, 8, 10, 11, 1, -10 },
  { 875, 9, 14, 11, 0, -14 },
  { 891, 8, 10, 11, 1, -10 },
  { 901, 10, 14, 11, 1, -14 },
  { 919, 9, 10, 11, 1, -10 },
  { 931, 9, 14, 11, 2, -14 },
  { 947, 10, 14, 11, 0, -10 },
  { 965, 9, 14, 11, 0, -14 },
  { 981, 8, 13, 11, 1, -13 },
  { 994, 9, 17, 11, 0, -13 },
  { 1014, 10, 14, 11, 0, -14 },
  { 1032, 8, 14, 11, 1, -14 },
  { 1046, 10, 10, 11, 0, -10 },
  { 1059, 9, 10, 11, 0, -10 },
  { 1071, 9, 10, 11, 1, -10 },
  { 1083, 9, 14, 11, 0, -10 },
  { 1099, 9, 14, 11, 1, -10 },
  { 1115, 8, 10, 11, 2, -10 },
  { 1125, 9, 10, 11, 1, -10 },
  { 1137, 8, 12, 11, 2, -12 },
  { 1149, 9, 10, 11, 1, -10 },
  { 1161, 9, 10, 11, 1, -10 },
  { 1173, 10, 10, 11, 1, -10 },
  { 1186, 11, 10, 11, 0, -10 },
  { 1200, 11, 14, 11, 0, -10 },
  { 1220, 10, 10, 11, 0, -10 },
  { 1233, 7, 17, 11, 3, -14 },
  { 1248, 4, 17, 11, 3, -13 },
  { 1257, 7, 17, 11, 2, -14 },
  { 1272, 10, 4, 11, 0, -7 },
};

const GFXfont RobotoMono_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic18pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_MEDIUMITALIC18PT7B_H_
