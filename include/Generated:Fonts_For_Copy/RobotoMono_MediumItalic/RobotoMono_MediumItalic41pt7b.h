#ifndef _ROBOTOMONO_MEDIUMITALIC41PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x0F, 0xC3, 0xF0,
  0x78, 0x00, 0x3C, 0x79, 0xC3, 0xCE, 0x1E, 0xF0, 0xF7, 0x87, 0x3C, 0x39,
  0xC1, 0xCE, 0x1E, 0x70, 0xE7, 0x87, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x70, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x10, 0xE0, 0xE0, 0x00, 0xE1, 0xE0, 0x01, 0xE1,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0x83,
  0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x7E, 0x0F,
  0x83, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xC7,
  0x80, 0x3E, 0x3E, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xDE, 0x00,
  0x78, 0xF0, 0x87, 0x0F, 0x0E, 0x70, 0xF1, 0xC7, 0x0E, 0x3C, 0x70, 0xE3,
  0x87, 0x1E, 0x70, 0x7F, 0xCF, 0x03, 0xFC, 0xE0, 0x1F, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xCF, 0xC0, 0x39, 0xFE, 0x07, 0xBF, 0xF0, 0x73, 0x87, 0x0E, 0x78, 0x71,
  0xC7, 0x87, 0x3C, 0x70, 0x70, 0x87, 0x07, 0x00, 0x78, 0xF0, 0x07, 0xDE,
  0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x80, 0x78, 0x3E,
  0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF8, 0x3C, 0xFF, 0xE0, 0xF3, 0xE7, 0xC7, 0xDF, 0x1F, 0x1E,
  0xF8, 0x3E, 0x7B, 0xE0, 0x7F, 0xEF, 0x81, 0xFF, 0x3E, 0x03, 0xF8, 0xF8,
  0x0F, 0xE3, 0xF0, 0x3F, 0x07, 0xF7, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFD,
  0xF0, 0x3F, 0xC7, 0xE0, 0x3C, 0xF3, 0x8E, 0x79, 0xE7, 0x9C, 0x71, 0xCF,
  0x00, 0x00, 0x04, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x81, 0xE0, 0x5C, 0x38, 0x7F, 0xE7, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xF8, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x1E, 0xF0, 0x07, 0xCE, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x70, 0x08, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x70, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC,
  0xFC, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80,
  0x3D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0x81, 0xFE, 0xF0, 0x7F, 0xFE, 0x3E,
  0xFF, 0xCF, 0x9F, 0xFF, 0xE3, 0xDF, 0xF0, 0x7B, 0xFC, 0x1F, 0x7E, 0x03,
  0xEF, 0x80, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0xF8, 0x0F,
  0x1F, 0x03, 0xE1, 0xF9, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x3F, 0xF7, 0xFF, 0xBF, 0xFB, 0xF3,
  0xDC, 0x1E, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0x3F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xC0, 0xFC,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0xEF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0F,
  0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0x7C, 0x78,
  0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x7C, 0x5F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xBF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0x7C, 0x0F, 0x83, 0xF9, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF3, 0xF8, 0x3E, 0xFF, 0x87, 0xFF, 0xF8, 0xFF,
  0xFF, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3D, 0xF0, 0x07, 0xBE, 0x01, 0xF3, 0xC0,
  0x7E, 0x7C, 0x1F, 0x87, 0xEF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xE7, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E,
  0x0F, 0x87, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x83, 0xF0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0xF8, 0x03, 0xCF, 0x80,
  0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0xF8, 0x7F,
  0x7F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xF9, 0xF8, 0x7E, 0x0F, 0x8F,
  0x80, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7F,
  0x3F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xF3, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x0F, 0xC7,
  0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x1F, 0xCF, 0xC7, 0xE1, 0xE0, 0x03,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7F, 0xBF, 0x9F, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x03, 0xC0, 0x78,
  0x03, 0x81, 0xE0, 0x03, 0x83, 0x87, 0xC7, 0x0E, 0x1F, 0xC6, 0x1C, 0x7F,
  0xCC, 0x71, 0xE3, 0x1C, 0xE7, 0x8E, 0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x38,
  0xCE, 0x70, 0x61, 0xB8, 0xE1, 0xC7, 0x71, 0xC3, 0x8E, 0xE3, 0x87, 0x1D,
  0xC7, 0x0C, 0x33, 0x8E, 0x38, 0xE7, 0x1C, 0xF1, 0x8E, 0x3F, 0xFF, 0x1C,
  0x7E, 0xFC, 0x38, 0x30, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x08, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1E, 0x00,
  0xFC, 0x78, 0x07, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFE, 0x3F, 0x0F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC3, 0xE0, 0x7E, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0x83, 0xF0,
  0x3C, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0x80,
  0x7E, 0x1E, 0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x7F, 0x07, 0xC0,
  0xFC, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x79, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x07, 0xFE, 0xF8, 0x3F, 0xF7, 0xC1, 0xFF, 0xBE, 0x0F, 0xFD, 0xE0,
  0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0xC1, 0xE0, 0x0F, 0xC0, 0xF8, 0x07,
  0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF0,
  0x7E, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xEF,
  0xC0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x1E, 0xE3, 0xFC, 0x1E,
  0xE7, 0xBC, 0x1E, 0xE7, 0xBC, 0x1E, 0xF7, 0x7C, 0x1E, 0xFF, 0x7C, 0x3E,
  0xFE, 0x78, 0x3E, 0xFE, 0x78, 0x3C, 0x7C, 0x78, 0x3C, 0x7C, 0x78, 0x3C,
  0x78, 0xF8, 0x3C, 0x78, 0xF8, 0x7C, 0x70, 0xF0, 0x7C, 0x70, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8,
  0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x1E, 0x07, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F,
  0xF0, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3C, 0x0F, 0x78, 0x3C, 0x1F,
  0x38, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F,
  0x1E, 0x78, 0x1E, 0x1E, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF0, 0x3C, 0x07, 0xF0, 0x7C,
  0x07, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x78,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xF7, 0xC0, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1E,
  0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xBC,
  0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0,
  0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xE0, 0x1F, 0x83, 0xC0, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0x81, 0xF8,
  0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x3C, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x1F, 0x81, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x87,
  0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0,
  0x0F, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x38, 0x3E, 0xF0, 0xF0, 0x7F, 0xE1, 0xE0, 0xF7,
  0xC3, 0xC1, 0xEF, 0x8F, 0x87, 0xDF, 0x1F, 0x0F, 0x3E, 0x3E, 0x1E, 0x7C,
  0xFC, 0x3C, 0xF1, 0xF8, 0xF9, 0xE3, 0xF1, 0xE3, 0xC7, 0xE3, 0xC7, 0x9F,
  0xCF, 0x8F, 0x3B, 0x9E, 0x1E, 0x77, 0x3C, 0x3D, 0xEE, 0x78, 0x7B, 0x9D,
  0xF0, 0xF7, 0x3B, 0xC1, 0xFE, 0x77, 0x83, 0xF8, 0xEF, 0x07, 0xF1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80,
  0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x79, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xE7, 0xC0,
  0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xE0, 0xF0, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0x9C, 0x07,
  0x9C, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x3C, 0x0F, 0x7C,
  0x0F, 0xF8, 0x0F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x0F, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x1E, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3C, 0x78,
  0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x7F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFE, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF1, 0xF0, 0x0F, 0x7F, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC,
  0x3F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3E,
  0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xBF, 0xF0, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x00,
  0x7B, 0xE0, 0x0F, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x78, 0x07,
  0xCF, 0x81, 0xF1, 0xFC, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0xE3, 0xC0, 0x7F, 0xDF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFC, 0x1F, 0xC3, 0xE0, 0x3F, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F,
  0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xDE, 0x00,
  0xFE, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0x83, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0x78,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0x07, 0xE0, 0x78,
  0x3F, 0xBF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xE1, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x7C, 0x0F, 0xFD, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7C, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x1F, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFB, 0xC0, 0x1F, 0xDF, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x20, 0x0F, 0x81, 0xC0, 0x7E, 0x0F, 0x87, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0xFC, 0x07, 0xCF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xE1,
  0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F,
  0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x02, 0x0F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xF0, 0xF0, 0x1F, 0x87, 0xC0, 0xFC,
  0x1F, 0x07, 0xE0, 0x7C, 0x3F, 0x01, 0xF1, 0xF8, 0x07, 0x8F, 0xC0, 0x3E,
  0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3F, 0x01,
  0xF0, 0x7C, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x8F, 0x80, 0x3E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x08, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x78, 0x78, 0x3D, 0xFB, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF1, 0xE3, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x9E,
  0x1E, 0x1F, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF3, 0xE3,
  0xE1, 0xE7, 0x87, 0xC7, 0xCF, 0x0F, 0x0F, 0x9E, 0x1E, 0x1E, 0x3C, 0x3C,
  0x3C, 0xF8, 0x78, 0x79, 0xF1, 0xF0, 0xF3, 0xC3, 0xE3, 0xE7, 0x87, 0x87,
  0xCF, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x80, 0xFB, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x78,
  0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x7C,
  0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80,
  0x3C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3C, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1E, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xC7,
  0xC0, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x03, 0xCF, 0xC0, 0x1F, 0x7F, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xE0, 0xFC, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E,
  0x07, 0xC1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x3E, 0xFF, 0xC0, 0xF9, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0xF0, 0x7F, 0xEF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x07, 0xF3,
  0xE0, 0x3F, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xF8, 0x7F, 0x7F, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x0F, 0x0F, 0xE3, 0xE7, 0xFC, 0x7D, 0xFF, 0x0F, 0x7F, 0xE1,
  0xFF, 0xFC, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xCF, 0x00, 0x3C, 0xF8,
  0x03, 0xCF, 0x80, 0x7C, 0x7E, 0x1F, 0xC7, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C,
  0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80,
  0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3,
  0xE0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0x78, 0x0F, 0xE3,
  0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F,
  0x3E, 0x00, 0x79, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x38, 0x3F, 0xF0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF7, 0x83, 0xC3, 0xEF, 0x0F,
  0x87, 0x9E, 0x1F, 0x0F, 0x3C, 0x3E, 0x3E, 0x78, 0xFC, 0x78, 0x71, 0xF8,
  0xF0, 0xE7, 0xF1, 0xC1, 0xCE, 0xE7, 0x83, 0x9D, 0xCF, 0x07, 0x71, 0x9C,
  0x0E, 0xE3, 0x78, 0x1D, 0xC6, 0xF0, 0x3F, 0x0D, 0xC0, 0x7E, 0x1F, 0x80,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xE3, 0xF0, 0x01, 0xF7, 0xE0,
  0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xEF, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07,
  0xE0, 0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E,
  0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x00, 0x03,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x3C, 0xFF,
  0xE0, 0x7B, 0xFF, 0xE1, 0xE7, 0x87, 0xFF, 0xDE, 0x07, 0xFF, 0x3C, 0x03,
  0xFE, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 10, 29, 24, 7, -29 },
  { 38, 13, 10, 24, 7, -31 },
  { 55, 24, 29, 24, 0, -29 },
  { 142, 21, 38, 24, 2, -34 },
  { 242, 20, 30, 24, 2, -30 },
  { 317, 22, 30, 24, 1, -30 },
  { 400, 6, 11, 24, 10, -31 },
  { 409, 14, 42, 24, 6, -33 },
  { 483, 14, 42, 24, 3, -33 },
  { 557, 19, 20, 24, 4, -29 },
  { 605, 20, 21, 24, 2, -24 },
  { 658, 8, 13, 24, 4, -5 },
  { 671, 16, 4, 24, 5, -15 },
  { 679, 7, 6, 24, 7, -6 },
  { 685, 21, 32, 24, 2, -29 },
  { 769, 19, 30, 24, 3, -30 },
  { 841, 13, 29, 24, 5, -29 },
  { 889, 21, 30, 24, 0, -30 },
  { 968, 21, 30, 24, 1, -30 },
  { 1047, 22, 29, 24, 0, -29 },
  { 1127, 21, 29, 24, 2, -29 },
  { 1204, 19, 29, 24, 2, -29 },
  { 1273, 21, 29, 24, 3, -29 },
  { 1350, 20, 30, 24, 2, -30 },
  { 1425, 19, 30, 24, 3, -30 },
  { 1497, 9, 23, 24, 8, -23 },
  { 1523, 12, 31, 24, 6, -23 },
  { 1570, 19, 19, 24, 3, -22 },
  { 1616, 20, 13, 24, 2, -19 },
  { 1649, 19, 19, 24, 2, -22 },
  { 1695, 18, 30, 24, 5, -30 },
  { 1763, 23, 29, 24, 1, -29 },
  { 1847, 22, 29, 24, -1, -29 },
  { 1927, 22, 29, 24, 1, -29 },
  { 2007, 21, 30, 24, 2, -30 },
  { 2086, 22, 29, 24, 1, -29 },
  { 2166, 23, 29, 24, 1, -29 },
  { 2250, 24, 29, 24, 1, -29 },
  { 2337, 21, 30, 24, 2, -30 },
  { 2416, 24, 29, 24, 0, -29 },
  { 2503, 22, 29, 24, 1, -29 },
  { 2583, 23, 29, 24, 1, -29 },
  { 2667, 26, 29, 24, 1, -29 },
  { 2762, 19, 29, 24, 1, -29 },
  { 2831, 24, 29, 24, 1, -29 },
  { 2918, 24, 29, 24, 0, -29 },
  { 3005, 21, 30, 24, 2, -30 },
  { 3084, 23, 29, 24, 1, -29 },
  { 3168, 21, 35, 24, 2, -30 },
  { 3260, 23, 29, 24, 1, -29 },
  { 3344, 23, 30, 24, 1, -30 },
  { 3431, 23, 29, 24, 3, -29 },
  { 3515, 22, 29, 24, 2, -29 },
  { 3595, 22, 29, 24, 4, -29 },
  { 3675, 23, 29, 24, 3, -29 },
  { 3759, 27, 29, 24, -1, -29 },
  { 3857, 22, 29, 24, 4, -29 },
  { 3937, 24, 29, 24, 0, -29 },
  { 4024, 15, 41, 24, 5, -34 },
  { 4101, 9, 32, 24, 8, -29 },
  { 4137, 14, 41, 24, 5, -34 },
  { 4209, 16, 15, 24, 4, -29 },
  { 4239, 19, 4, 24, 0, 0 },
  { 4249, 8, 6, 24, 11, -30 },
  { 4255, 20, 22, 24, 1, -22 },
  { 4310, 20, 31, 24, 1, -31 },
  { 4388, 19, 22, 24, 2, -22 },
  { 4441, 22, 31, 24, 2, -31 },
  { 4527, 20, 22, 24, 2, -22 },
  { 4582, 21, 32, 24, 4, -32 },
  { 4666, 22, 31, 24, 1, -22 },
  { 4752, 21, 31, 24, 1, -31 },
  { 4834, 18, 30, 24, 2, -30 },
  { 4902, 19, 39, 24, 1, -30 },
  { 4995, 22, 31, 24, 1, -31 },
  { 5081, 18, 31, 24, 2, -31 },
  { 5151, 23, 22, 24, 0, -22 },
  { 5215, 21, 22, 24, 1, -22 },
  { 5273, 20, 22, 24, 2, -22 },
  { 5328, 22, 30, 24, -1, -22 },
  { 5411, 20, 30, 24, 2, -22 },
  { 5486, 19, 22, 24, 4, -22 },
  { 5539, 20, 22, 24, 2, -22 },
  { 5594, 18, 27, 24, 4, -27 },
  { 5655, 21, 22, 24, 2, -22 },
  { 5713, 21, 22, 24, 3, -22 },
  { 5771, 23, 22, 24, 2, -22 },
  { 5835, 24, 22, 24, 0, -22 },
  { 5901, 25, 31, 24, 0, -22 },
  { 5998, 22, 22, 24, 1, -22 },
  { 6059, 16, 39, 24, 6, -32 },
  { 6137, 9, 37, 24, 7, -29 },
  { 6179, 16, 39, 24, 4, -32 },
  { 6257, 23, 8, 24, 0, -16 },
};

const GFXfont RobotoMono_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic41pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_MEDIUMITALIC41PT7B_H_
