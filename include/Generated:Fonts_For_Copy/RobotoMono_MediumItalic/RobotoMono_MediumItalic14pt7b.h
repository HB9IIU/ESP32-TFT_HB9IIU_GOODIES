#ifndef _ROBOTOMONO_MEDIUMITALIC14PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x66, 0x60, 0x4C, 0x9B, 0xAA, 0x09, 0x0A, 0x12, 0x7F,
  0x14, 0x24, 0xFE, 0x28, 0x48, 0x58, 0x08, 0x10, 0xF3, 0x34, 0x6C, 0x1C,
  0x0E, 0x0D, 0x0B, 0x33, 0xC2, 0x00, 0x61, 0x2A, 0xF7, 0x41, 0x04, 0x0F,
  0x2B, 0xD4, 0x38, 0x1C, 0x36, 0x26, 0x3C, 0x38, 0x7B, 0x4B, 0xCE, 0xCE,
  0x7E, 0xF0, 0x08, 0x88, 0xC4, 0x23, 0x18, 0xC6, 0x30, 0x84, 0x10, 0x20,
  0x84, 0x31, 0x8C, 0x63, 0x10, 0x8C, 0x44, 0x40, 0x18, 0x23, 0x59, 0xE3,
  0x8D, 0x13, 0x00, 0x18, 0x20, 0xCF, 0xE3, 0x06, 0x08, 0x00, 0x2D, 0xE4,
  0xF8, 0x7C, 0x06, 0x08, 0x30, 0x41, 0x86, 0x08, 0x30, 0x41, 0x82, 0x00,
  0x3C, 0xC9, 0x1E, 0x3D, 0xDC, 0xB1, 0x46, 0xC8, 0xF0, 0x1F, 0xB3, 0x32,
  0x26, 0x66, 0x1C, 0x4D, 0x88, 0x30, 0x61, 0x86, 0x18, 0x41, 0xFC, 0x1E,
  0x36, 0x62, 0x02, 0x1C, 0x1C, 0x06, 0xC6, 0x4C, 0x78, 0x06, 0x1C, 0x38,
  0xB3, 0x4C, 0xBF, 0xFF, 0x0C, 0x18, 0x3E, 0xFD, 0x82, 0x8F, 0xC1, 0x81,
  0x46, 0xCC, 0xF0, 0x1C, 0xC6, 0x34, 0xFF, 0x38, 0xE3, 0xC9, 0xE0, 0xFE,
  0x0C, 0x10, 0x61, 0x82, 0x0C, 0x10, 0x61, 0x80, 0x3C, 0xC9, 0x1A, 0x27,
  0xCF, 0xB3, 0x46, 0xCC, 0xF0, 0x39, 0xBC, 0x71, 0xC5, 0xF3, 0xC2, 0x39,
  0x80, 0x6C, 0x00, 0x36, 0x33, 0x00, 0x00, 0x66, 0x4C, 0x80, 0x04, 0x37,
  0xB0, 0xF0, 0x70, 0x40, 0xFE, 0x03, 0xF7, 0xE0, 0x83, 0x83, 0x83, 0x3F,
  0x88, 0x00, 0x7B, 0x38, 0xC2, 0x18, 0xC6, 0x00, 0x41, 0x00, 0x0E, 0x33,
  0x2D, 0x55, 0x55, 0xA5, 0xAE, 0x96, 0x40, 0x38, 0x0C, 0x18, 0x70, 0xA3,
  0x44, 0xDF, 0xBF, 0xC7, 0x84, 0x3E, 0x23, 0x23, 0x63, 0x7E, 0x7E, 0x42,
  0x42, 0x46, 0xFC, 0x3C, 0xCF, 0x1E, 0x08, 0x10, 0x20, 0x42, 0xCC, 0xF0,
  0x3C, 0x26, 0x63, 0x63, 0x63, 0x63, 0x42, 0x46, 0xCC, 0xF8, 0x3F, 0x20,
  0x20, 0x60, 0x7E, 0x7E, 0x60, 0x40, 0x40, 0xFE, 0x3F, 0x20, 0x20, 0x20,
  0x7E, 0x7E, 0x60, 0x40, 0x40, 0xC0, 0x3C, 0xCF, 0x1E, 0x08, 0x13, 0xE1,
  0x42, 0xCC, 0xF0, 0x21, 0x23, 0x63, 0x63, 0x7E, 0x7E, 0x42, 0x46, 0xC6,
  0xC6, 0x3F, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0xFC, 0x03,
  0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0xC6, 0x6C, 0x78, 0x31, 0x91, 0x89,
  0x8D, 0x87, 0x83, 0xC1, 0xB0, 0x98, 0x46, 0x63, 0x00, 0x30, 0x40, 0x81,
  0x06, 0x0C, 0x18, 0x20, 0x41, 0xFC, 0x33, 0x33, 0x75, 0x77, 0x7F, 0x5A,
  0x5A, 0x42, 0xC6, 0xC6, 0x31, 0x33, 0x73, 0x73, 0x7A, 0x6A, 0x4E, 0x4E,
  0xC6, 0xC6, 0x3C, 0xCB, 0x1E, 0x38, 0x70, 0xE1, 0x46, 0xC8, 0xF0, 0x3E,
  0x23, 0x21, 0x23, 0x63, 0x7E, 0x60, 0x40, 0x40, 0xC0, 0x3C, 0xCB, 0x1E,
  0x38, 0x70, 0xE1, 0x46, 0xCC, 0xF0, 0x30, 0x40, 0x3E, 0x23, 0x23, 0x63,
  0x66, 0x7C, 0x6C, 0x44, 0x46, 0xC6, 0x1E, 0x33, 0x63, 0x20, 0x38, 0x0E,
  0x02, 0xC2, 0x66, 0x3C, 0xFF, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x20, 0x42, 0x8F, 0x1E, 0x3C, 0x78, 0xA1, 0x46, 0xCC, 0xF0, 0xC3,
  0xC6, 0x46, 0x4C, 0x4C, 0x68, 0x78, 0x70, 0x70, 0x20, 0xDB, 0xDA, 0xDA,
  0xEE, 0xAE, 0xAC, 0xEC, 0xCC, 0xC8, 0xC8, 0x61, 0x99, 0x8D, 0x82, 0x81,
  0xC0, 0xC0, 0xF0, 0xC8, 0x66, 0x63, 0x00, 0xC3, 0x46, 0x64, 0x6C, 0x38,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x3F, 0x43, 0x06, 0x0C, 0x08, 0x18, 0x30,
  0x60, 0xC0, 0xFE, 0x39, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x8E, 0x00,
  0x92, 0x6C, 0x92, 0x6D, 0x80, 0x38, 0x84, 0x63, 0x18, 0xC4, 0x21, 0x18,
  0xCE, 0x00, 0x31, 0x94, 0xA9, 0x80, 0xFC, 0xD0, 0x08, 0x7D, 0x98, 0x77,
  0xE8, 0xD3, 0xBF, 0x30, 0x60, 0x81, 0x47, 0xEC, 0x58, 0xB1, 0x46, 0xCF,
  0xF0, 0x11, 0xFC, 0x70, 0x82, 0x0C, 0xDE, 0x02, 0x0C, 0x18, 0xB7, 0xF8,
  0xB1, 0x46, 0x8D, 0x99, 0xE0, 0x11, 0xFC, 0x71, 0xFE, 0x0C, 0xDE, 0x0F,
  0x1E, 0x10, 0x30, 0xFE, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x08, 0x3F,
  0x62, 0x62, 0x46, 0x46, 0x66, 0x3E, 0x04, 0xCC, 0x78, 0x30, 0x60, 0x81,
  0x27, 0xEC, 0x58, 0xB1, 0x46, 0x8F, 0x18, 0x18, 0x20, 0x1E, 0x10, 0x43,
  0x0C, 0x33, 0xF0, 0x06, 0x08, 0x01, 0xE0, 0xC1, 0x83, 0x04, 0x08, 0x30,
  0x61, 0xCF, 0x00, 0x30, 0x30, 0x20, 0x21, 0x66, 0x6C, 0x78, 0x78, 0x6C,
  0x4C, 0xC6, 0x79, 0xE1, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xCF, 0xC0, 0x12,
  0x7F, 0x4B, 0x5B, 0xDA, 0xD2, 0xD2, 0x96, 0x04, 0xFD, 0x8B, 0x16, 0x28,
  0xD1, 0xE3, 0x11, 0xFC, 0x61, 0x86, 0x3C, 0xDE, 0x08, 0xFD, 0x9B, 0x16,
  0x28, 0xD9, 0xFE, 0xC1, 0x82, 0x00, 0x10, 0xFF, 0x16, 0x28, 0xD1, 0xB3,
  0x3C, 0x08, 0x10, 0x60, 0x04, 0xFD, 0xC3, 0x06, 0x08, 0x10, 0x60, 0x11,
  0xFC, 0x58, 0x38, 0x3C, 0xDE, 0x30, 0xCF, 0xC8, 0x20, 0x86, 0x18, 0x3C,
  0xC7, 0x8B, 0x16, 0x68, 0xD9, 0xBF, 0x00, 0xC6, 0x89, 0x32, 0x47, 0x8E,
  0x08, 0x00, 0x93, 0x6E, 0xD5, 0xAD, 0xDB, 0x26, 0x00, 0x63, 0x36, 0x1C,
  0x18, 0x3C, 0x64, 0xC6, 0x63, 0xB1, 0x09, 0x86, 0x83, 0xC0, 0xC0, 0x40,
  0x60, 0x60, 0x60, 0x00, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0x08,
  0x84, 0x63, 0x13, 0x0C, 0x63, 0x18, 0xC3, 0x00, 0x32, 0x22, 0x22, 0x64,
  0x44, 0x44, 0xC0, 0x30, 0x41, 0x04, 0x10, 0x40, 0xC6, 0x30, 0x82, 0x08,
  0x42, 0x00, 0x20, 0x7B, 0x8E,
};

const GFXglyph RobotoMono_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 2, -10 },
  { 6, 4, 4, 8, 3, -11 },
  { 8, 8, 10, 8, 0, -10 },
  { 18, 7, 13, 8, 1, -12 },
  { 30, 7, 10, 8, 1, -10 },
  { 39, 8, 10, 8, 0, -10 },
  { 49, 1, 4, 8, 4, -11 },
  { 50, 5, 14, 8, 2, -11 },
  { 59, 5, 14, 8, 1, -11 },
  { 68, 7, 7, 8, 1, -10 },
  { 75, 7, 7, 8, 1, -8 },
  { 82, 3, 5, 8, 1, -2 },
  { 84, 5, 1, 8, 2, -5 },
  { 85, 3, 2, 8, 2, -2 },
  { 86, 7, 11, 8, 1, -10 },
  { 96, 7, 10, 8, 1, -10 },
  { 105, 4, 10, 8, 2, -10 },
  { 110, 7, 10, 8, 0, -10 },
  { 119, 8, 10, 8, 0, -10 },
  { 129, 7, 10, 8, 0, -10 },
  { 138, 7, 10, 8, 1, -10 },
  { 147, 6, 10, 8, 1, -10 },
  { 155, 7, 10, 8, 1, -10 },
  { 164, 7, 10, 8, 1, -10 },
  { 173, 6, 10, 8, 1, -10 },
  { 181, 3, 8, 8, 3, -8 },
  { 184, 4, 11, 8, 2, -8 },
  { 190, 6, 7, 8, 1, -8 },
  { 196, 7, 4, 8, 1, -6 },
  { 200, 6, 7, 8, 1, -8 },
  { 206, 6, 10, 8, 2, -10 },
  { 214, 8, 10, 8, 0, -10 },
  { 224, 7, 10, 8, 0, -10 },
  { 233, 8, 10, 8, 0, -10 },
  { 243, 7, 10, 8, 1, -10 },
  { 252, 8, 10, 8, 0, -10 },
  { 262, 8, 10, 8, 0, -10 },
  { 272, 8, 10, 8, 0, -10 },
  { 282, 7, 10, 8, 1, -10 },
  { 291, 8, 10, 8, 0, -10 },
  { 301, 8, 10, 8, 0, -10 },
  { 311, 8, 10, 8, 0, -10 },
  { 321, 9, 10, 8, 0, -10 },
  { 333, 7, 10, 8, 0, -10 },
  { 342, 8, 10, 8, 0, -10 },
  { 352, 8, 10, 8, 0, -10 },
  { 362, 7, 10, 8, 1, -10 },
  { 371, 8, 10, 8, 0, -10 },
  { 381, 7, 12, 8, 1, -10 },
  { 392, 8, 10, 8, 0, -10 },
  { 402, 8, 10, 8, 0, -10 },
  { 412, 8, 10, 8, 1, -10 },
  { 422, 7, 10, 8, 1, -10 },
  { 431, 8, 10, 8, 1, -10 },
  { 441, 8, 10, 8, 1, -10 },
  { 451, 9, 10, 8, 0, -10 },
  { 463, 8, 10, 8, 1, -10 },
  { 473, 8, 10, 8, 0, -10 },
  { 483, 5, 13, 8, 2, -11 },
  { 492, 3, 11, 8, 3, -10 },
  { 497, 5, 13, 8, 2, -11 },
  { 506, 5, 5, 8, 2, -10 },
  { 510, 6, 1, 8, 0, 0 },
  { 511, 2, 2, 8, 4, -10 },
  { 512, 7, 8, 8, 0, -8 },
  { 519, 7, 11, 8, 0, -11 },
  { 529, 6, 8, 8, 1, -8 },
  { 535, 7, 11, 8, 1, -11 },
  { 545, 6, 8, 8, 1, -8 },
  { 551, 8, 11, 8, 1, -11 },
  { 562, 8, 11, 8, 0, -8 },
  { 573, 7, 11, 8, 0, -11 },
  { 583, 6, 10, 8, 1, -10 },
  { 591, 7, 13, 8, 0, -10 },
  { 603, 8, 11, 8, 0, -11 },
  { 614, 6, 11, 8, 1, -11 },
  { 623, 8, 8, 8, 0, -8 },
  { 631, 7, 8, 8, 0, -8 },
  { 638, 6, 8, 8, 1, -8 },
  { 644, 7, 11, 8, 0, -8 },
  { 654, 7, 11, 8, 1, -8 },
  { 664, 7, 8, 8, 1, -8 },
  { 671, 6, 8, 8, 1, -8 },
  { 677, 6, 9, 8, 1, -9 },
  { 684, 7, 7, 8, 1, -7 },
  { 691, 7, 7, 8, 1, -7 },
  { 698, 7, 7, 8, 1, -7 },
  { 705, 8, 7, 8, 0, -7 },
  { 712, 9, 10, 8, 0, -7 },
  { 724, 8, 7, 8, 0, -7 },
  { 731, 5, 13, 8, 2, -11 },
  { 740, 4, 13, 8, 2, -10 },
  { 747, 6, 14, 8, 1, -11 },
  { 758, 8, 3, 8, 0, -6 },
};

const GFXfont RobotoMono_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic14pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_MEDIUMITALIC14PT7B_H_
