#ifndef _ROBOTOMONO_MEDIUMITALIC38PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0x78, 0xF7, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F,
  0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7E, 0x7F, 0x0F, 0x83, 0xE3,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF7, 0x80, 0x3E, 0xF0,
  0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xF0, 0x7F,
  0xF8, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xE7, 0x00, 0x38, 0xF0, 0x87,
  0x0E, 0x3D, 0xE3, 0xC7, 0x38, 0x71, 0xC7, 0x8E, 0x70, 0x73, 0xCE, 0x0F,
  0xF3, 0x80, 0xFC, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x9F, 0x80, 0xE7, 0xF8, 0x1D, 0xE7, 0x07,
  0x38, 0xE1, 0xCF, 0x1E, 0x71, 0xC3, 0x86, 0x38, 0x70, 0x07, 0x8E, 0x00,
  0x73, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0x78, 0x0F, 0x8F, 0x00, 0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x73, 0xFF, 0x0F, 0x7C,
  0xF8, 0xF7, 0x87, 0x8F, 0xF8, 0x7D, 0xEF, 0x03, 0xFE, 0xF0, 0x3F, 0xCF,
  0x01, 0xFC, 0xF8, 0x1F, 0x8F, 0xC7, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xE3, 0xE0, 0x7B, 0xDC, 0xE7, 0x7B, 0xDC, 0xE7, 0x00, 0x00, 0x10,
  0x03, 0x80, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x08, 0x18, 0x17, 0x8E, 0x3D, 0xFB, 0xBF,
  0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x03,
  0xCE, 0x01, 0xE3, 0x80, 0xF0, 0xF0, 0x78, 0x1E, 0x06, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x3C, 0xF9, 0xE3, 0xC7, 0x9F, 0x3C, 0xF1, 0xE1, 0x80, 0x7F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x73, 0xEF, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF9,
  0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0xFD, 0xF0, 0x3F, 0x3E, 0x1F, 0xE7,
  0x87, 0xBC, 0xF3, 0xE7, 0x9E, 0xF8, 0xF3, 0xFC, 0x3E, 0x7F, 0x07, 0xDF,
  0x80, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0xF8, 0xF0, 0x1E, 0x1E,
  0x07, 0xC3, 0xE1, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x30, 0x1F, 0x07, 0xF3, 0xFE, 0xFF, 0xEF, 0xFE, 0xF1, 0xE8, 0x1E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFC, 0x7E, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE3, 0xF1, 0xF0,
  0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xCF, 0x00, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xF1, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xBC, 0x00, 0xFB, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x7C,
  0x07, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x07,
  0x87, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE7, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xE1,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x07,
  0xC3, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x7C, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF3, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x79, 0xE0, 0x7C, 0xFC,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE7, 0xE1, 0xF0,
  0x3C, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0,
  0xF8, 0x7C, 0x3E, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x81, 0xF0, 0xF8, 0x7C, 0x0F, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0x87, 0xE3, 0xE3, 0xE0, 0xF3, 0xE0, 0x7D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0xFD,
  0xF9, 0xFC, 0x7F, 0xFE, 0x3F, 0xEF, 0x07, 0xEF, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0x80, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x3E,
  0x3F, 0x1F, 0x8F, 0xC3, 0xE0, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x0F, 0x81, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0xF8,
  0xE3, 0x9F, 0xE7, 0x38, 0xF3, 0x39, 0x8E, 0x39, 0xDC, 0x61, 0xCE, 0xE7,
  0x0C, 0x76, 0x38, 0x63, 0xF1, 0x87, 0x1B, 0x9C, 0x38, 0xDC, 0xE1, 0x86,
  0xE7, 0x0C, 0x77, 0x38, 0xE3, 0x39, 0xFF, 0x39, 0xC7, 0xDF, 0x8E, 0x3C,
  0xF8, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0x70, 0x03, 0xE3,
  0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07,
  0x81, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0,
  0x07, 0xBE, 0x00, 0x3E, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0,
  0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0x80, 0x7C, 0x3C, 0x03,
  0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C,
  0x01, 0xF3, 0xE0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFC,
  0xFE, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF8, 0x1F,
  0x07, 0xE3, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0x07, 0xE1,
  0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01,
  0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0x78, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFC, 0xFE, 0x1F,
  0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x03, 0xFE,
  0xF0, 0x7F, 0xCF, 0x07, 0xFC, 0xF0, 0x7F, 0xCF, 0x00, 0x3C, 0xF0, 0x07,
  0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x80, 0x78, 0x78, 0x0F, 0x87, 0xE3,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0xC7, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x0F, 0x03,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x1E, 0x3F,
  0x00, 0x1E, 0x7E, 0x00, 0x1E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x3C,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x1F,
  0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xDC, 0x0F, 0xE7, 0xF8, 0x1D, 0xEE,
  0xF0, 0x79, 0xFD, 0xE0, 0xF3, 0xF3, 0xC1, 0xE7, 0xE7, 0x83, 0xCF, 0x9E,
  0x07, 0x9F, 0x3C, 0x1F, 0x3C, 0x78, 0x3C, 0x78, 0xF0, 0x78, 0xE1, 0xE0,
  0xF1, 0xC7, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0xE0,
  0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC3, 0xF0,
  0x1F, 0x0F, 0xE0, 0x7C, 0x3F, 0x81, 0xE0, 0xFE, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1, 0xF7, 0x0F, 0x87, 0xDE, 0x3C, 0x1E,
  0x78, 0xF0, 0x78, 0xE3, 0xC1, 0xE3, 0xDF, 0x0F, 0x8F, 0x7C, 0x3E, 0x3D,
  0xF0, 0xF0, 0x77, 0x83, 0xC1, 0xFE, 0x0F, 0x07, 0xF8, 0x3C, 0x0F, 0xE1,
  0xF0, 0x3F, 0x87, 0xC0, 0xFC, 0x1E, 0x03, 0xF0, 0x78, 0x07, 0xC1, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x07, 0xE7, 0xE1, 0xF0, 0x3C, 0x7C, 0x07, 0xCF, 0x00, 0x7B, 0xE0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x1F, 0x3E, 0x07, 0xC3,
  0xF3, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x87,
  0x80, 0x7C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x07,
  0xC7, 0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x07, 0xC7, 0x80, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xE7, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x07, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x00, 0xF0,
  0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xC7, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x7C,
  0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x79, 0xF0, 0x03,
  0xCF, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xF0, 0x1F, 0x07, 0xE3, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x80,
  0xF0, 0xF8, 0x1F, 0x07, 0xE7, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x3C,
  0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF7,
  0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x3D, 0xE1, 0xE1, 0xEF,
  0x1F, 0x0F, 0x78, 0xF8, 0xF3, 0xC7, 0xC7, 0x9E, 0x3E, 0x3C, 0xF3, 0xF1,
  0xE7, 0x9F, 0x9E, 0x3C, 0xFC, 0xF1, 0xEF, 0xE7, 0x8F, 0x77, 0x3C, 0x7B,
  0xBB, 0xC3, 0xFD, 0xDE, 0x1F, 0xCE, 0xF0, 0xFE, 0x77, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1,
  0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x00,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0x1E, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xE3,
  0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0xF9, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x3E,
  0x00, 0xF0, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x7C, 0x78,
  0x07, 0x87, 0xC0, 0xF8, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03,
  0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x00, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xCE,
  0x07, 0x9C, 0x1E, 0x38, 0x3C, 0x78, 0xF0, 0xF1, 0xE0, 0xE7, 0x81, 0xDE,
  0x03, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x78, 0xF0, 0xF0, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C,
  0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF,
  0x80, 0xFB, 0xE0, 0x7E, 0x7C, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0x3E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xCF,
  0xE0, 0x7B, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0x8F, 0x80,
  0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01,
  0xF7, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x7C, 0x0F,
  0x8F, 0xC3, 0xF3, 0xFF, 0xFC, 0x7B, 0xFF, 0x0F, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xF7,
  0xC0, 0x7D, 0xE0, 0x0F, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFB, 0xE0, 0x3C, 0x78, 0x1F,
  0x1F, 0x0F, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x7F, 0xBE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1F,
  0x07, 0xE7, 0xF0, 0x7F, 0xFF, 0x03, 0xFE, 0xF0, 0x1F, 0xDE, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x3E, 0x07, 0xDF, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x21, 0xF0, 0x18, 0x7E,
  0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF8, 0x60, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x08, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF8, 0x7E, 0x1F,
  0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C,
  0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x3F, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xF7,
  0x80, 0xFE, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x40, 0x1F, 0x07, 0x03,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC7, 0xE0, 0x7B,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xDF, 0x00,
  0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0xC7, 0x81, 0xF8, 0x3C, 0x1F, 0x81, 0xE1, 0xF8, 0x0F,
  0x1F, 0x80, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3D, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1E, 0xF9, 0xF0, 0xEF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7C, 0xFC, 0xF3, 0xC3, 0xC7, 0x9E, 0x1E, 0x3C,
  0xF1, 0xE1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0x7B, 0xC3, 0xC7, 0x9E, 0x1E,
  0x3C, 0xF0, 0xF1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0x7B, 0xE3, 0xC3, 0xDE,
  0x1E, 0x3C, 0xF0, 0xF1, 0xE7, 0x87, 0x0F, 0x3C, 0x78, 0x79, 0xE3, 0xC3,
  0xC0, 0x1E, 0x7F, 0x03, 0xDF, 0xF8, 0x7F, 0xFF, 0x0F, 0xE3, 0xF1, 0xF0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80,
  0x79, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01,
  0xF3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x1F,
  0x8F, 0x81, 0xE7, 0xC0, 0x7D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x3E, 0xF8, 0x1F, 0x1F, 0x0F, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x0F, 0x3F, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F,
  0x81, 0xE1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x7F, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x07, 0x9F, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF9, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE3, 0xE0, 0x7C, 0xF8,
  0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0,
  0xF8, 0x7C, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xEF, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x3F, 0x8F, 0x7F, 0xC7, 0xFF,
  0xE7, 0xFF, 0xE3, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFC, 0x1F, 0x3C, 0x07,
  0xCF, 0x00, 0xF3, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xEF, 0x00, 0x7B, 0xC0,
  0x3E, 0xFC, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x30, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFC, 0x00, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x9E,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x3E, 0x78,
  0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0xF8, 0x7E, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF,
  0xBC, 0x0F, 0xC7, 0x80, 0xF0, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3C,
  0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC1, 0xE0, 0xF0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x0E, 0x3C, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x87, 0xBC, 0x3C, 0x3D,
  0xE1, 0xE1, 0xEF, 0x1F, 0x1E, 0x78, 0xF8, 0xF3, 0xC7, 0xC7, 0x9E, 0x7E,
  0x38, 0xF3, 0xF3, 0xC7, 0xB9, 0x9E, 0x3D, 0xCC, 0xE1, 0xEE, 0x6F, 0x0F,
  0xE3, 0x70, 0x7F, 0x1B, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x3E,
  0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x00, 0x1F, 0x00, 0x7C,
  0x3E, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00,
  0x7C, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0x80, 0xF8, 0x1F, 0x07, 0xC0,
  0x3C, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x78,
  0x03, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x00,
  0x1E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x80, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x01, 0xCF, 0xFC,
  0x0E, 0xFF, 0xF0, 0xF7, 0x07, 0xFF, 0x78, 0x1F, 0xF9, 0x80, 0x7F, 0x80,
  0x00, 0xF0,
};

const GFXglyph RobotoMono_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 27, 22, 7, -27 },
  { 32, 12, 10, 22, 7, -29 },
  { 47, 22, 27, 22, 0, -27 },
  { 122, 19, 35, 22, 2, -31 },
  { 206, 19, 27, 22, 2, -27 },
  { 271, 20, 27, 22, 1, -27 },
  { 339, 5, 10, 22, 10, -29 },
  { 346, 13, 39, 22, 6, -30 },
  { 410, 13, 39, 22, 3, -30 },
  { 474, 18, 19, 22, 3, -27 },
  { 517, 19, 19, 22, 2, -22 },
  { 563, 7, 11, 22, 4, -4 },
  { 573, 16, 4, 22, 4, -14 },
  { 581, 6, 6, 22, 7, -6 },
  { 586, 19, 29, 22, 2, -27 },
  { 655, 19, 27, 22, 2, -27 },
  { 720, 12, 27, 22, 5, -27 },
  { 761, 20, 27, 22, 0, -27 },
  { 829, 19, 27, 22, 1, -27 },
  { 894, 20, 27, 22, 0, -27 },
  { 962, 20, 27, 22, 2, -27 },
  { 1030, 17, 27, 22, 2, -27 },
  { 1088, 19, 27, 22, 3, -27 },
  { 1153, 19, 27, 22, 2, -27 },
  { 1218, 17, 27, 22, 3, -27 },
  { 1276, 9, 22, 22, 7, -22 },
  { 1301, 12, 29, 22, 5, -22 },
  { 1345, 17, 18, 22, 3, -21 },
  { 1384, 19, 12, 22, 2, -18 },
  { 1413, 18, 17, 22, 2, -20 },
  { 1452, 16, 27, 22, 5, -27 },
  { 1506, 21, 27, 22, 1, -27 },
  { 1577, 21, 27, 22, -1, -27 },
  { 1648, 21, 27, 22, 1, -27 },
  { 1719, 20, 27, 22, 2, -27 },
  { 1787, 20, 27, 22, 1, -27 },
  { 1855, 22, 27, 22, 1, -27 },
  { 1930, 22, 27, 22, 1, -27 },
  { 2005, 20, 27, 22, 2, -27 },
  { 2073, 22, 27, 22, 0, -27 },
  { 2148, 21, 27, 22, 1, -27 },
  { 2219, 21, 27, 22, 1, -27 },
  { 2290, 24, 27, 22, 1, -27 },
  { 2371, 18, 27, 22, 1, -27 },
  { 2432, 23, 27, 22, 0, -27 },
  { 2510, 22, 27, 22, 0, -27 },
  { 2585, 19, 27, 22, 2, -27 },
  { 2650, 21, 27, 22, 1, -27 },
  { 2721, 21, 32, 22, 1, -27 },
  { 2805, 21, 27, 22, 1, -27 },
  { 2876, 21, 27, 22, 1, -27 },
  { 2947, 21, 27, 22, 3, -27 },
  { 3018, 20, 27, 22, 2, -27 },
  { 3086, 21, 27, 22, 3, -27 },
  { 3157, 21, 27, 22, 3, -27 },
  { 3228, 25, 27, 22, -1, -27 },
  { 3313, 20, 27, 22, 4, -27 },
  { 3381, 22, 27, 22, 0, -27 },
  { 3456, 13, 37, 22, 5, -31 },
  { 3517, 9, 29, 22, 7, -27 },
  { 3550, 13, 37, 22, 5, -31 },
  { 3611, 15, 14, 22, 4, -27 },
  { 3638, 17, 4, 22, 0, 0 },
  { 3647, 7, 5, 22, 10, -27 },
  { 3652, 18, 20, 22, 1, -20 },
  { 3697, 19, 29, 22, 1, -29 },
  { 3766, 18, 21, 22, 2, -21 },
  { 3814, 20, 29, 22, 2, -29 },
  { 3887, 18, 20, 22, 2, -20 },
  { 3932, 21, 29, 22, 3, -29 },
  { 4009, 20, 28, 22, 1, -20 },
  { 4079, 19, 29, 22, 1, -29 },
  { 4148, 17, 28, 22, 2, -28 },
  { 4208, 17, 36, 22, 1, -28 },
  { 4285, 21, 29, 22, 1, -29 },
  { 4362, 17, 29, 22, 2, -29 },
  { 4424, 21, 20, 22, 0, -20 },
  { 4477, 19, 20, 22, 1, -20 },
  { 4525, 18, 21, 22, 2, -21 },
  { 4573, 20, 28, 22, 0, -20 },
  { 4643, 19, 28, 22, 2, -20 },
  { 4710, 17, 20, 22, 4, -20 },
  { 4753, 18, 20, 22, 2, -20 },
  { 4798, 17, 25, 22, 3, -25 },
  { 4852, 19, 20, 22, 2, -20 },
  { 4900, 19, 20, 22, 3, -20 },
  { 4948, 21, 20, 22, 2, -20 },
  { 5001, 22, 20, 22, 0, -20 },
  { 5056, 23, 28, 22, 0, -20 },
  { 5137, 20, 20, 22, 1, -20 },
  { 5187, 14, 37, 22, 6, -30 },
  { 5252, 8, 35, 22, 7, -27 },
  { 5287, 15, 37, 22, 3, -30 },
  { 5357, 21, 8, 22, 0, -15 },
};

const GFXfont RobotoMono_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic38pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_MEDIUMITALIC38PT7B_H_
