#ifndef _ROBOTOMONO_MEDIUMITALIC19PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x63, 0x18, 0xC6, 0x60, 0x00, 0x0E, 0x30, 0x65, 0xB4,
  0xF3, 0x02, 0x60, 0xC8, 0x13, 0x02, 0x63, 0xFE, 0x7F, 0xC2, 0x60, 0xC8,
  0x13, 0x1F, 0xF8, 0xC8, 0x13, 0x06, 0x40, 0xD8, 0x00, 0x02, 0x00, 0x80,
  0x60, 0x7E, 0x39, 0x8C, 0x77, 0x1C, 0xC0, 0x3C, 0x07, 0xC0, 0x70, 0x0E,
  0xC1, 0xB0, 0xE7, 0xF0, 0xF8, 0x18, 0x04, 0x00, 0x30, 0x3C, 0x32, 0x79,
  0x2D, 0xA3, 0xB0, 0x10, 0x10, 0x1B, 0x1B, 0xCB, 0x2D, 0x90, 0xD8, 0x38,
  0x06, 0x01, 0xF0, 0x66, 0x0C, 0xC1, 0x98, 0x3E, 0x07, 0x81, 0xE0, 0x7E,
  0x6C, 0xDB, 0x8F, 0x31, 0xC7, 0xF8, 0x7F, 0x80, 0xFF, 0x80, 0x04, 0x31,
  0x8C, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x83,
  0x00, 0x10, 0x10, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60,
  0xC1, 0x86, 0x0C, 0x30, 0xC3, 0x00, 0x0C, 0x06, 0x02, 0x19, 0x2F, 0xF8,
  0xE0, 0xE0, 0xD8, 0xC6, 0x22, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF,
  0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x76, 0x66, 0xC8, 0xFF, 0xFF, 0x7D,
  0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0E, 0x0F, 0x8C, 0x6C,
  0x36, 0x1B, 0x1D, 0x9F, 0xFB, 0xF1, 0xF1, 0xF0, 0xD8, 0x67, 0xE1, 0xE0,
  0x02, 0x19, 0xF3, 0x68, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86,
  0x00, 0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x70, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xFF, 0xBF, 0xE0, 0x07, 0x07, 0xE3, 0x9C, 0xC3,
  0x00, 0xC0, 0x70, 0xF8, 0x3C, 0x01, 0x80, 0x6E, 0x19, 0x86, 0x7F, 0x0F,
  0x80, 0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x0D, 0x83, 0x61, 0x98, 0xCE, 0x63,
  0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x01, 0xC0, 0x1F, 0xC7, 0xF3, 0x00, 0xC0,
  0x30, 0x1B, 0x87, 0xF0, 0x8C, 0x03, 0x80, 0x6C, 0x3B, 0x0C, 0x7F, 0x0F,
  0x00, 0x01, 0x07, 0x87, 0x06, 0x06, 0x03, 0x73, 0xFD, 0xC6, 0xC3, 0xE1,
  0xF0, 0xD8, 0x67, 0xE1, 0xE0, 0x7F, 0xDF, 0xF0, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x00, 0x0E,
  0x0F, 0xCC, 0x6E, 0x36, 0x1B, 0x8C, 0xFC, 0x7C, 0x63, 0x61, 0xF0, 0xD8,
  0x6F, 0xF3, 0xE0, 0x1C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF,
  0x36, 0x0E, 0x1C, 0xF8, 0xE0, 0x77, 0x70, 0x00, 0x00, 0xCE, 0xC0, 0x19,
  0xCE, 0x00, 0x00, 0x00, 0x03, 0x18, 0xCE, 0x62, 0x00, 0x01, 0x83, 0xCF,
  0x8F, 0x0E, 0x03, 0xE0, 0x3C, 0x06, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x60, 0x3C, 0x0F, 0x80, 0xF0, 0x79, 0xF3, 0xE1, 0x80, 0x80, 0x00,
  0x1C, 0x3F, 0x98, 0xDC, 0x70, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18, 0x00,
  0x00, 0x07, 0x01, 0x80, 0x0F, 0xC3, 0x08, 0xCD, 0x93, 0xD6, 0x92, 0xB2,
  0x56, 0x5A, 0x9A, 0xDA, 0x4B, 0xF1, 0x00, 0x31, 0x03, 0xE0, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x6C, 0x0D, 0x83, 0x30, 0x66, 0x18, 0xC3, 0xF8,
  0xFF, 0x18, 0x66, 0x0F, 0xC0, 0xC0, 0x1E, 0x03, 0xF8, 0xE3, 0x98, 0x33,
  0x06, 0x61, 0x8F, 0xE3, 0xFC, 0x60, 0xCC, 0x19, 0x83, 0x30, 0xE7, 0xF9,
  0xFE, 0x00, 0x0E, 0x07, 0xE3, 0x19, 0x83, 0x60, 0xF8, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x1B, 0x0C, 0x7F, 0x0F, 0x00, 0x1C, 0x07, 0xF0, 0xC7,
  0x18, 0x63, 0x0C, 0x61, 0xCC, 0x3B, 0x86, 0x60, 0xCC, 0x19, 0x86, 0x31,
  0xC7, 0xF1, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0F, 0xE1, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xF9, 0xFF, 0x00,
  0x3F, 0xCF, 0xF3, 0x01, 0xC0, 0x60, 0x18, 0x07, 0xF9, 0xFC, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x07, 0xE3, 0x19, 0x83, 0x60,
  0x38, 0x0C, 0x03, 0x1E, 0xC7, 0xB0, 0x6C, 0x1B, 0x8E, 0x7F, 0x0F, 0x80,
  0x18, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0x8F, 0xF3, 0xFE, 0x60,
  0xCC, 0x19, 0x86, 0x30, 0xCE, 0x19, 0x83, 0x00, 0x3F, 0xCF, 0xF0, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0xFF,
  0x3F, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xEC, 0x33, 0x0C, 0xFE, 0x1F, 0x00, 0x18, 0x71, 0x86, 0x38,
  0xC3, 0x1C, 0x33, 0x83, 0x70, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0x30, 0x63,
  0x06, 0x38, 0x61, 0x8E, 0x1C, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xFF, 0xFF, 0x18, 0x67, 0x1C, 0xE3, 0x9E,
  0xF3, 0xD6, 0x7E, 0xCF, 0xF3, 0x76, 0x66, 0xCC, 0x99, 0x83, 0x30, 0xC6,
  0x19, 0x83, 0x00, 0x18, 0x67, 0x0C, 0xE1, 0x9E, 0x73, 0xCC, 0x79, 0x8D,
  0x33, 0xB6, 0x66, 0xCC, 0xF9, 0x8E, 0x31, 0xCE, 0x39, 0x83, 0x00, 0x0E,
  0x07, 0xC3, 0x19, 0x86, 0x61, 0xF8, 0x7C, 0x1F, 0x06, 0xC1, 0xB0, 0x6C,
  0x3B, 0x0C, 0x7E, 0x0F, 0x00, 0x3C, 0x0F, 0xE3, 0x1D, 0xC3, 0x60, 0xD8,
  0x36, 0x19, 0xFE, 0xFE, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0E,
  0x07, 0xE3, 0x19, 0x87, 0x60, 0xF8, 0x3C, 0x1F, 0x06, 0xC1, 0xB0, 0x6C,
  0x1B, 0x0C, 0x7E, 0x0F, 0x80, 0x70, 0x0E, 0x1E, 0x03, 0xF8, 0xE3, 0x98,
  0x33, 0x06, 0x61, 0xCC, 0x71, 0xFC, 0x7F, 0x0C, 0x61, 0x8E, 0x30, 0xC6,
  0x19, 0xC3, 0x80, 0x0E, 0x0F, 0xE7, 0x1D, 0x83, 0x60, 0x1C, 0x03, 0xC0,
  0x7C, 0x03, 0x80, 0x6C, 0x1B, 0x0E, 0xFF, 0x0F, 0x80, 0x7F, 0xEF, 0xFE,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x00, 0x30, 0xDC, 0x36, 0x0D, 0x83, 0x61, 0xD8,
  0x66, 0x1B, 0x86, 0xC1, 0xB0, 0x6C, 0x33, 0x0C, 0x7E, 0x1F, 0x00, 0xC1,
  0xF0, 0x6C, 0x1B, 0x0E, 0xC3, 0x39, 0xC6, 0x61, 0xB8, 0x6C, 0x1B, 0x07,
  0x81, 0xE0, 0x70, 0x0C, 0x00, 0x66, 0x6C, 0xCD, 0xBB, 0x37, 0x64, 0xEC,
  0xBD, 0xB7, 0xE6, 0xBC, 0xF7, 0x9E, 0xE3, 0x9C, 0x73, 0x8E, 0x71, 0x8C,
  0x00, 0x30, 0x73, 0x86, 0x18, 0xE1, 0x9C, 0x1D, 0x80, 0xF0, 0x0F, 0x00,
  0xE0, 0x0F, 0x01, 0xB0, 0x3B, 0x07, 0x18, 0x61, 0x8E, 0x1C, 0xC0, 0xF0,
  0x6E, 0x39, 0x8C, 0x67, 0x19, 0x83, 0xC0, 0xF0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0x80, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFD, 0xFF, 0x00,
  0x1E, 0x3C, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xE3, 0xC0, 0x8C, 0xCC, 0xCC, 0x66, 0x66, 0x66, 0x33,
  0x30, 0x1E, 0x3C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x38, 0xE3, 0xC0, 0x0C, 0x18, 0x71, 0xA3, 0x6C, 0xD9,
  0xE1, 0xFF, 0xFF, 0x80, 0xC6, 0x30, 0x3E, 0x3B, 0x98, 0xE0, 0x73, 0xF7,
  0x1B, 0x0D, 0x8E, 0xFF, 0x3D, 0x80, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x37,
  0x8F, 0xE3, 0x1C, 0xC3, 0x70, 0xD8, 0x36, 0x1D, 0x86, 0x7F, 0xBF, 0xC0,
  0x1F, 0x3F, 0x98, 0x7C, 0x3C, 0x06, 0x03, 0x01, 0x86, 0x7F, 0x1E, 0x00,
  0x00, 0xC0, 0x30, 0x1C, 0x06, 0x3F, 0x9F, 0xE6, 0x1B, 0x86, 0xC3, 0xB0,
  0xCC, 0x33, 0x0C, 0x7F, 0x1E, 0xC0, 0x1F, 0x1F, 0x98, 0x7C, 0x3F, 0xFF,
  0xFF, 0x01, 0xC2, 0x7F, 0x1F, 0x00, 0x03, 0x83, 0xF1, 0xC0, 0x60, 0x18,
  0x3F, 0xCF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x00, 0x1F, 0xCF, 0xF3, 0x0D, 0xC3, 0x60, 0xD8, 0x76, 0x19, 0x86, 0x3F,
  0x8F, 0x60, 0x39, 0x0C, 0xFF, 0x0F, 0x00, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x37, 0x8F, 0xF3, 0x0C, 0xC3, 0x70, 0xD8, 0x76, 0x19, 0x86, 0x61, 0xB8,
  0x60, 0x06, 0x06, 0x02, 0x00, 0x3E, 0x7E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x40, 0x01, 0xF0, 0xF8, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x7C, 0x7C, 0x00,
  0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x1E, 0x67, 0x0D, 0xC1, 0xF0, 0x7C,
  0x0F, 0xC1, 0xDC, 0x31, 0x86, 0x39, 0xC3, 0x00, 0x3F, 0x3E, 0x06, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0xFF, 0xFF, 0x6F, 0xCF,
  0xF9, 0x99, 0xB3, 0x66, 0xCC, 0xD9, 0xB3, 0x36, 0x66, 0xCC, 0xD9, 0xB0,
  0x37, 0x8F, 0xF3, 0x0C, 0xC3, 0x70, 0xD8, 0x76, 0x19, 0x86, 0x61, 0xB8,
  0x60, 0x1E, 0x3F, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x86, 0x7E, 0x3E,
  0x00, 0x37, 0x8F, 0xE3, 0x1C, 0xC3, 0x70, 0xD8, 0x36, 0x1D, 0x86, 0x7F,
  0x9F, 0xCE, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x3F, 0xBF, 0xD8, 0x7C, 0x3C,
  0x3E, 0x1B, 0x0D, 0x86, 0xFF, 0x3D, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x7F,
  0xBF, 0x9C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x00, 0x3F,
  0x3D, 0xD8, 0x6C, 0x07, 0xC0, 0xF8, 0x0D, 0x86, 0xFF, 0x3F, 0x00, 0x18,
  0x38, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x7E, 0x3E, 0x61,
  0xD8, 0x66, 0x19, 0x86, 0xE1, 0xB0, 0xEC, 0x33, 0x0C, 0xFF, 0x1E, 0xC0,
  0xE1, 0xD8, 0x66, 0x19, 0x8C, 0x63, 0x0D, 0x83, 0x60, 0xF0, 0x38, 0x06,
  0x00, 0xCC, 0xF3, 0x3C, 0xCF, 0x76, 0xD5, 0xBD, 0x4E, 0x73, 0x9C, 0xE6,
  0x31, 0x80, 0x30, 0xE3, 0x38, 0x6E, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0xC1,
  0xD8, 0x71, 0x9C, 0x38, 0x70, 0x73, 0x0E, 0x30, 0xC3, 0x1C, 0x19, 0x81,
  0xB0, 0x1B, 0x01, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xF0, 0x0E,
  0x00, 0x3F, 0xCF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x7F,
  0xBF, 0xE0, 0x06, 0x1C, 0x30, 0xC1, 0x83, 0x06, 0x18, 0xF1, 0x81, 0x81,
  0x83, 0x06, 0x18, 0x10, 0x30, 0x70, 0x18, 0x84, 0x23, 0x18, 0xC4, 0x21,
  0x18, 0xC6, 0x31, 0x08, 0x46, 0x00, 0x30, 0x70, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x0E, 0x1C, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x61, 0x80, 0x10, 0x0F,
  0x8F, 0x3B, 0x63, 0xE0,
};

const GFXglyph RobotoMono_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 14, 11, 3, -14 },
  { 10, 6, 4, 11, 3, -14 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 10, 18, 11, 1, -16 },
  { 56, 9, 14, 11, 1, -14 },
  { 72, 11, 14, 11, 0, -14 },
  { 92, 2, 5, 11, 5, -14 },
  { 94, 6, 19, 11, 3, -15 },
  { 109, 7, 19, 11, 1, -15 },
  { 126, 9, 10, 11, 2, -14 },
  { 138, 9, 10, 11, 1, -11 },
  { 150, 4, 6, 11, 2, -2 },
  { 153, 8, 2, 11, 2, -7 },
  { 155, 3, 3, 11, 3, -3 },
  { 157, 10, 15, 11, 1, -14 },
  { 176, 9, 14, 11, 1, -14 },
  { 192, 7, 14, 11, 2, -14 },
  { 205, 10, 14, 11, 0, -14 },
  { 223, 10, 14, 11, 0, -14 },
  { 241, 10, 14, 11, 0, -14 },
  { 259, 10, 14, 11, 1, -14 },
  { 277, 9, 14, 11, 1, -14 },
  { 293, 10, 14, 11, 1, -14 },
  { 311, 9, 14, 11, 1, -14 },
  { 327, 8, 14, 11, 2, -14 },
  { 341, 4, 11, 11, 4, -11 },
  { 347, 5, 15, 11, 3, -11 },
  { 357, 9, 8, 11, 1, -10 },
  { 366, 9, 6, 11, 1, -9 },
  { 373, 9, 9, 11, 1, -10 },
  { 384, 9, 14, 11, 2, -14 },
  { 400, 11, 13, 11, 0, -13 },
  { 418, 11, 14, 11, -1, -14 },
  { 438, 11, 14, 11, 0, -14 },
  { 458, 10, 14, 11, 1, -14 },
  { 476, 11, 14, 11, 0, -14 },
  { 496, 11, 14, 11, 0, -14 },
  { 516, 10, 14, 11, 1, -14 },
  { 534, 10, 14, 11, 1, -14 },
  { 552, 11, 14, 11, 0, -14 },
  { 572, 10, 14, 11, 1, -14 },
  { 590, 10, 14, 11, 1, -14 },
  { 608, 12, 14, 11, 0, -14 },
  { 629, 8, 14, 11, 1, -14 },
  { 643, 11, 14, 11, 0, -14 },
  { 663, 11, 14, 11, 0, -14 },
  { 683, 10, 14, 11, 1, -14 },
  { 701, 10, 14, 11, 1, -14 },
  { 719, 10, 16, 11, 1, -14 },
  { 739, 11, 14, 11, 0, -14 },
  { 759, 10, 14, 11, 1, -14 },
  { 777, 11, 14, 11, 1, -14 },
  { 797, 10, 14, 11, 1, -14 },
  { 815, 10, 14, 11, 2, -14 },
  { 833, 11, 14, 11, 1, -14 },
  { 853, 12, 14, 11, 0, -14 },
  { 874, 10, 14, 11, 2, -14 },
  { 892, 11, 14, 11, 0, -14 },
  { 912, 7, 19, 11, 2, -16 },
  { 929, 4, 15, 11, 4, -14 },
  { 937, 7, 19, 11, 2, -16 },
  { 954, 7, 8, 11, 2, -14 },
  { 961, 9, 2, 11, 0, 0 },
  { 964, 4, 3, 11, 5, -14 },
  { 966, 9, 10, 11, 1, -10 },
  { 978, 10, 14, 11, 0, -14 },
  { 996, 9, 10, 11, 1, -10 },
  { 1008, 10, 14, 11, 1, -14 },
  { 1026, 9, 10, 11, 1, -10 },
  { 1038, 10, 15, 11, 2, -15 },
  { 1057, 10, 14, 11, 0, -10 },
  { 1075, 10, 14, 11, 0, -14 },
  { 1093, 8, 14, 11, 1, -14 },
  { 1107, 9, 18, 11, 0, -14 },
  { 1128, 11, 14, 11, 0, -14 },
  { 1148, 8, 14, 11, 1, -14 },
  { 1162, 11, 10, 11, 0, -10 },
  { 1176, 10, 10, 11, 0, -10 },
  { 1189, 9, 10, 11, 1, -10 },
  { 1201, 10, 14, 11, 0, -10 },
  { 1219, 9, 14, 11, 1, -10 },
  { 1235, 9, 10, 11, 2, -10 },
  { 1247, 9, 10, 11, 1, -10 },
  { 1259, 8, 12, 11, 2, -12 },
  { 1271, 10, 10, 11, 1, -10 },
  { 1284, 10, 10, 11, 1, -10 },
  { 1297, 10, 10, 11, 1, -10 },
  { 1310, 11, 10, 11, 0, -10 },
  { 1324, 12, 14, 11, 0, -10 },
  { 1345, 10, 10, 11, 0, -10 },
  { 1358, 7, 18, 11, 3, -15 },
  { 1374, 5, 18, 11, 3, -14 },
  { 1386, 7, 18, 11, 2, -15 },
  { 1402, 11, 4, 11, 0, -8 },
};

const GFXfont RobotoMono_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic19pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_MEDIUMITALIC19PT7B_H_
