#ifndef _ROBOTOCONDENSED_LIGHT24PT7B_H_
#define _ROBOTOCONDENSED_LIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light24pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x02, 0x80, 0xBB, 0xBB, 0xA0, 0x0C, 0x41, 0x10,
  0x22, 0x04, 0x40, 0x88, 0xFF, 0xC2, 0x20, 0x8C, 0x11, 0x02, 0x20, 0x44,
  0x7F, 0xE1, 0x10, 0x46, 0x08, 0x81, 0x10, 0x22, 0x00, 0x04, 0x02, 0x07,
  0x86, 0x66, 0x1A, 0x05, 0x02, 0x80, 0x60, 0x18, 0x07, 0x80, 0x60, 0x18,
  0x07, 0x03, 0x81, 0x41, 0xB9, 0x87, 0x81, 0x80, 0xC0, 0x38, 0x02, 0x40,
  0x21, 0x11, 0x08, 0x88, 0x48, 0x42, 0x41, 0x24, 0x07, 0x20, 0x02, 0x00,
  0x13, 0x81, 0x26, 0x09, 0x10, 0x98, 0x8C, 0xC4, 0x42, 0x20, 0x13, 0x00,
  0x70, 0x1E, 0x06, 0x60, 0x84, 0x10, 0x82, 0x10, 0x44, 0x0D, 0x00, 0xC0,
  0x38, 0x0D, 0x8D, 0x19, 0xE1, 0x2C, 0x15, 0x83, 0x90, 0x33, 0x9A, 0x3E,
  0x60, 0xFF, 0x80, 0x11, 0x22, 0x44, 0xC8, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xC4, 0x46, 0x21, 0x10, 0x88, 0x44, 0x22, 0x31, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x32, 0x24, 0x48, 0x80, 0x04, 0x01, 0x00, 0x41, 0x13, 0x7F, 0x83,
  0x00, 0xE0, 0x48, 0x31, 0x08, 0x40, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x57, 0x80, 0xF0,
  0xF0, 0x04, 0x08, 0x10, 0x60, 0x81, 0x06, 0x08, 0x10, 0x60, 0x81, 0x06,
  0x08, 0x10, 0x60, 0x81, 0x00, 0x1E, 0x19, 0x98, 0x68, 0x34, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x14, 0x0A, 0x0D, 0x84, 0x66, 0x1E,
  0x00, 0x0B, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x1E, 0x18, 0xC4, 0x1B, 0x06, 0xC0, 0x80, 0x60, 0x18, 0x04, 0x03, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x7F, 0xC0, 0x1E, 0x19,
  0x90, 0x68, 0x1C, 0x08, 0x04, 0x04, 0x06, 0x1E, 0x01, 0x80, 0x20, 0x1C,
  0x0E, 0x05, 0x06, 0xE6, 0x1E, 0x00, 0x03, 0x00, 0xC0, 0x50, 0x14, 0x09,
  0x06, 0x41, 0x10, 0xC4, 0x21, 0x18, 0x44, 0x13, 0x04, 0xFF, 0xC0, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF1,
  0xCC, 0x03, 0x00, 0x80, 0x60, 0x38, 0x1C, 0x0B, 0x04, 0xCC, 0x3C, 0x00,
  0x0E, 0x38, 0x60, 0x40, 0xC0, 0x80, 0xBC, 0xE6, 0xC3, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC3, 0x66, 0x3C, 0xFF, 0x80, 0x40, 0x20, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x00, 0x1E, 0x19, 0x90, 0x68, 0x14, 0x0A, 0x05, 0x86, 0x66, 0x1E, 0x30,
  0x90, 0x38, 0x1C, 0x0E, 0x05, 0x06, 0xE6, 0x1E, 0x00, 0x1E, 0x39, 0x90,
  0x58, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0x41, 0xB1, 0x4F, 0x20, 0x10, 0x18,
  0x08, 0x0C, 0x1C, 0x38, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x50, 0x00, 0x01,
  0x5E, 0x01, 0x07, 0x1C, 0x30, 0xC0, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x1C,
  0x38, 0x70, 0xE0, 0x40, 0x00, 0x3C, 0x66, 0xC2, 0x83, 0x03, 0x02, 0x02,
  0x04, 0x0C, 0x18, 0x10, 0x10, 0x00, 0x00, 0x00, 0x10, 0x10, 0x03, 0xF0,
  0x07, 0x0C, 0x06, 0x01, 0x02, 0x00, 0x42, 0x00, 0x31, 0x0F, 0x09, 0x0C,
  0xC4, 0x84, 0x22, 0x46, 0x31, 0x22, 0x18, 0xB1, 0x08, 0x50, 0x84, 0x28,
  0x42, 0x16, 0x21, 0x09, 0x11, 0x84, 0x8C, 0xE4, 0x43, 0x9C, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0xC3, 0x00, 0x3F, 0x00, 0x04, 0x00, 0xE0,
  0x0A, 0x00, 0xA0, 0x0B, 0x01, 0x10, 0x11, 0x01, 0x18, 0x30, 0x82, 0x08,
  0x20, 0xC7, 0xFC, 0x40, 0x44, 0x06, 0xC0, 0x68, 0x02, 0x80, 0x20, 0xFE,
  0x20, 0xC8, 0x1A, 0x02, 0x80, 0xA0, 0x28, 0x1A, 0x0C, 0xFE, 0x20, 0x68,
  0x0A, 0x02, 0x80, 0xE0, 0x28, 0x0A, 0x0E, 0xFE, 0x00, 0x1E, 0x1C, 0xE4,
  0x0B, 0x03, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x70, 0x34, 0x09, 0xCE, 0x1E, 0x00, 0xFE, 0x21, 0xC8, 0x1A, 0x03,
  0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x1A, 0x0C, 0xFE, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1F, 0x1C, 0xE4,
  0x0F, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x21, 0xF8, 0x06, 0x01,
  0x80, 0x70, 0x14, 0x05, 0xC7, 0x1F, 0x00, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x1C, 0x0B, 0x04, 0xCE, 0x3C, 0x00, 0x80, 0xD0, 0x32, 0x04,
  0x41, 0x08, 0x61, 0x18, 0x26, 0x04, 0x80, 0xB8, 0x1D, 0x83, 0x10, 0x43,
  0x08, 0x31, 0x02, 0x20, 0x64, 0x06, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xE8, 0x05, 0xA0, 0x16, 0xC0, 0xD9,
  0x02, 0x64, 0x09, 0x98, 0x66, 0x21, 0x18, 0x8C, 0x63, 0x21, 0x84, 0x86,
  0x16, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0xC0, 0x78, 0x0F, 0x81, 0xD0,
  0x3B, 0x07, 0x20, 0xE2, 0x1C, 0x63, 0x84, 0x70, 0xCE, 0x09, 0xC1, 0xB8,
  0x17, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x60, 0x1F, 0x0E, 0x73, 0x03, 0x40,
  0x28, 0x05, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x05, 0x00, 0x90, 0x33, 0x9C, 0x1F, 0x00, 0xFE, 0x20, 0xE8, 0x0A, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x02, 0x83, 0xBF, 0x88, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x03, 0x9C, 0x60, 0x64, 0x02, 0x40,
  0x24, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x02, 0x40,
  0x24, 0x02, 0x60, 0x63, 0x9C, 0x0F, 0x80, 0x0C, 0x00, 0x60, 0x02, 0xFE,
  0x20, 0xC8, 0x1A, 0x02, 0x80, 0xE0, 0x38, 0x0A, 0x06, 0x83, 0x3F, 0x88,
  0x22, 0x0C, 0x81, 0x20, 0x68, 0x0A, 0x03, 0x80, 0x40, 0x1F, 0x0C, 0xE6,
  0x0D, 0x01, 0x40, 0x50, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x70, 0x14, 0x0D, 0xC6, 0x1F, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x3C, 0x09, 0xCE, 0x3E, 0x00, 0x80, 0x30, 0x07, 0x01, 0xA0, 0x24, 0x04,
  0xC1, 0x88, 0x21, 0x04, 0x31, 0x82, 0x20, 0x44, 0x08, 0x81, 0xB0, 0x14,
  0x02, 0x80, 0x70, 0x04, 0x00, 0x80, 0x81, 0xE0, 0xC0, 0xB0, 0x70, 0x48,
  0x28, 0x24, 0x14, 0x32, 0x1A, 0x19, 0x89, 0x08, 0xC4, 0x44, 0x22, 0x22,
  0x13, 0x13, 0x09, 0x09, 0x86, 0x82, 0x81, 0x41, 0x40, 0xE0, 0xA0, 0x60,
  0x70, 0x30, 0x10, 0x18, 0x08, 0x00, 0xC0, 0x68, 0x09, 0x83, 0x10, 0xC3,
  0x10, 0x36, 0x02, 0x80, 0x70, 0x04, 0x01, 0xC0, 0x68, 0x09, 0x83, 0x18,
  0x41, 0x18, 0x32, 0x02, 0xC0, 0x60, 0x40, 0x36, 0x02, 0x20, 0x63, 0x04,
  0x10, 0xC1, 0x88, 0x08, 0x80, 0x90, 0x05, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xFF, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x18, 0x04, 0x03, 0x00, 0xFF, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x27, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04, 0xF3, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10, 0x60, 0xA1, 0x46, 0x89,
  0x91, 0x62, 0x86, 0xFF, 0x80, 0x42, 0x30, 0x1E, 0x31, 0x90, 0x58, 0x20,
  0x18, 0xFD, 0x86, 0x83, 0xC1, 0xE0, 0xF0, 0x6C, 0xF3, 0xD8, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xBC, 0xE6, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC3, 0xE6, 0xBC, 0x1E, 0x31, 0x90, 0x58, 0x3C, 0x0C, 0x02, 0x01,
  0x00, 0xC0, 0x60, 0x50, 0x6C, 0x61, 0xE0, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x09, 0xE5, 0x8A, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x05, 0x02,
  0x83, 0x72, 0x9E, 0x40, 0x1E, 0x31, 0x90, 0x58, 0x3C, 0x0C, 0x07, 0xFF,
  0x00, 0xC0, 0x60, 0x10, 0x0E, 0x71, 0xE0, 0x1C, 0xC2, 0x08, 0x23, 0xE2,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3C, 0xB1, 0x50,
  0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xA0, 0x50, 0x6E, 0x53, 0xC8,
  0x04, 0x02, 0x83, 0x63, 0x0F, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9C,
  0xA6, 0xC3, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC7, 0xFF, 0xC0, 0x11, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x13, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x8C, 0x98,
  0xB0, 0xA0, 0xF0, 0xD8, 0x88, 0x8C, 0x86, 0x82, 0x83, 0xFF, 0xFF, 0xC0,
  0xBC, 0x79, 0xCD, 0x9B, 0x0E, 0x14, 0x18, 0x38, 0x10, 0x70, 0x20, 0xE0,
  0x41, 0xC0, 0x83, 0x81, 0x07, 0x02, 0x0E, 0x04, 0x1C, 0x08, 0x38, 0x10,
  0x60, 0x9C, 0xA6, 0xC3, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x1E, 0x0C, 0xC4, 0x19, 0x02, 0xC0, 0xB0, 0x3C, 0x0F, 0x03,
  0xC0, 0x90, 0x24, 0x18, 0xCC, 0x1E, 0x00, 0xBC, 0xE6, 0xC3, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0xE6, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x3C, 0xB1, 0x50, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xA0,
  0x50, 0x6C, 0x53, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xBF, 0x31,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x00, 0x3E, 0x67, 0x41, 0x41, 0x40,
  0x30, 0x1C, 0x07, 0x01, 0xC1, 0xC1, 0x63, 0x3E, 0x30, 0xC3, 0x3F, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x07, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x83, 0xC5, 0x79, 0x81, 0x40, 0xB0,
  0x48, 0x64, 0x23, 0x10, 0x98, 0x48, 0x24, 0x0E, 0x06, 0x03, 0x01, 0x80,
  0x82, 0x0E, 0x0C, 0x2C, 0x30, 0x91, 0xC2, 0x45, 0x99, 0x12, 0x46, 0x49,
  0x0A, 0x24, 0x28, 0xD0, 0xA1, 0xC3, 0x86, 0x04, 0x18, 0x10, 0x60, 0xC1,
  0x21, 0x98, 0x84, 0xC3, 0x40, 0xC0, 0x60, 0x30, 0x34, 0x13, 0x18, 0x88,
  0x6C, 0x10, 0x81, 0x40, 0xB0, 0xC8, 0x44, 0x23, 0x10, 0x98, 0x48, 0x34,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x20, 0x70, 0x00, 0xFF,
  0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x18,
  0x0F, 0xF8, 0x0C, 0x61, 0x0C, 0x30, 0x82, 0x08, 0x20, 0x82, 0x18, 0xC1,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x30, 0x41, 0x83, 0xFF, 0xFF, 0xF0, 0x41,
  0x82, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x02, 0x0C, 0x61, 0x04, 0x10,
  0x41, 0x04, 0x30, 0x86, 0x10, 0x70, 0x7B, 0x8A, 0x1B, 0x41, 0xC0,
};

const GFXglyph RobotoCondensed_Light24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 17, 5, 2, -17 },
  { 6, 4, 5, 7, 2, -18 },
  { 9, 11, 17, 12, 1, -17 },
  { 33, 9, 21, 12, 1, -19 },
  { 57, 13, 17, 15, 1, -17 },
  { 85, 11, 17, 13, 1, -17 },
  { 109, 2, 5, 4, 1, -18 },
  { 111, 4, 25, 7, 2, -19 },
  { 124, 4, 25, 7, 1, -19 },
  { 137, 10, 10, 10, 0, -17 },
  { 150, 10, 12, 12, 1, -13 },
  { 165, 2, 5, 5, 1, -2 },
  { 167, 4, 1, 6, 1, -8 },
  { 168, 2, 2, 6, 2, -2 },
  { 169, 7, 18, 9, 1, -17 },
  { 185, 9, 17, 12, 1, -17 },
  { 205, 5, 17, 12, 2, -17 },
  { 216, 10, 17, 12, 1, -17 },
  { 238, 9, 17, 12, 1, -17 },
  { 258, 10, 17, 12, 1, -17 },
  { 280, 9, 17, 12, 2, -17 },
  { 300, 8, 17, 12, 2, -17 },
  { 317, 9, 17, 12, 1, -17 },
  { 337, 9, 17, 12, 1, -17 },
  { 357, 9, 17, 12, 1, -17 },
  { 377, 2, 13, 5, 2, -13 },
  { 381, 2, 16, 4, 1, -13 },
  { 385, 8, 10, 11, 1, -13 },
  { 395, 8, 6, 12, 2, -11 },
  { 401, 9, 10, 11, 1, -13 },
  { 413, 8, 17, 10, 1, -17 },
  { 430, 17, 22, 19, 1, -17 },
  { 477, 12, 17, 13, 1, -17 },
  { 503, 10, 17, 13, 2, -17 },
  { 525, 10, 17, 14, 2, -17 },
  { 547, 10, 17, 14, 2, -17 },
  { 569, 9, 17, 12, 2, -17 },
  { 589, 9, 17, 12, 2, -17 },
  { 609, 10, 17, 14, 2, -17 },
  { 631, 11, 17, 15, 2, -17 },
  { 655, 2, 17, 6, 2, -17 },
  { 660, 9, 17, 12, 1, -17 },
  { 680, 11, 17, 13, 2, -17 },
  { 704, 8, 17, 11, 2, -17 },
  { 721, 14, 17, 18, 2, -17 },
  { 751, 11, 17, 15, 2, -17 },
  { 775, 11, 17, 14, 2, -17 },
  { 799, 10, 17, 13, 2, -17 },
  { 821, 12, 20, 14, 1, -17 },
  { 851, 10, 17, 13, 2, -17 },
  { 873, 10, 17, 12, 1, -17 },
  { 895, 11, 17, 13, 1, -17 },
  { 919, 10, 17, 14, 2, -17 },
  { 941, 11, 17, 13, 1, -17 },
  { 965, 17, 17, 19, 1, -17 },
  { 1002, 11, 17, 13, 1, -17 },
  { 1026, 12, 17, 13, 0, -17 },
  { 1052, 10, 17, 13, 1, -17 },
  { 1074, 3, 24, 5, 2, -20 },
  { 1083, 7, 18, 8, 1, -17 },
  { 1099, 4, 24, 5, 0, -20 },
  { 1111, 7, 9, 9, 1, -17 },
  { 1119, 9, 1, 9, 0, 0 },
  { 1121, 4, 3, 7, 1, -18 },
  { 1123, 9, 13, 11, 1, -13 },
  { 1138, 8, 18, 12, 2, -18 },
  { 1156, 9, 13, 11, 1, -13 },
  { 1171, 9, 18, 12, 1, -18 },
  { 1192, 9, 13, 11, 1, -13 },
  { 1207, 6, 18, 7, 1, -18 },
  { 1221, 9, 18, 12, 1, -13 },
  { 1242, 8, 18, 12, 2, -18 },
  { 1260, 1, 18, 5, 2, -18 },
  { 1263, 4, 23, 5, -1, -18 },
  { 1275, 8, 18, 10, 2, -18 },
  { 1293, 1, 18, 5, 2, -18 },
  { 1296, 15, 13, 18, 2, -13 },
  { 1321, 8, 13, 12, 2, -13 },
  { 1334, 10, 13, 12, 1, -13 },
  { 1351, 8, 18, 12, 2, -13 },
  { 1369, 9, 18, 12, 1, -13 },
  { 1390, 5, 13, 7, 2, -13 },
  { 1399, 8, 13, 11, 1, -13 },
  { 1412, 6, 16, 7, 0, -16 },
  { 1424, 8, 13, 12, 2, -13 },
  { 1437, 9, 13, 10, 1, -13 },
  { 1452, 14, 13, 16, 1, -13 },
  { 1475, 9, 13, 10, 1, -13 },
  { 1490, 9, 18, 10, 1, -13 },
  { 1511, 9, 13, 10, 1, -13 },
  { 1526, 6, 24, 7, 1, -19 },
  { 1544, 1, 20, 5, 2, -17 },
  { 1547, 6, 24, 7, 0, -19 },
  { 1565, 11, 4, 14, 2, -9 },
};

const GFXfont RobotoCondensed_Light24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_LIGHT24PT7B_H_
