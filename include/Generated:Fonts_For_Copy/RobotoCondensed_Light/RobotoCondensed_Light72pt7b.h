#ifndef _ROBOTOCONDENSED_LIGHT72PT7B_H_
#define _ROBOTOCONDENSED_LIGHT72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light72pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xDE, 0x60, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x80, 0x3C, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x07, 0x81, 0xC0,
  0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x38, 0x00,
  0x00, 0xFF, 0x80, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x7E, 0x00, 0x00, 0x1E, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x3F, 0xFC,
  0x00, 0x03, 0xC1, 0xE0, 0xF8, 0x00, 0x0E, 0x07, 0x01, 0xE0, 0x00, 0x78,
  0x3C, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x07, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x1E, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x03, 0xC0,
  0x10, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x78, 0x1F, 0x00, 0x78,
  0x78, 0x07, 0xC0, 0x3C, 0x7C, 0x01, 0xE0, 0x1E, 0x3C, 0x00, 0xF8, 0x0F,
  0x1E, 0x00, 0x3E, 0x07, 0x9E, 0x00, 0x0F, 0x03, 0xCF, 0x00, 0x07, 0xC3,
  0xC7, 0x80, 0x01, 0xF1, 0xE3, 0xC0, 0x00, 0x7C, 0xF1, 0xE0, 0x00, 0x1E,
  0xF0, 0xF0, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x3F, 0xF8, 0x1F, 0xC0,
  0x7F, 0x3E, 0x07, 0xFF, 0xFE, 0x0F, 0x01, 0xFF, 0xFE, 0x03, 0xC0, 0x3F,
  0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEE, 0x00, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x10, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x03, 0x00, 0x38, 0x03, 0x9F,
  0x01, 0xC0, 0x7D, 0xFF, 0x0E, 0x1F, 0xEF, 0xFF, 0x73, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C,
  0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0x70, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xFF, 0xFF, 0x7C, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0,
  0xFF, 0xE7, 0xFD, 0xFF, 0xE3, 0xFF, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xF8,
  0x1F, 0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x87, 0xF8, 0x00, 0xE7, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x78,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xE0,
  0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x03, 0xF8, 0x03, 0xC3, 0xFF, 0xC0, 0xF1,
  0xFF, 0xF8, 0x3D, 0xFF, 0xFF, 0x0F, 0x7C, 0x07, 0xE3, 0xFC, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1,
  0xF8, 0x03, 0xE0, 0x3F, 0x83, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xFC,
  0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x0F, 0xF1, 0xF8, 0x0F, 0xBC, 0x3F, 0xFF,
  0xCF, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0xF0, 0x07, 0xE0, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7B, 0xEF, 0xFF, 0xF9, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xEF, 0xFF, 0xF9, 0xC0, 0x1E,
  0x1F, 0x3F, 0x3F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0x70, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x3F,
  0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0xFE, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0x07, 0x00, 0x07,
  0xE3, 0xF0, 0x03, 0x83, 0x80, 0x07, 0xC0, 0x78, 0x01, 0xC3, 0xC0, 0x03,
  0xC0, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x9C, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xCE, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE7, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x73, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x3B, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x1D, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0xF0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xB8,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xEE,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x77, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3B,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x1D, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x1C,
  0xF0, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x38, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x1C, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03, 0xF0, 0x03,
  0x87, 0x00, 0x3C, 0x01, 0xB8, 0x03, 0xC3, 0x80, 0x1E, 0x01, 0xDE, 0x01,
  0xC1, 0xE0, 0x07, 0x83, 0xCF, 0x03, 0xC0, 0x70, 0x03, 0xFF, 0xC3, 0xE7,
  0xE0, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1E, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x03, 0xF8,
  0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x1F, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7E, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x7F, 0x83, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7F, 0x0F,
  0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x03, 0xE0,
  0x7F, 0x03, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00,
  0xF1, 0xF8, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x00, 0xF7, 0xFE, 0x00, 0x00,
  0xF7, 0xBE, 0x00, 0x00, 0xFF, 0x9F, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00,
  0xFE, 0x07, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0xFD, 0xE0, 0x00, 0x00, 0x1E,
  0xFF, 0x78, 0x00, 0x00, 0x07, 0xBF, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0xF3,
  0xC0, 0x00, 0x00, 0xF3, 0xFC, 0xF0, 0x00, 0x00, 0x3C, 0xFF, 0x3C, 0x00,
  0x00, 0x1E, 0x3F, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0xF1, 0xE0, 0x00, 0x01,
  0xE3, 0xFC, 0x78, 0x00, 0x00, 0xF0, 0xFF, 0x0F, 0x00, 0x00, 0x3C, 0x3F,
  0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0xF0, 0x70, 0x00, 0x07, 0x83, 0xFC, 0x1E,
  0x00, 0x01, 0xE0, 0xFF, 0x07, 0x80, 0x00, 0x78, 0x3F, 0xC0, 0xE0, 0x00,
  0x3C, 0x0F, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xFC, 0x0F, 0x00, 0x03, 0x80,
  0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0xF0,
  0x1E, 0x00, 0x1C, 0x03, 0xFC, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x03, 0xC0, 0x3F, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0x00, 0x38, 0x0F, 0x00, 0x3F,
  0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xFC, 0x00,
  0x70, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0xFC, 0x00, 0x3C, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x38, 0x00, 0x3F, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x0F,
  0xF7, 0x80, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x0F,
  0xF1, 0xE0, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x0F,
  0xF0, 0x78, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x0F,
  0xF0, 0x3C, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x0F,
  0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0x80, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x0F,
  0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x00, 0xF8, 0x0F,
  0xF0, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x3C, 0x0F,
  0xF0, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x0F, 0x0F,
  0xF0, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0x07, 0xCF,
  0xF0, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x03, 0xEF, 0xF0, 0x00, 0x01, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xC3, 0xC0, 0x00,
  0x1F, 0x8F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07,
  0xE3, 0xC0, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0x00, 0x03, 0xF8, 0x1E, 0x00, 0x01, 0xF8, 0x3C, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0xC1,
  0xE0, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x38, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xC0,
  0x0F, 0x00, 0xF0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1C,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x0E, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x87, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x38, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x3C, 0x00,
  0x03, 0xCE, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3D, 0xC0, 0x03, 0x9E, 0x00, 0x39, 0xE0, 0x07,
  0x8E, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x03, 0x81, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x1C,
  0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE1, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x9C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x71,
  0xF8, 0x00, 0x38, 0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x0E, 0x78, 0x00, 0x07,
  0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xDF, 0x00, 0x3D, 0xEF, 0xE0, 0x7C, 0xF3, 0xFF,
  0xFC, 0x78, 0xFF, 0xFC, 0x3C, 0x1F, 0xFC, 0x1E, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x00, 0xF0, 0x7F, 0xF0, 0x3C, 0x7F, 0xFE, 0x0F, 0x3F, 0xFF,
  0xC3, 0xDF, 0x03, 0xF8, 0xF7, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xCF, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xF0, 0x00, 0x3E, 0xFE,
  0x00, 0x1F, 0x3F, 0xC0, 0x0F, 0xCF, 0x7C, 0x0F, 0xE3, 0xCF, 0xFF, 0xF0,
  0xF1, 0xFF, 0xF8, 0x3C, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x7E, 0x00, 0x3C, 0x07, 0xF0, 0x1F, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x0F, 0x01, 0xFF, 0xC3, 0xC1, 0xFF, 0xF8, 0xF0,
  0xFF, 0xFF, 0x3C, 0x7F, 0x03, 0xEF, 0x3F, 0x00, 0x3F, 0xCF, 0x80, 0x07,
  0xF7, 0xC0, 0x00, 0xFD, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0xF0, 0x00,
  0x3F, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x0F, 0xF1, 0xFC, 0x0F, 0xBC, 0x3F,
  0xFF, 0xCF, 0x07, 0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x3E, 0x00, 0x1F, 0x07, 0xF0,
  0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xF0, 0xF0, 0x7F, 0xFE, 0x3C, 0x3F, 0xFF, 0xCF, 0x1F, 0xC0, 0xFB, 0xCF,
  0xC0, 0x0F, 0xF3, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF1, 0xF0, 0x03,
  0xFC, 0x7F, 0x03, 0xEF, 0x0F, 0xFF, 0xF3, 0xC1, 0xFF, 0xF8, 0xF0, 0x1F,
  0xFC, 0x3C, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE1, 0x00, 0x00, 0x78, 0x60, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0xE0,
  0x1F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x7F, 0xF0, 0x78, 0x7F, 0xFC, 0x3C,
  0x7F, 0xFF, 0x1E, 0x7C, 0x1F, 0xCF, 0x78, 0x03, 0xE7, 0xF8, 0x00, 0xF3,
  0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3C, 0x37, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF0, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xCF,
  0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80,
  0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xC0,
  0x07, 0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0,
  0x00, 0x7B, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xEF, 0x00, 0x0F, 0xE7,
  0xC0, 0x07, 0xE1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0x83, 0xFF, 0x00, 0x3F, 0xF8, 0x3C, 0x7F, 0xFE,
  0x07, 0xFF, 0xE1, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x7C, 0x0F, 0xC7,
  0xC0, 0x7E, 0x7B, 0x80, 0x1F, 0x3C, 0x01, 0xF3, 0xF8, 0x00, 0x7B, 0xC0,
  0x07, 0xDF, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF7, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x3F, 0xF8, 0x3C, 0x3F, 0xFE, 0x1E,
  0x3F, 0xFF, 0x8F, 0x3E, 0x0F, 0xE7, 0xBC, 0x01, 0xF3, 0xFC, 0x00, 0x79,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x3C, 0x1F, 0xFC, 0x0F, 0x1F, 0xFF, 0x83, 0xCF, 0xFF,
  0xF0, 0xF7, 0xC0, 0xFE, 0x3F, 0xC0, 0x0F, 0xCF, 0xE0, 0x01, 0xF3, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xCF, 0xF0, 0x03, 0xF3, 0xDF, 0x03, 0xF8, 0xF3, 0xFF, 0xFC,
  0x3C, 0x7F, 0xFE, 0x0F, 0x0F, 0xFE, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xF0, 0xF0, 0x7F, 0xFE, 0x3C, 0x3F, 0xFF, 0xCF, 0x1F, 0xC0, 0xFB,
  0xCF, 0xC0, 0x0F, 0xF3, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x3F, 0x78, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF1, 0xF0,
  0x03, 0xFC, 0x7F, 0x03, 0xEF, 0x0F, 0xFF, 0xF3, 0xC1, 0xFF, 0xF8, 0xF0,
  0x1F, 0xFC, 0x3C, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF,
  0x7F, 0x3E, 0xF0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x3F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x81, 0xF7,
  0x1F, 0xFF, 0xE7, 0x0F, 0xFF, 0xC7, 0x07, 0xFF, 0x07, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x38, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x38, 0x00, 0x1F, 0x00, 0x07, 0x8F,
  0x00, 0x0F, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0xF0, 0x00,
  0xFE, 0x00, 0x1E, 0x1C, 0x00, 0x7B, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xCF, 0x00, 0x3C,
  0x0E, 0x00, 0xF1, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0xF0,
  0x0E, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x83, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0xE0, 0x1C, 0x01, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x70, 0x38, 0x00,
  0xE0, 0xE0, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x07, 0x87, 0x80, 0x0F, 0x1E,
  0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x00, 0x71, 0xC0, 0x0F,
  0x1C, 0x00, 0x1E, 0x70, 0x01, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x73, 0xC0,
  0x01, 0xEF, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x07, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x1E, 0x00,
  0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0,
  0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x40, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xC7, 0xFF,
  0x80, 0x01, 0xE7, 0xFF, 0xE0, 0x00, 0xF3, 0xC1, 0xF8, 0x00, 0x73, 0xC0,
  0x3E, 0x00, 0x39, 0xE0, 0x0F, 0x80, 0x3D, 0xE0, 0x03, 0xE0, 0x1C, 0xF0,
  0x00, 0xF8, 0x3E, 0x78, 0x00, 0x3F, 0xFE, 0x38, 0x00, 0x0F, 0xFF, 0x1C,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoCondensed_Light72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 52, 15, 5, -51 },
  { 34, 12, 16, 21, 5, -54 },
  { 58, 33, 51, 37, 3, -51 },
  { 269, 27, 67, 35, 4, -59 },
  { 496, 38, 53, 46, 4, -52 },
  { 748, 33, 53, 39, 4, -52 },
  { 967, 4, 16, 12, 4, -54 },
  { 975, 14, 74, 21, 5, -57 },
  { 1105, 14, 74, 21, 2, -57 },
  { 1235, 29, 29, 31, 1, -51 },
  { 1341, 29, 37, 36, 3, -42 },
  { 1476, 8, 16, 14, 2, -7 },
  { 1492, 14, 4, 19, 2, -25 },
  { 1499, 6, 6, 17, 5, -5 },
  { 1504, 21, 55, 26, 2, -51 },
  { 1649, 27, 53, 35, 4, -52 },
  { 1828, 15, 51, 35, 6, -51 },
  { 1924, 28, 52, 35, 4, -52 },
  { 2106, 27, 53, 35, 4, -52 },
  { 2285, 30, 51, 35, 3, -51 },
  { 2477, 26, 52, 35, 6, -51 },
  { 2646, 26, 52, 35, 5, -51 },
  { 2815, 28, 51, 35, 3, -51 },
  { 2994, 27, 53, 35, 4, -52 },
  { 3173, 26, 52, 35, 4, -52 },
  { 3342, 6, 38, 15, 5, -37 },
  { 3371, 8, 46, 13, 2, -37 },
  { 3417, 24, 30, 32, 3, -38 },
  { 3507, 25, 18, 35, 5, -33 },
  { 3564, 25, 30, 33, 4, -38 },
  { 3658, 23, 53, 29, 3, -52 },
  { 3811, 49, 66, 56, 4, -50 },
  { 4216, 36, 51, 40, 2, -51 },
  { 4446, 29, 51, 39, 6, -51 },
  { 4631, 32, 53, 41, 5, -52 },
  { 4843, 30, 51, 41, 6, -51 },
  { 5035, 27, 51, 36, 6, -51 },
  { 5208, 27, 51, 35, 6, -51 },
  { 5381, 32, 53, 43, 5, -52 },
  { 5593, 32, 51, 44, 6, -51 },
  { 5797, 4, 51, 18, 7, -51 },
  { 5823, 26, 52, 35, 3, -51 },
  { 5992, 32, 51, 40, 6, -51 },
  { 6196, 25, 51, 33, 6, -51 },
  { 6356, 42, 51, 54, 6, -51 },
  { 6624, 32, 51, 44, 6, -51 },
  { 6828, 33, 53, 42, 5, -52 },
  { 7047, 30, 51, 39, 6, -51 },
  { 7239, 34, 61, 42, 4, -52 },
  { 7499, 31, 51, 40, 6, -51 },
  { 7697, 31, 53, 37, 3, -52 },
  { 7903, 33, 51, 38, 2, -51 },
  { 8114, 31, 52, 41, 5, -51 },
  { 8316, 35, 51, 39, 2, -51 },
  { 8540, 50, 51, 56, 3, -51 },
  { 8859, 34, 51, 39, 2, -51 },
  { 9076, 35, 51, 38, 1, -51 },
  { 9300, 31, 51, 38, 3, -51 },
  { 9498, 10, 70, 16, 5, -59 },
  { 9586, 22, 55, 25, 2, -51 },
  { 9738, 10, 70, 16, 1, -59 },
  { 9826, 20, 26, 27, 3, -51 },
  { 9891, 26, 4, 28, 1, 0 },
  { 9904, 11, 10, 21, 4, -54 },
  { 9918, 25, 40, 34, 4, -39 },
  { 10043, 26, 55, 35, 5, -54 },
  { 10222, 27, 40, 33, 3, -39 },
  { 10357, 26, 55, 35, 4, -54 },
  { 10536, 27, 40, 33, 3, -39 },
  { 10671, 18, 55, 22, 3, -55 },
  { 10795, 26, 54, 35, 4, -39 },
  { 10971, 25, 54, 35, 5, -54 },
  { 11140, 5, 52, 15, 5, -52 },
  { 11173, 12, 67, 15, -2, -52 },
  { 11274, 25, 54, 31, 5, -54 },
  { 11443, 4, 54, 15, 6, -54 },
  { 11470, 45, 39, 55, 5, -39 },
  { 11690, 25, 39, 35, 5, -39 },
  { 11812, 28, 40, 35, 4, -39 },
  { 11952, 26, 54, 35, 5, -39 },
  { 12128, 26, 54, 35, 4, -39 },
  { 12304, 15, 39, 22, 5, -39 },
  { 12378, 24, 40, 32, 4, -39 },
  { 12498, 17, 49, 21, 1, -48 },
  { 12603, 24, 39, 35, 5, -38 },
  { 12720, 27, 38, 31, 2, -38 },
  { 12849, 42, 38, 47, 2, -38 },
  { 13049, 27, 38, 31, 2, -38 },
  { 13178, 27, 53, 30, 2, -38 },
  { 13357, 25, 38, 31, 3, -38 },
  { 13476, 17, 70, 21, 3, -56 },
  { 13625, 4, 61, 16, 6, -51 },
  { 13656, 18, 70, 21, 1, -56 },
  { 13814, 33, 13, 43, 5, -28 },
};

const GFXfont RobotoCondensed_Light72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_LIGHT72PT7B_H_
