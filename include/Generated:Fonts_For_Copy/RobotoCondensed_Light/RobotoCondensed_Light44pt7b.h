#ifndef _ROBOTOCONDENSED_LIGHT44PT7B_H_
#define _ROBOTOCONDENSED_LIGHT44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x00, 0x3F,
  0xD8, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x00, 0xC0,
  0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x30, 0x01, 0x83, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF0, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7C, 0xF8, 0x78, 0x1C, 0x38, 0x07, 0x18,
  0x01, 0x8C, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x39, 0x80, 0x1C, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x6C, 0x00, 0x76, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0C, 0x70, 0x0E,
  0x1F, 0x3E, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x60, 0x60, 0xC0, 0x60, 0x60, 0xC0, 0x60, 0xC0,
  0xC0, 0x60, 0xC0, 0xC0, 0x61, 0x80, 0xC0, 0x63, 0x00, 0x60, 0x63, 0x00,
  0x60, 0xC6, 0x00, 0x71, 0xC6, 0x00, 0x3F, 0x8C, 0x00, 0x1F, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x78, 0x00, 0x31, 0xFC, 0x00, 0x71, 0x8E,
  0x00, 0x63, 0x06, 0x00, 0xC3, 0x03, 0x00, 0xC2, 0x03, 0x01, 0x82, 0x03,
  0x01, 0x82, 0x03, 0x03, 0x02, 0x03, 0x03, 0x03, 0x03, 0x06, 0x03, 0x03,
  0x02, 0x03, 0x06, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0x8F, 0x00, 0x38, 0x38, 0x01, 0xC0,
  0xC0, 0x0C, 0x07, 0x00, 0x60, 0x38, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x1C, 0xE0, 0x00, 0x6E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xC7, 0x03, 0x0C,
  0x1C, 0x18, 0xE0, 0x60, 0xC6, 0x03, 0x86, 0x70, 0x0E, 0x33, 0x80, 0x3B,
  0x9C, 0x01, 0xD8, 0xE0, 0x07, 0xC3, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70,
  0x1F, 0x83, 0xE3, 0xEE, 0x0F, 0xFE, 0x38, 0x1F, 0xC0, 0xC0, 0xFF, 0xFF,
  0xF0, 0x01, 0x00, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x10, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70,
  0x30, 0x30, 0x18, 0x18, 0x18, 0x08, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x04, 0x0C, 0x03, 0x86, 0x0F, 0xFB, 0x3F,
  0x3F, 0xFE, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x77, 0x00, 0x71,
  0x80, 0x30, 0xE0, 0x38, 0x38, 0x38, 0x0E, 0x08, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x39, 0xCE, 0x73, 0x9C, 0xCE, 0x62, 0x00, 0xFF, 0xFF, 0xC0, 0x6F, 0xF6,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF0,
  0x3C, 0x78, 0x30, 0x1C, 0x70, 0x0C, 0x60, 0x0E, 0xE0, 0x06, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x06, 0x60, 0x0E,
  0x70, 0x0C, 0x38, 0x1C, 0x3E, 0x78, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x83,
  0xC7, 0xEF, 0xBF, 0x1E, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF0, 0x07,
  0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC7, 0x00, 0x73, 0x00, 0x39, 0x80, 0x0D,
  0xC0, 0x06, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xFD, 0xFF, 0xFE, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC7,
  0x00, 0x73, 0x80, 0x39, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0x9C, 0x01,
  0xC7, 0x01, 0xC1, 0xE3, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C,
  0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30,
  0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x0C, 0x0C,
  0x03, 0x07, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0x3F, 0xFF, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x33, 0xE0, 0x3F, 0xF8, 0x7E, 0x7C, 0x70,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x07, 0x30,
  0x06, 0x38, 0x0E, 0x1E, 0x3C, 0x0F, 0xF8, 0x03, 0xE0, 0x00, 0x78, 0x03,
  0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xCF, 0xF8, 0xDE,
  0x3C, 0xF8, 0x1E, 0xF0, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60,
  0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1E, 0x3C, 0x0F, 0xF8, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x8F, 0x87,
  0x01, 0xC3, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x38, 0x01, 0x9C, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0xE0, 0xF1, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1C, 0x1E, 0x1C, 0x03, 0x9C, 0x00, 0xCC, 0x00, 0x76,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x03, 0xB0, 0x01,
  0xDC, 0x01, 0xC7, 0x00, 0xE3, 0xE1, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x03, 0xC3, 0x00, 0xE3, 0x80, 0x39,
  0x80, 0x1C, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0x9C,
  0x07, 0x87, 0x8E, 0xC1, 0xFE, 0x60, 0x7C, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x3C, 0x00, 0x4E, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x4E, 0xEE, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9C, 0xE7, 0x39, 0xCC, 0xE6, 0x20,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x00, 0xE0, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xCF, 0x1C, 0x0E,
  0x60, 0x1B, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x10, 0x60, 0x0F,
  0x80, 0x61, 0x80, 0x7F, 0x01, 0x8C, 0x03, 0x86, 0x02, 0x30, 0x1C, 0x18,
  0x0C, 0xC0, 0x60, 0x60, 0x36, 0x03, 0x01, 0x80, 0xD8, 0x0C, 0x06, 0x03,
  0x60, 0x60, 0x18, 0x0D, 0x81, 0x80, 0x60, 0x36, 0x06, 0x01, 0x80, 0xD8,
  0x18, 0x06, 0x03, 0x60, 0x60, 0x18, 0x0D, 0x81, 0x80, 0x60, 0x36, 0x0E,
  0x01, 0x80, 0xD8, 0x38, 0x0C, 0x03, 0x60, 0x60, 0x30, 0x19, 0x81, 0x80,
  0xC0, 0x66, 0x06, 0x07, 0x81, 0x98, 0x1C, 0x36, 0x0C, 0x60, 0x39, 0xDC,
  0x61, 0x80, 0xFE, 0x3F, 0x83, 0x01, 0xE0, 0x78, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x80, 0x01, 0xC6, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0E,
  0x00, 0x70, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0x80,
  0x06, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00, 0x03,
  0x9C, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x0F, 0x18, 0x01, 0xCC, 0x00, 0x76, 0x00,
  0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0xD8,
  0x00, 0xCC, 0x00, 0xE6, 0x01, 0xE3, 0xFF, 0xE1, 0xFF, 0xF8, 0xC0, 0x1E,
  0x60, 0x03, 0xB0, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xD8, 0x01, 0xEC,
  0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x7C,
  0x3E, 0x1E, 0x01, 0xE3, 0x80, 0x1C, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x07, 0x1E, 0x01,
  0xE1, 0xF0, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0C, 0x07, 0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xEC, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x73, 0x00, 0x38, 0xC0,
  0x7C, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0x0F, 0x83, 0xC0, 0x1C, 0x38, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x1E, 0x0F, 0x87, 0xC0, 0x7F,
  0xF8, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E,
  0x70, 0x1C, 0x3C, 0x78, 0x1F, 0xF0, 0x07, 0xC0, 0xC0, 0x01, 0xD8, 0x00,
  0x73, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x0E,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x1C, 0x03, 0x07, 0x00, 0x61, 0xC0,
  0x0C, 0x70, 0x01, 0x8E, 0x00, 0x33, 0xC0, 0x06, 0xFC, 0x00, 0xFB, 0x80,
  0x1E, 0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0C, 0x07, 0x01, 0x80, 0x70,
  0x30, 0x0E, 0x06, 0x00, 0xE0, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x1C,
  0x60, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x03, 0xB0, 0x00, 0x38, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x6F, 0x60, 0x00, 0x37, 0xB8, 0x00, 0x3B, 0xDC, 0x00,
  0x19, 0xE6, 0x00, 0x0C, 0xF3, 0x80, 0x0E, 0x78, 0xC0, 0x06, 0x3C, 0x60,
  0x03, 0x1E, 0x38, 0x03, 0x8F, 0x0C, 0x01, 0x87, 0x86, 0x00, 0xC3, 0xC3,
  0x80, 0xE1, 0xE0, 0xC0, 0x60, 0xF0, 0x60, 0x70, 0x78, 0x38, 0x30, 0x3C,
  0x0C, 0x18, 0x1E, 0x06, 0x1C, 0x0F, 0x03, 0x8C, 0x07, 0x80, 0xC6, 0x03,
  0xC0, 0x67, 0x01, 0xE0, 0x1B, 0x00, 0xF0, 0x0D, 0x80, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x06, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xB0, 0x00,
  0xF7, 0x00, 0x1E, 0x60, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x01,
  0xE1, 0xC0, 0x3C, 0x18, 0x07, 0x83, 0x80, 0xF0, 0x30, 0x1E, 0x07, 0x03,
  0xC0, 0x60, 0x78, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0C, 0x3C, 0x01, 0xC7,
  0x80, 0x18, 0xF0, 0x03, 0x9E, 0x00, 0x33, 0xC0, 0x07, 0x78, 0x00, 0x6F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x18,
  0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0x9F, 0x83, 0xC0, 0x3C, 0x38, 0x01,
  0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x60, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1F, 0x9F,
  0x80, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x01,
  0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0xEC, 0x00, 0x73, 0x00, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0x9F, 0x83,
  0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x06,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x01, 0xC3,
  0xC0, 0x3C, 0x1F, 0x9F, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0C, 0x03, 0xE3, 0x00, 0x3C, 0xC0, 0x07, 0x30, 0x00, 0xEC,
  0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0E, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0xF3, 0x00, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFC, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x07, 0x0C,
  0x00, 0xC3, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xCC, 0x00, 0x33, 0x00,
  0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1C, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7C, 0x7C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xE0, 0x03, 0x98, 0x00,
  0x33, 0x00, 0x07, 0x60, 0x00, 0xEE, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x07,
  0x1C, 0x01, 0xE1, 0xF0, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07,
  0x1C, 0x01, 0xC1, 0xF0, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x66, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x30,
  0xC0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x60, 0x70,
  0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x18, 0x01, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18,
  0xE0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x0D, 0x80, 0x07, 0x00, 0x1B, 0x80, 0x1E, 0x00, 0x37,
  0x00, 0x3C, 0x00, 0xE6, 0x00, 0x78, 0x01, 0xCC, 0x00, 0xF8, 0x03, 0x18,
  0x03, 0xB0, 0x06, 0x38, 0x06, 0x60, 0x0C, 0x70, 0x0C, 0xC0, 0x38, 0x60,
  0x19, 0xC0, 0x70, 0xC0, 0x71, 0x80, 0xC1, 0x80, 0xC3, 0x01, 0x83, 0x81,
  0x86, 0x07, 0x07, 0x03, 0x0C, 0x0E, 0x06, 0x0E, 0x0C, 0x18, 0x0C, 0x18,
  0x18, 0x30, 0x18, 0x30, 0x30, 0x60, 0x38, 0x60, 0x61, 0xC0, 0x31, 0xC0,
  0x63, 0x80, 0x63, 0x00, 0xC6, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0xCC, 0x03,
  0x18, 0x03, 0xB8, 0x03, 0x70, 0x03, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x0D,
  0x80, 0x0D, 0x80, 0x1B, 0x00, 0x1B, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x39, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x01, 0xC1,
  0xC0, 0x0C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x63, 0x80, 0x03, 0x98, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x1C,
  0x0C, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0x80, 0x60, 0x0E, 0x07, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E,
  0x0C, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x30, 0x0E, 0x03, 0x80, 0x70,
  0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0xC7, 0x00,
  0x06, 0x30, 0x00, 0x3B, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0xFF, 0xFC, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xF8, 0x06, 0x00,
  0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0x98, 0x19, 0x81, 0x98, 0x30, 0xC3,
  0x0C, 0x30, 0xC7, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0x07, 0xF0, 0x1F,
  0xF8, 0x3C, 0x3C, 0x38, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x07, 0xFE, 0x1F, 0xFE, 0x3C, 0x06, 0x70,
  0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0x70,
  0x1E, 0x7C, 0xF7, 0x3F, 0xE7, 0x0F, 0x87, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE3, 0xF0, 0xEF, 0xF8, 0xFC, 0x3C, 0xF0, 0x0E, 0xF0,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xF0, 0x0E, 0xFC, 0x3C, 0xCF, 0xF8, 0xC3,
  0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3E, 0x3C, 0x38, 0x0E, 0x70, 0x06, 0x60,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x60,
  0x07, 0x70, 0x06, 0x38, 0x0E, 0x3E, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE3, 0x1F, 0xF3, 0x3E,
  0x3B, 0x38, 0x0F, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x03, 0x70, 0x07, 0x38, 0x0F, 0x3E,
  0x3B, 0x1F, 0xF3, 0x07, 0xE3, 0x03, 0xF0, 0x0F, 0xF8, 0x1E, 0x3C, 0x38,
  0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x02, 0x38, 0x07, 0x3F, 0x1E, 0x0F,
  0xFC, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x3C, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x03, 0xFF, 0x7F, 0xE1, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x3E, 0x3B, 0x38, 0x0F, 0x70, 0x07, 0x60,
  0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x70, 0x07, 0x38, 0x0F, 0x3E, 0x3B, 0x1F, 0xF3, 0x07, 0xE3, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x20, 0x07, 0x30, 0x0E, 0x3C,
  0x3E, 0x1F, 0xFC, 0x03, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x8F, 0xC7, 0x3F, 0xCE, 0xE3, 0xDF, 0x03, 0xBC, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xFD, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xC7, 0xBE, 0x78, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xE0,
  0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xE7, 0x00, 0xEE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xF3, 0x80, 0xE3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC3, 0xE0, 0x3F, 0x0C, 0xFF, 0x87, 0xF8, 0xDC, 0x3C, 0xE3, 0xCD,
  0x81, 0xD8, 0x0E, 0xF0, 0x0F, 0x00, 0xEE, 0x00, 0xF0, 0x06, 0xE0, 0x0E,
  0x00, 0x6E, 0x00, 0x60, 0x06, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07,
  0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00,
  0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00,
  0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0,
  0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x70, 0xE3, 0xF1,
  0xCF, 0xF3, 0xB8, 0xF7, 0xC0, 0xEF, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x8F,
  0x87, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x1D, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xC7, 0x00,
  0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xC3, 0xE0, 0xCF, 0xF8, 0xFC,
  0x3C, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xF0, 0x0E, 0xFC,
  0x3C, 0xEF, 0xF8, 0xE3, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07,
  0xE3, 0x1F, 0xF3, 0x3E, 0x3B, 0x38, 0x0F, 0x70, 0x07, 0x60, 0x03, 0x60,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70,
  0x07, 0x38, 0x0F, 0x3E, 0x3B, 0x1F, 0xFB, 0x07, 0xE3, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0xE3, 0xF7, 0xFF, 0xFF, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80,
  0xE7, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB8, 0x00, 0x38, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xE0,
  0x07, 0xC0, 0x0D, 0x80, 0x1B, 0x80, 0x73, 0xC7, 0xC3, 0xFF, 0x01, 0xF8,
  0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x3F,
  0x03, 0xC0, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1D,
  0x80, 0x3B, 0x80, 0xF7, 0xCF, 0x67, 0xFC, 0xC3, 0xE1, 0x80, 0xE0, 0x03,
  0x30, 0x01, 0x98, 0x01, 0xCE, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xE0,
  0x38, 0x70, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x07, 0x06, 0x01, 0x83, 0x00,
  0xC3, 0x80, 0x71, 0x80, 0x18, 0xC0, 0x0C, 0xE0, 0x07, 0x60, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xD8, 0x03, 0x80, 0x77, 0x00, 0xE0, 0x19, 0xC0, 0x78, 0x06,
  0x30, 0x1F, 0x01, 0x8C, 0x06, 0xC0, 0xE3, 0x01, 0xB0, 0x38, 0xE0, 0xCC,
  0x0C, 0x18, 0x33, 0x83, 0x06, 0x0C, 0x61, 0xC1, 0x87, 0x18, 0x70, 0x71,
  0x86, 0x18, 0x0C, 0x61, 0xC6, 0x03, 0x18, 0x31, 0x80, 0xCE, 0x0C, 0xE0,
  0x3B, 0x03, 0x30, 0x06, 0xC0, 0x6C, 0x01, 0xB0, 0x1B, 0x00, 0x78, 0x07,
  0xC0, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x30,
  0x03, 0x80, 0x70, 0x07, 0x38, 0x03, 0x0E, 0x03, 0x83, 0x01, 0x81, 0xC1,
  0xC0, 0x61, 0xC0, 0x38, 0xE0, 0x0C, 0xE0, 0x07, 0x60, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x1D, 0xC0, 0x0C, 0x60,
  0x0E, 0x38, 0x0E, 0x0C, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x00, 0xE3, 0x80,
  0x39, 0x80, 0x0C, 0xE0, 0x03, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x06, 0x70,
  0x06, 0x30, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x0C, 0x18, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x30, 0x06, 0x70, 0x07,
  0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x40, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x78, 0x38, 0x0F, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x3C,
  0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x08,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x03, 0x7B, 0xC0, 0x36, 0x0E, 0x03, 0xE0,
  0x70, 0x6C, 0x03, 0xCE, 0xC0, 0x1F, 0xC0, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Light44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 7, 10, 13, 3, -33 },
  { 22, 20, 31, 23, 2, -31 },
  { 100, 17, 39, 21, 2, -35 },
  { 183, 24, 31, 28, 2, -31 },
  { 276, 21, 31, 24, 2, -31 },
  { 358, 2, 10, 8, 3, -33 },
  { 361, 9, 45, 13, 3, -35 },
  { 412, 9, 45, 13, 1, -35 },
  { 463, 17, 18, 19, 1, -31 },
  { 502, 18, 22, 22, 2, -25 },
  { 552, 5, 10, 8, 1, -4 },
  { 559, 9, 2, 11, 1, -15 },
  { 562, 4, 4, 11, 3, -4 },
  { 564, 13, 34, 16, 1, -31 },
  { 620, 16, 31, 21, 3, -31 },
  { 682, 9, 31, 21, 4, -31 },
  { 717, 17, 31, 21, 2, -31 },
  { 783, 17, 31, 21, 2, -31 },
  { 849, 18, 31, 21, 2, -31 },
  { 919, 16, 31, 21, 3, -31 },
  { 981, 16, 31, 21, 3, -31 },
  { 1043, 17, 31, 21, 2, -31 },
  { 1109, 17, 31, 21, 2, -31 },
  { 1175, 17, 31, 21, 2, -31 },
  { 1241, 4, 24, 9, 3, -24 },
  { 1253, 5, 30, 8, 1, -24 },
  { 1272, 15, 18, 20, 2, -23 },
  { 1306, 15, 11, 21, 3, -20 },
  { 1327, 15, 18, 20, 3, -23 },
  { 1361, 14, 31, 18, 2, -31 },
  { 1416, 30, 41, 35, 2, -31 },
  { 1570, 22, 31, 24, 1, -31 },
  { 1656, 17, 31, 24, 4, -31 },
  { 1722, 19, 31, 25, 3, -31 },
  { 1796, 18, 31, 25, 4, -31 },
  { 1866, 16, 31, 22, 4, -31 },
  { 1928, 16, 31, 22, 4, -31 },
  { 1990, 20, 31, 26, 3, -31 },
  { 2068, 19, 31, 27, 4, -31 },
  { 2142, 3, 31, 11, 4, -31 },
  { 2154, 16, 31, 21, 2, -31 },
  { 2216, 19, 31, 24, 4, -31 },
  { 2290, 15, 31, 20, 4, -31 },
  { 2349, 25, 31, 33, 4, -31 },
  { 2446, 19, 31, 27, 4, -31 },
  { 2520, 20, 31, 26, 3, -31 },
  { 2598, 18, 31, 24, 4, -31 },
  { 2668, 20, 36, 26, 3, -31 },
  { 2758, 18, 31, 24, 4, -31 },
  { 2828, 19, 31, 23, 2, -31 },
  { 2902, 21, 31, 23, 1, -31 },
  { 2984, 19, 31, 25, 3, -31 },
  { 3058, 22, 31, 24, 1, -31 },
  { 3144, 31, 31, 34, 2, -31 },
  { 3265, 21, 31, 24, 1, -31 },
  { 3347, 21, 31, 23, 1, -31 },
  { 3429, 19, 31, 23, 2, -31 },
  { 3503, 6, 43, 10, 3, -36 },
  { 3536, 14, 34, 16, 1, -31 },
  { 3596, 7, 43, 10, 0, -36 },
  { 3634, 12, 16, 16, 2, -31 },
  { 3658, 17, 2, 17, 0, 0 },
  { 3663, 7, 6, 13, 2, -33 },
  { 3669, 16, 23, 21, 2, -23 },
  { 3715, 16, 33, 21, 3, -33 },
  { 3781, 16, 23, 20, 2, -23 },
  { 3827, 16, 33, 21, 2, -33 },
  { 3893, 16, 23, 20, 2, -23 },
  { 3939, 11, 33, 13, 2, -33 },
  { 3985, 16, 32, 21, 2, -23 },
  { 4049, 15, 33, 21, 3, -33 },
  { 4111, 3, 31, 9, 3, -31 },
  { 4123, 7, 40, 9, -1, -31 },
  { 4158, 16, 33, 19, 3, -33 },
  { 4224, 3, 33, 9, 3, -33 },
  { 4237, 28, 23, 34, 3, -23 },
  { 4318, 15, 23, 21, 3, -23 },
  { 4362, 17, 23, 22, 2, -23 },
  { 4411, 16, 32, 21, 3, -23 },
  { 4475, 16, 32, 22, 2, -23 },
  { 4539, 9, 23, 13, 3, -23 },
  { 4565, 15, 23, 20, 2, -23 },
  { 4609, 10, 29, 13, 1, -29 },
  { 4646, 15, 23, 21, 3, -23 },
  { 4690, 17, 23, 19, 1, -23 },
  { 4739, 26, 23, 29, 1, -23 },
  { 4814, 17, 23, 19, 1, -23 },
  { 4863, 16, 32, 18, 1, -23 },
  { 4927, 15, 23, 19, 2, -23 },
  { 4971, 10, 43, 13, 2, -34 },
  { 5025, 2, 37, 10, 4, -31 },
  { 5035, 10, 43, 13, 1, -34 },
  { 5089, 20, 8, 26, 3, -17 },
};

const GFXfont RobotoCondensed_Light44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_LIGHT44PT7B_H_
