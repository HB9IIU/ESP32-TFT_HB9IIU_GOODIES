#ifndef _ROBOTOCONDENSED_LIGHT30PT7B_H_
#define _ROBOTOCONDENSED_LIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0xCE, 0x73, 0x98, 0xC6, 0x20,
  0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x8C, 0x06, 0x30, 0x10, 0xC0, 0x42,
  0x1F, 0xFF, 0x04, 0x20, 0x30, 0x80, 0xC6, 0x03, 0x18, 0x08, 0x40, 0x21,
  0x0F, 0xFF, 0x82, 0x10, 0x18, 0xC0, 0x63, 0x01, 0x0C, 0x04, 0x20, 0x10,
  0x80, 0x42, 0x00, 0x04, 0x00, 0x80, 0x10, 0x0F, 0x83, 0xF8, 0xC1, 0x90,
  0x36, 0x03, 0xC0, 0x78, 0x0D, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xD8, 0x33, 0xFC,
  0x1F, 0x00, 0x80, 0x10, 0x02, 0x00, 0x78, 0x00, 0xEC, 0x00, 0x84, 0x00,
  0x86, 0x10, 0x86, 0x30, 0x86, 0x20, 0x86, 0x60, 0x84, 0x40, 0xEC, 0xC0,
  0x38, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x3C, 0x02, 0x76, 0x06, 0x42,
  0x04, 0x43, 0x08, 0x43, 0x08, 0x43, 0x10, 0x43, 0x10, 0x42, 0x00, 0x76,
  0x00, 0x3C, 0x1E, 0x00, 0xFC, 0x02, 0x18, 0x18, 0x20, 0x60, 0x81, 0x82,
  0x06, 0x18, 0x0C, 0xC0, 0x36, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x66,
  0x1B, 0x0C, 0x6C, 0x31, 0x20, 0x64, 0x80, 0xF2, 0x03, 0x8C, 0x06, 0x38,
  0x3C, 0x7F, 0x98, 0x7C, 0x60, 0xFE, 0x04, 0x31, 0x84, 0x30, 0x86, 0x18,
  0x41, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x04, 0x18,
  0x60, 0x83, 0x04, 0x18, 0x30, 0x40, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x18, 0x20, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x08, 0x21, 0x86,
  0x10, 0xC2, 0x18, 0x43, 0x08, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x62, 0x73, 0xFE, 0x07, 0x00, 0x70, 0x0D, 0x81, 0x8C, 0x30, 0xC1, 0x04,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F,
  0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x6D, 0xB7, 0xA0, 0xFF, 0xF0, 0xF8, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x00, 0x1F,
  0x07, 0xF1, 0x83, 0x20, 0x6C, 0x05, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x09,
  0x03, 0x30, 0x63, 0xF8, 0x3E, 0x00, 0x02, 0x3D, 0xFF, 0x38, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0x1F, 0x0F, 0xF3, 0x83, 0x60, 0x68, 0x05, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0x83, 0xFC,
  0x30, 0x66, 0x06, 0x60, 0x24, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x0C,
  0x0F, 0x80, 0xF8, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x40, 0x34, 0x03,
  0x60, 0x27, 0x06, 0x3F, 0xC0, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x2C, 0x03, 0x60, 0x13, 0x01, 0x98, 0x08, 0xC0, 0xC6, 0x04, 0x30,
  0x61, 0x86, 0x0C, 0x30, 0x63, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x3F, 0xE7, 0xFC, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x6F, 0x0F, 0xF1, 0x83, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0xC0, 0x68, 0x0D, 0x81, 0xB0, 0x63, 0xFC, 0x1E,
  0x00, 0x07, 0x81, 0xF0, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xCF, 0x1F, 0xF3, 0x83, 0x60, 0x2C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0D, 0x81, 0x30, 0x63, 0xF8, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x1F, 0x0F, 0xF1, 0x83, 0x60, 0x6C, 0x05,
  0x80, 0xF0, 0x16, 0x02, 0x60, 0xC7, 0xF0, 0xFC, 0x30, 0xCC, 0x0D, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xB0, 0x67, 0xF8, 0x3E, 0x00,
  0x1E, 0x07, 0xF1, 0x86, 0x60, 0x6C, 0x0D, 0x00, 0xA0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x76, 0x1E, 0xFE, 0xC7, 0x90, 0x02, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x83, 0xE0, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x6C,
  0x00, 0x00, 0x00, 0x00, 0xDB, 0x6F, 0x40, 0x00, 0x40, 0x30, 0x38, 0x3C,
  0x3C, 0x1C, 0x0C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x40,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0C, 0x07, 0x07, 0x07, 0x07, 0x03,
  0x80, 0x80, 0x00, 0x1E, 0x0F, 0xE6, 0x1B, 0x03, 0xC0, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x79, 0xF0,
  0x0C, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x06, 0x60, 0x78,
  0x24, 0x0D, 0xC2, 0x41, 0x0C, 0x3C, 0x30, 0xC3, 0xC2, 0x0C, 0x18, 0x20,
  0xC1, 0x86, 0x0C, 0x18, 0x60, 0x81, 0x86, 0x08, 0x38, 0x60, 0x83, 0x86,
  0x08, 0x28, 0x61, 0x82, 0x82, 0x1C, 0x6C, 0x3E, 0xCC, 0xC1, 0xC7, 0x84,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x34,
  0x00, 0x68, 0x00, 0x98, 0x03, 0x30, 0x06, 0x20, 0x08, 0x60, 0x10, 0xC0,
  0x60, 0x80, 0xC1, 0x81, 0x03, 0x06, 0x02, 0x0F, 0xFE, 0x1F, 0xFC, 0x60,
  0x18, 0xC0, 0x11, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xC0, 0xFF,
  0x1F, 0xF2, 0x03, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x80, 0xDF,
  0xF3, 0xFE, 0x40, 0x68, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x6F, 0xFD, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x0C, 0x0C, 0xC0,
  0x34, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x1A, 0x00, 0xD8,
  0x06, 0x60, 0x61, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xF8, 0x80, 0xC8, 0x06,
  0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x02, 0x80, 0x68, 0x0C,
  0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x1F, 0xF3, 0xFE, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03,
  0xFE, 0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x03, 0x18, 0x06,
  0x40, 0x1B, 0x00, 0x2C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x7F, 0xC1, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80,
  0x36, 0x00, 0xCC, 0x06, 0x1F, 0xF0, 0x1F, 0x00, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x63, 0xF8, 0x3E, 0x00, 0x80, 0x34, 0x03,
  0x20, 0x31, 0x03, 0x88, 0x18, 0x41, 0x82, 0x18, 0x11, 0xC0, 0x8C, 0x04,
  0xC0, 0x2E, 0x01, 0xD8, 0x0E, 0x60, 0x63, 0x02, 0x0C, 0x10, 0x30, 0x81,
  0x84, 0x06, 0x20, 0x39, 0x00, 0xC8, 0x03, 0x40, 0x1C, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xFF,
  0xF0, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFA, 0x00, 0x7D,
  0x80, 0x2E, 0xC0, 0x37, 0x20, 0x1B, 0x98, 0x09, 0xCC, 0x0C, 0xE2, 0x06,
  0x71, 0x82, 0x38, 0xC3, 0x1C, 0x21, 0x8E, 0x18, 0x87, 0x0C, 0xC3, 0x82,
  0x61, 0xC1, 0xA0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x0C, 0x0C,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3B, 0x01, 0xD8, 0x0E, 0x60, 0x71,
  0x03, 0x8C, 0x1C, 0x20, 0xE1, 0x87, 0x04, 0x38, 0x31, 0xC0, 0x8E, 0x06,
  0x70, 0x1B, 0x80, 0xDC, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0C,
  0x0F, 0xC0, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x40, 0x1B, 0x00, 0x2C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x09, 0x00, 0x66, 0x01, 0x8C, 0x0C, 0x1F,
  0xE0, 0x3F, 0x00, 0xFF, 0x0F, 0xFC, 0x80, 0x68, 0x06, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x06, 0x80, 0x6F, 0xFC, 0xFF, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x0F, 0xC0, 0xFF, 0x83, 0x03, 0x18, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x09, 0x00, 0x66, 0x01, 0x8C, 0x0C, 0x3F,
  0xE0, 0x3F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x20, 0xFF, 0x87,
  0xFF, 0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0B, 0x00, 0x58, 0x02, 0xC0,
  0x36, 0x01, 0xB0, 0x19, 0xFF, 0xCF, 0xF8, 0x60, 0xC3, 0x03, 0x18, 0x18,
  0xC0, 0x66, 0x03, 0x30, 0x0D, 0x80, 0x6C, 0x01, 0xE0, 0x0C, 0x0F, 0xC0,
  0xFF, 0x0C, 0x0C, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0xC0, 0x0A, 0x00, 0xD8, 0x06, 0xE0, 0x63, 0xFF, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD8, 0x04, 0xE0, 0x63, 0xFE, 0x07,
  0xC0, 0xC0, 0x05, 0x80, 0x1B, 0x00, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03,
  0x08, 0x06, 0x18, 0x08, 0x30, 0x30, 0x20, 0x60, 0x60, 0x80, 0xC3, 0x01,
  0x86, 0x01, 0x08, 0x03, 0x10, 0x06, 0x60, 0x04, 0xC0, 0x0D, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x1E, 0x01, 0x80,
  0xD0, 0x1C, 0x06, 0x80, 0xE0, 0x26, 0x05, 0x01, 0x30, 0x2C, 0x19, 0x83,
  0x60, 0xC4, 0x19, 0x06, 0x20, 0x88, 0x21, 0x84, 0x61, 0x0C, 0x63, 0x18,
  0x63, 0x08, 0xC1, 0x10, 0x46, 0x08, 0x83, 0x20, 0x6C, 0x19, 0x03, 0x60,
  0x58, 0x1B, 0x02, 0xC0, 0x50, 0x16, 0x02, 0x80, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0xC0, 0xC0, 0x0D, 0x80, 0x62, 0x01, 0x8C, 0x0C,
  0x18, 0x30, 0x61, 0x80, 0xC4, 0x03, 0x30, 0x07, 0x80, 0x1E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0xCC, 0x06, 0x18, 0x18, 0x60, 0xC0,
  0xC3, 0x03, 0x18, 0x06, 0x60, 0x1B, 0x00, 0x30, 0xC0, 0x0F, 0x00, 0x66,
  0x01, 0x98, 0x04, 0x30, 0x30, 0xC0, 0xC1, 0x06, 0x06, 0x18, 0x08, 0xC0,
  0x33, 0x00, 0xD8, 0x01, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCF, 0xF0, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10,
  0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80,
  0x60, 0x30, 0x08, 0x04, 0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80,
  0x08, 0x0E, 0x05, 0x02, 0x83, 0x61, 0xB0, 0x88, 0xC6, 0x63, 0x20, 0xB0,
  0x60, 0xFF, 0xFF, 0xFC, 0xC6, 0x23, 0x1F, 0x1F, 0xEC, 0x0F, 0x03, 0xC0,
  0xC0, 0x30, 0x0C, 0x7F, 0x78, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x7F,
  0xFC, 0xF3, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x78, 0xFF, 0xDC, 0x1B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x0D, 0xFF, 0x33, 0xC0, 0x0F, 0x07,
  0xF9, 0x81, 0xB0, 0x34, 0x02, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x20, 0x16, 0x06, 0xC0, 0xCF, 0xF0, 0x78, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0xF9, 0x7F, 0x78, 0x3C, 0x0F, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0x60, 0xDF, 0xD3,
  0xE4, 0x0F, 0x87, 0xF8, 0xC1, 0xB0, 0x34, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xE0, 0x4F, 0xF8, 0x7C, 0x0F,
  0x1F, 0x18, 0x30, 0x30, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x5F,
  0xDE, 0x0F, 0x03, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07,
  0x01, 0xC0, 0x78, 0x37, 0xF4, 0xF9, 0x00, 0x40, 0x10, 0x0D, 0x03, 0x7F,
  0x87, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x3C,
  0xDF, 0xB8, 0x3E, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x04, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xB8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x06, 0xC1, 0x98, 0x63, 0x18, 0x66, 0x0C, 0xC1,
  0xB0, 0x3E, 0x07, 0x60, 0xCC, 0x18, 0xC3, 0x0C, 0x61, 0x8C, 0x19, 0x81,
  0xB0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xCF, 0x0F, 0x9B, 0xF3,
  0xFB, 0x83, 0xC3, 0x60, 0x70, 0x3C, 0x06, 0x07, 0x80, 0x80, 0xF0, 0x10,
  0x1E, 0x02, 0x03, 0xC0, 0x40, 0x78, 0x08, 0x0F, 0x01, 0x01, 0xE0, 0x20,
  0x3C, 0x04, 0x07, 0x80, 0x80, 0xF0, 0x10, 0x1E, 0x02, 0x03, 0xCF, 0x37,
  0xEE, 0x0F, 0x83, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x1F, 0x0F, 0xF1, 0x83, 0x60, 0x3C,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xE0, 0x3C, 0x06,
  0xC1, 0x8F, 0xE0, 0xF8, 0xCF, 0x1F, 0xF3, 0x83, 0x60, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x05, 0xC1, 0xBF,
  0xE6, 0x78, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x3E,
  0x5F, 0xDE, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x01, 0xC0, 0x78, 0x37, 0xF4, 0xF9, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xCF, 0xFE, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x3E, 0x1F, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0xF0, 0x67, 0xF8, 0xF8, 0x30,
  0x60, 0xC1, 0x8F, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xF0, 0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xD8, 0x77, 0xF4,
  0xF9, 0xC0, 0x78, 0x0D, 0x01, 0x20, 0x66, 0x0C, 0xC1, 0x08, 0x61, 0x8C,
  0x31, 0x02, 0x20, 0x6C, 0x0D, 0x00, 0xA0, 0x1C, 0x03, 0x80, 0x20, 0xC0,
  0xC0, 0xE0, 0x60, 0xD0, 0x70, 0x68, 0x38, 0x36, 0x16, 0x13, 0x0B, 0x08,
  0x8C, 0x8C, 0x46, 0x46, 0x32, 0x32, 0x19, 0x19, 0x05, 0x85, 0x82, 0x82,
  0xC1, 0xC1, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x10, 0x18, 0xC0, 0x6C, 0x19,
  0x82, 0x18, 0xC1, 0x30, 0x36, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x6C,
  0x18, 0x83, 0x18, 0xC1, 0x98, 0x36, 0x03, 0xC0, 0x78, 0x0B, 0x03, 0x30,
  0x66, 0x0C, 0xC1, 0x08, 0x61, 0x8C, 0x31, 0x02, 0x60, 0x6C, 0x0D, 0x00,
  0xA0, 0x1C, 0x03, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x0F, 0x01,
  0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0x02, 0x06, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x30, 0xE0, 0xE0, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x0C, 0x06, 0x02, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x07, 0x07,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x60, 0x40, 0x3C, 0x0D, 0xF8, 0x3C, 0x30, 0xB0, 0x7E, 0xC0, 0xF0,
};

const GFXglyph RobotoCondensed_Light30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 22, 6, 2, -22 },
  { 7, 5, 7, 9, 2, -23 },
  { 12, 14, 22, 15, 1, -22 },
  { 51, 11, 28, 15, 2, -25 },
  { 90, 16, 22, 19, 2, -22 },
  { 134, 14, 22, 16, 2, -22 },
  { 173, 1, 7, 5, 2, -23 },
  { 174, 6, 31, 9, 2, -24 },
  { 198, 6, 31, 9, 1, -24 },
  { 222, 12, 12, 13, 0, -22 },
  { 240, 13, 16, 15, 1, -18 },
  { 266, 3, 7, 6, 1, -3 },
  { 269, 6, 2, 8, 1, -11 },
  { 271, 3, 2, 7, 2, -2 },
  { 272, 9, 24, 11, 1, -22 },
  { 299, 11, 22, 15, 2, -22 },
  { 330, 7, 22, 15, 2, -22 },
  { 350, 11, 22, 15, 2, -22 },
  { 381, 12, 22, 15, 1, -22 },
  { 414, 13, 22, 15, 1, -22 },
  { 450, 11, 22, 15, 2, -22 },
  { 481, 11, 22, 15, 2, -22 },
  { 512, 12, 22, 15, 1, -22 },
  { 545, 11, 22, 15, 2, -22 },
  { 576, 11, 22, 15, 2, -22 },
  { 607, 2, 16, 6, 2, -16 },
  { 611, 3, 20, 6, 1, -16 },
  { 619, 10, 13, 13, 1, -16 },
  { 636, 10, 8, 15, 2, -14 },
  { 646, 10, 13, 14, 2, -16 },
  { 663, 10, 22, 12, 1, -22 },
  { 691, 20, 28, 24, 2, -21 },
  { 761, 15, 22, 16, 1, -22 },
  { 803, 11, 22, 16, 3, -22 },
  { 834, 13, 22, 17, 2, -22 },
  { 870, 12, 22, 17, 3, -22 },
  { 903, 11, 22, 15, 3, -22 },
  { 934, 11, 22, 15, 3, -22 },
  { 965, 14, 22, 18, 2, -22 },
  { 1004, 13, 22, 18, 3, -22 },
  { 1040, 2, 22, 7, 3, -22 },
  { 1046, 11, 22, 14, 1, -22 },
  { 1077, 13, 22, 16, 3, -22 },
  { 1113, 10, 22, 14, 3, -22 },
  { 1141, 17, 22, 22, 3, -22 },
  { 1188, 13, 22, 19, 3, -22 },
  { 1224, 14, 22, 18, 2, -22 },
  { 1263, 12, 22, 16, 3, -22 },
  { 1296, 14, 26, 18, 2, -22 },
  { 1342, 13, 22, 17, 2, -22 },
  { 1378, 13, 22, 16, 1, -22 },
  { 1414, 14, 22, 16, 1, -22 },
  { 1453, 13, 22, 17, 2, -22 },
  { 1489, 15, 22, 16, 1, -22 },
  { 1531, 21, 22, 23, 1, -22 },
  { 1589, 14, 22, 16, 1, -22 },
  { 1628, 14, 22, 16, 1, -22 },
  { 1667, 13, 22, 16, 1, -22 },
  { 1703, 4, 29, 7, 2, -24 },
  { 1718, 9, 24, 11, 1, -22 },
  { 1745, 5, 29, 7, 0, -24 },
  { 1764, 9, 11, 11, 1, -22 },
  { 1777, 11, 2, 12, 0, 0 },
  { 1780, 4, 4, 9, 2, -22 },
  { 1782, 10, 16, 14, 2, -16 },
  { 1802, 11, 23, 15, 2, -23 },
  { 1834, 11, 16, 14, 1, -16 },
  { 1856, 10, 23, 15, 2, -23 },
  { 1885, 11, 16, 14, 1, -16 },
  { 1907, 8, 23, 9, 1, -23 },
  { 1930, 10, 22, 15, 2, -16 },
  { 1958, 10, 23, 14, 2, -23 },
  { 1987, 2, 21, 6, 2, -21 },
  { 1993, 5, 27, 6, -1, -21 },
  { 2010, 11, 23, 13, 2, -23 },
  { 2042, 2, 23, 6, 2, -23 },
  { 2048, 19, 16, 23, 2, -16 },
  { 2086, 10, 16, 14, 2, -16 },
  { 2106, 11, 16, 15, 2, -16 },
  { 2128, 11, 22, 15, 2, -16 },
  { 2159, 10, 22, 15, 2, -16 },
  { 2187, 6, 16, 9, 2, -16 },
  { 2199, 10, 16, 13, 2, -16 },
  { 2219, 7, 20, 9, 1, -20 },
  { 2237, 10, 16, 14, 2, -16 },
  { 2257, 11, 16, 13, 1, -16 },
  { 2279, 17, 16, 20, 1, -16 },
  { 2313, 11, 16, 13, 1, -16 },
  { 2335, 11, 22, 13, 1, -16 },
  { 2366, 11, 16, 13, 1, -16 },
  { 2388, 8, 29, 9, 1, -23 },
  { 2417, 1, 26, 7, 3, -22 },
  { 2421, 8, 29, 9, 0, -23 },
  { 2450, 14, 5, 18, 2, -11 },
};

const GFXfont RobotoCondensed_Light30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_LIGHT30PT7B_H_
