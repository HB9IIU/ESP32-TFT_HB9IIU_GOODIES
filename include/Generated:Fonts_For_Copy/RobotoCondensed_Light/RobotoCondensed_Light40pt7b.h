#ifndef _ROBOTOCONDENSED_LIGHT40PT7B_H_
#define _ROBOTOCONDENSED_LIGHT40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light40pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0x1B, 0xE0,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xE3, 0x8C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x18, 0x20, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C,
  0x18, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x20, 0xC0, 0x18, 0x30, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0x60, 0x80, 0x18, 0x20, 0x04, 0x18, 0x03, 0x06, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0x0C, 0x18, 0x03, 0x04, 0x00, 0x83, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7E, 0x03, 0xFE, 0x07, 0x0E, 0x1C,
  0x0E, 0x70, 0x0C, 0xE0, 0x1D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6E, 0x00,
  0x0C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x77, 0x00, 0xC7, 0x87, 0x87, 0xFE, 0x03, 0xF0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x06,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x0C,
  0x30, 0x30, 0x30, 0x80, 0xC0, 0xC6, 0x03, 0x06, 0x30, 0x06, 0x18, 0xC0,
  0x0F, 0xC6, 0x00, 0x1E, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x78, 0x00, 0x43, 0xF0, 0x03, 0x18, 0x60, 0x18, 0xC1, 0x80, 0x63,
  0x02, 0x03, 0x0C, 0x0C, 0x0C, 0x30, 0x30, 0x60, 0xC0, 0xC1, 0x83, 0x02,
  0x0C, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x01, 0xFE, 0x00, 0x70, 0xC0, 0x0C, 0x1C, 0x03, 0x81, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0xC1, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x73,
  0x80, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xCE,
  0x0C, 0x70, 0xC1, 0x8C, 0x1C, 0x33, 0x81, 0xC6, 0x70, 0x18, 0xCC, 0x01,
  0xB9, 0x80, 0x3E, 0x38, 0x03, 0xC3, 0x00, 0x30, 0x70, 0x0F, 0x07, 0x07,
  0x70, 0x7F, 0xC7, 0x07, 0xE0, 0x60, 0xFF, 0xFF, 0xC0, 0x02, 0x03, 0x06,
  0x0C, 0x0C, 0x18, 0x10, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06,
  0x03, 0x02, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x18, 0x30, 0xFE, 0x6F, 0x9F, 0xFC, 0x07, 0xC0,
  0x07, 0x00, 0x1B, 0x00, 0x67, 0x01, 0xC7, 0x03, 0x06, 0x0C, 0x06, 0x08,
  0x08, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x33, 0x33, 0x33, 0x66, 0x40, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0x70, 0xE1, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1B, 0x00,
  0x36, 0x00, 0x6C, 0x01, 0xD8, 0x03, 0x38, 0x06, 0x38, 0x1C, 0x38, 0x70,
  0x7F, 0xC0, 0x3E, 0x00, 0x01, 0x83, 0xC7, 0xFF, 0x3E, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x07, 0xC0, 0x1F, 0xF0, 0x38, 0x38, 0x70, 0x1C, 0x60, 0x0C, 0x60, 0x0C,
  0xE0, 0x0C, 0xC0, 0x0E, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xC0, 0x3F, 0xE0,
  0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x80, 0xFC, 0x01, 0xFC,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xB0, 0x06, 0x70, 0x1C, 0x70, 0x70, 0x7F, 0xC0, 0x3F,
  0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x06, 0xC0,
  0x06, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18, 0x30,
  0x0C, 0x18, 0x06, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x9F, 0x03, 0xFF, 0x87,
  0x87, 0x8C, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0x98, 0x03, 0x30, 0x06, 0x70, 0x18,
  0x70, 0x70, 0x7F, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xF0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x7C, 0x37, 0xFC, 0xF8, 0x7B, 0xC0, 0x6E, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xD8, 0x07,
  0x70, 0x38, 0xE1, 0xC1, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0xE0, 0xF0, 0xE1, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0xD8,
  0x03, 0xB0, 0x03, 0x60, 0x0E, 0xC0, 0x1D, 0xC0, 0x31, 0x80, 0xE1, 0xC3,
  0x81, 0xFE, 0x07, 0xFC, 0x1C, 0x1C, 0x70, 0x0C, 0xC0, 0x1F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xB0, 0x07, 0x70, 0x0C, 0x70,
  0x78, 0x7F, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xF1, 0xE1, 0x80,
  0xC6, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0x60, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x6C, 0x01, 0xD8, 0x03, 0xB8, 0x0F, 0x38,
  0x76, 0x3F, 0xCC, 0x3E, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x63, 0x18, 0xCC, 0x62, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x00,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x0F, 0x83, 0xFC, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x30,
  0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x18, 0x07,
  0x80, 0xC6, 0x03, 0xFC, 0x08, 0xC0, 0xE1, 0x81, 0xB0, 0x18, 0x30, 0x36,
  0x06, 0x06, 0x06, 0xC0, 0xC0, 0xC0, 0xD8, 0x30, 0x18, 0x1A, 0x06, 0x03,
  0x03, 0xC0, 0xC0, 0x60, 0x78, 0x18, 0x0C, 0x0F, 0x03, 0x01, 0x81, 0xE0,
  0x40, 0x30, 0x3C, 0x08, 0x04, 0x07, 0x81, 0x01, 0x80, 0xF0, 0x30, 0x30,
  0x12, 0x06, 0x06, 0x06, 0x40, 0xC1, 0xE0, 0xCC, 0x1C, 0x6C, 0x31, 0x81,
  0xF8, 0xFC, 0x30, 0x1E, 0x0F, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x39, 0x80, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x38, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0E,
  0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x3C,
  0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x1C, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0x07,
  0x87, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x0E, 0xE0, 0x06, 0x38, 0x07, 0x1E,
  0x0F, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x38, 0x0F,
  0x1C, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70,
  0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F,
  0xFF, 0xBF, 0xFF, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xE0, 0xF0, 0xE0,
  0x1C, 0x70, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x03,
  0xC7, 0x83, 0xE0, 0xFF, 0xE0, 0x0F, 0xE0, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x6C, 0x00, 0xD8, 0x03,
  0xB0, 0x06, 0x70, 0x1C, 0x78, 0x70, 0x7F, 0xC0, 0x3E, 0x00, 0xE0, 0x03,
  0xB8, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x0E, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x9C,
  0x00, 0xE6, 0x00, 0x3B, 0xC0, 0x0F, 0xF8, 0x03, 0xE7, 0x00, 0xF1, 0xC0,
  0x38, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0xE0, 0x38, 0x38, 0x07, 0x0E,
  0x00, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3B, 0x80,
  0x07, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xD8, 0x00, 0x1F, 0xD8, 0x00, 0x1F, 0xDC, 0x00, 0x37, 0xCC,
  0x00, 0x37, 0xEC, 0x00, 0x37, 0xEE, 0x00, 0x67, 0xE6, 0x00, 0x67, 0xE6,
  0x00, 0x67, 0xE3, 0x00, 0xC7, 0xE3, 0x00, 0xC7, 0xE3, 0x01, 0xC7, 0xE1,
  0x81, 0x87, 0xE1, 0x81, 0x87, 0xE1, 0x83, 0x87, 0xE0, 0xC3, 0x07, 0xE0,
  0xC3, 0x07, 0xE0, 0xE6, 0x07, 0xE0, 0x66, 0x07, 0xE0, 0x66, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x18, 0x07, 0xE0,
  0x18, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x3E, 0xC0, 0x0F, 0x98, 0x03, 0xE6, 0x00, 0xF8, 0xC0,
  0x3E, 0x38, 0x0F, 0x86, 0x03, 0xE1, 0xC0, 0xF8, 0x30, 0x3E, 0x0E, 0x0F,
  0x81, 0x83, 0xE0, 0x30, 0xF8, 0x0C, 0x3E, 0x01, 0x8F, 0x80, 0x73, 0xE0,
  0x0C, 0xF8, 0x03, 0xBE, 0x00, 0x6F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xE1, 0xE0,
  0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x66, 0x00, 0x19, 0xC0, 0x0E, 0x38,
  0x07, 0x0F, 0x87, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE,
  0x38, 0x07, 0x9C, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x6E, 0x00, 0x37,
  0x00, 0x3B, 0x80, 0x79, 0xFF, 0xF8, 0xFF, 0xF0, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x78, 0x3C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xE0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01,
  0x9C, 0x00, 0x31, 0xC0, 0x0E, 0x3C, 0x03, 0x83, 0xE1, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x40, 0xFF, 0xE0, 0x7F, 0xFC, 0x38, 0x07, 0x1C, 0x01, 0xCE,
  0x00, 0x77, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x01,
  0xB8, 0x00, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0xE3, 0xFF, 0xE1, 0xFF,
  0xC0, 0xE0, 0x70, 0x70, 0x18, 0x38, 0x0E, 0x1C, 0x03, 0x0E, 0x01, 0xC7,
  0x00, 0x63, 0x80, 0x39, 0xC0, 0x0C, 0xE0, 0x07, 0x70, 0x01, 0xB8, 0x00,
  0xFC, 0x00, 0x30, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x86, 0x00, 0xE7,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0E, 0xC0, 0x03, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0E, 0xC0, 0x07, 0x70, 0x07, 0x1E, 0x0F, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0E, 0xC0,
  0x06, 0x70, 0x07, 0x1E, 0x0F, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x01, 0xC3, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x38, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0,
  0x03, 0x98, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x60, 0x07, 0x00, 0x3B,
  0x00, 0x38, 0x01, 0x98, 0x01, 0xC0, 0x0C, 0xC0, 0x0E, 0x00, 0x67, 0x00,
  0xD8, 0x07, 0x18, 0x06, 0xC0, 0x30, 0xC0, 0x36, 0x01, 0x86, 0x01, 0xB0,
  0x0C, 0x30, 0x18, 0xC0, 0x61, 0xC0, 0xC6, 0x07, 0x06, 0x06, 0x30, 0x30,
  0x30, 0x31, 0x81, 0x81, 0x83, 0x06, 0x0C, 0x0E, 0x18, 0x30, 0x60, 0x30,
  0xC1, 0x86, 0x01, 0x86, 0x0C, 0x30, 0x0C, 0x60, 0x31, 0x80, 0x63, 0x01,
  0x8C, 0x03, 0x98, 0x0C, 0x60, 0x0C, 0xC0, 0x66, 0x00, 0x6C, 0x01, 0xB0,
  0x03, 0x60, 0x0D, 0x80, 0x1B, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0xEE, 0x00, 0x38, 0xE0, 0x07, 0x0C, 0x01, 0xC1,
  0xC0, 0x30, 0x18, 0x0E, 0x03, 0x81, 0x80, 0x30, 0x70, 0x07, 0x0C, 0x00,
  0x63, 0x80, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xB8, 0x00, 0x73, 0x00, 0x0C, 0x70, 0x03,
  0x86, 0x00, 0x60, 0xE0, 0x1C, 0x0C, 0x07, 0x01, 0xC0, 0xC0, 0x1C, 0x38,
  0x01, 0x86, 0x00, 0x39, 0xC0, 0x03, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xEC,
  0x00, 0x19, 0xC0, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x38, 0x70, 0x06, 0x06,
  0x01, 0xC0, 0xE0, 0x30, 0x0C, 0x06, 0x01, 0xC1, 0x80, 0x18, 0x30, 0x03,
  0x8C, 0x00, 0x31, 0x80, 0x07, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF,
  0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xB0, 0x36, 0x0C, 0xC1, 0x8C,
  0x31, 0x8C, 0x31, 0x83, 0x70, 0x6C, 0x0D, 0x80, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C,
  0x06, 0x60, 0x1D, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x3F, 0xF3,
  0xFF, 0xDE, 0x03, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x80, 0xF7, 0x0E, 0xCF, 0xF3, 0x1F, 0x8C, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x1F,
  0x0D, 0xFF, 0x3E, 0x1E, 0xE0, 0x1B, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xBE, 0x1E, 0xDF, 0xF3, 0x1F, 0x00,
  0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xF8, 0x03, 0x60, 0x0D, 0xC0, 0x73, 0x83, 0x87, 0xFC, 0x07,
  0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x1F, 0x9C, 0x7F, 0xB9, 0xC1, 0xF7,
  0x01, 0xEC, 0x01, 0xD8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0x60, 0x0E,
  0xC0, 0x1D, 0xC0, 0x79, 0xC1, 0xF1, 0xFE, 0xE1, 0xF8, 0xC0, 0x07, 0xC0,
  0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0x60,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x18, 0xF0, 0x70, 0xFF, 0xC0,
  0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x1F, 0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0xC6, 0x3F, 0xDC,
  0xE0, 0xFB, 0x80, 0xF6, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xB0, 0x07, 0x60, 0x0E, 0xE0, 0x3C, 0xE0, 0xF8, 0xFF, 0x70, 0xFC, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x40, 0x38, 0xE0, 0xE0, 0xFF,
  0x80, 0x7C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x3E, 0x33, 0xFD, 0xB0, 0xEF, 0x03,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0C, 0xDF, 0x00, 0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6C, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x77, 0xCF, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0xEC, 0x07, 0x30, 0x38, 0xC0, 0xC3, 0x06,
  0x0C, 0x38, 0x31, 0xC0, 0xCE, 0x03, 0x70, 0x0D, 0xC0, 0x3F, 0x80, 0xE7,
  0x03, 0x8C, 0x0C, 0x38, 0x30, 0x70, 0xC0, 0xC3, 0x03, 0x8C, 0x07, 0x30,
  0x0C, 0xC0, 0x3B, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC7, 0xC0, 0xFC, 0x67, 0xF8, 0xFF, 0x36, 0x1C, 0xC3, 0xDE, 0x07,
  0xC0, 0x6E, 0x01, 0xC0, 0x36, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0F, 0x80,
  0x30, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x78,
  0x03, 0x00, 0x3C, 0x01, 0x80, 0x1E, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x07,
  0x80, 0x30, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06, 0x00,
  0x78, 0x03, 0x00, 0x3C, 0x01, 0x80, 0x18, 0xC7, 0xC6, 0x7F, 0xB6, 0x1D,
  0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0x80, 0x07, 0xE0, 0x1F, 0xF0, 0x3C, 0x38,
  0x70, 0x1C, 0x60, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x06,
  0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x3C, 0x38, 0x1F, 0xF0, 0x07, 0xE0,
  0xC7, 0xC3, 0x7F, 0xCF, 0x87, 0xB8, 0x06, 0xE0, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x6F, 0x87, 0xB7, 0xFC, 0xC7,
  0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0F, 0xCE, 0x3F, 0xDC, 0xE0, 0xFB, 0x80, 0xF6, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xB0, 0x07, 0x60, 0x0E, 0xE0,
  0x3C, 0xE0, 0xF8, 0xFF, 0x70, 0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0xC7, 0xDF,
  0xDC, 0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0x87,
  0x18, 0x0E, 0x60, 0x19, 0x80, 0x76, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xF0, 0x07, 0xE0,
  0x1D, 0x80, 0x67, 0x83, 0x8F, 0xFC, 0x0F, 0xC0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC3, 0xFF, 0xFF, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C,
  0x07, 0xC1, 0xE0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01, 0xDC, 0x3E, 0x7F, 0xB1,
  0xF1, 0x80, 0xC0, 0x07, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x67, 0x01, 0xC6,
  0x03, 0x0C, 0x06, 0x1C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x63,
  0x00, 0xC6, 0x01, 0x8C, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x18, 0x07, 0x60, 0x18, 0x06,
  0x60, 0x3C, 0x06, 0x60, 0x3C, 0x06, 0x70, 0x3C, 0x0E, 0x30, 0x3C, 0x0C,
  0x30, 0x66, 0x0C, 0x30, 0x66, 0x0C, 0x38, 0x66, 0x1C, 0x18, 0x46, 0x18,
  0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x1C, 0xC3, 0x18, 0x0D, 0x81, 0xB0,
  0x0D, 0x81, 0xB0, 0x0D, 0x81, 0xB0, 0x0D, 0x81, 0xB0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x60, 0x0C, 0xE0,
  0x38, 0xC0, 0x61, 0xC1, 0xC1, 0x83, 0x01, 0x8E, 0x03, 0x18, 0x03, 0x60,
  0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0xDC, 0x03,
  0x18, 0x0E, 0x38, 0x18, 0x30, 0x70, 0x30, 0xC0, 0x73, 0x80, 0x6E, 0x00,
  0xE0, 0xC0, 0x0F, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x67, 0x01, 0x86, 0x03,
  0x0C, 0x06, 0x1C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x71, 0xC0, 0x63, 0x00,
  0xC6, 0x01, 0x8C, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x70,
  0x38, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x03, 0x83, 0xC0, 0xF0, 0x0E,
  0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x07,
  0x07, 0x02, 0x00, 0x1E, 0x00, 0xDF, 0xC0, 0x37, 0x38, 0x0F, 0x07, 0x06,
  0xC0, 0xF3, 0xB0, 0x1F, 0xC0, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_Light40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 28, 9, 3, -28 },
  { 12, 6, 9, 12, 3, -30 },
  { 19, 18, 28, 21, 2, -28 },
  { 82, 15, 36, 19, 2, -32 },
  { 150, 22, 28, 26, 2, -28 },
  { 227, 19, 28, 22, 2, -28 },
  { 294, 2, 9, 7, 2, -30 },
  { 297, 8, 41, 12, 3, -32 },
  { 338, 8, 41, 12, 1, -32 },
  { 379, 15, 16, 17, 1, -28 },
  { 409, 16, 20, 20, 2, -23 },
  { 449, 4, 9, 8, 1, -4 },
  { 454, 8, 2, 10, 1, -14 },
  { 456, 3, 3, 10, 3, -3 },
  { 458, 12, 30, 14, 1, -28 },
  { 503, 15, 28, 19, 2, -28 },
  { 556, 9, 28, 19, 3, -28 },
  { 588, 16, 28, 19, 2, -28 },
  { 644, 15, 28, 19, 2, -28 },
  { 697, 17, 28, 19, 1, -28 },
  { 757, 15, 28, 19, 3, -28 },
  { 810, 14, 28, 19, 3, -28 },
  { 859, 15, 28, 19, 2, -28 },
  { 912, 15, 28, 19, 2, -28 },
  { 965, 15, 28, 19, 2, -28 },
  { 1018, 3, 21, 8, 3, -21 },
  { 1026, 5, 26, 7, 1, -21 },
  { 1043, 13, 17, 18, 2, -21 },
  { 1071, 14, 10, 19, 3, -18 },
  { 1089, 14, 16, 18, 2, -21 },
  { 1117, 12, 28, 16, 2, -28 },
  { 1159, 27, 37, 31, 2, -28 },
  { 1284, 20, 28, 22, 1, -28 },
  { 1354, 16, 28, 21, 3, -28 },
  { 1410, 17, 28, 23, 3, -28 },
  { 1470, 17, 28, 23, 3, -28 },
  { 1530, 15, 28, 20, 3, -28 },
  { 1583, 15, 28, 20, 3, -28 },
  { 1636, 18, 28, 24, 3, -28 },
  { 1699, 18, 28, 25, 3, -28 },
  { 1762, 2, 28, 10, 4, -28 },
  { 1769, 15, 28, 19, 1, -28 },
  { 1822, 18, 28, 22, 3, -28 },
  { 1885, 14, 28, 19, 3, -28 },
  { 1934, 24, 28, 30, 3, -28 },
  { 2018, 18, 28, 25, 3, -28 },
  { 2081, 18, 28, 24, 3, -28 },
  { 2144, 17, 28, 22, 3, -28 },
  { 2204, 19, 33, 24, 2, -28 },
  { 2283, 17, 28, 22, 3, -28 },
  { 2343, 17, 28, 21, 2, -28 },
  { 2403, 19, 28, 21, 1, -28 },
  { 2470, 17, 28, 23, 3, -28 },
  { 2530, 20, 28, 22, 1, -28 },
  { 2600, 29, 28, 31, 1, -28 },
  { 2702, 19, 28, 21, 1, -28 },
  { 2769, 19, 28, 21, 1, -28 },
  { 2836, 17, 28, 21, 2, -28 },
  { 2896, 6, 39, 9, 3, -33 },
  { 2926, 12, 30, 14, 1, -28 },
  { 2971, 6, 39, 9, 0, -33 },
  { 3001, 11, 14, 15, 2, -28 },
  { 3021, 15, 2, 15, 0, 0 },
  { 3025, 7, 5, 11, 2, -30 },
  { 3030, 14, 21, 19, 2, -21 },
  { 3067, 14, 30, 19, 3, -30 },
  { 3120, 14, 21, 18, 2, -21 },
  { 3157, 15, 30, 20, 2, -30 },
  { 3214, 15, 21, 18, 2, -21 },
  { 3254, 11, 30, 12, 1, -30 },
  { 3296, 15, 29, 19, 2, -21 },
  { 3351, 13, 30, 19, 3, -30 },
  { 3400, 3, 29, 8, 3, -29 },
  { 3411, 7, 37, 9, -1, -29 },
  { 3444, 14, 30, 17, 3, -30 },
  { 3497, 2, 30, 8, 3, -30 },
  { 3505, 25, 21, 31, 3, -21 },
  { 3571, 13, 21, 19, 3, -21 },
  { 3606, 16, 21, 20, 2, -21 },
  { 3648, 14, 29, 19, 3, -21 },
  { 3699, 15, 29, 20, 2, -21 },
  { 3754, 8, 21, 12, 3, -21 },
  { 3775, 14, 21, 18, 2, -21 },
  { 3812, 9, 27, 12, 1, -27 },
  { 3843, 13, 21, 19, 3, -21 },
  { 3878, 15, 21, 17, 1, -21 },
  { 3918, 24, 21, 26, 1, -21 },
  { 3981, 15, 21, 17, 1, -21 },
  { 4021, 15, 29, 17, 1, -21 },
  { 4076, 14, 21, 17, 2, -21 },
  { 4113, 10, 39, 12, 1, -31 },
  { 4162, 2, 33, 9, 3, -28 },
  { 4171, 9, 39, 12, 1, -31 },
  { 4215, 18, 7, 24, 3, -15 },
};

const GFXfont RobotoCondensed_Light40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_LIGHT40PT7B_H_
