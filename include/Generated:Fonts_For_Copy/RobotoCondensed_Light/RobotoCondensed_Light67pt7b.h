#ifndef _ROBOTOCONDENSED_LIGHT67PT7B_H_
#define _ROBOTOCONDENSED_LIGHT67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light67pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFE, 0x60, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDC, 0x3B, 0x87, 0x70,
  0xEE, 0x1D, 0x83, 0xB0, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x1F,
  0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x07, 0xC7, 0xC0, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x08, 0x07, 0x00,
  0x70, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x18, 0x03, 0x80, 0x70, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x3C,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x03, 0x81, 0xE0, 0x07, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0x81, 0xC0, 0x01, 0xE0,
  0xF0, 0x70, 0x00, 0x1F, 0xFC, 0x0E, 0x00, 0x01, 0xFF, 0x03, 0x80, 0x00,
  0x1F, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x0F, 0xE0, 0x00,
  0x07, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0xFF, 0xE0, 0x00, 0x38, 0x3C, 0x1E,
  0x00, 0x0E, 0x07, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x70, 0x38,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x06, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x18, 0x03, 0x80, 0x70, 0x03, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x3C, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x03,
  0x80, 0xC0, 0x07, 0x00, 0x70, 0x08, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x07, 0x87,
  0x81, 0xF0, 0x0F, 0x1E, 0x01, 0xF0, 0x1E, 0x3C, 0x01, 0xE0, 0x38, 0xF0,
  0x01, 0xE0, 0x71, 0xE0, 0x03, 0xE0, 0xE3, 0xC0, 0x03, 0xC3, 0xC7, 0x00,
  0x03, 0xC7, 0x8E, 0x00, 0x07, 0xCE, 0x1C, 0x00, 0x07, 0xFC, 0x38, 0x00,
  0x07, 0xF8, 0x78, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xC1, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0xFF, 0x03, 0xE0, 0x03,
  0xFE, 0x07, 0xE0, 0x1F, 0x9E, 0x07, 0xFF, 0xFE, 0x1E, 0x07, 0xFF, 0xF0,
  0x3E, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x02, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x40, 0x0E, 0x00, 0xCF,
  0x01, 0xC0, 0x7B, 0xFC, 0x38, 0x7F, 0x7F, 0xE7, 0x3F, 0xF1, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xC0, 0x03, 0x80, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x1E,
  0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0xB8, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F,
  0x80, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x38, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFE, 0xFF, 0xE3, 0xFE, 0x0F,
  0xE0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x03, 0xE0,
  0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x3F, 0x80, 0x0E, 0x7F, 0xF0, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0xF0, 0x01, 0xF0, 0x30, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87,
  0xC0, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x1F, 0xC0, 0x1C, 0x3F, 0xF8, 0x0E, 0x3F, 0xFE, 0x07, 0x3F, 0xBF,
  0x87, 0xBC, 0x03, 0xE3, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0x3C, 0xFC, 0x00,
  0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0x80, 0xF0, 0x03, 0xE0,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF8,
  0x07, 0xC0, 0x3F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x03, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xC3, 0xE0,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1C, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x3D, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x9E, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x07, 0x70, 0xF8, 0x0F,
  0xB8, 0x7F, 0xBF, 0x9C, 0x1F, 0xFF, 0x9E, 0x03, 0xFF, 0x0F, 0x00, 0x7E,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x31, 0xFF, 0xFF, 0x7C, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x1E, 0xFF, 0xF7, 0x8C, 0x1C, 0x3E, 0x3F, 0x3F, 0x3E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0,
  0x3E, 0x1E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x1F, 0x80, 0x03,
  0x83, 0x80, 0x01, 0xFF, 0x00, 0x1C, 0x1C, 0x00, 0x3F, 0xFC, 0x00, 0x61,
  0xE0, 0x03, 0xE0, 0xF8, 0x03, 0x8E, 0x00, 0x1E, 0x03, 0x80, 0x1C, 0x70,
  0x01, 0xE0, 0x1C, 0x00, 0xE7, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x19, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xCE, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x3C, 0x00,
  0x70, 0x01, 0xF8, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xF0, 0x07, 0x80, 0x07, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0x38, 0x00, 0xFC, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xB8,
  0x03, 0x80, 0x07, 0x00, 0x0D, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xEE, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x3B, 0x80, 0x38,
  0x00, 0xF0, 0x01, 0x9C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0xE0, 0x0F, 0x00,
  0x7C, 0x00, 0xE3, 0x80, 0x38, 0x03, 0xE0, 0x0E, 0x1C, 0x01, 0xE0, 0x3B,
  0x80, 0x70, 0xE0, 0x0F, 0x83, 0x9C, 0x07, 0x07, 0x00, 0x3F, 0xF8, 0xF8,
  0xF0, 0x3C, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xE0, 0x03, 0xF8, 0x0F, 0xF0,
  0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x7E, 0x38, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF3,
  0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x7C, 0x38, 0x03, 0xFE,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x38, 0x00,
  0x1F, 0x8E, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xEE, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0,
  0x00, 0xFE, 0x0E, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x3F, 0x0E, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEE, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0x3F,
  0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0xE0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x01,
  0xF1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x0F, 0x83,
  0x80, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x07, 0x00,
  0x07, 0xC0, 0x38, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x03, 0xE0, 0x03, 0x80, 0x3E, 0x00, 0x1C, 0x03, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x1F, 0x00, 0x01, 0xC1,
  0xF0, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x03, 0x8F, 0xC0,
  0x00, 0x1C, 0xFF, 0x00, 0x00, 0xEF, 0xFC, 0x00, 0x07, 0xF9, 0xE0, 0x00,
  0x3F, 0x8F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xE0, 0x07, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xF0,
  0x0E, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF8, 0x1C,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x7C, 0x38, 0x00,
  0x01, 0xF1, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x00,
  0xFB, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xEE, 0x00, 0x00, 0x01, 0xDF, 0xBC, 0x00, 0x00,
  0x0F, 0x7E, 0xF0, 0x00, 0x00, 0x3D, 0xF9, 0xE0, 0x00, 0x00, 0xE7, 0xE7,
  0x80, 0x00, 0x07, 0x9F, 0x8E, 0x00, 0x00, 0x1E, 0x7E, 0x3C, 0x00, 0x00,
  0xF1, 0xF8, 0xF0, 0x00, 0x03, 0xC7, 0xE1, 0xC0, 0x00, 0x0E, 0x1F, 0x87,
  0x80, 0x00, 0x78, 0x7E, 0x1E, 0x00, 0x01, 0xE1, 0xF8, 0x38, 0x00, 0x07,
  0x07, 0xE0, 0xF0, 0x00, 0x3C, 0x1F, 0x83, 0xC0, 0x00, 0xF0, 0x7E, 0x07,
  0x00, 0x03, 0x81, 0xF8, 0x1E, 0x00, 0x1E, 0x07, 0xE0, 0x78, 0x00, 0x78,
  0x1F, 0x80, 0xE0, 0x01, 0xC0, 0x7E, 0x03, 0xC0, 0x0F, 0x01, 0xF8, 0x0F,
  0x00, 0x3C, 0x07, 0xE0, 0x1C, 0x00, 0xE0, 0x1F, 0x80, 0x78, 0x07, 0x80,
  0x7E, 0x01, 0xE0, 0x1E, 0x01, 0xF8, 0x03, 0x80, 0x70, 0x07, 0xE0, 0x0F,
  0x03, 0xC0, 0x1F, 0x80, 0x1C, 0x0F, 0x00, 0x7E, 0x00, 0x70, 0x38, 0x01,
  0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xE0, 0x03, 0x87, 0x00, 0x1F, 0x80, 0x0E,
  0x1C, 0x00, 0x7E, 0x00, 0x3C, 0xF0, 0x01, 0xF8, 0x00, 0x73, 0x80, 0x07,
  0xE0, 0x01, 0xCE, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xC0, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0x3F,
  0x9E, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x0F, 0xE3,
  0xC0, 0x00, 0x3F, 0x87, 0x80, 0x00, 0xFE, 0x0E, 0x00, 0x03, 0xF8, 0x3C,
  0x00, 0x0F, 0xE0, 0x78, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0xFE, 0x03, 0xC0,
  0x03, 0xF8, 0x0F, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x3F, 0x80, 0x78, 0x00,
  0xFE, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0xE0, 0x07, 0x80, 0x3F,
  0x80, 0x0E, 0x00, 0xFE, 0x00, 0x3C, 0x03, 0xF8, 0x00, 0x78, 0x0F, 0xE0,
  0x01, 0xE0, 0x3F, 0x80, 0x03, 0xC0, 0xFE, 0x00, 0x0F, 0x03, 0xF8, 0x00,
  0x1E, 0x0F, 0xE0, 0x00, 0x78, 0x3F, 0x80, 0x00, 0xF0, 0xFE, 0x00, 0x03,
  0xC3, 0xF8, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x0E, 0x3F, 0x80, 0x00, 0x3C,
  0xFE, 0x00, 0x00, 0x7B, 0xF8, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x1F,
  0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xB8, 0x00, 0x03, 0xE7, 0x00, 0x01,
  0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x7E, 0x0E, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0xCE, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x1F, 0x0E,
  0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E,
  0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x0F, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0xCE, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7E, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0xC0, 0x1F,
  0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x70, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x1E,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x1C,
  0x38, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x38,
  0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x1E, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0xF0,
  0x0F, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0xE0,
  0x07, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xC0,
  0x03, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x00, 0xE3, 0x80,
  0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0xF3, 0x80,
  0x01, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xEE, 0x00,
  0x3D, 0xC0, 0x07, 0x3C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x00,
  0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x07,
  0x00, 0xF0, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x3C, 0xE0, 0x03, 0xBC,
  0x00, 0x77, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0x80, 0x7C, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F,
  0xE0, 0x0F, 0x1F, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0x7C,
  0x00, 0xFF, 0x3E, 0x03, 0xEF, 0x3F, 0xFF, 0xCF, 0x1F, 0xFF, 0x8F, 0x07,
  0xFE, 0x0F, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x3E, 0x00, 0xE0, 0xFF, 0xC0, 0xE3, 0xFF, 0xF0, 0xE7, 0xFF, 0xF8, 0xEF,
  0x00, 0xF8, 0xEE, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xFC, 0x00, 0x7C, 0xEF,
  0x00, 0xF8, 0xE7, 0xFF, 0xF0, 0xE3, 0xFF, 0xE0, 0xE1, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x03, 0xDC,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x0F, 0x03, 0xFF, 0x0F, 0x0F, 0xFF,
  0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x00, 0xEF, 0x3E, 0x00, 0x7F, 0x7C, 0x00,
  0x3F, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x3E, 0x00, 0x7F, 0x1F, 0x00, 0xFF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF,
  0xCF, 0x03, 0xFF, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x18, 0x3E, 0x00, 0x1E, 0x0F,
  0xC0, 0x3F, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0x0F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x00,
  0xEF, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x70, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x00,
  0xFF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x0F, 0x00, 0xFC,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x10, 0x00, 0x1E, 0x38, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0xC7, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0xF0,
  0xF1, 0xFF, 0xE3, 0xCF, 0xFF, 0xCF, 0x78, 0x0F, 0xBF, 0x80, 0x1E, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0xF7, 0xBF,
  0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xFB,
  0xFE, 0x7F, 0xCF, 0xF1, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0x87, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xC0,
  0x78, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0x8F, 0x80, 0x0F, 0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xF9, 0xE0, 0x03, 0xE1, 0xE0, 0x07, 0xC3,
  0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x0F,
  0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x70, 0x7F, 0xE0, 0x0F, 0xFC, 0x38, 0xFF, 0xF8, 0x1F, 0xFF, 0x1C, 0xFF,
  0xFE, 0x1F, 0xFF, 0xCE, 0xF0, 0x1F, 0x9E, 0x03, 0xF7, 0x70, 0x03, 0xDE,
  0x00, 0x7B, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x03, 0x83, 0xFF, 0x0E, 0x1F, 0xFE, 0x38, 0xFF, 0xFC, 0xE7,
  0x80, 0xFB, 0xB8, 0x01, 0xEF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x0F,
  0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF,
  0xF0, 0xE7, 0xFF, 0xF8, 0xEF, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0xF8, 0x00,
  0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x3C, 0xFC, 0x00, 0x7C, 0xEF, 0x00, 0xF8, 0xE7, 0xFF, 0xF0, 0xE3, 0xFF,
  0xE0, 0xE1, 0xFF, 0xC0, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0x0F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x3F, 0x00,
  0xFF, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x00,
  0xFF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x0F, 0x00, 0xFC,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7B, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF,
  0x83, 0xB8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F,
  0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x79, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0x9E, 0x00, 0x1E, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3E,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0,
  0x0F, 0xCF, 0x80, 0xF7, 0x3F, 0xFF, 0xDC, 0x7F, 0xFC, 0x70, 0x7F, 0xE1,
  0xC0, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x80,
  0x0E, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x70, 0x00,
  0xE0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x0F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x73, 0xC0,
  0x00, 0x39, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0xE0, 0x00,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xE0, 0x00,
  0xE7, 0x80, 0x07, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0xC0, 0x07, 0x8F, 0x00,
  0x3F, 0x80, 0x0F, 0x1E, 0x00, 0x77, 0x00, 0x1C, 0x3C, 0x00, 0xEF, 0x00,
  0x38, 0x38, 0x01, 0xDE, 0x00, 0xF0, 0x70, 0x07, 0x9C, 0x01, 0xE0, 0xF0,
  0x0E, 0x38, 0x03, 0x81, 0xE0, 0x1C, 0x78, 0x07, 0x01, 0xC0, 0x38, 0x70,
  0x1E, 0x03, 0x80, 0xF0, 0xE0, 0x3C, 0x07, 0x81, 0xC1, 0xC0, 0x70, 0x0F,
  0x03, 0x83, 0xC0, 0xE0, 0x0E, 0x0F, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x07,
  0x07, 0x80, 0x3C, 0x38, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x0E, 0x1C, 0x00,
  0x71, 0xE0, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x38, 0xF0, 0x01, 0xE7, 0x00,
  0x79, 0xC0, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x03, 0xBC, 0x00, 0xE7, 0x00,
  0x07, 0x70, 0x01, 0xDE, 0x00, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7, 0x80, 0x03,
  0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x38,
  0x1E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x3C, 0x00,
  0xF0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x1E,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x73, 0xFF, 0xC0, 0x01, 0xCF, 0xFF, 0x80, 0x07, 0x78, 0x1F, 0x00, 0x1D,
  0xC0, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x03, 0xB8, 0x00, 0xF8, 0x1E, 0xE0,
  0x01, 0xFF, 0xF3, 0x80, 0x03, 0xFF, 0x8E, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xE0,
};

const GFXglyph RobotoCondensed_Light67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 49, 14, 5, -48 },
  { 32, 11, 15, 19, 5, -50 },
  { 53, 31, 48, 34, 3, -48 },
  { 239, 25, 63, 33, 4, -56 },
  { 436, 35, 50, 43, 4, -49 },
  { 655, 31, 50, 36, 4, -49 },
  { 849, 3, 15, 11, 4, -50 },
  { 855, 14, 68, 20, 4, -53 },
  { 974, 13, 68, 20, 2, -53 },
  { 1085, 27, 27, 28, 1, -48 },
  { 1177, 27, 35, 33, 3, -40 },
  { 1296, 7, 15, 13, 2, -6 },
  { 1310, 13, 3, 17, 2, -22 },
  { 1315, 5, 6, 16, 5, -5 },
  { 1319, 20, 52, 24, 1, -48 },
  { 1449, 25, 50, 33, 4, -49 },
  { 1606, 14, 48, 33, 6, -48 },
  { 1690, 27, 49, 33, 3, -49 },
  { 1856, 26, 50, 33, 3, -49 },
  { 2019, 29, 48, 33, 2, -48 },
  { 2193, 25, 49, 33, 5, -48 },
  { 2347, 25, 49, 33, 4, -48 },
  { 2501, 26, 48, 33, 3, -48 },
  { 2657, 25, 50, 33, 4, -49 },
  { 2814, 25, 49, 33, 3, -49 },
  { 2968, 6, 36, 14, 4, -35 },
  { 2995, 8, 44, 12, 2, -35 },
  { 3039, 22, 29, 30, 3, -36 },
  { 3119, 23, 18, 32, 5, -31 },
  { 3171, 23, 28, 31, 4, -36 },
  { 3252, 21, 50, 27, 3, -49 },
  { 3384, 45, 62, 53, 4, -47 },
  { 3733, 34, 48, 37, 1, -48 },
  { 3937, 26, 48, 36, 6, -48 },
  { 4093, 30, 50, 38, 4, -49 },
  { 4281, 28, 48, 38, 6, -48 },
  { 4449, 25, 48, 33, 6, -48 },
  { 4599, 24, 48, 33, 6, -48 },
  { 4743, 30, 50, 40, 5, -49 },
  { 4931, 30, 48, 41, 6, -48 },
  { 5111, 4, 48, 16, 6, -48 },
  { 5135, 24, 49, 32, 3, -48 },
  { 5282, 29, 48, 37, 6, -48 },
  { 5456, 23, 48, 31, 6, -48 },
  { 5594, 38, 48, 50, 6, -48 },
  { 5822, 30, 48, 41, 6, -48 },
  { 6002, 31, 50, 40, 4, -49 },
  { 6196, 27, 48, 36, 6, -48 },
  { 6358, 31, 57, 40, 4, -49 },
  { 6579, 28, 48, 37, 6, -48 },
  { 6747, 29, 50, 35, 3, -49 },
  { 6929, 31, 48, 35, 2, -48 },
  { 7115, 28, 49, 38, 5, -48 },
  { 7287, 33, 48, 36, 2, -48 },
  { 7485, 48, 48, 52, 2, -48 },
  { 7773, 32, 48, 36, 2, -48 },
  { 7965, 33, 48, 35, 1, -48 },
  { 8163, 29, 48, 35, 3, -48 },
  { 8337, 9, 64, 15, 5, -54 },
  { 8409, 20, 52, 24, 2, -48 },
  { 8539, 9, 64, 15, 1, -54 },
  { 8611, 19, 24, 25, 3, -48 },
  { 8668, 24, 3, 26, 1, 0 },
  { 8677, 11, 9, 19, 3, -50 },
  { 8690, 24, 37, 32, 3, -36 },
  { 8801, 24, 51, 33, 5, -50 },
  { 8954, 25, 37, 30, 3, -36 },
  { 9070, 24, 51, 33, 4, -50 },
  { 9223, 25, 37, 31, 3, -36 },
  { 9339, 18, 51, 20, 2, -51 },
  { 9454, 24, 50, 33, 4, -36 },
  { 9604, 22, 50, 32, 5, -50 },
  { 9742, 5, 48, 14, 5, -48 },
  { 9772, 11, 62, 14, -2, -48 },
  { 9858, 23, 50, 29, 5, -50 },
  { 10002, 4, 50, 14, 5, -50 },
  { 10027, 41, 36, 51, 5, -36 },
  { 10212, 22, 36, 32, 5, -36 },
  { 10311, 26, 37, 33, 3, -36 },
  { 10432, 24, 50, 33, 5, -36 },
  { 10582, 24, 50, 33, 4, -36 },
  { 10732, 14, 36, 20, 5, -36 },
  { 10795, 23, 37, 30, 3, -36 },
  { 10902, 16, 45, 19, 1, -44 },
  { 10992, 22, 36, 32, 5, -35 },
  { 11091, 25, 35, 28, 2, -35 },
  { 11201, 39, 35, 44, 2, -35 },
  { 11372, 25, 35, 29, 2, -35 },
  { 11482, 26, 49, 28, 1, -35 },
  { 11642, 24, 35, 29, 3, -35 },
  { 11747, 16, 65, 20, 3, -52 },
  { 11877, 3, 57, 15, 6, -48 },
  { 11899, 16, 65, 20, 1, -52 },
  { 12029, 30, 12, 40, 5, -26 },
};

const GFXfont RobotoCondensed_Light67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_LIGHT67PT7B_H_
