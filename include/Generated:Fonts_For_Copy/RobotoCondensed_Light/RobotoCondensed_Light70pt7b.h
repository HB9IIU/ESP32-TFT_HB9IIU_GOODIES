#ifndef _ROBOTOCONDENSED_LIGHT70PT7B_H_
#define _ROBOTOCONDENSED_LIGHT70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light70pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFB, 0xDC, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x1C, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0x80, 0x07,
  0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x79, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xC1, 0xFC,
  0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x40, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0xF0, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x78,
  0x00, 0xE0, 0x07, 0x03, 0x80, 0x03, 0x80, 0x78, 0x3C, 0x00, 0x1E, 0x03,
  0x81, 0xC0, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0xE0, 0x00,
  0x0F, 0xFC, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0x03, 0xFF, 0x00, 0x00,
  0x70, 0x3F, 0xFC, 0x00, 0x03, 0x83, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x03,
  0x80, 0x03, 0xC1, 0xE0, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x01, 0xE0,
  0x70, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x1C,
  0x3E, 0x07, 0xC0, 0x1C, 0x7C, 0x03, 0xC0, 0x3C, 0x78, 0x03, 0xE0, 0x3C,
  0x78, 0x01, 0xF0, 0x3C, 0xF0, 0x00, 0xF0, 0x3C, 0xF0, 0x00, 0x78, 0x38,
  0xF0, 0x00, 0x7C, 0x38, 0xF0, 0x00, 0x3E, 0x78, 0xF0, 0x00, 0x1E, 0x78,
  0xF0, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xF0,
  0x7C, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x3F, 0xF8, 0x1F, 0x80, 0xFE, 0x7C,
  0x0F, 0xFF, 0xFC, 0x3C, 0x07, 0xFF, 0xF0, 0x1E, 0x01, 0xFF, 0xE0, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xE0,
  0x00, 0x08, 0x00, 0x60, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0x80, 0x02, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x20, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x40, 0x0F, 0x00, 0x27, 0x00, 0xF0, 0x0E, 0xFE,
  0x0F, 0x07, 0xEF, 0xFC, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE7,
  0x8F, 0x1C, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xE0,
  0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xE7,
  0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x78, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xF8, 0x00, 0xF3, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x0E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x07, 0xF0, 0x07,
  0x87, 0xFF, 0x01, 0xE7, 0xFF, 0xE0, 0x7B, 0xFF, 0xFC, 0x1D, 0xF0, 0x1F,
  0x87, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xBF, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x9E,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03,
  0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF9, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xE3,
  0xF0, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0x81, 0xF8, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1F,
  0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xFC, 0xF0,
  0x00, 0x7E, 0x3E, 0x00, 0x7B, 0x87, 0xE0, 0x3E, 0xE0, 0xFF, 0xFF, 0x38,
  0x1F, 0xFF, 0x0E, 0x03, 0xFF, 0x87, 0x80, 0x3F, 0x81, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x1E, 0x3F,
  0x3F, 0x3F, 0x1F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0x03, 0xF0, 0xF8, 0x03, 0xC7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x1E, 0x00, 0x07,
  0xFC, 0x00, 0x38, 0x38, 0x00, 0x3F, 0xFE, 0x00, 0x38, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x71, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0xE3, 0x80, 0x07, 0x80,
  0x38, 0x01, 0xC7, 0x00, 0x1E, 0x00, 0x70, 0x01, 0x9E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1D, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0x38, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xDC, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xB8, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x70, 0x03, 0x80, 0x07, 0x80, 0x0E, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x38,
  0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x71, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xE3,
  0x80, 0x3C, 0x01, 0xF8, 0x03, 0x87, 0x00, 0x3C, 0x07, 0x70, 0x0F, 0x0F,
  0x00, 0x7C, 0x1C, 0xF0, 0x3C, 0x0E, 0x00, 0x7F, 0xF8, 0xF9, 0xF0, 0x1C,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3C, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x7F, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x3F,
  0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x3F, 0x83, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x03,
  0xE1, 0xF0, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x79, 0xFC, 0x00, 0x00, 0xF7, 0xFC, 0x00, 0x01, 0xEF, 0x78, 0x00,
  0x03, 0xFE, 0xF8, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x0F, 0xE0, 0xF0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x80, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xEF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0xF7, 0xFF, 0x00, 0x00, 0x00, 0xF7, 0xF7, 0x80, 0x00, 0x00, 0xE7, 0xF7,
  0x80, 0x00, 0x01, 0xE7, 0xF7, 0x80, 0x00, 0x01, 0xE7, 0xF3, 0xC0, 0x00,
  0x01, 0xC7, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0xF1, 0xC0, 0x00, 0x03, 0xC7,
  0xF1, 0xE0, 0x00, 0x03, 0x87, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0xF0, 0xE0,
  0x00, 0x07, 0x87, 0xF0, 0xF0, 0x00, 0x07, 0x07, 0xF0, 0xF0, 0x00, 0x0F,
  0x07, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0xF0,
  0x78, 0x00, 0x1E, 0x07, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0xF0, 0x3C, 0x00,
  0x3C, 0x07, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xF0, 0x1C, 0x00, 0x3C, 0x07,
  0xF0, 0x1E, 0x00, 0x78, 0x07, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0x00, 0xF0,
  0x07, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xF0,
  0x03, 0x81, 0xE0, 0x07, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0xF0, 0x03, 0xC3,
  0xC0, 0x07, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0xF0, 0x01, 0xE3, 0x80, 0x07,
  0xF0, 0x01, 0xE7, 0x80, 0x07, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0xF0, 0x00,
  0xF7, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xEF, 0x00, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x7F, 0x9E, 0x00, 0x00,
  0xFF, 0x1E, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x07,
  0xF8, 0x78, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x3F,
  0xC0, 0xF0, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFF, 0x01, 0xE0, 0x01, 0xFE,
  0x01, 0xE0, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xF0,
  0x07, 0x80, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0x80,
  0x0F, 0x00, 0xFF, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x1E, 0x03, 0xFC, 0x00,
  0x1E, 0x07, 0xF8, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x3C, 0x1F, 0xE0, 0x00,
  0x78, 0x3F, 0xC0, 0x00, 0x78, 0x7F, 0x80, 0x00, 0xF0, 0xFF, 0x00, 0x00,
  0xF1, 0xFE, 0x00, 0x01, 0xF3, 0xFC, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x01,
  0xEF, 0xF0, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0x00,
  0x01, 0xF8, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3F,
  0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xEE, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0xF0, 0x00,
  0x38, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC7, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x83,
  0x80, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x01, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x70, 0x07, 0x80, 0x1E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x0F,
  0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xF0, 0x00,
  0x70, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x01, 0xE1, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E,
  0x00, 0x03, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3B, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xC0, 0x07, 0x1E, 0x00, 0xF0,
  0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xE0, 0x78, 0x1C,
  0x07, 0x83, 0xC0, 0x38, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x01, 0xC7,
  0x80, 0x1E, 0x70, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC3, 0xFC, 0x01, 0xE3, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xC0,
  0x00, 0x7D, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x3C, 0x00, 0x77, 0x9F,
  0x81, 0xFB, 0xC7, 0xFF, 0xF9, 0xE1, 0xFF, 0xF8, 0xF0, 0x7F, 0xF0, 0x7C,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0xFF, 0xE0, 0x78, 0xFF, 0xFC, 0x3C,
  0xFF, 0xFF, 0x1E, 0xF0, 0x1F, 0x8F, 0xE0, 0x03, 0xE7, 0xE0, 0x00, 0xF3,
  0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF8, 0x00, 0x3C, 0xFE, 0x00, 0x3E,
  0x7B, 0xC0, 0x7E, 0x3D, 0xFF, 0xFE, 0x1E, 0x3F, 0xFE, 0x0F, 0x0F, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0xC1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x0F, 0x03, 0xFF, 0x87, 0x83, 0xFF, 0xE3, 0xC3, 0xFF, 0xFD, 0xE3, 0xF0,
  0x1E, 0xF3, 0xE0, 0x03, 0xF9, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xF0,
  0x00, 0x3E, 0x78, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x8F, 0xC0, 0x7B, 0xC3,
  0xFF, 0xFD, 0xE0, 0xFF, 0xFC, 0xF0, 0x3F, 0xF8, 0x78, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x04, 0x1E, 0x00, 0x03, 0x07,
  0xE0, 0x01, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC3, 0xC1, 0xFF,
  0xF1, 0xE1, 0xFF, 0xFE, 0xF1, 0xF8, 0x0F, 0x79, 0xF0, 0x01, 0xFC, 0xF0,
  0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x9F,
  0x00, 0x1F, 0xC7, 0xE0, 0x3D, 0xE1, 0xFF, 0xFE, 0xF0, 0x7F, 0xFE, 0x78,
  0x1F, 0xFC, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE1, 0x00, 0x00,
  0xF0, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x7E, 0x00, 0xFC, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x7F, 0xE0, 0xF1, 0xFF, 0xF0, 0xF3, 0xFF, 0xF8, 0xF7, 0xC0, 0xFC, 0xF7,
  0x00, 0x3C, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xF8,
  0x00, 0x0E, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x27, 0xBF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80,
  0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x00,
  0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xF1, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0x3F,
  0xFF, 0x87, 0xFF, 0xF8, 0xF7, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0xF0, 0x07,
  0xCF, 0x00, 0x7C, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xCF, 0xC0, 0x01, 0xFC,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0xF0, 0x7F, 0xE0, 0xF1, 0xFF, 0xF0, 0xF3, 0xFF, 0xF8, 0xF7,
  0xC0, 0xFC, 0xF7, 0x00, 0x3C, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0x1E, 0xFC,
  0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x7F, 0xF0, 0x3C,
  0x7F, 0xFC, 0x1E, 0x7F, 0xFF, 0x8F, 0x78, 0x0F, 0xC7, 0xF0, 0x01, 0xF3,
  0xF0, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1E,
  0x7F, 0x00, 0x1F, 0x3F, 0xE0, 0x3F, 0x1E, 0xFF, 0xFF, 0x0F, 0x3F, 0xFF,
  0x07, 0x87, 0xFF, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC3, 0xC1, 0xFF, 0xF9, 0xE1, 0xFF, 0xFE,
  0xF1, 0xF8, 0x0F, 0x79, 0xF0, 0x01, 0xFC, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0xC7, 0xE0,
  0x3F, 0xE1, 0xFF, 0xFE, 0xF0, 0x7F, 0xFE, 0x78, 0x1F, 0xFC, 0x3C, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x3D, 0xE1, 0xFF, 0xC7,
  0xFF, 0x9F, 0xFF, 0x7C, 0x3F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0x87, 0x80, 0x0F,
  0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0x3D,
  0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0xFC, 0x03, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x3F, 0x7C, 0x00, 0x7F, 0x3C, 0x00, 0xFF, 0x3F, 0x03, 0xEF, 0x1F, 0xFF,
  0xCF, 0x0F, 0xFF, 0x8F, 0x07, 0xFF, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00,
  0x70, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x00, 0x03, 0xDE, 0x00, 0x0F,
  0x80, 0x01, 0xCF, 0x00, 0x07, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xF0, 0x00,
  0xF1, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0xF0, 0x01, 0xFC, 0x00, 0x3C, 0x78,
  0x00, 0xFE, 0x00, 0x3C, 0x3C, 0x00, 0x77, 0x80, 0x1E, 0x0E, 0x00, 0x3B,
  0xC0, 0x0F, 0x07, 0x80, 0x3C, 0xE0, 0x07, 0x83, 0xC0, 0x1C, 0x70, 0x03,
  0x81, 0xE0, 0x0E, 0x3C, 0x03, 0xC0, 0x70, 0x07, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x87, 0x00, 0xF0, 0x1E, 0x03, 0x83, 0x80, 0x70, 0x0F, 0x01, 0xC1,
  0xE0, 0x78, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x01, 0xE0, 0xF0, 0x38, 0x1E,
  0x00, 0xF0, 0x70, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x0F, 0x07, 0x00, 0x1C,
  0x3C, 0x03, 0x87, 0x80, 0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x07, 0x8E, 0x00,
  0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x00, 0xE7, 0x80, 0x1C, 0xF0,
  0x00, 0x73, 0x80, 0x0E, 0x78, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0x1E,
  0xE0, 0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00,
  0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x03, 0xC0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1C, 0x00, 0x38, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x40, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x1F, 0xFC, 0x00, 0x0F, 0x3F, 0xFE, 0x00, 0x0F, 0x7C, 0x1F, 0x00, 0x0E,
  0x78, 0x0F, 0x80, 0x0E, 0x70, 0x07, 0xC0, 0x1E, 0xF0, 0x03, 0xE0, 0x1C,
  0xF0, 0x01, 0xF8, 0x3C, 0xE0, 0x00, 0xFF, 0xF8, 0xE0, 0x00, 0x7F, 0xF8,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_Light70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 51, 15, 5, -50 },
  { 33, 11, 16, 20, 5, -53 },
  { 55, 32, 50, 36, 3, -50 },
  { 255, 26, 65, 34, 4, -58 },
  { 467, 37, 52, 45, 4, -51 },
  { 708, 32, 52, 38, 4, -51 },
  { 916, 4, 15, 12, 4, -53 },
  { 924, 14, 72, 20, 5, -56 },
  { 1050, 14, 72, 21, 2, -56 },
  { 1176, 28, 28, 30, 1, -50 },
  { 1274, 29, 36, 35, 3, -41 },
  { 1405, 7, 16, 13, 2, -7 },
  { 1419, 14, 4, 18, 2, -24 },
  { 1426, 6, 6, 17, 5, -5 },
  { 1431, 21, 54, 25, 1, -50 },
  { 1573, 26, 52, 34, 4, -51 },
  { 1742, 15, 50, 34, 6, -50 },
  { 1836, 27, 51, 34, 4, -51 },
  { 2009, 27, 52, 34, 3, -51 },
  { 2185, 29, 50, 34, 3, -50 },
  { 2367, 26, 51, 34, 5, -50 },
  { 2533, 26, 51, 34, 4, -50 },
  { 2699, 28, 50, 34, 3, -50 },
  { 2874, 26, 52, 34, 4, -51 },
  { 3043, 26, 51, 34, 4, -51 },
  { 3209, 6, 38, 14, 4, -37 },
  { 3238, 8, 46, 13, 2, -37 },
  { 3284, 24, 29, 31, 3, -37 },
  { 3371, 24, 18, 34, 5, -32 },
  { 3425, 25, 29, 32, 4, -37 },
  { 3516, 22, 52, 28, 3, -51 },
  { 3659, 47, 64, 55, 4, -49 },
  { 4035, 35, 50, 38, 2, -50 },
  { 4254, 28, 50, 38, 6, -50 },
  { 4429, 31, 52, 40, 5, -51 },
  { 4631, 29, 50, 40, 6, -50 },
  { 4813, 26, 50, 35, 6, -50 },
  { 4976, 26, 50, 34, 6, -50 },
  { 5139, 31, 52, 42, 5, -51 },
  { 5341, 31, 50, 43, 6, -50 },
  { 5535, 4, 50, 17, 7, -50 },
  { 5560, 25, 51, 34, 3, -50 },
  { 5720, 31, 50, 38, 6, -50 },
  { 5914, 24, 50, 33, 6, -50 },
  { 6064, 40, 50, 52, 6, -50 },
  { 6314, 31, 50, 43, 6, -50 },
  { 6508, 32, 52, 41, 5, -51 },
  { 6716, 29, 50, 38, 6, -50 },
  { 6898, 33, 60, 41, 4, -51 },
  { 7146, 30, 50, 38, 6, -50 },
  { 7334, 30, 52, 36, 3, -51 },
  { 7529, 32, 50, 36, 2, -50 },
  { 7729, 30, 51, 40, 5, -50 },
  { 7921, 34, 50, 38, 2, -50 },
  { 8134, 50, 50, 54, 2, -50 },
  { 8447, 33, 50, 38, 2, -50 },
  { 8654, 34, 50, 37, 1, -50 },
  { 8867, 30, 50, 37, 3, -50 },
  { 9055, 10, 68, 16, 5, -57 },
  { 9140, 21, 54, 25, 2, -50 },
  { 9282, 10, 68, 16, 1, -57 },
  { 9367, 20, 25, 26, 3, -50 },
  { 9430, 25, 4, 27, 1, 0 },
  { 9443, 11, 10, 20, 4, -53 },
  { 9457, 25, 39, 33, 4, -38 },
  { 9579, 25, 54, 34, 5, -53 },
  { 9748, 26, 39, 32, 3, -38 },
  { 9875, 25, 54, 34, 4, -53 },
  { 10044, 26, 39, 32, 3, -38 },
  { 10171, 19, 54, 21, 2, -54 },
  { 10300, 25, 52, 34, 4, -38 },
  { 10463, 24, 53, 34, 5, -53 },
  { 10622, 5, 51, 15, 5, -51 },
  { 10654, 12, 65, 15, -2, -51 },
  { 10752, 24, 53, 30, 5, -53 },
  { 10911, 4, 53, 15, 5, -53 },
  { 10938, 44, 38, 53, 5, -38 },
  { 11147, 24, 38, 34, 5, -38 },
  { 11261, 27, 39, 34, 4, -38 },
  { 11393, 25, 52, 34, 5, -38 },
  { 11556, 25, 52, 34, 4, -38 },
  { 11719, 15, 38, 21, 5, -38 },
  { 11791, 23, 39, 31, 4, -38 },
  { 11904, 17, 47, 20, 1, -46 },
  { 12004, 24, 38, 34, 5, -37 },
  { 12118, 26, 37, 30, 2, -37 },
  { 12239, 41, 37, 46, 2, -37 },
  { 12429, 26, 37, 30, 2, -37 },
  { 12550, 26, 51, 29, 2, -37 },
  { 12716, 25, 37, 30, 3, -37 },
  { 12832, 17, 69, 21, 3, -55 },
  { 12979, 4, 59, 16, 6, -50 },
  { 13009, 17, 69, 21, 1, -55 },
  { 13156, 32, 13, 42, 5, -27 },
};

const GFXfont RobotoCondensed_Light70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_LIGHT70PT7B_H_
