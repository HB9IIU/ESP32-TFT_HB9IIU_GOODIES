#ifndef _ROBOTOCONDENSED_LIGHT56PT7B_H_
#define _ROBOTOCONDENSED_LIGHT56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x70,
  0x00, 0x30, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0,
  0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0C, 0x0F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x03, 0x01, 0xC0, 0x01,
  0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00,
  0x30, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x00,
  0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x38, 0x0C, 0x00, 0x1C, 0x06,
  0x00, 0x0E, 0x07, 0x00, 0x06, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x80,
  0xE0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x30,
  0x1C, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0x80, 0xF8, 0x38, 0x01,
  0xC3, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xCF, 0x00, 0x0F, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0xDE, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0x70, 0x00, 0x7B, 0xC0, 0x03, 0x8F, 0x00, 0x3C, 0x7C, 0x03,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x80, 0xE0, 0x08, 0x0E,
  0x01, 0x80, 0x70, 0x38, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x0E, 0x03, 0x00,
  0x60, 0x30, 0x0C, 0x01, 0x81, 0xC0, 0x30, 0x06, 0x06, 0x00, 0xE0, 0x18,
  0x38, 0x03, 0x80, 0x60, 0xC0, 0x06, 0x03, 0x87, 0x00, 0x1C, 0x0C, 0x18,
  0x00, 0x78, 0x70, 0xE0, 0x00, 0xFF, 0x83, 0x00, 0x01, 0xFC, 0x1C, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x10, 0x00, 0x03, 0x83, 0xF8, 0x00, 0x0C, 0x1F, 0xF0, 0x00,
  0x70, 0xE1, 0xE0, 0x01, 0x83, 0x03, 0x80, 0x0E, 0x1C, 0x06, 0x00, 0x30,
  0x60, 0x1C, 0x01, 0xC1, 0x80, 0x70, 0x06, 0x06, 0x00, 0xC0, 0x38, 0x18,
  0x03, 0x00, 0xC0, 0x60, 0x0C, 0x07, 0x01, 0x80, 0x30, 0x18, 0x06, 0x01,
  0xC0, 0xE0, 0x18, 0x07, 0x03, 0x00, 0x70, 0x18, 0x04, 0x00, 0xC0, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x70, 0xF0, 0x1C, 0x38, 0x1C, 0x07,
  0x1E, 0x07, 0x81, 0xC7, 0x00, 0xF0, 0x73, 0xC0, 0x1C, 0x1C, 0xE0, 0x07,
  0x87, 0x38, 0x00, 0xF1, 0x8E, 0x00, 0x1E, 0xE3, 0x80, 0x03, 0xB8, 0xE0,
  0x00, 0xFC, 0x38, 0x00, 0x1F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xF0,
  0x78, 0x00, 0xFE, 0x0F, 0x00, 0x7B, 0xC1, 0xF9, 0xFC, 0x70, 0x3F, 0xFE,
  0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x20, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x04, 0x40, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x0C, 0x06, 0xFC, 0x30,
  0xFF, 0xFE, 0xDF, 0xF1, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x87, 0x00, 0x1C,
  0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0x10, 0x02,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x7B, 0xBD, 0xC4, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x77, 0xFF, 0xE2, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0x1F, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x00, 0x1E,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xF7, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01,
  0xEE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x70,
  0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x3F, 0x3E, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF,
  0x7F, 0x7F, 0xC7, 0xF0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xF8, 0x07, 0xE7, 0xF0, 0x3E, 0x03, 0xC0, 0xE0, 0x07, 0x87, 0x80,
  0x0E, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xC0, 0x3C,
  0x1C, 0x00, 0xF1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xBC, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x80, 0x0E,
  0x1E, 0x00, 0xF0, 0x7F, 0x3F, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01,
  0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE3, 0xF0, 0x07, 0x7F, 0xE0, 0x3F, 0xFF, 0x81, 0xF0,
  0x3E, 0x0E, 0x00, 0xF8, 0x20, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x38, 0x78, 0x03,
  0xC1, 0xE0, 0x3C, 0x07, 0xE7, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0xFC, 0x0E, 0x3F, 0xF0, 0xEF, 0xFF, 0x8F, 0xE0, 0x7C, 0xFC,
  0x03, 0xCF, 0x80, 0x1E, 0xF0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00,
  0xF7, 0x00, 0x0E, 0x78, 0x00, 0xE3, 0xC0, 0x1C, 0x1E, 0x03, 0xC1, 0xF9,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0x1F, 0x81, 0xE0, 0x3E,
  0x1E, 0x00, 0xF0, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xE0, 0x0F, 0x07, 0xC0,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7C, 0x1F, 0x07,
  0x80, 0x3C, 0x38, 0x00, 0xF3, 0x80, 0x03, 0x9C, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x80, 0x0F,
  0x1E, 0x00, 0xF0, 0x7F, 0x3F, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0x3F,
  0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0x70,
  0x00, 0xF7, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x7D,
  0xE0, 0x07, 0xE7, 0x80, 0x77, 0x1E, 0x07, 0xB0, 0x7F, 0xFB, 0x81, 0xFF,
  0x1C, 0x07, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x39, 0xF7, 0xCF, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0xF3, 0xCF, 0x3C, 0xE3, 0x8E, 0x79, 0xCF, 0x38, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF,
  0xE0, 0x7E, 0xFC, 0x3C, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC0, 0x07,
  0x70, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x3E, 0x00, 0x30, 0x60, 0x03, 0xFE, 0x00, 0xE3,
  0x80, 0x1F, 0xFC, 0x01, 0x8E, 0x00, 0xF0, 0x38, 0x06, 0x30, 0x03, 0x80,
  0xE0, 0x19, 0xC0, 0x1C, 0x03, 0x80, 0x67, 0x00, 0x60, 0x0C, 0x01, 0xDC,
  0x03, 0x80, 0x30, 0x07, 0x60, 0x0C, 0x00, 0xC0, 0x1D, 0x80, 0x70, 0x03,
  0x00, 0x76, 0x01, 0xC0, 0x0C, 0x01, 0xF8, 0x07, 0x00, 0x30, 0x07, 0xE0,
  0x18, 0x01, 0xC0, 0x1F, 0x80, 0x60, 0x07, 0x00, 0x7E, 0x03, 0x80, 0x1C,
  0x01, 0xF8, 0x0E, 0x00, 0x70, 0x07, 0xE0, 0x38, 0x01, 0xC0, 0x1B, 0x80,
  0xE0, 0x07, 0x00, 0x6E, 0x03, 0x80, 0x1C, 0x01, 0xB8, 0x0E, 0x00, 0x60,
  0x0E, 0x60, 0x18, 0x03, 0x80, 0x31, 0x80, 0x70, 0x0F, 0x00, 0xC6, 0x01,
  0xC0, 0x7C, 0x07, 0x1C, 0x07, 0x83, 0xF0, 0x38, 0x70, 0x0F, 0x3C, 0xE1,
  0xC0, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0x80, 0x7F, 0x07, 0xF0, 0x0E, 0x00,
  0x20, 0x02, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38, 0x01, 0xF8, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x7B, 0x80, 0x01,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0x80, 0x0F, 0x8E, 0x00, 0x0F,
  0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C,
  0xE0, 0x03, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x01,
  0xF0, 0x07, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1C,
  0x70, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x03,
  0x87, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0xDF,
  0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0x00, 0x3F, 0x0E, 0x00,
  0x1F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0xF3, 0x80, 0x03, 0xC7, 0x00, 0x0F, 0x8E, 0x00, 0x7E, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0x01, 0xF0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x38,
  0x00, 0x03, 0xDC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xBC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x71,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x1F, 0xEF, 0xF8, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x77, 0x00, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1,
  0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0,
  0x07, 0x80, 0x70, 0x07, 0x80, 0x38, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x0E,
  0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC3, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x39, 0xF0, 0x00, 0x1D, 0xFC, 0x00,
  0x0F, 0xEE, 0x00, 0x07, 0xE7, 0x80, 0x03, 0xF1, 0xE0, 0x01, 0xF0, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x01, 0xC0,
  0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xEE, 0x00,
  0x00, 0x77, 0xEE, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0xE7, 0xE7, 0x00,
  0x00, 0xE7, 0xE7, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x01, 0xC7, 0xE3, 0x80,
  0x01, 0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE3, 0xC0, 0x03, 0x87, 0xE1, 0xC0,
  0x03, 0x87, 0xE1, 0xC0, 0x03, 0x87, 0xE0, 0xE0, 0x07, 0x07, 0xE0, 0xE0,
  0x07, 0x07, 0xE0, 0xE0, 0x07, 0x07, 0xE0, 0x70, 0x0E, 0x07, 0xE0, 0x70,
  0x0E, 0x07, 0xE0, 0x70, 0x0E, 0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0, 0x38,
  0x1C, 0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0, 0x1C, 0x38, 0x07, 0xE0, 0x1C,
  0x38, 0x07, 0xE0, 0x1C, 0x30, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E,
  0x70, 0x07, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xDC, 0x00, 0x07, 0xEF, 0x00, 0x03, 0xF3, 0x80,
  0x01, 0xF9, 0xE0, 0x00, 0xFC, 0x70, 0x00, 0x7E, 0x1C, 0x00, 0x3F, 0x0E,
  0x00, 0x1F, 0x83, 0x80, 0x0F, 0xC1, 0xC0, 0x07, 0xE0, 0x70, 0x03, 0xF0,
  0x3C, 0x01, 0xF8, 0x0E, 0x00, 0xFC, 0x07, 0x80, 0x7E, 0x01, 0xC0, 0x3F,
  0x00, 0xF0, 0x1F, 0x80, 0x38, 0x0F, 0xC0, 0x0E, 0x07, 0xE0, 0x07, 0x03,
  0xF0, 0x01, 0xC1, 0xF8, 0x00, 0xE0, 0xFC, 0x00, 0x38, 0x7E, 0x00, 0x1E,
  0x3F, 0x00, 0x07, 0x1F, 0x80, 0x03, 0xCF, 0xC0, 0x00, 0xE7, 0xE0, 0x00,
  0x3B, 0xF0, 0x00, 0x1D, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xF0, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x1E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x03,
  0xC7, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x00, 0x0F, 0x8E, 0x00,
  0x0F, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xCE, 0x00, 0x1F, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0x80,
  0x07, 0x81, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x0F, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF3, 0x80, 0x03,
  0xC7, 0x00, 0x1F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x70, 0x07, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x78, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xF3, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00,
  0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0xE7, 0xF8, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x3E, 0x00, 0x78, 0x1F, 0xE7, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0xF0,
  0x00, 0x3B, 0x80, 0x01, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xC0, 0x01, 0xEE,
  0x00, 0x0F, 0x80, 0x03, 0x9C, 0x00, 0x1F, 0x80, 0x07, 0x1C, 0x00, 0x37,
  0x00, 0x0E, 0x38, 0x00, 0xE6, 0x00, 0x1C, 0x70, 0x01, 0xCC, 0x00, 0x70,
  0xE0, 0x03, 0x9C, 0x00, 0xE1, 0xE0, 0x06, 0x38, 0x01, 0xC1, 0xC0, 0x1C,
  0x70, 0x03, 0x83, 0x80, 0x38, 0x60, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x1C,
  0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x1E, 0x03, 0x83, 0x80, 0x70, 0x1C, 0x07,
  0x03, 0x00, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x07,
  0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x18, 0x1C, 0x01, 0xC1,
  0xC0, 0x38, 0x38, 0x03, 0x83, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x00, 0xC3, 0x80, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x1C,
  0x60, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x06,
  0x70, 0x00, 0xE7, 0x00, 0x0C, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x01,
  0xD8, 0x00, 0x3B, 0x80, 0x03, 0xF0, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x01,
  0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x1E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x30, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x18, 0x1C, 0x1C, 0x38, 0x1C, 0x38,
  0x0C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81,
  0xF0, 0xFC, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3E, 0x00, 0xE7, 0x80,
  0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xF0, 0x03, 0xE7,
  0x80, 0xFE, 0x7F, 0xFE, 0xE3, 0xFF, 0xCF, 0x0F, 0xF0, 0x70, 0x18, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xFE, 0x0E, 0x7F, 0xF8, 0xEF,
  0x9F, 0xCF, 0xC0, 0x3C, 0xF8, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x80, 0x1E, 0xFC,
  0x03, 0xCE, 0xFD, 0xF8, 0xE7, 0xFF, 0x8E, 0x3F, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xF8, 0xFC, 0x3C, 0x03,
  0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x0E, 0x78, 0x00, 0xE3, 0xC0, 0x1C, 0x1F, 0x8F,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x07, 0xFC, 0x70, 0xFF, 0xE7, 0x1F, 0x9F, 0x73, 0xC0, 0x3F,
  0x38, 0x01, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x07, 0x78, 0x00, 0xF3, 0x80, 0x1F, 0x3C, 0x03, 0xF1, 0xFD, 0xF7,
  0x0F, 0xFE, 0x70, 0x7F, 0xC7, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x81, 0xF9, 0xFC, 0x3C, 0x03, 0xC3, 0x80, 0x1E, 0x70,
  0x00, 0xE7, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x63, 0xE0, 0x0F, 0x1F, 0xCF, 0xE0, 0xFF, 0xFC, 0x03,
  0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0xF9, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC7, 0x0F, 0xFE, 0x71, 0xF9, 0xF7, 0x3C, 0x03, 0xF3, 0x80, 0x1F, 0x78,
  0x00, 0xF7, 0x00, 0x07, 0x70, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x80,
  0x0F, 0x38, 0x01, 0xF3, 0xC0, 0x3F, 0x1F, 0xDF, 0x70, 0xFF, 0xE7, 0x07,
  0xFC, 0x70, 0x04, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x10, 0x00, 0xE3, 0x80, 0x1E, 0x3E, 0x03, 0xC1, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x1F, 0xE1,
  0xC7, 0xFE, 0x39, 0xF7, 0xE7, 0x70, 0x1E, 0xFC, 0x01, 0xDF, 0x00, 0x3B,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0xFF, 0xF6, 0x00,
  0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x3C, 0xFF, 0x3F, 0x8F, 0xC0, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00,
  0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xE0,
  0xF0, 0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x0E,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xDC, 0x00, 0xF9, 0xE0, 0x0F, 0x0E, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xE0, 0x1E,
  0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00,
  0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x3F, 0xC0, 0x7F, 0xC3, 0x9F, 0xFC, 0x1F, 0xFC, 0x77,
  0xCF, 0xC7, 0xCF, 0xCE, 0xC0, 0x3D, 0xC0, 0x3D, 0xF0, 0x03, 0xF0, 0x07,
  0xBE, 0x00, 0x7C, 0x00, 0x77, 0x80, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00,
  0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8,
  0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x3F, 0xC3, 0x8F, 0xFC, 0x73, 0xEF, 0xCE,
  0xE0, 0x3D, 0xF8, 0x03, 0xBE, 0x00, 0x77, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8,
  0x07, 0xE3, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xEF, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00,
  0x71, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1F, 0xCF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0E, 0x3F,
  0xE0, 0xE7, 0xFF, 0x8E, 0xF9, 0xFC, 0xFC, 0x03, 0xCF, 0x80, 0x1E, 0xF0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xEF, 0x00,
  0x0E, 0xF8, 0x01, 0xEF, 0xC0, 0x3C, 0xEF, 0x9F, 0x8E, 0x7F, 0xF0, 0xE3,
  0xFE, 0x0E, 0x02, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0x0F, 0xFE,
  0x71, 0xF8, 0xF7, 0x3C, 0x03, 0xF3, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0x00,
  0x07, 0x70, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x80, 0x0F, 0x38, 0x00,
  0xF3, 0xC0, 0x3F, 0x1F, 0x9F, 0x70, 0xFF, 0xE7, 0x07, 0xFC, 0x70, 0x04,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x0E, 0x3F, 0xE7, 0xFE, 0xFF, 0xEE, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x8F, 0xC3, 0xC0,
  0x7C, 0xF0, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x0F, 0x70, 0x00, 0xEE, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3D, 0xC0, 0x07, 0x3C, 0x01, 0xE3, 0xF9, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0x02, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x20, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x7D, 0xE0, 0x1F, 0x9F,
  0xBF, 0x71, 0xFF, 0xCE, 0x1F, 0xF1, 0xC0, 0x60, 0x00, 0x70, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x1E, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x81, 0xC0, 0x1C, 0x0E,
  0x00, 0xE0, 0x70, 0x03, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x0C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x30, 0x00, 0x1B, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07,
  0x70, 0x03, 0xC0, 0x07, 0x70, 0x03, 0xC0, 0x07, 0x70, 0x03, 0xE0, 0x0E,
  0x70, 0x07, 0xE0, 0x0E, 0x78, 0x07, 0xE0, 0x0E, 0x38, 0x07, 0x60, 0x0E,
  0x38, 0x06, 0x70, 0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38, 0x0E, 0x70, 0x1C,
  0x1C, 0x0E, 0x30, 0x1C, 0x1C, 0x0C, 0x38, 0x18, 0x1C, 0x1C, 0x38, 0x38,
  0x1C, 0x1C, 0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x38, 0x0E, 0x18, 0x1C, 0x38,
  0x0E, 0x38, 0x1C, 0x70, 0x0E, 0x38, 0x0C, 0x70, 0x06, 0x30, 0x0E, 0x70,
  0x07, 0x30, 0x0E, 0x70, 0x07, 0x70, 0x0E, 0x60, 0x07, 0x70, 0x06, 0xE0,
  0x03, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3,
  0x80, 0x1C, 0x1C, 0x03, 0xC1, 0xC0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0xF0,
  0x07, 0x0E, 0x00, 0x79, 0xE0, 0x03, 0x9C, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x07, 0x0E, 0x00, 0xF0, 0xF0, 0x0E,
  0x07, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC7,
  0x80, 0x1E, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x78, 0xF0,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x0F, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0xC0, 0x0F, 0x00, 0xFC, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0xCF, 0xFC, 0x00,
  0x6F, 0x0F, 0x00, 0x77, 0x03, 0xC0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0x3E,
  0x3D, 0xC0, 0x0F, 0xFC, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Light56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 41, 12, 4, -40 },
  { 22, 9, 12, 16, 4, -42 },
  { 36, 25, 40, 29, 3, -40 },
  { 161, 21, 53, 27, 3, -47 },
  { 301, 30, 42, 36, 3, -41 },
  { 459, 26, 42, 30, 3, -41 },
  { 596, 3, 12, 10, 3, -42 },
  { 601, 11, 58, 16, 4, -45 },
  { 681, 12, 58, 17, 1, -45 },
  { 768, 22, 22, 24, 1, -40 },
  { 829, 23, 29, 28, 2, -33 },
  { 913, 5, 13, 11, 2, -5 },
  { 922, 11, 3, 14, 2, -19 },
  { 927, 5, 5, 13, 4, -4 },
  { 931, 17, 43, 20, 1, -40 },
  { 1023, 21, 42, 27, 3, -41 },
  { 1134, 12, 40, 27, 5, -40 },
  { 1194, 22, 41, 27, 3, -41 },
  { 1307, 21, 42, 27, 3, -41 },
  { 1418, 24, 40, 27, 2, -40 },
  { 1538, 21, 41, 27, 4, -40 },
  { 1646, 20, 41, 27, 4, -40 },
  { 1749, 22, 40, 27, 2, -40 },
  { 1859, 21, 42, 27, 3, -41 },
  { 1970, 21, 41, 27, 3, -41 },
  { 2078, 4, 30, 11, 4, -29 },
  { 2093, 6, 37, 10, 2, -29 },
  { 2121, 19, 24, 25, 2, -30 },
  { 2178, 19, 15, 27, 4, -26 },
  { 2214, 20, 24, 26, 3, -30 },
  { 2274, 18, 42, 23, 2, -41 },
  { 2369, 38, 51, 44, 3, -39 },
  { 2612, 29, 40, 31, 1, -40 },
  { 2757, 22, 40, 30, 5, -40 },
  { 2867, 25, 42, 32, 4, -41 },
  { 2999, 23, 40, 32, 5, -40 },
  { 3114, 21, 40, 28, 5, -40 },
  { 3219, 20, 40, 27, 5, -40 },
  { 3319, 25, 42, 33, 4, -41 },
  { 3451, 25, 40, 34, 5, -40 },
  { 3576, 3, 40, 14, 5, -40 },
  { 3591, 20, 41, 27, 2, -40 },
  { 3694, 25, 40, 31, 5, -40 },
  { 3819, 19, 40, 26, 5, -40 },
  { 3914, 32, 40, 42, 5, -40 },
  { 4074, 25, 40, 35, 5, -40 },
  { 4199, 25, 42, 33, 4, -41 },
  { 4331, 23, 40, 30, 5, -40 },
  { 4446, 26, 48, 33, 3, -41 },
  { 4602, 23, 40, 31, 5, -40 },
  { 4717, 24, 42, 29, 3, -41 },
  { 4843, 25, 40, 29, 2, -40 },
  { 4968, 24, 41, 32, 4, -40 },
  { 5091, 28, 40, 30, 1, -40 },
  { 5231, 39, 40, 43, 2, -40 },
  { 5426, 26, 40, 30, 2, -40 },
  { 5556, 27, 40, 29, 1, -40 },
  { 5691, 24, 40, 29, 3, -40 },
  { 5811, 8, 55, 13, 4, -46 },
  { 5866, 17, 43, 20, 2, -40 },
  { 5958, 7, 55, 13, 1, -46 },
  { 6007, 16, 20, 21, 2, -40 },
  { 6047, 20, 3, 22, 1, 0 },
  { 6055, 9, 8, 16, 3, -42 },
  { 6064, 20, 32, 26, 3, -31 },
  { 6144, 20, 43, 27, 4, -42 },
  { 6252, 20, 32, 25, 3, -31 },
  { 6332, 20, 43, 27, 3, -42 },
  { 6440, 20, 32, 26, 3, -31 },
  { 6520, 14, 43, 17, 2, -43 },
  { 6596, 20, 42, 27, 3, -31 },
  { 6701, 19, 42, 27, 4, -42 },
  { 6801, 4, 40, 12, 4, -40 },
  { 6821, 10, 51, 12, -2, -40 },
  { 6885, 20, 42, 24, 4, -42 },
  { 6990, 3, 42, 12, 4, -42 },
  { 7006, 35, 31, 43, 4, -31 },
  { 7142, 19, 31, 27, 4, -31 },
  { 7216, 22, 32, 27, 3, -31 },
  { 7304, 20, 42, 27, 4, -31 },
  { 7409, 20, 42, 27, 3, -31 },
  { 7514, 12, 31, 17, 4, -31 },
  { 7561, 19, 32, 25, 3, -31 },
  { 7637, 13, 38, 16, 1, -37 },
  { 7699, 19, 31, 27, 4, -30 },
  { 7773, 21, 30, 24, 1, -30 },
  { 7852, 32, 30, 37, 2, -30 },
  { 7972, 20, 30, 24, 2, -30 },
  { 8047, 21, 41, 23, 1, -30 },
  { 8155, 19, 30, 24, 3, -30 },
  { 8227, 14, 55, 17, 2, -44 },
  { 8324, 3, 47, 12, 5, -40 },
  { 8342, 14, 55, 17, 1, -44 },
  { 8439, 25, 10, 33, 4, -22 },
};

const GFXfont RobotoCondensed_Light56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_LIGHT56PT7B_H_
