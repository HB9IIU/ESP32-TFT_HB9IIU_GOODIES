#ifndef _ROBOTOCONDENSED_LIGHT43PT7B_H_
#define _ROBOTOCONDENSED_LIGHT43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xB6, 0xD8, 0x00, 0x07,
  0xD8, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x00, 0xC1,
  0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x81, 0x00, 0x18,
  0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x07, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF0, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0C, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x78, 0xF0, 0x70, 0x1C, 0x38, 0x07, 0x18,
  0x03, 0x9C, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x33, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xB8,
  0x00, 0xDC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0xC0, 0x1C, 0x70, 0x1C,
  0x3E, 0x3E, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC7, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x0C, 0x06, 0x18, 0x08, 0x18, 0x30, 0x10, 0x30, 0x60,
  0x20, 0xC0, 0xC0, 0x41, 0x81, 0x81, 0x86, 0x01, 0x83, 0x0C, 0x03, 0x8E,
  0x30, 0x03, 0xF8, 0xC0, 0x03, 0xE1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x61, 0xE0, 0x01, 0x87, 0xF0, 0x03, 0x18,
  0x60, 0x0C, 0x30, 0x60, 0x18, 0xC0, 0xC0, 0x61, 0x81, 0x80, 0xC3, 0x03,
  0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x20, 0x18, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0,
  0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x1C, 0x01, 0x81, 0x80, 0x1C, 0x30,
  0x00, 0xCF, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1D, 0xC0, 0x03, 0x8E, 0x06, 0x30, 0x60, 0x67, 0x07, 0x06, 0x60,
  0x38, 0xEE, 0x01, 0xCC, 0xE0, 0x1C, 0xCE, 0x00, 0xFC, 0xE0, 0x07, 0x86,
  0x00, 0x38, 0x70, 0x07, 0x87, 0x80, 0xFC, 0x3C, 0x3E, 0xC1, 0xFF, 0x8E,
  0x07, 0xE0, 0x70, 0xFF, 0xFE, 0x80, 0x01, 0x01, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x10, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x06, 0x0C, 0x0B, 0xC6,
  0x3D, 0xFF, 0x7E, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xEC, 0x00,
  0xE7, 0x00, 0x61, 0xC0, 0x70, 0x70, 0x70, 0x18, 0x10, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x39, 0xCE,
  0x73, 0x98, 0xCE, 0x62, 0x00, 0xFF, 0xFF, 0xC0, 0x0E, 0xF6, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xF1, 0xE3,
  0x80, 0xE6, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x73, 0x80, 0xC3, 0xC7,
  0x83, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0x83, 0xC7, 0xEF, 0xFF, 0x3E, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0x0F, 0x07, 0x01,
  0xC7, 0x00, 0xE3, 0x00, 0x33, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0xE0,
  0x0F, 0xF8, 0x3C, 0x3C, 0x38, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x07,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x3C, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0x60, 0x07, 0x70, 0x06, 0x38, 0x0E, 0x3C, 0x3C, 0x0F, 0xF8, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00,
  0x3B, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x18, 0x30, 0x0E, 0x0C, 0x03, 0x03, 0x01, 0xC0, 0xC0, 0x60, 0x30,
  0x38, 0x0C, 0x0C, 0x03, 0x07, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFE,
  0x3F, 0xFE, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x33, 0xE0, 0x7F, 0xF8,
  0x7C, 0x7C, 0x70, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x07, 0x60, 0x07,
  0x60, 0x06, 0x70, 0x0E, 0x38, 0x0C, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0,
  0x00, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC3, 0xE0,
  0xCF, 0xF8, 0xDC, 0x3C, 0xF0, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06,
  0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x1C, 0x38, 0x0F, 0xF0,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x07, 0xFC,
  0x07, 0x8F, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x39, 0x80, 0x0C, 0xC0,
  0x06, 0x60, 0x03, 0x30, 0x01, 0x9C, 0x01, 0xC6, 0x00, 0xC3, 0x80, 0xE0,
  0xF1, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1C, 0x1C, 0x1C, 0x07, 0x1C, 0x01,
  0xCC, 0x00, 0x6E, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0x30, 0x01, 0x9C, 0x01, 0xC7, 0x01, 0xC3, 0xE3, 0xE0, 0xFF, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xF8, 0x1C, 0x3C, 0x38, 0x1C, 0x70, 0x0E,
  0x70, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x70, 0x0F,
  0x38, 0x1F, 0x1C, 0x3B, 0x1F, 0xF3, 0x07, 0xC7, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0,
  0x0F, 0xC0, 0x0F, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2F,
  0xF8, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x73, 0x9C, 0xE7, 0x31, 0x9C, 0xC4, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0xFF,
  0x0E, 0x3C, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x1E, 0x01,
  0x8C, 0x03, 0xFC, 0x04, 0x60, 0x38, 0x70, 0x33, 0x01, 0x81, 0x81, 0xB0,
  0x18, 0x0C, 0x0D, 0x80, 0xC0, 0x60, 0x6C, 0x0C, 0x02, 0x03, 0x60, 0x60,
  0x30, 0x0B, 0x03, 0x01, 0x80, 0x58, 0x18, 0x0C, 0x06, 0xC1, 0xC0, 0x60,
  0x34, 0x0C, 0x03, 0x01, 0xA0, 0x60, 0x18, 0x0D, 0x03, 0x00, 0xC0, 0x68,
  0x18, 0x06, 0x03, 0x60, 0xC0, 0x70, 0x33, 0x03, 0x03, 0x81, 0x98, 0x18,
  0x3C, 0x18, 0xC0, 0xE3, 0x30, 0xC6, 0x03, 0xF1, 0xFC, 0x18, 0x0F, 0x07,
  0xC0, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x01,
  0x8E, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x03,
  0x00, 0x1C, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xE0, 0x0E, 0x01, 0x80,
  0x38, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x30, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x70, 0xC0, 0x01,
  0xC7, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x60, 0x00, 0x3B, 0x80, 0x00, 0x6E,
  0x00, 0x01, 0xC0, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x1F, 0x18, 0x01, 0xCC,
  0x00, 0xE6, 0x00, 0x33, 0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x07, 0x60, 0x03,
  0xB0, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x01, 0xE3, 0xFF, 0xC1, 0xFF,
  0xF0, 0xC0, 0x1E, 0x60, 0x03, 0x30, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01,
  0xD8, 0x01, 0xCC, 0x03, 0xE7, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7C, 0x3C, 0x1E, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x01, 0x98,
  0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0xCE, 0x00, 0x18, 0xC0,
  0x07, 0x1E, 0x01, 0xC1, 0xF0, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0C, 0x07, 0xC3, 0x00, 0x78, 0xC0, 0x07, 0x30, 0x00,
  0xCC, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0x73,
  0x00, 0x78, 0xC0, 0x7C, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x7C, 0x3E, 0x1E, 0x01, 0xE3, 0x80,
  0x1C, 0xE0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03, 0x70, 0x00,
  0x6E, 0x00, 0x0C, 0xE0, 0x03, 0x8E, 0x00, 0xF1, 0xF0, 0x7C, 0x0F, 0xFE,
  0x00, 0x7F, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x33, 0x80, 0xE3, 0xC7, 0x83, 0xFE, 0x03, 0xF0, 0x00,
  0xC0, 0x03, 0x98, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x07, 0x0C, 0x01, 0xC1,
  0x80, 0x38, 0x30, 0x0E, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x3C, 0x03,
  0x07, 0x00, 0x61, 0xC0, 0x0C, 0x70, 0x01, 0x9C, 0x00, 0x33, 0xC0, 0x06,
  0xF8, 0x00, 0xFB, 0x80, 0x1E, 0x38, 0x03, 0x87, 0x00, 0x60, 0x70, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x0E, 0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x18,
  0x01, 0xC3, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x39, 0x80, 0x03, 0xB0,
  0x00, 0x70, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x60, 0x00, 0x6F, 0xB0,
  0x00, 0x37, 0xDC, 0x00, 0x3B, 0xE6, 0x00, 0x19, 0xF3, 0x00, 0x0C, 0xF9,
  0xC0, 0x0E, 0x7C, 0x60, 0x06, 0x3E, 0x30, 0x03, 0x1F, 0x1C, 0x03, 0x8F,
  0x86, 0x01, 0x87, 0xC3, 0x00, 0xC3, 0xE1, 0xC0, 0xE1, 0xF0, 0x60, 0x60,
  0xF8, 0x30, 0x30, 0x7C, 0x1C, 0x38, 0x3E, 0x06, 0x18, 0x1F, 0x03, 0x0C,
  0x0F, 0x80, 0xCE, 0x07, 0xC0, 0x66, 0x03, 0xE0, 0x33, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0xE0, 0x1F, 0x00,
  0x60, 0x0E, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xB0, 0x01, 0xF7, 0x00, 0x3E, 0x60, 0x07, 0xCE, 0x00, 0xF8,
  0xC0, 0x1F, 0x1C, 0x03, 0xE1, 0x80, 0x7C, 0x38, 0x0F, 0x83, 0x01, 0xF0,
  0x70, 0x3E, 0x07, 0x07, 0xC0, 0x60, 0xF8, 0x0E, 0x1F, 0x00, 0xC3, 0xE0,
  0x1C, 0x7C, 0x01, 0x8F, 0x80, 0x39, 0xF0, 0x03, 0x3E, 0x00, 0x77, 0xC0,
  0x06, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x38, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0x0F, 0x03,
  0xC0, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xEE, 0x00, 0x06,
  0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xE0,
  0x00, 0x6E, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00, 0x0C, 0x30, 0x01, 0xC3,
  0xC0, 0x38, 0x1F, 0x0F, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x7F, 0xFE, 0x30, 0x0F, 0x98, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1B, 0x00, 0x1D, 0x80, 0x3C, 0xFF, 0xFC, 0x7F, 0xF8,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1C,
  0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0x98, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x07, 0x60, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x1C, 0x01, 0xC1, 0xF1,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x20, 0xFF, 0xE0, 0x3F, 0xFE, 0x0C, 0x03,
  0xE3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0E,
  0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x01, 0xCC, 0x00, 0xE3, 0x00, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0C, 0x07,
  0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30,
  0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0xB0,
  0x00, 0x6C, 0x00, 0x1C, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE1, 0xF0, 0xE0,
  0x1E, 0x70, 0x03, 0x9C, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xD8, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x0E, 0x1F, 0x0F, 0x03, 0xFF, 0x80,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x77, 0x00, 0x18, 0xE0, 0x0E, 0x3E,
  0x1F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xD8,
  0x00, 0x0E, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x18, 0x00, 0x38, 0xE0, 0x01,
  0x87, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x18,
  0x03, 0x80, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xC0, 0x70,
  0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x38,
  0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0xDC, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0x70, 0x01, 0xB8, 0x01, 0xE0, 0x06, 0xE0, 0x07, 0x80, 0x39, 0x80,
  0x36, 0x00, 0xE6, 0x00, 0xD8, 0x03, 0x18, 0x03, 0x70, 0x0C, 0x70, 0x0C,
  0xC0, 0x31, 0xC0, 0x63, 0x01, 0xC3, 0x01, 0x8C, 0x07, 0x0C, 0x06, 0x38,
  0x18, 0x30, 0x18, 0x60, 0x60, 0xE0, 0xE1, 0x81, 0x81, 0x83, 0x06, 0x0E,
  0x06, 0x0C, 0x18, 0x38, 0x18, 0x30, 0x30, 0xC0, 0x61, 0xC0, 0xC3, 0x01,
  0xC6, 0x03, 0x0C, 0x03, 0x18, 0x0C, 0x70, 0x0C, 0x60, 0x19, 0xC0, 0x33,
  0x80, 0x66, 0x00, 0xEC, 0x01, 0x98, 0x03, 0xB0, 0x06, 0x60, 0x06, 0xC0,
  0x0D, 0x80, 0x1B, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x71, 0x80, 0x03, 0x8E, 0x00, 0x38, 0x30, 0x01, 0xC1,
  0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x07,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00,
  0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x77, 0x00, 0x03, 0x18, 0x00, 0x38, 0xE0, 0x01, 0x83, 0x00, 0x1C,
  0x1C, 0x00, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x70,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xC0, 0xE0,
  0x00, 0x33, 0x00, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC3, 0x80, 0x0C,
  0x1C, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x18, 0x01, 0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0xC6, 0x00,
  0x06, 0x70, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x06,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0x98, 0x19, 0x83, 0x98, 0x30,
  0xC3, 0x0C, 0x70, 0xC6, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3C, 0x3C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x07, 0xFE, 0x1F, 0xFE, 0x3C, 0x06, 0x70, 0x06,
  0x60, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x1E,
  0x7C, 0xF6, 0x3F, 0xE6, 0x0F, 0x87, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC3, 0xE0, 0xCF, 0xF8, 0xDC, 0x3C, 0xF0, 0x1C, 0xE0, 0x0E, 0xE0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x06,
  0xE0, 0x0E, 0xF0, 0x1C, 0xDC, 0x3C, 0xCF, 0xF8, 0xC3, 0xE0, 0x07, 0xE0,
  0x1F, 0xF8, 0x3C, 0x3C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x06,
  0x30, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x07, 0xC7, 0x1F, 0xF7, 0x3C, 0x3F, 0x38, 0x0F, 0x70, 0x07,
  0x60, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07,
  0x60, 0x07, 0x70, 0x07, 0x38, 0x0F, 0x3C, 0x3B, 0x1F, 0xF3, 0x07, 0xC3,
  0x07, 0xE0, 0x1F, 0xF8, 0x3E, 0x3C, 0x38, 0x0E, 0x70, 0x0E, 0x60, 0x06,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x06, 0x3E, 0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xE1,
  0xFC, 0x38, 0x8E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x1F, 0xF3,
  0xFE, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x07, 0xC3, 0x1F, 0xF3, 0x3C, 0x3B,
  0x38, 0x0F, 0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x07, 0x60, 0x07, 0x70, 0x07, 0x38, 0x0F, 0x3C, 0x3F,
  0x1F, 0xF7, 0x07, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x20, 0x06, 0x30, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x87, 0xC3, 0x3F, 0xE6, 0xE1, 0xCD, 0x81, 0xDE, 0x01,
  0xB8, 0x03, 0x70, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC7, 0xBE, 0x78, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x3B, 0x00, 0xE6, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x30,
  0x70, 0x61, 0xC0, 0xC7, 0x01, 0x9C, 0x03, 0x38, 0x06, 0xF0, 0x0F, 0xF0,
  0x1E, 0x60, 0x38, 0xE0, 0x60, 0xE0, 0xC1, 0xC1, 0x81, 0xC3, 0x01, 0xC6,
  0x03, 0x8C, 0x03, 0x98, 0x03, 0x30, 0x07, 0x60, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x3E,
  0x19, 0xFF, 0x1F, 0xF3, 0x71, 0xE7, 0x0F, 0x78, 0x0F, 0xC0, 0xEF, 0x00,
  0xF0, 0x0D, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0x70, 0x07,
  0xC0, 0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x38, 0x03, 0xE0, 0x07,
  0x00, 0x7C, 0x00, 0xE0, 0x0F, 0x80, 0x1C, 0x01, 0xF0, 0x03, 0x80, 0x3E,
  0x00, 0x70, 0x07, 0xC0, 0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x38,
  0x03, 0xE0, 0x07, 0x00, 0x7C, 0x00, 0xE0, 0x0F, 0x80, 0x1C, 0x01, 0xF0,
  0x03, 0x80, 0x38, 0xC3, 0xE1, 0x9F, 0xF3, 0x70, 0xE6, 0xC0, 0xEF, 0x00,
  0xDC, 0x01, 0xB8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0x80, 0x03,
  0xE0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x19,
  0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x60, 0x03, 0x38,
  0x01, 0x9C, 0x01, 0xC7, 0x01, 0xC1, 0xE3, 0xC0, 0x7F, 0xC0, 0x0F, 0x80,
  0xC3, 0xE0, 0xCF, 0xF8, 0xDC, 0x7C, 0xF0, 0x1C, 0xE0, 0x0E, 0xE0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xE0, 0x0E, 0xF0, 0x1C, 0xDC, 0x3C, 0xCF, 0xF8, 0xC7, 0xE0, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x07, 0xC3, 0x1F, 0xF3, 0x3C, 0x3B, 0x38, 0x0F,
  0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0x60, 0x07, 0x60, 0x07, 0x70, 0x07, 0x38, 0x0F, 0x3C, 0x3F, 0x1F, 0xF7,
  0x07, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xC7, 0xE7, 0xF7, 0xBB,
  0x0F, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x07, 0xE0,
  0x3F, 0xE0, 0xF1, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xD8, 0x03, 0xB8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0x63,
  0xC7, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x0F, 0xFF, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x00, 0xE0, 0x3F, 0x07, 0xC0, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1D, 0x80, 0x7B, 0x81, 0xF7, 0x87, 0xE7, 0xFD,
  0xC3, 0xE3, 0x80, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x70, 0x06, 0x70,
  0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x38, 0x0C, 0x18, 0x1C, 0x18, 0x18, 0x1C,
  0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x07, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0xB0, 0x06, 0x00, 0xD8, 0x07, 0x80, 0x6E, 0x03,
  0xC0, 0x73, 0x01, 0xE0, 0x31, 0x80, 0xF0, 0x18, 0xC0, 0xDC, 0x0C, 0x70,
  0x66, 0x0E, 0x18, 0x33, 0x06, 0x0C, 0x39, 0x83, 0x06, 0x18, 0x61, 0x83,
  0x0C, 0x30, 0xC1, 0xC6, 0x18, 0xC0, 0x67, 0x0C, 0x60, 0x33, 0x03, 0x30,
  0x19, 0x81, 0x98, 0x0E, 0xC0, 0xD8, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x70, 0x07, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x1C, 0x18, 0x0C,
  0x38, 0x0E, 0x30, 0x06, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C,
  0x38, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x30,
  0x0C, 0x38, 0x1C, 0x18, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x38, 0x0C,
  0x30, 0x0E, 0x30, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x81, 0xC0,
  0xE0, 0x3C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0x60, 0x1E, 0x01, 0xC0, 0xF0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x03,
  0x73, 0xC0, 0x66, 0x0E, 0x06, 0xC0, 0x70, 0x6C, 0x03, 0x9C, 0xC0, 0x1F,
  0xC0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Light43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 7, 10, 12, 3, -32 },
  { 22, 20, 31, 22, 2, -31 },
  { 100, 17, 39, 21, 2, -35 },
  { 183, 23, 31, 27, 2, -31 },
  { 273, 20, 31, 23, 2, -31 },
  { 351, 2, 9, 7, 3, -32 },
  { 354, 9, 44, 13, 3, -34 },
  { 404, 9, 44, 13, 1, -34 },
  { 454, 17, 17, 18, 1, -31 },
  { 491, 17, 22, 21, 2, -25 },
  { 538, 5, 10, 8, 1, -4 },
  { 545, 9, 2, 11, 1, -14 },
  { 548, 4, 4, 10, 3, -4 },
  { 550, 13, 34, 15, 1, -31 },
  { 606, 15, 31, 21, 3, -31 },
  { 665, 9, 31, 21, 4, -31 },
  { 700, 17, 31, 21, 2, -31 },
  { 766, 16, 31, 21, 2, -31 },
  { 828, 18, 31, 21, 2, -31 },
  { 898, 16, 31, 21, 3, -31 },
  { 960, 16, 31, 21, 3, -31 },
  { 1022, 17, 31, 21, 2, -31 },
  { 1088, 17, 31, 21, 2, -31 },
  { 1154, 16, 31, 21, 2, -31 },
  { 1216, 3, 23, 9, 3, -23 },
  { 1225, 5, 29, 8, 1, -23 },
  { 1244, 14, 18, 19, 2, -23 },
  { 1276, 15, 10, 21, 3, -19 },
  { 1295, 15, 18, 20, 3, -23 },
  { 1329, 13, 31, 17, 2, -31 },
  { 1380, 29, 40, 34, 2, -30 },
  { 1525, 22, 31, 24, 1, -31 },
  { 1611, 17, 31, 23, 4, -31 },
  { 1677, 19, 31, 24, 3, -31 },
  { 1751, 18, 31, 25, 4, -31 },
  { 1821, 16, 31, 21, 4, -31 },
  { 1883, 16, 31, 21, 4, -31 },
  { 1945, 19, 31, 26, 3, -31 },
  { 2019, 19, 31, 26, 4, -31 },
  { 2093, 2, 31, 11, 4, -31 },
  { 2101, 15, 31, 21, 2, -31 },
  { 2160, 19, 31, 24, 4, -31 },
  { 2234, 15, 31, 20, 4, -31 },
  { 2293, 25, 31, 32, 4, -31 },
  { 2390, 19, 31, 27, 4, -31 },
  { 2464, 20, 31, 25, 3, -31 },
  { 2542, 17, 31, 23, 4, -31 },
  { 2608, 19, 36, 25, 3, -31 },
  { 2694, 18, 31, 24, 4, -31 },
  { 2764, 18, 31, 22, 2, -31 },
  { 2834, 20, 31, 22, 1, -31 },
  { 2912, 18, 31, 25, 3, -31 },
  { 2982, 21, 31, 23, 1, -31 },
  { 3064, 30, 31, 33, 2, -31 },
  { 3181, 21, 31, 23, 1, -31 },
  { 3263, 21, 31, 22, 1, -31 },
  { 3345, 19, 31, 22, 2, -31 },
  { 3419, 6, 42, 10, 3, -35 },
  { 3451, 13, 34, 15, 1, -31 },
  { 3507, 6, 42, 10, 0, -35 },
  { 3539, 12, 15, 16, 2, -31 },
  { 3562, 16, 2, 17, 0, 0 },
  { 3566, 7, 6, 12, 2, -32 },
  { 3572, 16, 23, 20, 2, -23 },
  { 3618, 16, 32, 21, 3, -32 },
  { 3682, 16, 23, 20, 2, -23 },
  { 3728, 16, 32, 21, 2, -32 },
  { 3792, 16, 23, 20, 2, -23 },
  { 3838, 11, 32, 13, 2, -32 },
  { 3882, 16, 32, 21, 2, -23 },
  { 3946, 15, 32, 21, 3, -32 },
  { 4006, 3, 31, 9, 3, -31 },
  { 4018, 7, 40, 9, -1, -31 },
  { 4053, 15, 32, 19, 3, -32 },
  { 4113, 3, 32, 9, 3, -32 },
  { 4125, 27, 23, 33, 3, -23 },
  { 4203, 15, 23, 21, 3, -23 },
  { 4247, 17, 23, 21, 2, -23 },
  { 4296, 16, 32, 21, 3, -23 },
  { 4360, 16, 32, 21, 2, -23 },
  { 4424, 9, 23, 13, 3, -23 },
  { 4450, 15, 23, 19, 2, -23 },
  { 4494, 10, 29, 13, 1, -29 },
  { 4531, 15, 23, 21, 3, -23 },
  { 4575, 16, 23, 18, 1, -23 },
  { 4621, 25, 23, 28, 1, -23 },
  { 4693, 16, 23, 18, 1, -23 },
  { 4739, 16, 32, 18, 1, -23 },
  { 4803, 15, 23, 18, 2, -23 },
  { 4847, 10, 42, 13, 2, -34 },
  { 4900, 2, 37, 10, 4, -31 },
  { 4910, 10, 42, 13, 1, -34 },
  { 4963, 20, 8, 26, 3, -17 },
};

const GFXfont RobotoCondensed_Light43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_LIGHT43PT7B_H_
