#ifndef _ROBOTOCONDENSED_LIGHT50PT7B_H_
#define _ROBOTOCONDENSED_LIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x63, 0xB1, 0xD8, 0xEC, 0x76, 0x3B, 0x1D, 0x8E, 0xC6,
  0xE3, 0x71, 0xB8, 0xC0, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80,
  0xC0, 0x03, 0x03, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x81,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x38, 0x18, 0x00, 0x70, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x18,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3C, 0x07, 0x07, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x33,
  0x80, 0x06, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xB8,
  0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x07, 0x38,
  0x00, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0x83, 0x80, 0x00, 0xC0, 0x60, 0x10, 0x30, 0x18, 0x06, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x70, 0x60, 0x30, 0x1C, 0x38, 0x0C, 0x06,
  0x0C, 0x03, 0x01, 0x87, 0x00, 0xC0, 0x61, 0x80, 0x18, 0x38, 0xE0, 0x07,
  0x1C, 0x30, 0x00, 0xFE, 0x1C, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0xF8, 0x00, 0x18, 0x7F, 0x00, 0x0C,
  0x38, 0xE0, 0x03, 0x1C, 0x1C, 0x01, 0x86, 0x03, 0x00, 0xE1, 0x80, 0xC0,
  0x30, 0x60, 0x30, 0x1C, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x70, 0x18, 0x0C, 0x18, 0x06, 0x03, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x70, 0x01, 0xC0,
  0x60, 0x03, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0C, 0x00, 0x60, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0,
  0x01, 0xCF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xE7, 0x00, 0x03, 0x87, 0x01, 0x8E,
  0x0E, 0x03, 0x1C, 0x0E, 0x06, 0x70, 0x0E, 0x0C, 0xE0, 0x1E, 0x39, 0xC0,
  0x1C, 0x73, 0x00, 0x1C, 0xC6, 0x00, 0x1F, 0x8E, 0x00, 0x3F, 0x1C, 0x00,
  0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0xF8, 0x78, 0x07, 0xF0, 0x78, 0x3E,
  0x70, 0x7F, 0xF8, 0x70, 0x7F, 0xC0, 0xF0, 0x08, 0x00, 0x00, 0xFF, 0xFF,
  0xB6, 0xDB, 0x00, 0x00, 0x40, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x04, 0x40, 0x38, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0xE0, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x60, 0x6F, 0x86, 0x1E, 0xFE, 0x6F, 0xF1, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3B, 0x80, 0x07, 0x1C,
  0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x80,
  0x20, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x71,
  0xC7, 0x1C, 0x63, 0x8E, 0x71, 0xC2, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF,
  0xFE, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C,
  0x38, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x07, 0x60, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xE7, 0x00,
  0x38, 0xE0, 0x1C, 0x1C, 0x0F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xFF, 0xEF, 0xE1, 0xF0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1E, 0x07, 0x87,
  0x00, 0x78, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x01, 0xD8,
  0x00, 0x3B, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0x03, 0xC3, 0x80, 0x3C, 0x70, 0x03, 0x9C, 0x00, 0x33, 0x80, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x77, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x31, 0xC0, 0x0E, 0x3C, 0x03, 0x83, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xEC,
  0x00, 0x0E, 0x60, 0x00, 0x73, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x03,
  0x86, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60,
  0x06, 0x03, 0x00, 0x70, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x03, 0x80,
  0x30, 0x1C, 0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xFC,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x0F, 0x1C, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00,
  0x67, 0x00, 0x39, 0xE0, 0x1E, 0x3C, 0x0F, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x1F, 0x80, 0xCF, 0xFC, 0x3B,
  0xFF, 0xC7, 0xF0, 0x3C, 0xF8, 0x03, 0x9E, 0x00, 0x3B, 0xC0, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00, 0x67, 0x00, 0x1C, 0xE0,
  0x03, 0x8E, 0x00, 0xE1, 0xE0, 0x1C, 0x1E, 0x07, 0x01, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1E, 0x07, 0x87, 0x80, 0x78, 0xE0, 0x07,
  0x1C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x30, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x0E, 0x00, 0xE1, 0xE0, 0x78,
  0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0x07, 0x83, 0x80, 0x78,
  0xE0, 0x07, 0x38, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xBC, 0x00, 0x73,
  0x80, 0x1E, 0x3C, 0x07, 0x87, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x1C,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x1F, 0x3C, 0x0F, 0xC7,
  0xFF, 0x70, 0xFF, 0x9C, 0x1F, 0x87, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x7C, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x7B,
  0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE7, 0x39, 0xCE, 0x67, 0x3B, 0x9C, 0x40, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x38, 0x1E,
  0x70, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x00, 0x30, 0xE0, 0x03, 0xE0, 0x0C, 0x30, 0x03, 0xFC, 0x03, 0x0C,
  0x01, 0xE3, 0x80, 0x67, 0x00, 0xE0, 0x60, 0x19, 0x80, 0x30, 0x18, 0x06,
  0x60, 0x1C, 0x06, 0x01, 0x98, 0x06, 0x01, 0x80, 0x6E, 0x03, 0x80, 0x60,
  0x1B, 0x80, 0xC0, 0x18, 0x06, 0xC0, 0x30, 0x06, 0x01, 0xB0, 0x1C, 0x01,
  0x80, 0x6C, 0x07, 0x00, 0x60, 0x1B, 0x01, 0xC0, 0x38, 0x06, 0xC0, 0x60,
  0x0E, 0x01, 0xB0, 0x18, 0x03, 0x80, 0x6C, 0x06, 0x00, 0xE0, 0x1B, 0x01,
  0x80, 0x30, 0x06, 0xC0, 0x60, 0x0C, 0x03, 0x30, 0x1C, 0x07, 0x00, 0xCE,
  0x07, 0x01, 0xE0, 0x71, 0x80, 0xC0, 0xD8, 0x18, 0x60, 0x38, 0x67, 0x0E,
  0x18, 0x07, 0xF9, 0xFF, 0x07, 0x00, 0xFC, 0x3F, 0x80, 0xC0, 0x08, 0x01,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x80,
  0x60, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x70, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8E, 0x00, 0x78, 0xE0,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x78, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0E, 0x00, 0x7C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x03, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xC0, 0x07, 0x87, 0x80, 0x07,
  0x0E, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xC0,
  0x0F, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x03, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03,
  0x9C, 0x00, 0x38, 0xE0, 0x07, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0x80, 0x78, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xCF, 0x00, 0x0F, 0x1E, 0x00,
  0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x1E, 0x3C, 0x0F, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xE0,
  0x00, 0x3B, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x03,
  0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x03, 0xC0, 0xE0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x87,
  0x80, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xBF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0x38, 0x00, 0xF8, 0x70, 0x03, 0xC1, 0xE0, 0x0F,
  0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x6F, 0xF0, 0x00, 0x07,
  0x7D, 0x80, 0x00, 0x3B, 0xEE, 0x00, 0x01, 0x9F, 0x70, 0x00, 0x1C, 0xF9,
  0x80, 0x00, 0xE7, 0xCE, 0x00, 0x06, 0x7E, 0x70, 0x00, 0x73, 0xF1, 0x80,
  0x03, 0x9F, 0x8E, 0x00, 0x18, 0xFC, 0x70, 0x01, 0xC7, 0xE1, 0xC0, 0x0E,
  0x3F, 0x0E, 0x00, 0xE1, 0xF8, 0x30, 0x07, 0x0F, 0xC1, 0xC0, 0x30, 0x7E,
  0x0E, 0x03, 0x83, 0xF0, 0x30, 0x1C, 0x1F, 0x81, 0xC0, 0xC0, 0xFC, 0x0E,
  0x0E, 0x07, 0xE0, 0x30, 0x70, 0x3F, 0x01, 0xC3, 0x01, 0xF8, 0x0E, 0x38,
  0x0F, 0xC0, 0x31, 0xC0, 0x7E, 0x01, 0xCC, 0x03, 0xF0, 0x0E, 0xE0, 0x1F,
  0x80, 0x37, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x3C, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x70, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFB, 0x80, 0x03, 0xF7, 0x00, 0x07, 0xE7, 0x00, 0x0F,
  0xCE, 0x00, 0x1F, 0x8E, 0x00, 0x3F, 0x1C, 0x00, 0x7E, 0x1C, 0x00, 0xFC,
  0x18, 0x01, 0xF8, 0x38, 0x03, 0xF0, 0x38, 0x07, 0xE0, 0x70, 0x0F, 0xC0,
  0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x00, 0xE0, 0x7E, 0x01, 0xC0, 0xFC, 0x01,
  0xC1, 0xF8, 0x03, 0x83, 0xF0, 0x03, 0x87, 0xE0, 0x03, 0x0F, 0xC0, 0x07,
  0x1F, 0x80, 0x07, 0x3F, 0x00, 0x0E, 0x7E, 0x00, 0x0E, 0xFC, 0x00, 0x1D,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xF8, 0x07, 0x81, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E,
  0x00, 0x3C, 0x0F, 0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xC0, 0x07,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00,
  0x1F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x07,
  0x81, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x0C, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x67, 0x00, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1F, 0x00, 0xF0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x08, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xC0, 0x07,
  0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xE7, 0x00,
  0x1E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x70, 0x07, 0x03,
  0x80, 0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00,
  0x70, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78,
  0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x19, 0xC0, 0x00, 0x67, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0xE7,
  0x80, 0x03, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x39, 0xC0, 0x01, 0xCF, 0x00, 0x1C,
  0x3C, 0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x0C, 0x60, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xE6, 0x00, 0x1F,
  0x00, 0x1C, 0xE0, 0x03, 0x60, 0x03, 0x9C, 0x00, 0x6C, 0x00, 0x73, 0x80,
  0x1D, 0x80, 0x0C, 0x30, 0x03, 0xB8, 0x03, 0x87, 0x00, 0x63, 0x00, 0x70,
  0xE0, 0x0C, 0x60, 0x0E, 0x1C, 0x03, 0x8C, 0x01, 0xC3, 0x80, 0x71, 0xC0,
  0x30, 0x30, 0x0C, 0x38, 0x0E, 0x07, 0x01, 0x83, 0x01, 0xC0, 0xE0, 0x70,
  0x60, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x30,
  0x30, 0x18, 0x38, 0x07, 0x0E, 0x03, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0xE0,
  0x1C, 0x38, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18,
  0xE0, 0x07, 0x38, 0x03, 0x1C, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x1C, 0xC0,
  0x06, 0x60, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x19, 0x80, 0x06,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39,
  0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x0E,
  0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x78, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xFE,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xFF,
  0xFE, 0x03, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x3B, 0x00,
  0xCC, 0x03, 0x38, 0x1C, 0x60, 0x61, 0x81, 0x87, 0x0E, 0x0C, 0x30, 0x30,
  0xC0, 0xE7, 0x01, 0x98, 0x06, 0x60, 0x1F, 0x80, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x7F,
  0xF1, 0xFF, 0xF9, 0xF8, 0x1D, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7E,
  0xFF, 0xF7, 0x3F, 0xF3, 0x87, 0xE1, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC3, 0xF0,
  0x33, 0xFF, 0x0D, 0xFF, 0xE3, 0x60, 0x3C, 0xF0, 0x07, 0x38, 0x00, 0xEE,
  0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xE0, 0x03, 0xBC, 0x01, 0xCF,
  0x80, 0xF3, 0x7F, 0xF8, 0xCF, 0xFC, 0x30, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0xC3, 0x80, 0x1C, 0xE0, 0x03, 0x9C,
  0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00, 0x67, 0x00, 0x1C, 0x70,
  0x03, 0x0F, 0x01, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x07, 0xE1, 0xC7, 0xFE, 0x73, 0xFF, 0xDD, 0xE0, 0x3F, 0x70,
  0x03, 0xDC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70,
  0x03, 0xDC, 0x00, 0xF3, 0x80, 0xFC, 0xFF, 0xF7, 0x1F, 0xF9, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0E, 0x03, 0xC3, 0x80,
  0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x06, 0x60, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x01, 0x0F, 0x80, 0x70, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x0F, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x7F, 0xF3, 0xFF, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xE1, 0xC7, 0xFE, 0x73,
  0xFF, 0xDD, 0xE0, 0x3F, 0x70, 0x07, 0xDC, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0x70, 0x03, 0xDC, 0x00, 0xF3, 0x80, 0xFC, 0xFF,
  0xF7, 0x1F, 0xF9, 0xC1, 0xF8, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x80, 0x0E, 0x78, 0x07, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x1F, 0x06, 0x3F, 0xE3, 0x3F, 0xF9,
  0xB8, 0x1C, 0xF8, 0x07, 0x78, 0x03, 0xB8, 0x00, 0xDC, 0x00, 0x6C, 0x00,
  0x36, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1C, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0xFC, 0xFC,
  0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0xF6, 0x00, 0x73, 0x00, 0x71, 0x80, 0x70, 0xC0,
  0x70, 0x60, 0x78, 0x30, 0x78, 0x18, 0x78, 0x0C, 0x38, 0x06, 0x38, 0x03,
  0x38, 0x01, 0xBC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3C, 0xE0, 0x1C, 0x38,
  0x0C, 0x1E, 0x06, 0x07, 0x03, 0x01, 0xC1, 0x80, 0xF0, 0xC0, 0x38, 0x60,
  0x0E, 0x30, 0x07, 0x98, 0x01, 0xCC, 0x00, 0x76, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC3, 0xF0, 0x0F, 0xC1, 0x8F, 0xF8, 0x3F, 0xE3, 0x3F, 0xF9, 0xFF,
  0xE6, 0xC0, 0x73, 0x81, 0xEF, 0x00, 0x7C, 0x01, 0xDC, 0x00, 0xF8, 0x03,
  0xB8, 0x01, 0xE0, 0x03, 0x70, 0x01, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x0F,
  0x80, 0x06, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x7C,
  0x00, 0x30, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xF0, 0x00, 0xC0, 0x03, 0xE0,
  0x01, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1F, 0x00,
  0x0C, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x30, 0x00, 0xF8, 0x00,
  0x60, 0x01, 0xF0, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x07, 0xC0, 0x03,
  0x00, 0x0F, 0x80, 0x06, 0x00, 0x1C, 0xC1, 0xF0, 0x63, 0xFE, 0x33, 0xFF,
  0x9B, 0x81, 0xCF, 0x80, 0x77, 0x80, 0x3B, 0x80, 0x0D, 0xC0, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0xC7,
  0x80, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x70,
  0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x07, 0x0F, 0x01, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0x00, 0xC3, 0xF0, 0x33, 0xFF, 0x0D, 0xFF, 0xE3, 0xE0,
  0x3C, 0xF0, 0x07, 0x38, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x01,
  0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x00,
  0x0E, 0xE0, 0x03, 0xBC, 0x01, 0xCF, 0x80, 0xF3, 0x7F, 0xF8, 0xCF, 0xFC,
  0x30, 0xFC, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xE1, 0xC7, 0xFE, 0x73, 0xFF, 0xDD, 0xE0, 0x3F, 0x70, 0x03,
  0xDC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0xF3, 0x80, 0xFC, 0xFF, 0xF7, 0x1F, 0xF9, 0xC1, 0xF8, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xC3, 0xF3,
  0xFD, 0xFF, 0x70, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x8F, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x06,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xB0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x37, 0x00, 0x39, 0xC0, 0x3C, 0x7F, 0xFC, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x0F, 0xFE, 0xFF, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0xE0, 0x7F, 0x01, 0xF0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0x70, 0x1F, 0x7F, 0xFB, 0x3F, 0xF3, 0x0F, 0xC3, 0xE0, 0x00, 0xEE,
  0x00, 0x19, 0xC0, 0x07, 0x38, 0x00, 0xE3, 0x00, 0x1C, 0x70, 0x07, 0x0E,
  0x00, 0xE0, 0xC0, 0x1C, 0x1C, 0x03, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x03, 0x00, 0xE0, 0xE0, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x38, 0x60, 0x07,
  0x1C, 0x00, 0x63, 0x00, 0x0E, 0x60, 0x01, 0xDC, 0x00, 0x1B, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xB8, 0x03, 0xC0, 0x1C, 0xC0, 0x1E,
  0x00, 0xE7, 0x00, 0xF8, 0x07, 0x38, 0x07, 0xC0, 0x31, 0xC0, 0x76, 0x03,
  0x86, 0x03, 0x30, 0x1C, 0x30, 0x19, 0xC0, 0xE1, 0xC0, 0xCE, 0x06, 0x0E,
  0x0E, 0x30, 0x30, 0x30, 0x61, 0x83, 0x81, 0x83, 0x0E, 0x1C, 0x0E, 0x38,
  0x30, 0xC0, 0x71, 0xC1, 0x86, 0x01, 0x8C, 0x0E, 0x70, 0x0C, 0x60, 0x73,
  0x80, 0x77, 0x01, 0x98, 0x03, 0xB8, 0x0C, 0xC0, 0x0D, 0x80, 0x76, 0x00,
  0x6C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x70,
  0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x1C, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0xC0,
  0x03, 0x98, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x70,
  0x38, 0x0E, 0x0F, 0x00, 0xE1, 0xC0, 0x1E, 0x70, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE3, 0x80, 0x18,
  0x70, 0x07, 0x0E, 0x00, 0xE0, 0xC0, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x03, 0x00, 0xE0, 0xE0, 0x0C, 0x1C, 0x01, 0xC3, 0x00,
  0x38, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x30, 0x07, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x0F,
  0x80, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x07, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x00, 0xF0, 0x1F, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xC0, 0x0C, 0xFF, 0xC0, 0x1B, 0x83, 0xC0, 0x37, 0x03, 0xC0,
  0xEC, 0x03, 0xC3, 0xB8, 0x03, 0xFF, 0x70, 0x03, 0xFC, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_Light50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 9, 11, 14, 3, -38 },
  { 28, 23, 36, 26, 2, -36 },
  { 132, 19, 46, 24, 3, -41 },
  { 242, 26, 36, 32, 3, -36 },
  { 359, 23, 37, 27, 3, -36 },
  { 466, 3, 11, 9, 3, -38 },
  { 471, 10, 51, 15, 3, -40 },
  { 535, 10, 51, 15, 1, -40 },
  { 599, 20, 20, 21, 1, -36 },
  { 649, 21, 26, 25, 2, -29 },
  { 718, 6, 11, 10, 1, -5 },
  { 727, 10, 3, 13, 1, -17 },
  { 731, 4, 4, 12, 4, -4 },
  { 733, 15, 39, 18, 1, -36 },
  { 807, 18, 36, 24, 3, -36 },
  { 888, 11, 36, 24, 4, -36 },
  { 938, 19, 36, 24, 3, -36 },
  { 1024, 19, 36, 24, 2, -36 },
  { 1110, 21, 36, 24, 2, -36 },
  { 1205, 18, 36, 24, 4, -36 },
  { 1286, 19, 36, 24, 3, -36 },
  { 1372, 20, 36, 24, 2, -36 },
  { 1462, 19, 36, 24, 3, -36 },
  { 1548, 18, 36, 24, 3, -36 },
  { 1629, 4, 27, 10, 3, -27 },
  { 1643, 5, 33, 9, 2, -27 },
  { 1664, 17, 20, 22, 2, -26 },
  { 1707, 17, 13, 24, 4, -23 },
  { 1735, 17, 21, 23, 3, -27 },
  { 1780, 16, 36, 20, 2, -36 },
  { 1852, 34, 46, 39, 3, -35 },
  { 2048, 25, 36, 27, 1, -36 },
  { 2161, 20, 36, 27, 4, -36 },
  { 2251, 23, 36, 28, 3, -36 },
  { 2355, 21, 36, 28, 4, -36 },
  { 2450, 19, 36, 25, 4, -36 },
  { 2536, 19, 36, 25, 4, -36 },
  { 2622, 22, 36, 30, 4, -36 },
  { 2721, 22, 36, 31, 4, -36 },
  { 2820, 3, 36, 12, 5, -36 },
  { 2834, 18, 36, 24, 2, -36 },
  { 2915, 22, 36, 27, 4, -36 },
  { 3014, 18, 36, 23, 4, -36 },
  { 3095, 29, 36, 37, 4, -36 },
  { 3226, 23, 36, 31, 4, -36 },
  { 3330, 23, 36, 30, 3, -36 },
  { 3434, 21, 36, 27, 4, -36 },
  { 3529, 23, 42, 30, 3, -36 },
  { 3650, 21, 36, 27, 4, -36 },
  { 3745, 22, 36, 26, 2, -36 },
  { 3844, 23, 36, 26, 2, -36 },
  { 3948, 21, 36, 29, 4, -36 },
  { 4043, 25, 36, 27, 1, -36 },
  { 4156, 35, 36, 39, 2, -36 },
  { 4314, 23, 36, 27, 2, -36 },
  { 4418, 24, 36, 26, 1, -36 },
  { 4526, 22, 36, 26, 2, -36 },
  { 4625, 7, 49, 11, 4, -41 },
  { 4668, 16, 39, 18, 1, -36 },
  { 4746, 7, 49, 11, 1, -41 },
  { 4789, 14, 18, 18, 2, -36 },
  { 4821, 18, 3, 19, 1, 0 },
  { 4828, 8, 7, 14, 3, -38 },
  { 4835, 17, 26, 24, 3, -26 },
  { 4891, 18, 38, 24, 4, -38 },
  { 4977, 19, 26, 23, 2, -26 },
  { 5039, 18, 38, 24, 3, -38 },
  { 5125, 19, 26, 23, 2, -26 },
  { 5187, 13, 39, 15, 2, -39 },
  { 5251, 18, 36, 24, 3, -26 },
  { 5332, 17, 38, 24, 4, -38 },
  { 5413, 3, 36, 11, 4, -36 },
  { 5427, 8, 46, 11, -1, -36 },
  { 5473, 17, 38, 22, 4, -38 },
  { 5554, 3, 38, 11, 4, -38 },
  { 5569, 31, 26, 38, 4, -26 },
  { 5670, 17, 26, 24, 4, -26 },
  { 5726, 19, 26, 25, 3, -26 },
  { 5788, 18, 36, 24, 4, -26 },
  { 5869, 18, 36, 24, 3, -26 },
  { 5950, 10, 26, 15, 4, -26 },
  { 5983, 17, 26, 22, 3, -26 },
  { 6039, 12, 33, 15, 1, -33 },
  { 6089, 16, 26, 24, 4, -26 },
  { 6141, 19, 26, 21, 1, -26 },
  { 6203, 29, 26, 33, 2, -26 },
  { 6298, 19, 26, 21, 1, -26 },
  { 6360, 19, 36, 21, 1, -26 },
  { 6446, 18, 26, 21, 2, -26 },
  { 6505, 12, 49, 15, 2, -39 },
  { 6579, 3, 43, 11, 4, -36 },
  { 6596, 12, 49, 15, 1, -39 },
  { 6670, 23, 9, 30, 3, -19 },
};

const GFXfont RobotoCondensed_Light50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_LIGHT50PT7B_H_
