#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_Light6pt7b, 6, "RobotoCondensed_Light6pt7b" },
  { &RobotoCondensed_Light7pt7b, 7, "RobotoCondensed_Light7pt7b" },
  { &RobotoCondensed_Light8pt7b, 8, "RobotoCondensed_Light8pt7b" },
  { &RobotoCondensed_Light9pt7b, 9, "RobotoCondensed_Light9pt7b" },
  { &RobotoCondensed_Light10pt7b, 10, "RobotoCondensed_Light10pt7b" },
  { &RobotoCondensed_Light11pt7b, 11, "RobotoCondensed_Light11pt7b" },
  { &RobotoCondensed_Light12pt7b, 12, "RobotoCondensed_Light12pt7b" },
  { &RobotoCondensed_Light13pt7b, 13, "RobotoCondensed_Light13pt7b" },
  { &RobotoCondensed_Light14pt7b, 14, "RobotoCondensed_Light14pt7b" },
  { &RobotoCondensed_Light15pt7b, 15, "RobotoCondensed_Light15pt7b" },
  { &RobotoCondensed_Light16pt7b, 16, "RobotoCondensed_Light16pt7b" },
  { &RobotoCondensed_Light17pt7b, 17, "RobotoCondensed_Light17pt7b" },
  { &RobotoCondensed_Light18pt7b, 18, "RobotoCondensed_Light18pt7b" },
  { &RobotoCondensed_Light19pt7b, 19, "RobotoCondensed_Light19pt7b" },
  { &RobotoCondensed_Light20pt7b, 20, "RobotoCondensed_Light20pt7b" },
  { &RobotoCondensed_Light21pt7b, 21, "RobotoCondensed_Light21pt7b" },
  { &RobotoCondensed_Light22pt7b, 22, "RobotoCondensed_Light22pt7b" },
  { &RobotoCondensed_Light23pt7b, 23, "RobotoCondensed_Light23pt7b" },
  { &RobotoCondensed_Light24pt7b, 24, "RobotoCondensed_Light24pt7b" },
  { &RobotoCondensed_Light25pt7b, 25, "RobotoCondensed_Light25pt7b" },
  { &RobotoCondensed_Light26pt7b, 26, "RobotoCondensed_Light26pt7b" },
  { &RobotoCondensed_Light27pt7b, 27, "RobotoCondensed_Light27pt7b" },
  { &RobotoCondensed_Light28pt7b, 28, "RobotoCondensed_Light28pt7b" },
  { &RobotoCondensed_Light29pt7b, 29, "RobotoCondensed_Light29pt7b" },
  { &RobotoCondensed_Light30pt7b, 30, "RobotoCondensed_Light30pt7b" },
  { &RobotoCondensed_Light31pt7b, 31, "RobotoCondensed_Light31pt7b" },
  { &RobotoCondensed_Light32pt7b, 32, "RobotoCondensed_Light32pt7b" },
  { &RobotoCondensed_Light33pt7b, 33, "RobotoCondensed_Light33pt7b" },
  { &RobotoCondensed_Light34pt7b, 34, "RobotoCondensed_Light34pt7b" },
  { &RobotoCondensed_Light35pt7b, 35, "RobotoCondensed_Light35pt7b" },
  { &RobotoCondensed_Light36pt7b, 36, "RobotoCondensed_Light36pt7b" },
  { &RobotoCondensed_Light37pt7b, 37, "RobotoCondensed_Light37pt7b" },
  { &RobotoCondensed_Light38pt7b, 38, "RobotoCondensed_Light38pt7b" },
  { &RobotoCondensed_Light39pt7b, 39, "RobotoCondensed_Light39pt7b" },
  { &RobotoCondensed_Light40pt7b, 40, "RobotoCondensed_Light40pt7b" },
  { &RobotoCondensed_Light41pt7b, 41, "RobotoCondensed_Light41pt7b" },
  { &RobotoCondensed_Light42pt7b, 42, "RobotoCondensed_Light42pt7b" },
  { &RobotoCondensed_Light43pt7b, 43, "RobotoCondensed_Light43pt7b" },
  { &RobotoCondensed_Light44pt7b, 44, "RobotoCondensed_Light44pt7b" },
  { &RobotoCondensed_Light45pt7b, 45, "RobotoCondensed_Light45pt7b" },
  { &RobotoCondensed_Light46pt7b, 46, "RobotoCondensed_Light46pt7b" },
  { &RobotoCondensed_Light47pt7b, 47, "RobotoCondensed_Light47pt7b" },
  { &RobotoCondensed_Light48pt7b, 48, "RobotoCondensed_Light48pt7b" },
  { &RobotoCondensed_Light49pt7b, 49, "RobotoCondensed_Light49pt7b" },
  { &RobotoCondensed_Light50pt7b, 50, "RobotoCondensed_Light50pt7b" },
  { &RobotoCondensed_Light51pt7b, 51, "RobotoCondensed_Light51pt7b" },
  { &RobotoCondensed_Light52pt7b, 52, "RobotoCondensed_Light52pt7b" },
  { &RobotoCondensed_Light53pt7b, 53, "RobotoCondensed_Light53pt7b" },
  { &RobotoCondensed_Light54pt7b, 54, "RobotoCondensed_Light54pt7b" },
  { &RobotoCondensed_Light55pt7b, 55, "RobotoCondensed_Light55pt7b" },
  { &RobotoCondensed_Light56pt7b, 56, "RobotoCondensed_Light56pt7b" },
  { &RobotoCondensed_Light57pt7b, 57, "RobotoCondensed_Light57pt7b" },
  { &RobotoCondensed_Light58pt7b, 58, "RobotoCondensed_Light58pt7b" },
  { &RobotoCondensed_Light59pt7b, 59, "RobotoCondensed_Light59pt7b" },
  { &RobotoCondensed_Light60pt7b, 60, "RobotoCondensed_Light60pt7b" },
  { &RobotoCondensed_Light61pt7b, 61, "RobotoCondensed_Light61pt7b" },
  { &RobotoCondensed_Light62pt7b, 62, "RobotoCondensed_Light62pt7b" },
  { &RobotoCondensed_Light63pt7b, 63, "RobotoCondensed_Light63pt7b" },
  { &RobotoCondensed_Light64pt7b, 64, "RobotoCondensed_Light64pt7b" },
  { &RobotoCondensed_Light65pt7b, 65, "RobotoCondensed_Light65pt7b" },
  { &RobotoCondensed_Light66pt7b, 66, "RobotoCondensed_Light66pt7b" },
  { &RobotoCondensed_Light67pt7b, 67, "RobotoCondensed_Light67pt7b" },
  { &RobotoCondensed_Light68pt7b, 68, "RobotoCondensed_Light68pt7b" },
  { &RobotoCondensed_Light69pt7b, 69, "RobotoCondensed_Light69pt7b" },
  { &RobotoCondensed_Light70pt7b, 70, "RobotoCondensed_Light70pt7b" },
  { &RobotoCondensed_Light71pt7b, 71, "RobotoCondensed_Light71pt7b" },
  { &RobotoCondensed_Light72pt7b, 72, "RobotoCondensed_Light72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
