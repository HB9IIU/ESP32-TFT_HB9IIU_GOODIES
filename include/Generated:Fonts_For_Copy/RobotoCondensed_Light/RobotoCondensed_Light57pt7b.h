#ifndef _ROBOTOCONDENSED_LIGHT57PT7B_H_
#define _ROBOTOCONDENSED_LIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x18, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0xC0, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x38,
  0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x30, 0x00, 0x38, 0x0C, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0x70, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x01, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x1E, 0x07, 0x00, 0x3C,
  0x3C, 0x00, 0x70, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x78,
  0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x80,
  0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x01, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x40, 0x38, 0x06, 0x00, 0xC0, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x06, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80,
  0x70, 0x30, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x01, 0x81, 0x80, 0x1C, 0x03,
  0x07, 0x00, 0x18, 0x0E, 0x0C, 0x00, 0x38, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x60, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0x7F, 0x03, 0x00, 0x00, 0x10, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x0F, 0xE0, 0x00, 0x1C, 0x3F,
  0xE0, 0x00, 0x70, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0xE0, 0x03, 0x83, 0x01,
  0xC0, 0x06, 0x0E, 0x01, 0x80, 0x1C, 0x1C, 0x03, 0x00, 0x30, 0x38, 0x07,
  0x00, 0xE0, 0x70, 0x0E, 0x01, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0C, 0x03, 0x80, 0x60, 0x38, 0x07, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x3C, 0x03, 0x87, 0x03, 0xC0, 0x71, 0xE0,
  0x3C, 0x0E, 0x38, 0x03, 0x81, 0xCF, 0x00, 0x78, 0x71, 0xC0, 0x07, 0x8E,
  0x38, 0x00, 0x71, 0xC7, 0x00, 0x0F, 0x38, 0xE0, 0x00, 0xFE, 0x1C, 0x00,
  0x0F, 0xC3, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xE0,
  0xF0, 0x01, 0xFC, 0x0F, 0x80, 0x7F, 0xC0, 0xFE, 0xFE, 0x3C, 0x0F, 0xFF,
  0x83, 0x80, 0x7F, 0xC0, 0x78, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x20, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x04, 0x40, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x04,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x10, 0x0E, 0x03, 0xF8,
  0x38, 0x7F, 0xFC, 0xE7, 0xF3, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x73, 0x80, 0x03, 0xCF, 0x00,
  0x0E, 0x1E, 0x00, 0x70, 0x38, 0x03, 0xC0, 0x70, 0x1E, 0x01, 0xE0, 0x70,
  0x03, 0x80, 0x40, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x3C, 0xF3, 0xCF, 0x3C,
  0xE3, 0x8E, 0x79, 0xCF, 0x38, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x77,
  0xFF, 0xE2, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0x9F, 0x81,
  0xE0, 0x3C, 0x0E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x00, 0x0E, 0x78, 0x00,
  0x73, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xFB, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFF,
  0x7F, 0x7F, 0xC7, 0xF0, 0x7C, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x3E, 0x03, 0xE0, 0xF0, 0x07,
  0x87, 0x80, 0x0F, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCE,
  0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0,
  0x3F, 0xBF, 0x81, 0xE0, 0x1E, 0x1E, 0x00, 0x71, 0xE0, 0x03, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0E,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x78, 0xF8, 0x07, 0x83, 0xFB,
  0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x1F, 0x80, 0x3B, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xC1, 0xF0, 0x78, 0x03, 0xC3, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x03, 0xDE, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0xC0,
  0x0E, 0x0F, 0x00, 0xF0, 0x3F, 0x3F, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x83, 0xF0, 0x1C, 0x7F, 0xE0, 0xE7, 0xFF, 0x87,
  0x78, 0x3E, 0x3F, 0x00, 0x79, 0xF0, 0x01, 0xCF, 0x00, 0x0F, 0x78, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0x70,
  0x01, 0xC3, 0xC0, 0x1E, 0x0F, 0x01, 0xE0, 0x3F, 0x7E, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xF3, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E,
  0x00, 0x1C, 0x70, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x3C, 0x00, 0xF0, 0x70, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xF0, 0x3C, 0x07, 0x00, 0x78, 0x38, 0x00,
  0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x78, 0xF0, 0x03,
  0xC3, 0xE0, 0x1E, 0x07, 0xF3, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xBF, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x8E, 0x00, 0x1E,
  0x70, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xBC, 0x00,
  0x7C, 0xE0, 0x03, 0xE7, 0x80, 0x3F, 0x1F, 0x07, 0xB8, 0x7F, 0xF9, 0xC1,
  0xFF, 0x8E, 0x03, 0xF0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x39, 0xF7,
  0xCF, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0x39, 0xE7,
  0x3C, 0xE1, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3C, 0x07, 0x8E, 0x00,
  0xE7, 0x80, 0x3D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x03, 0xF0, 0x01, 0x83, 0x80, 0x0F, 0xF0, 0x03, 0x06, 0x00, 0x3F, 0xF8,
  0x06, 0x1C, 0x00, 0xE0, 0x70, 0x0E, 0x38, 0x03, 0x80, 0x60, 0x0C, 0x60,
  0x0E, 0x01, 0xC0, 0x19, 0xC0, 0x1C, 0x03, 0x80, 0x33, 0x80, 0x70, 0x07,
  0x00, 0x67, 0x00, 0xE0, 0x0E, 0x00, 0xCC, 0x01, 0xC0, 0x1C, 0x01, 0x98,
  0x03, 0x00, 0x38, 0x03, 0x30, 0x0E, 0x00, 0x70, 0x06, 0xE0, 0x1C, 0x00,
  0xE0, 0x0D, 0xC0, 0x38, 0x01, 0x80, 0x1B, 0x80, 0x70, 0x03, 0x00, 0x37,
  0x00, 0xC0, 0x06, 0x00, 0x6E, 0x01, 0x80, 0x0C, 0x00, 0xDC, 0x03, 0x00,
  0x18, 0x01, 0xB8, 0x06, 0x00, 0x30, 0x03, 0x70, 0x0C, 0x00, 0xE0, 0x0E,
  0x60, 0x18, 0x01, 0xC0, 0x18, 0xC0, 0x38, 0x03, 0x80, 0x31, 0x80, 0x70,
  0x0F, 0x00, 0xE3, 0x00, 0xE0, 0x36, 0x01, 0x87, 0x00, 0xE0, 0xEE, 0x07,
  0x0E, 0x01, 0xE7, 0x9E, 0x1C, 0x0C, 0x01, 0xFE, 0x1F, 0xF0, 0x1C, 0x01,
  0xF8, 0x1F, 0xC0, 0x38, 0x00, 0x80, 0x04, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x01,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x38,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0,
  0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0x80,
  0x0F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0x80, 0x07,
  0x8E, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xB8, 0x00, 0x1E, 0xE0, 0x00, 0xF3, 0x80, 0x0F, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03,
  0xDC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xE0, 0xE0, 0x01, 0xF0, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF0, 0xE0,
  0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xF8, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E,
  0x78, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x0F, 0xF7, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x1F, 0x01, 0xE0,
  0x7F, 0x7F, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0x80, 0x07, 0x81, 0xC0, 0x07, 0x80,
  0xE0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0xC0,
  0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC1, 0xE0,
  0x00, 0xE1, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0xFC,
  0x00, 0x0E, 0xFE, 0x00, 0x07, 0xF7, 0x80, 0x03, 0xF1, 0xE0, 0x01, 0xF0,
  0x70, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x01,
  0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x77,
  0xEE, 0x00, 0x00, 0x3B, 0xF7, 0x00, 0x00, 0x39, 0xFB, 0xC0, 0x00, 0x1C,
  0xFC, 0xE0, 0x00, 0x0E, 0x7E, 0x70, 0x00, 0x0E, 0x3F, 0x3C, 0x00, 0x07,
  0x1F, 0x8E, 0x00, 0x03, 0x8F, 0xC7, 0x00, 0x03, 0x87, 0xE1, 0xC0, 0x01,
  0xC3, 0xF0, 0xE0, 0x00, 0xE1, 0xF8, 0x70, 0x00, 0xE0, 0xFC, 0x1C, 0x00,
  0x70, 0x7E, 0x0E, 0x00, 0x38, 0x3F, 0x07, 0x00, 0x38, 0x1F, 0x81, 0xC0,
  0x1C, 0x0F, 0xC0, 0xE0, 0x0E, 0x07, 0xE0, 0x70, 0x0E, 0x03, 0xF0, 0x1C,
  0x07, 0x01, 0xF8, 0x0E, 0x03, 0x80, 0xFC, 0x07, 0x03, 0x80, 0x7E, 0x01,
  0xC1, 0xC0, 0x3F, 0x00, 0xE0, 0xE0, 0x1F, 0x80, 0x70, 0xE0, 0x0F, 0xC0,
  0x1C, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x03, 0xF0, 0x07, 0x38, 0x01, 0xF8,
  0x01, 0xDC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xDC, 0x00, 0x07, 0xEF, 0x00, 0x03, 0xF3, 0x80, 0x01,
  0xF9, 0xE0, 0x00, 0xFC, 0x70, 0x00, 0x7E, 0x1C, 0x00, 0x3F, 0x0E, 0x00,
  0x1F, 0x83, 0x80, 0x0F, 0xC1, 0xE0, 0x07, 0xE0, 0x70, 0x03, 0xF0, 0x3C,
  0x01, 0xF8, 0x0E, 0x00, 0xFC, 0x07, 0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00,
  0xF0, 0x1F, 0x80, 0x38, 0x0F, 0xC0, 0x0E, 0x07, 0xE0, 0x07, 0x03, 0xF0,
  0x01, 0xC1, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0x38, 0x7E, 0x00, 0x1E, 0x3F,
  0x00, 0x07, 0x1F, 0x80, 0x03, 0xCF, 0xC0, 0x00, 0xE7, 0xE0, 0x00, 0x7B,
  0xF0, 0x00, 0x1D, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0x00, 0x0F, 0x8E, 0x00, 0x07,
  0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x03, 0xCE, 0x00, 0x1F, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81,
  0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x87, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xF0,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0,
  0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x7C,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x0F, 0xF7, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x3E,
  0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x78, 0x00, 0x7E, 0x00, 0x0E,
  0x38, 0x00, 0x76, 0x00, 0x1E, 0x38, 0x00, 0x77, 0x00, 0x1C, 0x38, 0x00,
  0xE7, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x3C, 0x00, 0xE3, 0x00,
  0x1C, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0xC1, 0x80, 0x38, 0x1E, 0x01, 0xC1,
  0xC0, 0x38, 0x0E, 0x01, 0x81, 0xC0, 0x78, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x07, 0x03,
  0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x03,
  0x8E, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x31, 0xC0, 0x03, 0x8C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0,
  0x01, 0xDC, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x19, 0x80, 0x01, 0xD8,
  0x00, 0x1B, 0x80, 0x01, 0xD8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x3C,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x70, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x78, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x0C, 0xE0, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x0E, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x30, 0x0E,
  0x38, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xF9, 0xFC, 0x3C, 0x03,
  0xE7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xF1, 0xFF, 0xFF, 0x3E, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0x70, 0x03, 0xF7, 0x80, 0x77, 0x3F, 0xFE,
  0x73, 0xFF, 0xC7, 0x0F, 0xF0, 0x70, 0x18, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0xFF, 0x83, 0x9F, 0xFE, 0x1D,
  0xFB, 0xF8, 0xEC, 0x03, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x00, 0x7B,
  0xE0, 0x07, 0x9F, 0x80, 0x7C, 0xEF, 0xDF, 0xC7, 0x3F, 0xFC, 0x38, 0x7F,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81,
  0xF8, 0xFC, 0x3C, 0x01, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xF7, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xE3,
  0xC0, 0x1E, 0x1F, 0xCF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x83, 0xFE,
  0x1C, 0x3F, 0xFC, 0xE3, 0xFB, 0xE7, 0x3E, 0x03, 0xB9, 0xC0, 0x07, 0xDE,
  0x00, 0x3E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0xBC, 0x00, 0x3C, 0xE0, 0x03, 0xE7, 0xC0, 0x77, 0x1F, 0xDF, 0xB8,
  0x7F, 0xF9, 0xC0, 0xFF, 0x0E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0x3F, 0x83, 0xE0, 0x3E, 0x1C, 0x00, 0x71,
  0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x01, 0x0F, 0x00, 0x18, 0x7C, 0x01, 0xE1, 0xFC, 0xFE,
  0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1,
  0xC3, 0xFF, 0xCE, 0x3F, 0xBE, 0x73, 0xE0, 0x3B, 0x9C, 0x00, 0x7D, 0xE0,
  0x03, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x7B, 0xC0, 0x03, 0xCE, 0x00, 0x3E, 0x7C, 0x07, 0x71, 0xFD, 0xFB, 0x87,
  0xFF, 0x9C, 0x1F, 0xF0, 0xE0, 0x08, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x08, 0x00, 0x78, 0xE0,
  0x07, 0x87, 0xC0, 0x7C, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0x01, 0xC3, 0xFC, 0x38, 0xFF, 0xE7,
  0x3E, 0xFE, 0xEE, 0x03, 0xDF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x0F, 0xFF, 0x60, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x83, 0xEF, 0xF3, 0xF8, 0xFC, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0xE0, 0x03,
  0xCE, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x1C, 0x0E, 0x03,
  0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xE3,
  0x80, 0x0E, 0x78, 0x00, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0xFD, 0xC0, 0x0F,
  0x9E, 0x00, 0xF0, 0xF0, 0x0E, 0x07, 0x00, 0xE0, 0x78, 0x0E, 0x03, 0xC0,
  0xE0, 0x1C, 0x0E, 0x01, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00,
  0x10, 0x0E, 0x1F, 0xE0, 0x1F, 0xF0, 0xE7, 0xFF, 0x87, 0xFF, 0x8E, 0xFD,
  0xF8, 0xFD, 0xFC, 0xEE, 0x03, 0xCE, 0x03, 0xCF, 0xC0, 0x1D, 0xC0, 0x1E,
  0xF8, 0x01, 0xF8, 0x00, 0xEF, 0x00, 0x0F, 0x00, 0x0E, 0xF0, 0x00, 0xF0,
  0x00, 0xEE, 0x00, 0x0F, 0x00, 0x0E, 0xE0, 0x00, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x10, 0x1C, 0x3F, 0xC3, 0x8F, 0xFE,
  0x73, 0xEF, 0xEE, 0xE0, 0x3D, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xF3, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC7,
  0x80, 0x07, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x78, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78,
  0x0F, 0xCF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x07, 0x0F, 0xF8, 0x39, 0xFF, 0xE1, 0xDF, 0xBF, 0x8F, 0xC0, 0x3E,
  0x7C, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0x3E, 0x00, 0x79, 0xF8, 0x07,
  0xCE, 0xFD, 0xFC, 0x73, 0xFF, 0xC3, 0x87, 0xF8, 0x1C, 0x06, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xC3, 0xFF, 0xCE,
  0x3F, 0x1F, 0x73, 0xE0, 0x3B, 0x9C, 0x00, 0x7D, 0xE0, 0x01, 0xEE, 0x00,
  0x0F, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xC0, 0x03,
  0xCE, 0x00, 0x3E, 0x7C, 0x03, 0xF1, 0xFD, 0xFF, 0x87, 0xFF, 0xBC, 0x1F,
  0xF1, 0xE0, 0x08, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0E, 0x3F,
  0xE7, 0xFE, 0xFF, 0xEE, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xCF, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0x9C, 0x00,
  0x7B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07,
  0xBC, 0x01, 0xE3, 0xF9, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x02, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0xFC, 0x00, 0x80, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0x70, 0x01, 0xEF, 0x00, 0x7D, 0xF0, 0x1F, 0x9F, 0xFF, 0x71, 0xFF,
  0xCE, 0x1F, 0xF1, 0xC0, 0x20, 0x00, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0xC0,
  0x07, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x61,
  0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x0C, 0xE0, 0x00, 0x3B, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0,
  0x01, 0xDC, 0x00, 0x70, 0x01, 0xCE, 0x00, 0x7C, 0x00, 0xE7, 0x00, 0x3E,
  0x00, 0x73, 0x80, 0x1F, 0x00, 0x38, 0xE0, 0x1D, 0xC0, 0x3C, 0x70, 0x0E,
  0xE0, 0x1C, 0x38, 0x07, 0x70, 0x0E, 0x1C, 0x03, 0x38, 0x07, 0x07, 0x03,
  0x8E, 0x03, 0x83, 0x81, 0xC7, 0x03, 0x81, 0xC0, 0xE3, 0x81, 0xC0, 0xE0,
  0x60, 0xC0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x1C, 0x38, 0x38, 0x70, 0x0E,
  0x1C, 0x1C, 0x38, 0x07, 0x0C, 0x06, 0x1C, 0x03, 0x8E, 0x03, 0x8E, 0x00,
  0xE7, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x1D, 0xC0, 0x07, 0xE0, 0x0E, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x73,
  0x80, 0x07, 0x9E, 0x00, 0x78, 0x78, 0x03, 0x81, 0xC0, 0x3C, 0x0F, 0x01,
  0xC0, 0x38, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x70, 0x00,
  0xE7, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x07,
  0x3C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0x70,
  0x1C, 0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x78, 0xF0, 0x01, 0xC7, 0x00,
  0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0x9E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xF1, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x0F, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0,
  0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F,
  0x00, 0xFC, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x0C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x73, 0xFF, 0x00, 0x1D, 0xE1, 0xF0,
  0x07, 0x70, 0x3C, 0x01, 0xB8, 0x07, 0xC0, 0xEE, 0x00, 0xF8, 0x7B, 0x80,
  0x1F, 0xFC, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_Light57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 42, 12, 4, -41 },
  { 22, 9, 13, 16, 4, -43 },
  { 37, 26, 41, 29, 3, -41 },
  { 171, 22, 54, 28, 3, -48 },
  { 320, 31, 43, 36, 3, -42 },
  { 487, 27, 43, 31, 3, -42 },
  { 633, 3, 12, 10, 3, -43 },
  { 638, 11, 58, 17, 4, -45 },
  { 718, 12, 58, 17, 1, -45 },
  { 805, 22, 23, 24, 1, -41 },
  { 869, 24, 29, 28, 2, -33 },
  { 956, 6, 13, 11, 2, -5 },
  { 966, 11, 3, 15, 2, -19 },
  { 971, 5, 5, 14, 4, -4 },
  { 975, 17, 44, 20, 1, -41 },
  { 1069, 21, 43, 28, 3, -42 },
  { 1182, 12, 41, 28, 5, -41 },
  { 1244, 22, 42, 28, 3, -42 },
  { 1360, 21, 43, 28, 3, -42 },
  { 1473, 24, 41, 28, 2, -41 },
  { 1596, 21, 42, 28, 4, -41 },
  { 1707, 21, 42, 28, 4, -41 },
  { 1818, 23, 41, 28, 2, -41 },
  { 1936, 22, 43, 28, 3, -42 },
  { 2055, 21, 42, 28, 3, -42 },
  { 2166, 4, 31, 12, 4, -30 },
  { 2182, 6, 38, 11, 2, -30 },
  { 2211, 20, 24, 26, 2, -30 },
  { 2271, 20, 14, 28, 4, -26 },
  { 2306, 19, 24, 26, 4, -30 },
  { 2363, 18, 43, 23, 2, -42 },
  { 2460, 39, 53, 45, 3, -40 },
  { 2719, 29, 41, 31, 1, -41 },
  { 2868, 22, 41, 31, 5, -41 },
  { 2981, 25, 43, 32, 4, -42 },
  { 3116, 24, 41, 32, 5, -41 },
  { 3239, 21, 41, 28, 5, -41 },
  { 3347, 21, 41, 28, 5, -41 },
  { 3455, 25, 43, 34, 4, -42 },
  { 3590, 25, 41, 35, 5, -41 },
  { 3719, 4, 41, 14, 5, -41 },
  { 3740, 21, 42, 28, 2, -41 },
  { 3851, 25, 41, 31, 5, -41 },
  { 3980, 20, 41, 26, 5, -41 },
  { 4083, 33, 41, 43, 5, -41 },
  { 4253, 25, 41, 35, 5, -41 },
  { 4382, 26, 43, 34, 4, -42 },
  { 4522, 23, 41, 31, 5, -41 },
  { 4640, 26, 49, 34, 4, -42 },
  { 4800, 24, 41, 31, 5, -41 },
  { 4923, 24, 43, 29, 3, -42 },
  { 5052, 26, 41, 30, 2, -41 },
  { 5186, 24, 42, 33, 4, -41 },
  { 5312, 29, 41, 31, 1, -41 },
  { 5461, 40, 41, 44, 2, -41 },
  { 5666, 27, 41, 31, 2, -41 },
  { 5805, 28, 41, 30, 1, -41 },
  { 5949, 24, 41, 30, 3, -41 },
  { 6072, 8, 55, 13, 4, -46 },
  { 6127, 17, 44, 20, 2, -41 },
  { 6221, 8, 55, 13, 1, -46 },
  { 6276, 17, 20, 21, 2, -41 },
  { 6319, 20, 3, 22, 1, 0 },
  { 6327, 9, 8, 16, 3, -43 },
  { 6336, 20, 32, 27, 3, -31 },
  { 6416, 21, 44, 28, 4, -43 },
  { 6532, 20, 32, 26, 3, -31 },
  { 6612, 21, 44, 28, 3, -43 },
  { 6728, 21, 32, 26, 3, -31 },
  { 6812, 15, 44, 17, 2, -44 },
  { 6895, 21, 43, 28, 3, -31 },
  { 7008, 19, 43, 27, 4, -43 },
  { 7111, 4, 41, 12, 4, -41 },
  { 7132, 10, 53, 12, -2, -41 },
  { 7199, 20, 43, 25, 4, -43 },
  { 7307, 4, 43, 12, 4, -43 },
  { 7329, 36, 31, 43, 4, -31 },
  { 7469, 19, 31, 27, 4, -31 },
  { 7543, 22, 32, 28, 3, -31 },
  { 7631, 21, 43, 28, 4, -31 },
  { 7744, 21, 43, 28, 3, -31 },
  { 7857, 12, 31, 17, 4, -31 },
  { 7904, 19, 32, 25, 3, -31 },
  { 7980, 13, 39, 17, 1, -38 },
  { 8044, 19, 31, 27, 4, -30 },
  { 8118, 22, 30, 24, 1, -30 },
  { 8201, 33, 30, 37, 2, -30 },
  { 8325, 21, 30, 25, 2, -30 },
  { 8404, 22, 42, 24, 1, -30 },
  { 8520, 20, 30, 25, 3, -30 },
  { 8595, 14, 55, 17, 2, -44 },
  { 8692, 3, 49, 13, 5, -41 },
  { 8711, 14, 55, 17, 1, -44 },
  { 8808, 26, 10, 34, 4, -22 },
};

const GFXfont RobotoCondensed_Light57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_LIGHT57PT7B_H_
