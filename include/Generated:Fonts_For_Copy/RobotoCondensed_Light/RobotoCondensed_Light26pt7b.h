#ifndef _ROBOTOCONDENSED_LIGHT26PT7B_H_
#define _ROBOTOCONDENSED_LIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEA, 0xAA, 0xA0, 0x3C, 0x99, 0x99, 0x99, 0x04, 0x60, 0x44,
  0x04, 0x40, 0xC4, 0x0C, 0x40, 0x84, 0x7F, 0xF0, 0x88, 0x08, 0x80, 0x88,
  0x18, 0x81, 0x08, 0xFF, 0xE1, 0x18, 0x11, 0x01, 0x10, 0x31, 0x02, 0x10,
  0x21, 0x00, 0x04, 0x01, 0x00, 0x40, 0x7C, 0x3B, 0x98, 0x26, 0x0D, 0x01,
  0x40, 0x58, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x03, 0xC0, 0x50,
  0x14, 0x05, 0x83, 0x3B, 0x87, 0xC0, 0x40, 0x10, 0x38, 0x01, 0x30, 0x04,
  0x42, 0x31, 0x88, 0xC6, 0x63, 0x19, 0x04, 0x4C, 0x13, 0x20, 0x39, 0x00,
  0x04, 0x00, 0x23, 0x80, 0x93, 0x04, 0xC4, 0x12, 0x10, 0x88, 0x42, 0x21,
  0x10, 0xC4, 0x01, 0x30, 0x03, 0x80, 0x1E, 0x03, 0xB0, 0x31, 0x82, 0x18,
  0x21, 0x82, 0x10, 0x33, 0x01, 0x60, 0x1C, 0x01, 0xC0, 0x26, 0x36, 0x23,
  0x43, 0x2C, 0x1A, 0xC0, 0xE4, 0x0C, 0x60, 0xE3, 0x3A, 0x1E, 0x30, 0xFC,
  0x08, 0xCC, 0x46, 0x21, 0x18, 0xC4, 0x21, 0x08, 0x42, 0x10, 0x84, 0x31,
  0x84, 0x21, 0x84, 0x30, 0xC2, 0x84, 0x10, 0xC2, 0x10, 0xC2, 0x10, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC4, 0x21, 0x18, 0x8C, 0x44, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x22, 0x27, 0xFC, 0x1C, 0x02, 0x80, 0xD8, 0x31, 0x84, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x55, 0xE0, 0xF8, 0xF0, 0x02, 0x04,
  0x18, 0x20, 0x41, 0x82, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x08, 0x30,
  0x40, 0x83, 0x04, 0x08, 0x00, 0x3C, 0x3B, 0xB0, 0x58, 0x38, 0x1C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x83, 0xC1,
  0x3B, 0x8F, 0x00, 0x0C, 0xFE, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x1E, 0x06, 0x71, 0x82, 0x20, 0x6C,
  0x0D, 0x81, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0xFF, 0x80, 0x1E, 0x0E, 0xE6,
  0x09, 0x03, 0x40, 0xC0, 0x30, 0x0C, 0x02, 0x07, 0x03, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x1C, 0x07, 0x03, 0x60, 0x8E, 0xE1, 0xE0, 0x01, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x58, 0x13, 0x02, 0x60, 0x8C, 0x31, 0x84, 0x31, 0x86,
  0x20, 0xCC, 0x19, 0xFF, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x7F, 0xB0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xBC, 0x77, 0x20, 0xC0,
  0x20, 0x10, 0x08, 0x06, 0x03, 0x81, 0x41, 0xB9, 0x87, 0x80, 0x0E, 0x0E,
  0x0C, 0x0C, 0x04, 0x06, 0x02, 0x01, 0x3C, 0xB7, 0x60, 0xE0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x83, 0x41, 0xBB, 0x87, 0x80, 0xFF, 0xC0, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0x1E, 0x0E, 0xE6, 0x09,
  0x03, 0x40, 0xD0, 0x34, 0x0D, 0x82, 0x3B, 0x87, 0xC2, 0x19, 0x03, 0x40,
  0x70, 0x1C, 0x05, 0x01, 0x60, 0xCE, 0xE1, 0xF0, 0x1E, 0x0E, 0xC6, 0x19,
  0x02, 0x40, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x50, 0x36, 0x1C, 0xCF, 0x1E,
  0xC0, 0x30, 0x08, 0x06, 0x03, 0x03, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x6C, 0x00, 0x00, 0x00, 0x04, 0x92, 0xD0, 0x00, 0x81, 0xC3, 0x83, 0x07,
  0x06, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x20, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x1C, 0x38,
  0x70, 0x60, 0x20, 0x00, 0x3C, 0x76, 0x43, 0xC1, 0xC1, 0x01, 0x01, 0x03,
  0x02, 0x06, 0x0C, 0x08, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x01,
  0xF8, 0x01, 0xC7, 0x80, 0xC0, 0x30, 0x60, 0x04, 0x30, 0x00, 0x88, 0x3C,
  0x22, 0x19, 0x89, 0x0C, 0x21, 0x42, 0x18, 0x50, 0x86, 0x14, 0x61, 0x05,
  0x18, 0x41, 0x44, 0x10, 0x51, 0x04, 0x14, 0x61, 0x09, 0x18, 0xC2, 0x43,
  0x79, 0x10, 0x73, 0x86, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE1, 0x80, 0x0F, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x1A, 0x00,
  0x90, 0x04, 0xC0, 0x66, 0x03, 0x10, 0x10, 0x80, 0x86, 0x0C, 0x10, 0x40,
  0x82, 0x06, 0x3F, 0xF1, 0x00, 0x88, 0x06, 0xC0, 0x36, 0x00, 0xA0, 0x06,
  0xFE, 0x30, 0xEC, 0x0B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x02, 0xC3, 0xBF,
  0xCC, 0x1B, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0xEF, 0xF0,
  0x1F, 0x07, 0x79, 0x81, 0x60, 0x3C, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x70, 0x0E, 0x03, 0x60, 0x47,
  0x78, 0x7C, 0x00, 0xFE, 0x18, 0xF3, 0x03, 0x60, 0x2C, 0x07, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x02, 0xC0, 0xD8, 0x73, 0xF8, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFC, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0x07, 0x39, 0x81, 0xE0, 0x1C,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x0A, 0x01, 0x60, 0x67, 0x3C, 0x7E, 0x00, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03,
  0x81, 0xC1, 0xB9, 0x8F, 0x80, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x18, 0xC3,
  0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD8, 0x0F, 0x80, 0xEC, 0x0C, 0x60, 0xC2,
  0x0C, 0x30, 0xC1, 0x8C, 0x08, 0xC0, 0xCC, 0x06, 0xC0, 0x20, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xE0, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xBA, 0x03, 0x74, 0x06, 0xEC, 0x09, 0xC8,
  0x33, 0x90, 0x67, 0x30, 0x8E, 0x23, 0x1C, 0x46, 0x38, 0xC8, 0x70, 0xB0,
  0xE1, 0x41, 0xC3, 0x83, 0x83, 0x07, 0x04, 0x08, 0xC0, 0x3C, 0x03, 0xE0,
  0x3F, 0x03, 0xD0, 0x3D, 0x83, 0xC8, 0x3C, 0xC3, 0xC4, 0x3C, 0x63, 0xC2,
  0x3C, 0x33, 0xC1, 0x3C, 0x1B, 0xC0, 0xBC, 0x0F, 0xC0, 0x7C, 0x03, 0xC0,
  0x30, 0x1F, 0x03, 0xBC, 0x60, 0x4C, 0x06, 0xC0, 0x28, 0x02, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x2C,
  0x06, 0x60, 0x43, 0xBC, 0x1F, 0x00, 0xFF, 0x18, 0x33, 0x03, 0x60, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xD8, 0x3B, 0xFC, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x1F, 0x03, 0xBC,
  0x60, 0x4C, 0x06, 0x80, 0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x02, 0x80, 0x2C, 0x06, 0x60, 0x43, 0xBC,
  0x1F, 0x80, 0x0C, 0x00, 0x60, 0x02, 0xFF, 0x18, 0x73, 0x03, 0x60, 0x2C,
  0x05, 0x80, 0xF0, 0x16, 0x02, 0xC0, 0xD8, 0x33, 0xFC, 0x61, 0x8C, 0x11,
  0x83, 0x30, 0x26, 0x06, 0xC0, 0xD8, 0x0F, 0x01, 0x80, 0x1F, 0x07, 0x39,
  0x81, 0x20, 0x34, 0x02, 0x80, 0x58, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x70, 0x0A, 0x01, 0x60, 0x67, 0x38, 0x7E, 0x00,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0x40, 0xCF, 0x70, 0x7C, 0x00, 0x80, 0x16, 0x01, 0xB0,
  0x0C, 0x80, 0x44, 0x02, 0x30, 0x30, 0x81, 0x84, 0x08, 0x30, 0xC1, 0x86,
  0x04, 0x20, 0x31, 0x01, 0x98, 0x04, 0x80, 0x24, 0x01, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x80, 0xC0, 0x70, 0x30, 0x3C, 0x0C, 0x0D, 0x03, 0x83,
  0x41, 0xA0, 0x90, 0x48, 0x26, 0x12, 0x19, 0x84, 0x86, 0x23, 0x31, 0x88,
  0xC4, 0x42, 0x21, 0x10, 0xC8, 0x4C, 0x36, 0x1B, 0x05, 0x82, 0x81, 0x40,
  0xA0, 0x50, 0x28, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0x80, 0x40, 0xC0, 0x36,
  0x06, 0x60, 0x63, 0x0C, 0x30, 0xC1, 0x98, 0x09, 0x00, 0xF0, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xF0, 0x19, 0x81, 0x98, 0x30, 0xC2, 0x04, 0x60, 0x64,
  0x02, 0xC0, 0x30, 0x40, 0x1B, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x06, 0x0C,
  0x20, 0x23, 0x01, 0x98, 0x0C, 0x80, 0x2C, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xE0,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0xFF,
  0x80, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x30, 0x10,
  0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0xF3,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0,
  0x10, 0x30, 0xE1, 0x62, 0x4C, 0x91, 0xA1, 0xC2, 0xFF, 0xC0, 0x43, 0x0C,
  0x20, 0x1E, 0x0C, 0xE6, 0x09, 0x02, 0x00, 0x80, 0x21, 0xF9, 0xC2, 0x40,
  0xB0, 0x2C, 0x0B, 0x06, 0x76, 0x8F, 0x30, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x79, 0x6E, 0xC1, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0xE0, 0xED, 0xD3, 0xC0, 0x1E, 0x0C, 0xE6, 0x09, 0x03, 0xC0,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x34, 0x09, 0x82, 0x33, 0x07, 0x80,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x31, 0xEC, 0xCF, 0x60, 0xD0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0xD8, 0x33, 0x3C,
  0x7B, 0x1E, 0x0C, 0xE6, 0x09, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x82, 0x3B, 0x87, 0xC0, 0x1E, 0x74, 0xC1, 0x02, 0x04,
  0x3F, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x00, 0x1E, 0xCC, 0xF6, 0x0D, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x34, 0x0D, 0x83, 0x33, 0xC7, 0xB0, 0x0C, 0x03, 0x00, 0x9C, 0xE1,
  0xF0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0x6E, 0xC1, 0x60,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0xF0, 0x2A, 0xAA, 0xAA, 0xA8, 0x18, 0xC0, 0x00, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xDC, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x0D, 0x0C, 0x84, 0x46, 0x26, 0x16, 0x0F, 0x06, 0xC2,
  0x21, 0x18, 0x86, 0x41, 0x20, 0xD0, 0x30, 0xFF, 0xFF, 0xF0, 0x9E, 0x3C,
  0xB7, 0x66, 0xC1, 0xC3, 0xC1, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x9E, 0x5B, 0xB0, 0x58, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x1F, 0x0E, 0xE6, 0x0D, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14, 0x05, 0x83, 0x3B, 0x87, 0xC0,
  0x9E, 0x5B, 0xB0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x78, 0x3B, 0x74, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1E, 0xCC,
  0xF6, 0x0D, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x34, 0x0D,
  0x83, 0x33, 0xC7, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x9D, 0xF1,
  0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x1E, 0x39, 0x90, 0x68, 0x14,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x28, 0x37, 0x30, 0xF0, 0x10,
  0x20, 0x47, 0xE1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x0C, 0x0E, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x78, 0x76, 0x79, 0xEC, 0x80, 0xE0, 0xF0, 0x68, 0x24, 0x13,
  0x18, 0x88, 0x44, 0x36, 0x0A, 0x05, 0x02, 0x81, 0xC0, 0x40, 0x81, 0x07,
  0x86, 0x0F, 0x0E, 0x12, 0x14, 0x24, 0x28, 0x4C, 0xD1, 0x99, 0x32, 0x12,
  0x24, 0x24, 0x48, 0x78, 0xF0, 0xE0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06,
  0x00, 0xC1, 0xA0, 0x98, 0xC4, 0x43, 0x60, 0xA0, 0x30, 0x38, 0x14, 0x1B,
  0x08, 0x8C, 0x64, 0x1E, 0x0C, 0x80, 0xE0, 0xF0, 0x68, 0x26, 0x33, 0x18,
  0x88, 0x44, 0x36, 0x0A, 0x05, 0x03, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x38, 0x38, 0x00, 0xFF, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x0C, 0x07, 0xFC, 0x04, 0x21, 0x84, 0x30, 0xC3,
  0x0C, 0x30, 0xC2, 0x18, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41,
  0x83, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0xC0, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x60, 0x61, 0x06, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x0C, 0x30, 0x40, 0x38, 0x37, 0xC3, 0x86, 0x28, 0x36,
  0x81, 0xC0,
};

const GFXglyph RobotoCondensed_Light26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 4, 6, 7, 2, -20 },
  { 9, 12, 19, 13, 1, -19 },
  { 38, 10, 24, 13, 1, -22 },
  { 68, 14, 19, 17, 1, -19 },
  { 102, 12, 19, 14, 1, -19 },
  { 131, 1, 6, 4, 2, -20 },
  { 132, 5, 27, 8, 2, -21 },
  { 149, 5, 27, 8, 1, -21 },
  { 166, 11, 10, 11, 0, -19 },
  { 180, 11, 13, 13, 1, -15 },
  { 198, 2, 6, 5, 1, -2 },
  { 200, 5, 1, 7, 1, -8 },
  { 201, 2, 2, 6, 2, -2 },
  { 202, 7, 21, 9, 1, -19 },
  { 221, 9, 19, 13, 2, -19 },
  { 243, 6, 19, 13, 2, -19 },
  { 258, 11, 19, 13, 1, -19 },
  { 285, 10, 19, 13, 1, -19 },
  { 309, 11, 19, 13, 1, -19 },
  { 336, 9, 19, 13, 2, -19 },
  { 358, 9, 19, 13, 2, -19 },
  { 380, 10, 19, 13, 1, -19 },
  { 404, 10, 19, 13, 1, -19 },
  { 428, 10, 19, 13, 1, -19 },
  { 452, 2, 14, 5, 2, -14 },
  { 456, 3, 18, 5, 1, -14 },
  { 463, 9, 11, 12, 1, -14 },
  { 476, 9, 6, 13, 2, -12 },
  { 483, 9, 11, 12, 2, -14 },
  { 496, 8, 19, 11, 1, -19 },
  { 515, 18, 24, 20, 1, -18 },
  { 569, 13, 19, 14, 1, -19 },
  { 600, 10, 19, 14, 2, -19 },
  { 624, 11, 19, 15, 2, -19 },
  { 651, 11, 19, 15, 2, -19 },
  { 678, 10, 19, 13, 2, -19 },
  { 702, 10, 19, 13, 2, -19 },
  { 726, 11, 19, 15, 2, -19 },
  { 753, 12, 19, 16, 2, -19 },
  { 782, 2, 19, 6, 2, -19 },
  { 787, 9, 19, 13, 1, -19 },
  { 809, 12, 19, 14, 2, -19 },
  { 838, 9, 19, 12, 2, -19 },
  { 860, 15, 19, 19, 2, -19 },
  { 896, 12, 19, 16, 2, -19 },
  { 925, 12, 19, 15, 2, -19 },
  { 954, 11, 19, 14, 2, -19 },
  { 981, 12, 22, 15, 2, -19 },
  { 1014, 11, 19, 14, 2, -19 },
  { 1041, 11, 19, 13, 1, -19 },
  { 1068, 12, 19, 14, 1, -19 },
  { 1097, 11, 19, 15, 2, -19 },
  { 1124, 13, 19, 14, 1, -19 },
  { 1155, 18, 19, 20, 1, -19 },
  { 1198, 12, 19, 14, 1, -19 },
  { 1227, 13, 19, 14, 0, -19 },
  { 1258, 11, 19, 14, 1, -19 },
  { 1285, 4, 25, 6, 2, -21 },
  { 1298, 8, 21, 9, 1, -19 },
  { 1319, 4, 25, 6, 0, -21 },
  { 1332, 7, 9, 10, 1, -19 },
  { 1340, 10, 1, 10, 0, 0 },
  { 1342, 5, 4, 7, 1, -20 },
  { 1345, 10, 14, 12, 1, -14 },
  { 1363, 9, 20, 13, 2, -20 },
  { 1386, 10, 14, 12, 1, -14 },
  { 1404, 10, 20, 13, 1, -20 },
  { 1429, 10, 14, 12, 1, -14 },
  { 1447, 7, 20, 8, 1, -20 },
  { 1465, 10, 19, 13, 1, -14 },
  { 1489, 9, 20, 13, 2, -20 },
  { 1512, 2, 19, 6, 2, -19 },
  { 1517, 5, 24, 6, -1, -19 },
  { 1532, 9, 20, 11, 2, -20 },
  { 1555, 1, 20, 6, 2, -20 },
  { 1558, 16, 14, 20, 2, -14 },
  { 1586, 9, 14, 13, 2, -14 },
  { 1602, 10, 14, 13, 1, -14 },
  { 1620, 9, 19, 13, 2, -14 },
  { 1642, 10, 19, 13, 1, -14 },
  { 1666, 5, 14, 8, 2, -14 },
  { 1675, 9, 14, 12, 1, -14 },
  { 1691, 7, 17, 8, 0, -17 },
  { 1706, 9, 14, 13, 2, -14 },
  { 1722, 9, 14, 11, 1, -14 },
  { 1738, 15, 14, 17, 1, -14 },
  { 1765, 9, 14, 11, 1, -14 },
  { 1781, 9, 19, 11, 1, -14 },
  { 1803, 9, 14, 11, 1, -14 },
  { 1819, 6, 25, 8, 1, -20 },
  { 1838, 2, 22, 6, 2, -19 },
  { 1844, 7, 25, 8, 0, -20 },
  { 1866, 12, 5, 15, 2, -10 },
};

const GFXfont RobotoCondensed_Light26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_LIGHT26PT7B_H_
