#ifndef _ROBOTOCONDENSED_LIGHT68PT7B_H_
#define _ROBOTOCONDENSED_LIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light68pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x70, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0D, 0xC1, 0xB0, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x1F,
  0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x1E, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x8F,
  0x00, 0x07, 0xC7, 0xC0, 0x07, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x20, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x07,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x07, 0x01, 0xE0, 0xE0,
  0x00, 0x78, 0x3C, 0x0E, 0x00, 0x03, 0xFF, 0x81, 0xC0, 0x00, 0x1F, 0xF8,
  0x1C, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x03,
  0xC1, 0xFF, 0x80, 0x00, 0x38, 0x3F, 0xFC, 0x00, 0x07, 0x83, 0x81, 0xC0,
  0x00, 0x70, 0x70, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0xE0,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x01,
  0xE0, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xF8, 0xF8,
  0x01, 0xC3, 0xE0, 0xF0, 0x03, 0x87, 0x80, 0xF0, 0x07, 0x1E, 0x01, 0xF0,
  0x0E, 0x3C, 0x01, 0xF0, 0x3C, 0xF0, 0x01, 0xE0, 0x79, 0xE0, 0x01, 0xE0,
  0xF3, 0xC0, 0x03, 0xE1, 0xC7, 0x00, 0x03, 0xC7, 0x8E, 0x00, 0x03, 0xCF,
  0x1C, 0x00, 0x07, 0xDC, 0x38, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3F, 0x83,
  0xE0, 0x00, 0xFF, 0x03, 0xE0, 0x03, 0xEF, 0x07, 0xE0, 0x1F, 0x9F, 0x07,
  0xFF, 0xFE, 0x1E, 0x03, 0xFF, 0xF8, 0x1E, 0x03, 0xFF, 0xC0, 0x3E, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00,
  0x08, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x04, 0x80, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x40, 0x0E, 0x00, 0x4F, 0x01, 0xC0, 0x7B, 0xFC, 0x38, 0x7F,
  0xFF, 0xF7, 0x3F, 0xF1, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00,
  0xE0, 0x03, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF3, 0xC7, 0x9E, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x73, 0xEF, 0xBE, 0xF9, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x39, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x1F,
  0xFD, 0xFF, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x1F, 0x03,
  0xC0, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E,
  0x07, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x03, 0xF0,
  0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x3F, 0x80, 0x0F, 0x7F, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0xF0, 0x01, 0xF8, 0x70, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83,
  0xE0, 0x07, 0x80, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0xE0, 0x07, 0x0F, 0xFE, 0x01, 0xC7, 0xFF, 0xE0,
  0x73, 0xFF, 0xFC, 0x1D, 0xE0, 0x1F, 0x8F, 0xF0, 0x03, 0xE3, 0xF8, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xF0, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0x1F,
  0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF8,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x03,
  0xF3, 0xE0, 0x01, 0xFC, 0x7C, 0x00, 0xFF, 0x0F, 0x80, 0x7B, 0xC3, 0xFD,
  0xFC, 0xE0, 0x7F, 0xFE, 0x38, 0x07, 0xFF, 0x0E, 0x00, 0x7E, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0x7C, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xDF, 0x30, 0x1C, 0x3E, 0x3F, 0x3F,
  0x3E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3E, 0x1E, 0x00,
  0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0x07,
  0x80, 0x03, 0xFF, 0x00, 0x1C, 0x1C, 0x00, 0x1F, 0xFE, 0x00, 0x70, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0xC3, 0x80, 0x07, 0x80, 0x70, 0x03, 0x8E, 0x00,
  0x3C, 0x01, 0xC0, 0x0E, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x39, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x9C, 0x00, 0xF0,
  0x01, 0xC0, 0x06, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x19, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x6E, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xB8, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1B, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0x6E, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xB8, 0x03, 0xC0, 0x03, 0x80,
  0x06, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x3B, 0x80, 0x3C, 0x00, 0x38, 0x00,
  0xEE, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xB8, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x3B, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xCE,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x38, 0x03, 0xC0, 0x0F, 0x80, 0x1C, 0xF0,
  0x07, 0x00, 0x3E, 0x00, 0xE1, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x87, 0x00,
  0x78, 0x0E, 0xE0, 0x1C, 0x1C, 0x00, 0xF0, 0x7B, 0xC0, 0xF0, 0x70, 0x03,
  0xFF, 0xC7, 0x87, 0x80, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0x00, 0x07, 0xE1, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x0F, 0xC3, 0xC0, 0x00,
  0x7C, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x8F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x07,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00,
  0x7E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x3F, 0x0F, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x3F, 0x80, 0x00, 0x3D, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0xF8, 0x00, 0x0F, 0xE1, 0xE0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF7,
  0x00, 0x00, 0x00, 0xF7, 0xEF, 0x00, 0x00, 0x01, 0xEF, 0xDE, 0x00, 0x00,
  0x03, 0xDF, 0x9C, 0x00, 0x00, 0x0F, 0x3F, 0x3C, 0x00, 0x00, 0x1E, 0x7E,
  0x78, 0x00, 0x00, 0x38, 0xFC, 0x70, 0x00, 0x00, 0xF1, 0xF8, 0xF0, 0x00,
  0x01, 0xE7, 0xF1, 0xE0, 0x00, 0x03, 0x8F, 0xE1, 0xC0, 0x00, 0x0F, 0x1F,
  0xC3, 0xC0, 0x00, 0x1E, 0x3F, 0x87, 0x80, 0x00, 0x38, 0x7F, 0x07, 0x80,
  0x00, 0xF0, 0xFE, 0x0F, 0x00, 0x01, 0xE1, 0xFC, 0x0E, 0x00, 0x03, 0x83,
  0xF8, 0x1E, 0x00, 0x0F, 0x07, 0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0xF0, 0x38,
  0x00, 0x38, 0x1F, 0xE0, 0x78, 0x00, 0xF0, 0x3F, 0xC0, 0xF0, 0x01, 0xC0,
  0x7F, 0x80, 0xE0, 0x03, 0x80, 0xFF, 0x01, 0xE0, 0x0F, 0x01, 0xFE, 0x03,
  0xC0, 0x1C, 0x03, 0xFC, 0x03, 0x80, 0x78, 0x07, 0xF8, 0x07, 0x80, 0xF0,
  0x0F, 0xF0, 0x0F, 0x01, 0xC0, 0x1F, 0xE0, 0x0E, 0x07, 0x80, 0x3F, 0xC0,
  0x1E, 0x0F, 0x00, 0x7F, 0x80, 0x3C, 0x1C, 0x00, 0xFF, 0x00, 0x38, 0x78,
  0x01, 0xFE, 0x00, 0x78, 0xF0, 0x03, 0xFC, 0x00, 0x71, 0xC0, 0x07, 0xF8,
  0x00, 0xE7, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x01, 0xDC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0xFF, 0x78, 0x00, 0x03,
  0xFC, 0xF0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0xFF,
  0x0F, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x3F, 0xC1,
  0xE0, 0x00, 0xFF, 0x03, 0xC0, 0x03, 0xFC, 0x0F, 0x00, 0x0F, 0xF0, 0x1E,
  0x00, 0x3F, 0xC0, 0x3C, 0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0xFF, 0x00, 0x3C, 0x03,
  0xFC, 0x00, 0x78, 0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x03, 0xC0, 0xFF,
  0x00, 0x07, 0x83, 0xFC, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x3C, 0x3F, 0xC0,
  0x00, 0xF0, 0xFF, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x07, 0x8F, 0xF0, 0x00,
  0x0F, 0x3F, 0xC0, 0x00, 0x3C, 0xFF, 0x00, 0x00, 0x7B, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x8F,
  0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x0F,
  0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x3E, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xFC, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x70, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0E,
  0x38, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x1C,
  0x1C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x07, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0xF0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0xC0,
  0x01, 0xC7, 0x80, 0x00, 0xF3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0x80,
  0x00, 0xE7, 0x80, 0x00, 0xF3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x80,
  0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x3C, 0x00,
  0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x07,
  0x03, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x0E, 0x3C,
  0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x70,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x1E, 0x3E,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7E, 0xF8,
  0x01, 0xFE, 0x7E, 0x07, 0xDE, 0x3F, 0xFF, 0x9E, 0x1F, 0xFF, 0x0F, 0x0F,
  0xFE, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x3F, 0x00, 0xF0, 0xFF, 0xC0, 0xF3, 0xFF, 0xF0, 0xF7, 0xFF, 0xF8, 0xFF,
  0x00, 0xFC, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x3E, 0xFE,
  0x00, 0x7C, 0xEF, 0x00, 0xFC, 0xE7, 0xFF, 0xF8, 0xE3, 0xFF, 0xF0, 0xE0,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xF0,
  0xF8, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x1E,
  0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7C,
  0x0F, 0x03, 0xFF, 0x0F, 0x0F, 0xFF, 0xCF, 0x1F, 0xFF, 0xEF, 0x1F, 0x00,
  0xFF, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3E, 0x00,
  0x77, 0x1F, 0x00, 0xF7, 0x0F, 0xFF, 0xE7, 0x07, 0xFF, 0xC7, 0x03, 0xFF,
  0x87, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x78,
  0x00, 0x7C, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x08, 0x7C, 0x00, 0x04, 0x1F, 0x00, 0x0F, 0x07,
  0xE0, 0x1F, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0x07, 0x0F, 0xFF, 0xC7, 0x1F, 0xFF, 0xE7,
  0x1F, 0x00, 0xF7, 0x3E, 0x00, 0x77, 0x7C, 0x00, 0x3F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x3E, 0x00, 0x7F, 0x1F, 0x00, 0xFF, 0x1F, 0xFF, 0xEF, 0x07, 0xFF, 0xCF,
  0x03, 0xFF, 0x8F, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x10, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0xE7, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x78, 0x7F, 0xE0, 0xF1, 0xFF, 0xF1, 0xE7, 0xFF,
  0xE3, 0xDE, 0x03, 0xE7, 0xF8, 0x03, 0xEF, 0xE0, 0x03, 0xDF, 0x80, 0x07,
  0xBE, 0x00, 0x07, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78,
  0xF7, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xCF,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x00,
  0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0xF0, 0x00,
  0xFC, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3E, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x38, 0x3F,
  0xF0, 0x07, 0xFE, 0x0E, 0x3F, 0xFE, 0x07, 0xFF, 0xE3, 0x9F, 0xFF, 0xC3,
  0xFF, 0xFC, 0xE7, 0x81, 0xF8, 0xF0, 0x1F, 0x3B, 0x80, 0x1E, 0x70, 0x03,
  0xEF, 0xC0, 0x03, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE1,
  0xFF, 0x83, 0xC7, 0xFF, 0xC7, 0x9F, 0xFF, 0x8F, 0x78, 0x0F, 0x9F, 0xE0,
  0x0F, 0xBF, 0x80, 0x0F, 0x7E, 0x00, 0x1E, 0xF8, 0x00, 0x1D, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x0F,
  0x80, 0x0F, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0xE0, 0xFF, 0xC0, 0xE3, 0xFF, 0xF0, 0xE7, 0xFF, 0xF8, 0xEF,
  0x00, 0xFC, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x7C, 0xFF, 0x00, 0xF8, 0xF7, 0xFF, 0xF8, 0xF3, 0xFF, 0xF0, 0xF0,
  0xFF, 0xC0, 0xF0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x87, 0x0F, 0xFF, 0xC7, 0x1F, 0xFF, 0xE7, 0x1F, 0x00, 0xF7, 0x3E,
  0x00, 0x77, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0xFF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x8F, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC7, 0xFF, 0x3F, 0xFD, 0xFF,
  0xF7, 0x83, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x38, 0x00,
  0x1E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x3E, 0x1F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3E,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xEF,
  0x00, 0x07, 0xDE, 0x00, 0x1F, 0xBE, 0x00, 0x7F, 0x3E, 0x03, 0xFE, 0x7F,
  0xFF, 0xBC, 0x7F, 0xFE, 0x78, 0x3F, 0xF0, 0xF0, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07,
  0x80, 0xE0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x3E, 0x00, 0x1E,
  0x78, 0x00, 0x7E, 0x00, 0x1E, 0x38, 0x00, 0x7E, 0x00, 0x1E, 0x3C, 0x00,
  0x7E, 0x00, 0x1C, 0x3C, 0x00, 0x7F, 0x00, 0x3C, 0x3C, 0x00, 0xFF, 0x00,
  0x3C, 0x1C, 0x00, 0xE7, 0x00, 0x3C, 0x1E, 0x00, 0xE7, 0x00, 0x38, 0x1E,
  0x01, 0xE7, 0x80, 0x78, 0x1E, 0x01, 0xC3, 0x80, 0x78, 0x0E, 0x01, 0xC3,
  0x80, 0x78, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x0F, 0x03, 0xC3, 0xC0, 0x70,
  0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x07, 0x03,
  0x81, 0xE0, 0xE0, 0x07, 0x87, 0x81, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0xE1,
  0xE0, 0x03, 0x87, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x03,
  0xCF, 0x00, 0x71, 0xC0, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00,
  0x73, 0xC0, 0x01, 0xDE, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x01, 0xFC, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x8F, 0x00,
  0x07, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3C,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xCE, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3E,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x00, 0xE0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xF0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1C, 0xFF, 0xF0, 0x00, 0x79, 0xFF, 0xF0, 0x00, 0xE7, 0x81, 0xF0, 0x01,
  0xCE, 0x01, 0xF0, 0x03, 0xBC, 0x01, 0xF0, 0x0F, 0x70, 0x01, 0xF0, 0x3C,
  0xE0, 0x01, 0xFF, 0xF9, 0xC0, 0x01, 0xFF, 0xE3, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_Light68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 49, 15, 5, -48 },
  { 32, 11, 15, 20, 5, -51 },
  { 53, 31, 48, 35, 3, -48 },
  { 239, 25, 63, 33, 4, -56 },
  { 436, 36, 50, 43, 4, -49 },
  { 661, 31, 50, 37, 4, -49 },
  { 855, 4, 15, 12, 4, -51 },
  { 863, 13, 70, 20, 5, -54 },
  { 977, 13, 70, 20, 2, -54 },
  { 1091, 27, 27, 29, 1, -48 },
  { 1183, 28, 35, 34, 3, -40 },
  { 1306, 7, 15, 13, 2, -6 },
  { 1320, 13, 3, 18, 2, -23 },
  { 1325, 6, 6, 16, 5, -5 },
  { 1330, 21, 52, 24, 1, -48 },
  { 1467, 25, 50, 33, 4, -49 },
  { 1624, 14, 48, 33, 6, -48 },
  { 1708, 26, 49, 33, 4, -49 },
  { 1868, 26, 50, 33, 3, -49 },
  { 2031, 29, 48, 33, 2, -48 },
  { 2205, 25, 49, 33, 5, -48 },
  { 2359, 26, 49, 33, 4, -48 },
  { 2519, 27, 48, 33, 3, -48 },
  { 2681, 26, 50, 33, 4, -49 },
  { 2844, 26, 49, 33, 3, -49 },
  { 3004, 6, 37, 14, 4, -36 },
  { 3032, 8, 45, 13, 2, -36 },
  { 3077, 23, 28, 31, 3, -36 },
  { 3158, 23, 19, 33, 5, -32 },
  { 3213, 24, 28, 31, 4, -36 },
  { 3297, 21, 50, 27, 3, -49 },
  { 3429, 46, 62, 53, 4, -47 },
  { 3786, 34, 48, 37, 2, -48 },
  { 3990, 27, 48, 36, 6, -48 },
  { 4152, 30, 50, 38, 5, -49 },
  { 4340, 28, 48, 39, 6, -48 },
  { 4508, 25, 48, 34, 6, -48 },
  { 4658, 25, 48, 33, 6, -48 },
  { 4808, 30, 50, 40, 5, -49 },
  { 4996, 30, 48, 42, 6, -48 },
  { 5176, 4, 48, 17, 6, -48 },
  { 5200, 24, 49, 33, 3, -48 },
  { 5347, 30, 48, 37, 6, -48 },
  { 5527, 23, 48, 32, 6, -48 },
  { 5665, 39, 48, 51, 6, -48 },
  { 5899, 30, 48, 42, 6, -48 },
  { 6079, 32, 50, 40, 4, -49 },
  { 6279, 28, 48, 37, 6, -48 },
  { 6447, 32, 57, 40, 4, -49 },
  { 6675, 29, 48, 37, 6, -48 },
  { 6849, 29, 50, 35, 3, -49 },
  { 7031, 31, 48, 35, 2, -48 },
  { 7217, 29, 49, 39, 5, -48 },
  { 7395, 33, 48, 37, 2, -48 },
  { 7593, 48, 48, 52, 2, -48 },
  { 7881, 32, 48, 36, 2, -48 },
  { 8073, 33, 48, 36, 1, -48 },
  { 8271, 29, 48, 36, 3, -48 },
  { 8445, 10, 65, 15, 5, -55 },
  { 8527, 21, 52, 24, 2, -48 },
  { 8664, 9, 65, 15, 1, -55 },
  { 8738, 19, 24, 25, 3, -48 },
  { 8795, 25, 3, 26, 1, 0 },
  { 8805, 12, 9, 19, 3, -51 },
  { 8819, 24, 38, 32, 4, -37 },
  { 8933, 24, 52, 33, 5, -51 },
  { 9089, 25, 38, 31, 3, -37 },
  { 9208, 24, 52, 33, 4, -51 },
  { 9364, 25, 38, 31, 3, -37 },
  { 9483, 18, 52, 20, 2, -52 },
  { 9600, 24, 51, 33, 4, -37 },
  { 9753, 23, 51, 33, 5, -51 },
  { 9900, 5, 49, 14, 5, -49 },
  { 9931, 12, 63, 15, -2, -49 },
  { 10026, 24, 51, 30, 5, -51 },
  { 10179, 4, 51, 14, 5, -51 },
  { 10205, 42, 37, 52, 5, -37 },
  { 10400, 23, 37, 33, 5, -37 },
  { 10507, 26, 38, 33, 4, -37 },
  { 10631, 24, 51, 33, 5, -37 },
  { 10784, 24, 51, 33, 4, -37 },
  { 10937, 14, 37, 21, 5, -37 },
  { 11002, 24, 38, 30, 3, -37 },
  { 11116, 16, 46, 20, 1, -45 },
  { 11208, 23, 37, 33, 5, -36 },
  { 11315, 25, 36, 29, 2, -36 },
  { 11428, 40, 36, 44, 2, -36 },
  { 11608, 25, 36, 29, 2, -36 },
  { 11721, 25, 50, 28, 2, -36 },
  { 11878, 24, 36, 29, 3, -36 },
  { 11986, 16, 66, 20, 3, -53 },
  { 12118, 3, 57, 15, 6, -48 },
  { 12140, 17, 66, 20, 1, -53 },
  { 12281, 31, 12, 40, 5, -26 },
};

const GFXfont RobotoCondensed_Light68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_LIGHT68PT7B_H_
