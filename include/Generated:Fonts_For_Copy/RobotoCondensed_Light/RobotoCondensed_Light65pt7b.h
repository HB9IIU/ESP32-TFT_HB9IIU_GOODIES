#ifndef _ROBOTOCONDENSED_LIGHT65PT7B_H_
#define _ROBOTOCONDENSED_LIGHT65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x60, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x80, 0xF8, 0x1E, 0x00, 0x7C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x04, 0x03, 0x80, 0x38, 0x03, 0x80, 0xC0, 0x0E,
  0x00, 0xE0, 0x30, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x38, 0x0E, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x30, 0x03, 0x81, 0xC0, 0x0E,
  0x00, 0xE0, 0xE0, 0x03, 0x80, 0x70, 0x38, 0x00, 0xF0, 0x1C, 0x1C, 0x00,
  0x1E, 0x0E, 0x07, 0x00, 0x03, 0xFF, 0x83, 0x80, 0x00, 0x7F, 0xC0, 0xE0,
  0x00, 0x0F, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xC0, 0x00, 0x0E, 0x0F, 0xF8, 0x00,
  0x07, 0x07, 0xFF, 0x00, 0x01, 0xC3, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x38,
  0x00, 0x70, 0x30, 0x07, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x0E, 0x07, 0x00,
  0x70, 0x03, 0x81, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x70, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x70, 0x18,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0,
  0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x7C, 0x03,
  0xC3, 0xC0, 0x78, 0x07, 0x87, 0x80, 0x78, 0x0E, 0x1E, 0x00, 0x78, 0x1C,
  0x3C, 0x00, 0xF0, 0x38, 0x70, 0x00, 0xF0, 0x70, 0xE0, 0x00, 0xF1, 0xE3,
  0xC0, 0x01, 0xF3, 0xC7, 0x80, 0x01, 0xE7, 0x07, 0x00, 0x01, 0xFE, 0x0E,
  0x00, 0x01, 0xF8, 0x1C, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFF, 0x80, 0xF8,
  0x03, 0xE7, 0x80, 0xFF, 0xFF, 0x87, 0x80, 0xFF, 0xFE, 0x0F, 0x80, 0x7F,
  0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x02, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x20, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x60, 0x1C, 0x01, 0xBF, 0x07, 0x03, 0xEF, 0xF1,
  0xC3, 0xFD, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0xE0,
  0x00, 0x0E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x0E, 0x3C, 0x78, 0xE3, 0xCF, 0x1E, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x27, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x01,
  0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00,
  0x1E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x04,
  0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x1F, 0xFD, 0xFE, 0x7F, 0xE1, 0xFE, 0x07,
  0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x7F, 0x00, 0x3B, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3E, 0x01, 0xF8, 0x7C, 0x00, 0x7C,
  0x18, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x3F, 0x00, 0x70, 0xFF, 0xE0, 0x73, 0xFF, 0xF0, 0xF7, 0xE3, 0xF8,
  0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x3C, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0xF8,
  0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x1F, 0x81, 0xF0, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x1F,
  0x3C, 0x00, 0x3F, 0x1E, 0x00, 0x7F, 0x1F, 0x00, 0xF7, 0x0F, 0xE3, 0xE7,
  0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x87, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x21, 0xEF, 0xFF, 0x78, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x87, 0xBF, 0xFD, 0xE3, 0x00, 0x08, 0x7C, 0xF9,
  0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x71, 0xE0, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x70, 0xE0, 0x00, 0xFF, 0x80, 0x0E, 0x38, 0x00, 0x7F, 0xF8, 0x00,
  0xC7, 0x00, 0x0F, 0x07, 0x80, 0x18, 0xE0, 0x03, 0xC0, 0x70, 0x03, 0xB8,
  0x00, 0xF0, 0x0E, 0x00, 0x77, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x80, 0x38, 0x00, 0x70, 0x01, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x3E,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xF8, 0x03,
  0x80, 0x06, 0x00, 0x3F, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xE0, 0x0E, 0x00,
  0x38, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x78, 0x00, 0xE0,
  0x03, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x6E, 0x00, 0xE0, 0x03, 0x80, 0x1D,
  0xC0, 0x1C, 0x00, 0xF0, 0x03, 0xB8, 0x03, 0x80, 0x1E, 0x00, 0x67, 0x00,
  0x70, 0x07, 0xC0, 0x1C, 0x70, 0x0F, 0x01, 0xDC, 0x07, 0x8E, 0x00, 0xF0,
  0x73, 0x80, 0xE1, 0xC0, 0x1F, 0xFE, 0x78, 0x78, 0x38, 0x01, 0xFF, 0x87,
  0xFE, 0x03, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x1F, 0xF0, 0xF0, 0x00,
  0x7E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x1C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0,
  0x01, 0xF0, 0xF0, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0xCF, 0x00, 0x1F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0xFF, 0xC0, 0xF0,
  0x00, 0x7E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xE0,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C,
  0x1F, 0x80, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x79, 0xFC, 0x00, 0x03, 0xCF,
  0xE0, 0x00, 0x1E, 0xF7, 0x80, 0x00, 0xFF, 0x3E, 0x00, 0x07, 0xF8, 0xF0,
  0x00, 0x3F, 0x83, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x77, 0xF7, 0x00, 0x00, 0x03, 0xDF, 0xDE, 0x00,
  0x00, 0x0F, 0x7F, 0x78, 0x00, 0x00, 0x39, 0xFC, 0xE0, 0x00, 0x01, 0xE7,
  0xF3, 0xC0, 0x00, 0x07, 0x9F, 0xCF, 0x00, 0x00, 0x1C, 0x7F, 0x1C, 0x00,
  0x00, 0xF1, 0xFC, 0x78, 0x00, 0x03, 0x87, 0xF1, 0xE0, 0x00, 0x0E, 0x1F,
  0xC3, 0x80, 0x00, 0x78, 0x7F, 0x0F, 0x00, 0x01, 0xC1, 0xFC, 0x1C, 0x00,
  0x07, 0x07, 0xF0, 0x70, 0x00, 0x3C, 0x1F, 0xC1, 0xE0, 0x00, 0xE0, 0x7F,
  0x03, 0x80, 0x07, 0x81, 0xFC, 0x0E, 0x00, 0x1E, 0x07, 0xF0, 0x3C, 0x00,
  0x70, 0x3F, 0xC0, 0x70, 0x03, 0xC0, 0xFF, 0x01, 0xC0, 0x0F, 0x03, 0xFC,
  0x07, 0x80, 0x38, 0x0F, 0xF0, 0x0E, 0x01, 0xE0, 0x3F, 0xC0, 0x38, 0x07,
  0x80, 0xFF, 0x00, 0xF0, 0x1C, 0x03, 0xFC, 0x01, 0xC0, 0xF0, 0x0F, 0xF0,
  0x07, 0x83, 0x80, 0x3F, 0xC0, 0x1E, 0x0E, 0x00, 0xFF, 0x00, 0x38, 0x78,
  0x03, 0xFC, 0x00, 0xF1, 0xC0, 0x0F, 0xF0, 0x01, 0xC7, 0x00, 0x3F, 0xC0,
  0x07, 0x3C, 0x00, 0xFF, 0x00, 0x1E, 0xE0, 0x03, 0xFC, 0x00, 0x3B, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x0F,
  0xF7, 0x80, 0x00, 0x3F, 0xCE, 0x00, 0x00, 0xFF, 0x3C, 0x00, 0x03, 0xFC,
  0x78, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x3F, 0xC3, 0xC0, 0x00, 0xFF, 0x0F,
  0x00, 0x03, 0xFC, 0x1E, 0x00, 0x0F, 0xF0, 0x38, 0x00, 0x3F, 0xC0, 0xF0,
  0x00, 0xFF, 0x01, 0xC0, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0xF0, 0x0F, 0x00,
  0x3F, 0xC0, 0x3C, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F,
  0xF0, 0x03, 0xC0, 0x3F, 0xC0, 0x07, 0x00, 0xFF, 0x00, 0x1E, 0x03, 0xFC,
  0x00, 0x38, 0x0F, 0xF0, 0x00, 0xF0, 0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0x00,
  0x07, 0x83, 0xFC, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x3C, 0x3F, 0xC0, 0x00,
  0x78, 0xFF, 0x00, 0x00, 0xE3, 0xFC, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x07,
  0x3F, 0xC0, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xFF,
  0x0F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x1F, 0x3C, 0x00, 0x07, 0xE7, 0x80, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC1, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x7E, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF0, 0x00, 0x0E,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0x3C,
  0x00, 0x0E, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0xC1, 0xC0,
  0x01, 0xCE, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x1E, 0x00,
  0x1C, 0x70, 0x00, 0xE0, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0x81, 0xE0, 0x03,
  0x87, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x38,
  0x38, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x00, 0xF0, 0x07, 0x03,
  0x80, 0x1C, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x1C,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x07,
  0x80, 0x0E, 0x07, 0x80, 0x38, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70,
  0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xF0, 0x00,
  0x70, 0xE0, 0x01, 0xE3, 0x80, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x07,
  0x9E, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8F, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x3C, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0x79, 0xC0, 0x0E, 0xF0, 0x03,
  0xBC, 0x00, 0xFE, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x1E,
  0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0x78, 0x00, 0x7E, 0x78, 0x00, 0xFE,
  0x3E, 0x03, 0xDE, 0x3F, 0xFF, 0xDE, 0x1F, 0xFF, 0x0E, 0x0F, 0xFE, 0x0F,
  0x01, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x80, 0x70, 0xFF,
  0xC0, 0xE3, 0xFF, 0xE1, 0xCF, 0xFF, 0xE3, 0xB8, 0x07, 0xE7, 0xE0, 0x03,
  0xCF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x07,
  0x9D, 0xC0, 0x3E, 0x39, 0xFF, 0xFC, 0x71, 0xFF, 0xF0, 0xE1, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x0F,
  0x03, 0xFF, 0x8F, 0x07, 0xFF, 0xCF, 0x0F, 0xFF, 0xEF, 0x1F, 0x00, 0xFF,
  0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x1F, 0x00, 0xFF, 0x0F, 0xFF, 0xE7,
  0x07, 0xFF, 0xC7, 0x03, 0xFF, 0x87, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x04, 0x1E, 0x00, 0x0E, 0x1F, 0x80, 0x3E, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x87, 0x07, 0xFF, 0xC7, 0x0F, 0xFF, 0xE7, 0x1F, 0x00, 0xF7, 0x3E,
  0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C,
  0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x1F, 0x00, 0xFF, 0x0F, 0xFF, 0xEF, 0x07,
  0xFF, 0xCF, 0x03, 0xFF, 0x8F, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x1E, 0x1C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0xC1, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0xE0, 0x38, 0x3F, 0xE0, 0xE3, 0xFF, 0xE3, 0x9F, 0xFF, 0x8E, 0xF0, 0x1F,
  0x3B, 0x80, 0x3E, 0xFC, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xBC,
  0x00, 0x0E, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x3C, 0x0F, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x81, 0xF6, 0xFC, 0xFF, 0x9F, 0xE3, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x3E, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8E, 0x00, 0x3C,
  0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x83, 0x80, 0x7C, 0x0E, 0x01, 0xE0, 0x38,
  0x0F, 0x00, 0xE0, 0x78, 0x03, 0x83, 0xC0, 0x0E, 0x1F, 0x00, 0x38, 0xF8,
  0x00, 0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x0E, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFD, 0xE0, 0x03, 0xF3, 0xC0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0E, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0xE0, 0x07,
  0x83, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xE3,
  0x80, 0x03, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xE3, 0xFF,
  0xC0, 0xFF, 0xF8, 0xE7, 0xFF, 0xE1, 0xFF, 0xFC, 0xEF, 0x01, 0xF3, 0xC0,
  0x7C, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3E, 0x03, 0x83, 0xFE,
  0x0E, 0x3F, 0xFE, 0x39, 0xFF, 0xF8, 0xEF, 0x01, 0xF3, 0xB8, 0x03, 0xEF,
  0xC0, 0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xC3, 0xFF, 0x03, 0x8F,
  0xFF, 0x87, 0x3F, 0xFF, 0x8E, 0xE0, 0x1F, 0x9F, 0x80, 0x0F, 0x3E, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x1E, 0x77, 0x00,
  0xF8, 0xEF, 0xFF, 0xF1, 0xCF, 0xFF, 0xC3, 0x87, 0xFE, 0x07, 0x03, 0xF0,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0x87, 0x07, 0xFF, 0xC7, 0x0F, 0xFF, 0xEF, 0x1F,
  0x00, 0xFF, 0x3E, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x0F,
  0xFF, 0xEF, 0x07, 0xFF, 0xCF, 0x03, 0xFF, 0x8F, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x7F, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x1E, 0x01, 0xF8, 0xF0, 0x01,
  0xE3, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x77,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x3E,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFD, 0xE0, 0x07, 0xF7, 0xC0, 0x3F, 0xCF,
  0xFF, 0xEF, 0x1F, 0xFF, 0x3C, 0x3F, 0xF8, 0xF0, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x01, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03,
  0x83, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC7, 0x80, 0x01,
  0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0xC0, 0x01,
  0xE0, 0x00, 0xF7, 0x00, 0x07, 0x80, 0x03, 0x9E, 0x00, 0x1F, 0x00, 0x0E,
  0x78, 0x00, 0xFC, 0x00, 0x78, 0xE0, 0x03, 0xF0, 0x01, 0xE3, 0x80, 0x0F,
  0xC0, 0x07, 0x0F, 0x00, 0x3F, 0x80, 0x1C, 0x3C, 0x01, 0xCE, 0x00, 0xF0,
  0x70, 0x07, 0x38, 0x03, 0xC1, 0xC0, 0x1C, 0xE0, 0x0E, 0x07, 0x80, 0x73,
  0xC0, 0x38, 0x1E, 0x03, 0x87, 0x00, 0xE0, 0x38, 0x0E, 0x1C, 0x07, 0x80,
  0xE0, 0x38, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0xE0, 0x70, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0x1C, 0x1C, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x3C, 0x38, 0x01,
  0xC3, 0xC0, 0x70, 0xE0, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x07,
  0x1E, 0x00, 0x38, 0xE0, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x03,
  0xDC, 0x00, 0xE7, 0x00, 0x0F, 0x70, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x00,
  0xE7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xEF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x07,
  0x81, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0x9E,
  0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xE0,
  0x70, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x05, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x40, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x71, 0xFF, 0xC0, 0x01, 0xCF, 0xFF,
  0x80, 0x07, 0x3C, 0x1F, 0x00, 0x1D, 0xE0, 0x3E, 0x00, 0xE7, 0x00, 0x7C,
  0x03, 0x9C, 0x00, 0xF8, 0x1E, 0x70, 0x01, 0xFF, 0xF3, 0xC0, 0x03, 0xFF,
  0x8F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoCondensed_Light65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 47, 14, 5, -46 },
  { 25, 10, 14, 19, 5, -49 },
  { 43, 30, 46, 33, 3, -46 },
  { 216, 24, 60, 32, 4, -53 },
  { 396, 34, 48, 42, 4, -47 },
  { 600, 31, 48, 35, 3, -47 },
  { 786, 3, 14, 11, 4, -49 },
  { 792, 13, 67, 19, 4, -52 },
  { 901, 13, 67, 19, 2, -52 },
  { 1010, 26, 26, 28, 1, -46 },
  { 1095, 26, 34, 32, 3, -39 },
  { 1206, 7, 15, 13, 2, -6 },
  { 1220, 13, 3, 17, 2, -22 },
  { 1225, 5, 6, 16, 5, -5 },
  { 1229, 20, 50, 23, 1, -46 },
  { 1354, 24, 48, 32, 4, -47 },
  { 1498, 14, 46, 32, 5, -46 },
  { 1579, 26, 47, 32, 3, -47 },
  { 1732, 25, 48, 32, 3, -47 },
  { 1882, 28, 46, 32, 2, -46 },
  { 2043, 24, 47, 32, 5, -46 },
  { 2184, 24, 47, 32, 4, -46 },
  { 2325, 25, 46, 32, 3, -46 },
  { 2469, 24, 48, 32, 4, -47 },
  { 2613, 24, 47, 32, 3, -47 },
  { 2754, 6, 35, 13, 4, -34 },
  { 2781, 7, 43, 12, 2, -34 },
  { 2819, 22, 27, 29, 3, -34 },
  { 2894, 22, 15, 31, 5, -29 },
  { 2936, 23, 28, 30, 4, -35 },
  { 3017, 20, 48, 26, 3, -47 },
  { 3137, 43, 59, 51, 4, -45 },
  { 3455, 33, 46, 36, 1, -46 },
  { 3645, 26, 46, 35, 5, -46 },
  { 3795, 29, 48, 37, 4, -47 },
  { 3969, 28, 46, 37, 5, -46 },
  { 4130, 25, 46, 32, 5, -46 },
  { 4274, 25, 46, 32, 5, -46 },
  { 4418, 29, 48, 39, 5, -47 },
  { 4592, 29, 46, 40, 5, -46 },
  { 4759, 4, 46, 16, 6, -46 },
  { 4782, 24, 47, 31, 2, -46 },
  { 4923, 29, 46, 36, 5, -46 },
  { 5090, 23, 46, 30, 5, -46 },
  { 5223, 38, 46, 49, 5, -46 },
  { 5442, 30, 46, 40, 5, -46 },
  { 5615, 30, 48, 38, 4, -47 },
  { 5795, 27, 46, 35, 5, -46 },
  { 5951, 30, 55, 38, 4, -47 },
  { 6158, 28, 46, 36, 5, -46 },
  { 6319, 28, 48, 34, 3, -47 },
  { 6487, 30, 46, 34, 2, -46 },
  { 6660, 27, 47, 37, 5, -46 },
  { 6819, 33, 46, 35, 1, -46 },
  { 7009, 46, 46, 50, 2, -46 },
  { 7274, 31, 46, 35, 2, -46 },
  { 7453, 32, 46, 34, 1, -46 },
  { 7637, 28, 46, 34, 3, -46 },
  { 7798, 9, 63, 15, 5, -53 },
  { 7869, 20, 50, 23, 2, -46 },
  { 7994, 9, 63, 15, 1, -53 },
  { 8065, 18, 23, 24, 3, -46 },
  { 8117, 23, 3, 25, 1, 0 },
  { 8126, 11, 9, 19, 3, -49 },
  { 8139, 24, 36, 31, 3, -35 },
  { 8247, 23, 50, 32, 5, -49 },
  { 8391, 24, 36, 29, 3, -35 },
  { 8499, 24, 50, 32, 3, -49 },
  { 8649, 24, 36, 30, 3, -35 },
  { 8757, 17, 50, 20, 2, -50 },
  { 8864, 24, 48, 32, 3, -35 },
  { 9008, 22, 49, 31, 5, -49 },
  { 9143, 4, 46, 14, 5, -46 },
  { 9166, 11, 59, 14, -2, -46 },
  { 9248, 22, 49, 28, 5, -49 },
  { 9383, 4, 49, 14, 5, -49 },
  { 9408, 40, 35, 50, 5, -35 },
  { 9583, 22, 35, 31, 5, -35 },
  { 9680, 26, 36, 32, 3, -35 },
  { 9797, 23, 48, 32, 5, -35 },
  { 9935, 24, 48, 32, 3, -35 },
  { 10079, 13, 35, 20, 5, -35 },
  { 10136, 22, 36, 29, 3, -35 },
  { 10235, 15, 44, 19, 1, -43 },
  { 10318, 22, 35, 31, 5, -34 },
  { 10415, 24, 34, 28, 2, -34 },
  { 10517, 38, 34, 42, 2, -34 },
  { 10679, 24, 34, 28, 2, -34 },
  { 10781, 25, 47, 27, 1, -34 },
  { 10928, 23, 34, 28, 3, -34 },
  { 11026, 16, 64, 19, 2, -51 },
  { 11154, 3, 55, 14, 6, -46 },
  { 11175, 16, 64, 19, 1, -51 },
  { 11303, 30, 12, 39, 4, -25 },
};

const GFXfont RobotoCondensed_Light65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_LIGHT65PT7B_H_
