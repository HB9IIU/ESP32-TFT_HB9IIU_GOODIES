#ifndef _ROBOTOCONDENSED_LIGHT42PT7B_H_
#define _ROBOTOCONDENSED_LIGHT42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC4, 0x00, 0xC1, 0x80,
  0x10, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00,
  0x60, 0xC0, 0x08, 0x18, 0x03, 0x06, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x81,
  0x83, 0x00, 0x30, 0x60, 0x04, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x60, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x0F, 0xFF, 0xFD, 0xFF,
  0xFF, 0x83, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x20,
  0x60, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x1E, 0x3C, 0x38,
  0x0E, 0x30, 0x06, 0x70, 0x06, 0x70, 0x07, 0x70, 0x03, 0x70, 0x03, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x07, 0x70, 0x07, 0x38, 0x0E, 0x3E,
  0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06, 0x00,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0,
  0xC0, 0xC3, 0x01, 0x81, 0x84, 0x01, 0x83, 0x18, 0x03, 0x0C, 0x60, 0x03,
  0xF8, 0xC0, 0x03, 0xC3, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0xF0, 0x00, 0xC7, 0xF0, 0x01, 0x8C, 0x30, 0x06, 0x30, 0x60, 0x0C,
  0x60, 0x60, 0x30, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x10, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x3F,
  0x80, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1E, 0x38, 0x01,
  0xC1, 0x80, 0x18, 0x1C, 0x03, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x81, 0xC0,
  0x18, 0x18, 0x01, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xEE, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00, 0x39, 0xC0, 0xC3, 0x0E,
  0x0C, 0x70, 0x70, 0xC6, 0x03, 0x0C, 0xE0, 0x38, 0xCE, 0x01, 0xDC, 0xE0,
  0x0D, 0x8E, 0x00, 0xF8, 0x60, 0x07, 0x06, 0x00, 0x78, 0x70, 0x0F, 0x83,
  0xC3, 0xDC, 0x1F, 0xF8, 0xE0, 0x7E, 0x06, 0x6D, 0xB7, 0xF6, 0xC0, 0x01,
  0x03, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18,
  0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x60, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x81, 0x81, 0xF1, 0x8F, 0xFF, 0xFF, 0x1F, 0xF8, 0x03, 0xC0, 0x03,
  0xC0, 0x06, 0xE0, 0x0E, 0x70, 0x1C, 0x30, 0x18, 0x18, 0x38, 0x1C, 0x10,
  0x08, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x39, 0xCE, 0x73, 0x18, 0xCE, 0xE2, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1C, 0x3C, 0x38, 0x1C, 0x30, 0x0E,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x07,
  0x60, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x38, 0x1C, 0x1E, 0x3C, 0x0F, 0xF8,
  0x07, 0xE0, 0x00, 0x81, 0xC7, 0xEF, 0xBF, 0x1E, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x0F, 0x06, 0x03, 0x87, 0x00, 0xE3, 0x00,
  0x33, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0xFB, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x30, 0x0C,
  0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x06, 0x38, 0x0E, 0x3C, 0x3C,
  0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x01,
  0x8E, 0x01, 0x87, 0x00, 0xC3, 0x80, 0xC1, 0xC0, 0xE0, 0xE0, 0x60, 0x70,
  0x70, 0x38, 0x30, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x1C, 0x03, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFE, 0x3F, 0xFE,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x77, 0xE0, 0x7F, 0xF0, 0x7C, 0x78,
  0x70, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x06, 0xC0, 0x06, 0xE0, 0x06, 0x60, 0x06, 0x70, 0x0E,
  0x30, 0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xF0, 0x07, 0xE0,
  0x3E, 0x00, 0xF0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x1F, 0x86, 0x7F, 0x8D, 0xC7, 0x9E, 0x03, 0xB8, 0x03,
  0x70, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0x60, 0x0E, 0xE0, 0x18, 0xC0, 0x71, 0xE3,
  0xC1, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1C, 0x3C, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x07, 0x60,
  0x06, 0x70, 0x06, 0x30, 0x0E, 0x38, 0x0C, 0x1C, 0x38, 0x0F, 0xF0, 0x0F,
  0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x3C,
  0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1C, 0x78, 0x38,
  0x1C, 0x70, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x07, 0x70,
  0x0F, 0x38, 0x1F, 0x3C, 0x3F, 0x1F, 0xE7, 0x07, 0xC6, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x78, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x73, 0x9C, 0xE6, 0x33, 0x98, 0x80, 0x00, 0x04, 0x00, 0x70,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x00,
  0x80, 0x00, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xC0, 0x6E, 0x03, 0xE0, 0x0F,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61,
  0xC0, 0x3E, 0x01, 0x8C, 0x03, 0xF8, 0x0C, 0x60, 0x38, 0x60, 0x66, 0x03,
  0x83, 0x01, 0x30, 0x18, 0x18, 0x09, 0x81, 0x80, 0xC0, 0x4C, 0x0C, 0x06,
  0x03, 0x60, 0x60, 0x30, 0x1A, 0x06, 0x01, 0x80, 0xD0, 0x30, 0x0C, 0x07,
  0x81, 0x80, 0x60, 0x2C, 0x0C, 0x03, 0x01, 0x60, 0x60, 0x10, 0x19, 0x03,
  0x01, 0x80, 0xC8, 0x18, 0x0C, 0x06, 0x60, 0xC0, 0xE0, 0x63, 0x07, 0x05,
  0x83, 0x18, 0x1C, 0x6C, 0x30, 0xC0, 0x7E, 0x3F, 0x03, 0x01, 0xE0, 0xF0,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x60, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x07, 0x70, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x70, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x70, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x38,
  0x03, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xE0, 0x03, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x63, 0x80, 0x03, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00,
  0x03, 0xF0, 0x00, 0x0C, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x7C, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0xF8,
  0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x3C,
  0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0,
  0x0E, 0x70, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x63, 0x80, 0x38, 0x78, 0x3C, 0x0F, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x30, 0x1F, 0x18, 0x03, 0xCC, 0x00, 0xE6, 0x00,
  0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x07, 0x30, 0x07, 0x98, 0x0F, 0x8F,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x78, 0x3C, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x03,
  0x98, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x1C,
  0xF0, 0x07, 0x0F, 0x87, 0xC0, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0D, 0xC0, 0x39, 0xC0, 0x63, 0xC3, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xC0,
  0x03, 0xB0, 0x01, 0xCC, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x1C, 0x30, 0x0E,
  0x0C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x70, 0x0C, 0x38, 0x03,
  0x1C, 0x00, 0xC7, 0x00, 0x33, 0x80, 0x0D, 0xF0, 0x03, 0xEC, 0x00, 0xF3,
  0x80, 0x38, 0x70, 0x0E, 0x0C, 0x03, 0x03, 0x80, 0xC0, 0x70, 0x30, 0x0C,
  0x0C, 0x03, 0x83, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x03, 0x8C, 0x00, 0x73,
  0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x70, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1B, 0xD8, 0x00, 0x3B, 0xD8, 0x00, 0x33,
  0xDC, 0x00, 0x33, 0xCC, 0x00, 0x73, 0xCC, 0x00, 0x63, 0xCE, 0x00, 0x63,
  0xC6, 0x00, 0xE3, 0xC6, 0x00, 0xC3, 0xC7, 0x00, 0xC3, 0xC3, 0x01, 0xC3,
  0xC3, 0x01, 0x83, 0xC3, 0x81, 0x83, 0xC1, 0x83, 0x83, 0xC1, 0x83, 0x03,
  0xC1, 0xC3, 0x03, 0xC0, 0xC7, 0x03, 0xC0, 0xC6, 0x03, 0xC0, 0xE6, 0x03,
  0xC0, 0x6E, 0x03, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0xC0, 0x38, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x0F, 0x30, 0x03,
  0xCE, 0x00, 0xF1, 0x80, 0x3C, 0x70, 0x0F, 0x0C, 0x03, 0xC3, 0x80, 0xF0,
  0x60, 0x3C, 0x1C, 0x0F, 0x03, 0x03, 0xC0, 0x60, 0xF0, 0x1C, 0x3C, 0x03,
  0x0F, 0x00, 0xE3, 0xC0, 0x18, 0xF0, 0x07, 0x3C, 0x00, 0xCF, 0x00, 0x3B,
  0xC0, 0x06, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x30, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x7C, 0x1C, 0x01, 0xC7,
  0x00, 0x18, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x06, 0x60,
  0x01, 0xCE, 0x00, 0x30, 0xE0, 0x0E, 0x0F, 0x8F, 0x80, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x0F, 0x98, 0x01, 0xCC, 0x00,
  0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x39, 0x80, 0x7C,
  0xFF, 0xFC, 0x7F, 0xF8, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78,
  0x7C, 0x1C, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00,
  0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x37, 0x00, 0x06, 0x60, 0x01, 0xCE, 0x00, 0x30, 0xE0, 0x0E, 0x0F, 0x0F,
  0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0E, 0x01,
  0xE3, 0x80, 0x1C, 0xE0, 0x03, 0x38, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06,
  0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x03, 0xB8,
  0x00, 0xCE, 0x00, 0x73, 0x80, 0x78, 0xFF, 0xFC, 0x3F, 0xFC, 0x0E, 0x03,
  0x83, 0x80, 0x60, 0xE0, 0x1C, 0x38, 0x03, 0x0E, 0x00, 0xE3, 0x80, 0x18,
  0xE0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF8,
  0x00, 0x30, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x70,
  0x03, 0x98, 0x00, 0x66, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00,
  0x63, 0x80, 0x38, 0xF8, 0x3C, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0x9C, 0x00, 0xE7,
  0x80, 0x70, 0xF8, 0x7C, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0x98, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x87, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x07,
  0x00, 0x70, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0C,
  0x00, 0xC0, 0x60, 0x06, 0x07, 0x00, 0x38, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x1C, 0x00, 0x38, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0D, 0x80, 0x0E, 0x00, 0x76,
  0x00, 0x38, 0x01, 0xDC, 0x01, 0xE0, 0x06, 0x70, 0x06, 0x80, 0x18, 0xC0,
  0x1B, 0x00, 0x63, 0x00, 0x6C, 0x03, 0x8C, 0x03, 0xB0, 0x0E, 0x38, 0x0C,
  0xC0, 0x30, 0xE0, 0x31, 0x80, 0xC1, 0x80, 0xC6, 0x03, 0x06, 0x07, 0x18,
  0x1C, 0x18, 0x18, 0x60, 0x60, 0x70, 0x60, 0xC1, 0x80, 0xC1, 0x83, 0x06,
  0x03, 0x06, 0x0C, 0x18, 0x0C, 0x30, 0x30, 0xE0, 0x30, 0xC0, 0x63, 0x00,
  0xE3, 0x01, 0x8C, 0x01, 0x8C, 0x06, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x19,
  0x80, 0x77, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xD8, 0x03, 0x60, 0x03, 0xC0,
  0x0D, 0x80, 0x0F, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x77,
  0x00, 0x0E, 0x38, 0x00, 0xE1, 0x80, 0x1C, 0x1C, 0x01, 0x80, 0xC0, 0x38,
  0x0E, 0x03, 0x00, 0x60, 0x70, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x9C,
  0x00, 0x1D, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x1D, 0x80, 0x01, 0x9C, 0x00, 0x38, 0xC0, 0x03,
  0x0E, 0x00, 0x70, 0x60, 0x06, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x81,
  0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07,
  0xE0, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x38, 0x01,
  0xC3, 0x80, 0x18, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xE0,
  0x70, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00, 0x39, 0xC0, 0x01,
  0x98, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0xFF,
  0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1B,
  0x01, 0xB0, 0x19, 0x83, 0x18, 0x31, 0x83, 0x0C, 0x60, 0xC6, 0x0C, 0x60,
  0x6C, 0x06, 0xC0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xC0,
  0xC1, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0xE6, 0x00, 0xCC,
  0x01, 0xD8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x7F, 0xF9, 0xE0,
  0x77, 0x00, 0xEC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x3D,
  0x80, 0xFB, 0xC7, 0xF3, 0xFE, 0xE3, 0xF0, 0xC0, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x1F, 0x86, 0x7F, 0xCD, 0xC7, 0x9E, 0x03, 0xB8, 0x03,
  0x70, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00,
  0x6F, 0x01, 0xDB, 0x8F, 0x33, 0xFC, 0x63, 0xF0, 0x07, 0xE0, 0x3F, 0xF0,
  0xF0, 0xF3, 0x80, 0x66, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x03, 0x60, 0x06, 0xC0, 0x1D, 0xC0, 0x31, 0xE1, 0xE1, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x1F, 0x18, 0xFF,
  0xB3, 0xC3, 0xEE, 0x01, 0xDC, 0x03, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x80, 0x37, 0x00, 0xE7, 0x87, 0xC7, 0xFD,
  0x83, 0xE3, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0x66, 0x00, 0xEC,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x19, 0xF0, 0xF1, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xE0, 0xFC, 0x1C,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xFF, 0x7F,
  0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x07, 0xC6, 0x3F, 0xEC, 0xF0, 0xFB, 0x80, 0x77,
  0x00, 0xEC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0xE0, 0x0D, 0xC0, 0x39, 0xE1, 0xF1, 0xFF, 0x60, 0xF8, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x39, 0x80, 0x63, 0xC3, 0xC3, 0xFF,
  0x01, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x3E, 0x33, 0xFC,
  0xDC, 0x7B, 0x40, 0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x63, 0xDF, 0x3C, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x76, 0x01, 0xCC, 0x07, 0x18, 0x1C,
  0x30, 0x70, 0x61, 0xC0, 0xC3, 0x81, 0x8E, 0x03, 0x38, 0x06, 0xE0, 0x0F,
  0xE0, 0x1E, 0xE0, 0x38, 0xC0, 0x61, 0xC0, 0xC1, 0xC1, 0x81, 0x83, 0x03,
  0x86, 0x03, 0x8C, 0x03, 0x18, 0x07, 0x30, 0x07, 0x60, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0,
  0x7E, 0x33, 0xFC, 0x3F, 0xCD, 0xC7, 0x9C, 0x7B, 0xC0, 0x7C, 0x06, 0xE0,
  0x1E, 0x01, 0xF8, 0x03, 0x80, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30,
  0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00,
  0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F,
  0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x30, 0xC3, 0xE3,
  0x3F, 0xCD, 0xC7, 0xB4, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x30, 0x07, 0xE0, 0x0F, 0xF8, 0x3C, 0x3C, 0x38, 0x0E, 0x70, 0x06, 0x60,
  0x07, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x07, 0x70,
  0x06, 0x38, 0x0E, 0x3C, 0x3C, 0x0F, 0xF8, 0x07, 0xE0, 0xC7, 0xE1, 0x9F,
  0xF3, 0x71, 0xE7, 0x80, 0xEE, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x1B, 0xC0, 0x76, 0xC3, 0xCC, 0xFF,
  0x18, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC6, 0x3F, 0xEC,
  0xF0, 0xFB, 0x80, 0x77, 0x00, 0x6C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xB0, 0x03, 0x60, 0x06, 0xE0, 0x0D, 0xC0, 0x39, 0xE1, 0xF1, 0xFF, 0x60,
  0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0xC7, 0xE7, 0xF7, 0x3E, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x0F, 0xC0, 0x7F, 0xC3,
  0x87, 0x9C, 0x07, 0x60, 0x0D, 0x80, 0x36, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x37, 0x01, 0xCE, 0x1E, 0x1F, 0xF0, 0x3F, 0x80, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x0F, 0xFB, 0xFE, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xFC, 0x1F, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x76, 0x03, 0xDE, 0x1F, 0x3F, 0xEC, 0x7E,
  0x30, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30,
  0x0C, 0x30, 0x1C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0xB0, 0x0E, 0x01, 0xD8, 0x07, 0x00, 0xCE, 0x03, 0xC0, 0x63, 0x03, 0xE0,
  0x71, 0x81, 0xB0, 0x38, 0xC0, 0xD8, 0x18, 0x70, 0x6E, 0x0C, 0x18, 0x63,
  0x06, 0x0C, 0x31, 0x87, 0x06, 0x18, 0xC3, 0x03, 0x0C, 0x31, 0x80, 0xCC,
  0x18, 0xC0, 0x66, 0x0C, 0xE0, 0x33, 0x06, 0x60, 0x19, 0x81, 0xB0, 0x0F,
  0x80, 0xD8, 0x03, 0xC0, 0x6C, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x18, 0x03, 0x80, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C,
  0x18, 0x1C, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0x60,
  0x0C, 0x30, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0C,
  0x30, 0x0C, 0x30, 0x1C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x38, 0x1C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x70, 0x30, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0,
  0x3C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x07,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0xC0, 0xF0, 0x70, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x03,
  0x80, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x0D, 0xCF, 0x01, 0xF0, 0x60,
  0x3C, 0x0E, 0x0D, 0x80, 0xF3, 0xB0, 0x0F, 0xE0, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Light42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 30, 9, 3, -30 },
  { 13, 7, 9, 12, 3, -32 },
  { 21, 19, 30, 22, 2, -30 },
  { 93, 16, 38, 20, 2, -34 },
  { 169, 23, 30, 27, 2, -30 },
  { 256, 20, 30, 23, 2, -30 },
  { 331, 3, 9, 7, 2, -32 },
  { 335, 8, 44, 12, 3, -34 },
  { 379, 8, 44, 12, 1, -34 },
  { 423, 16, 17, 18, 1, -30 },
  { 457, 17, 22, 21, 2, -25 },
  { 504, 5, 10, 8, 1, -4 },
  { 511, 9, 2, 11, 1, -14 },
  { 514, 3, 3, 10, 3, -3 },
  { 516, 12, 33, 15, 1, -30 },
  { 566, 16, 30, 20, 2, -30 },
  { 626, 9, 30, 20, 3, -30 },
  { 660, 17, 30, 20, 2, -30 },
  { 724, 16, 30, 20, 2, -30 },
  { 784, 17, 30, 20, 2, -30 },
  { 848, 16, 30, 20, 3, -30 },
  { 908, 15, 30, 20, 3, -30 },
  { 965, 16, 30, 20, 2, -30 },
  { 1025, 16, 30, 20, 2, -30 },
  { 1085, 16, 30, 20, 2, -30 },
  { 1145, 3, 22, 8, 3, -22 },
  { 1154, 5, 28, 8, 1, -22 },
  { 1172, 14, 17, 19, 2, -22 },
  { 1202, 14, 10, 20, 3, -19 },
  { 1220, 14, 17, 19, 3, -22 },
  { 1250, 13, 30, 17, 2, -30 },
  { 1299, 29, 38, 33, 2, -29 },
  { 1437, 21, 30, 23, 1, -30 },
  { 1516, 16, 30, 23, 4, -30 },
  { 1576, 18, 30, 24, 3, -30 },
  { 1644, 17, 30, 24, 4, -30 },
  { 1708, 15, 30, 21, 4, -30 },
  { 1765, 15, 30, 21, 4, -30 },
  { 1822, 19, 30, 25, 3, -30 },
  { 1894, 18, 30, 26, 4, -30 },
  { 1962, 2, 30, 10, 4, -30 },
  { 1970, 15, 30, 20, 2, -30 },
  { 2027, 18, 30, 23, 4, -30 },
  { 2095, 14, 30, 20, 4, -30 },
  { 2148, 24, 30, 31, 4, -30 },
  { 2238, 18, 30, 26, 4, -30 },
  { 2306, 19, 30, 25, 3, -30 },
  { 2378, 17, 30, 23, 4, -30 },
  { 2442, 19, 35, 25, 3, -30 },
  { 2526, 18, 30, 23, 3, -30 },
  { 2594, 18, 30, 22, 2, -30 },
  { 2662, 20, 30, 22, 1, -30 },
  { 2737, 18, 30, 24, 3, -30 },
  { 2805, 21, 30, 23, 1, -30 },
  { 2884, 30, 30, 32, 1, -30 },
  { 2997, 20, 30, 23, 1, -30 },
  { 3072, 20, 30, 22, 1, -30 },
  { 3147, 18, 30, 22, 2, -30 },
  { 3215, 6, 40, 9, 3, -34 },
  { 3245, 13, 33, 15, 1, -30 },
  { 3299, 6, 40, 9, 0, -34 },
  { 3329, 12, 15, 16, 2, -30 },
  { 3352, 16, 2, 16, 0, 0 },
  { 3356, 7, 6, 12, 2, -32 },
  { 3362, 15, 22, 20, 2, -22 },
  { 3404, 15, 32, 20, 3, -32 },
  { 3464, 15, 22, 19, 2, -22 },
  { 3506, 15, 32, 20, 2, -32 },
  { 3566, 15, 22, 19, 2, -22 },
  { 3608, 11, 32, 13, 1, -32 },
  { 3652, 15, 31, 20, 2, -22 },
  { 3711, 14, 32, 20, 3, -32 },
  { 3767, 3, 30, 9, 3, -30 },
  { 3779, 7, 39, 9, -1, -30 },
  { 3814, 15, 32, 18, 3, -32 },
  { 3874, 3, 32, 9, 3, -32 },
  { 3886, 26, 22, 32, 3, -22 },
  { 3958, 14, 22, 20, 3, -22 },
  { 3997, 16, 22, 21, 2, -22 },
  { 4041, 15, 31, 20, 3, -22 },
  { 4100, 15, 31, 21, 2, -22 },
  { 4159, 9, 22, 13, 3, -22 },
  { 4184, 14, 22, 19, 2, -22 },
  { 4223, 10, 28, 12, 1, -28 },
  { 4258, 14, 22, 20, 3, -22 },
  { 4297, 16, 22, 18, 1, -22 },
  { 4341, 25, 22, 27, 1, -22 },
  { 4410, 16, 22, 18, 1, -22 },
  { 4454, 16, 31, 18, 1, -22 },
  { 4516, 15, 22, 18, 2, -22 },
  { 4558, 10, 41, 13, 2, -33 },
  { 4610, 2, 36, 9, 4, -30 },
  { 4619, 10, 41, 13, 1, -33 },
  { 4671, 19, 8, 25, 3, -17 },
};

const GFXfont RobotoCondensed_Light42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_LIGHT42PT7B_H_
