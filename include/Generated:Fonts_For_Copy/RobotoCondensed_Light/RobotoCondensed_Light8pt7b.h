#ifndef _ROBOTOCONDENSED_LIGHT8PT7B_H_
#define _ROBOTOCONDENSED_LIGHT8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light8pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0xC0, 0x15, 0x76, 0x62, 0x0E, 0x23, 0x58, 0x45, 0xB8, 0x66,
  0xAC, 0x66, 0x45, 0xB7, 0xC0, 0xFE, 0x15, 0x56, 0x19, 0x00, 0x04, 0xF0,
  0x40, 0xC0, 0x00, 0x09, 0x25, 0x00, 0x76, 0xDA, 0xC0, 0x78, 0x69, 0x22,
  0x4E, 0x74, 0x8A, 0xC0, 0x22, 0x6A, 0xF0, 0xD3, 0x13, 0x80, 0x6F, 0xF0,
  0xE4, 0x94, 0x80, 0x76, 0xBA, 0xC0, 0x76, 0xB2, 0x40, 0x00, 0x08, 0x71,
  0x80, 0xC0, 0x45, 0x00, 0x54, 0xA0, 0x80, 0x39, 0x19, 0x69, 0xB6, 0xD4,
  0x0C, 0x02, 0x65, 0xB8, 0xD6, 0xFA, 0xC0, 0xD6, 0x49, 0xC0, 0xD6, 0xDA,
  0x80, 0xF2, 0x48, 0x80, 0xF2, 0x48, 0x00, 0xF2, 0x7B, 0xC0, 0x16, 0xFA,
  0x00, 0x78, 0x04, 0x9B, 0xC0, 0x3A, 0x6C, 0x40, 0x2A, 0x80, 0x09, 0x9B,
  0xF4, 0x16, 0xFA, 0x40, 0xD6, 0xDB, 0xC0, 0xD6, 0xE8, 0x00, 0x69, 0x99,
  0x97, 0x10, 0xD6, 0xEA, 0x40, 0x69, 0x42, 0x97, 0xF2, 0x22, 0x20, 0x16,
  0xDB, 0xC0, 0x89, 0x56, 0x62, 0x86, 0x5B, 0x5D, 0x49, 0x20, 0x95, 0x22,
  0x69, 0x99, 0x62, 0x20, 0xF2, 0x24, 0x4A, 0xFE, 0x91, 0x24, 0x00, 0xFE,
  0x48, 0x00, 0x40, 0x00, 0x6E, 0xF0, 0x2F, 0xF0, 0xD2, 0x70, 0x0E, 0xDA,
  0xC0, 0xF6, 0x20, 0x55, 0x40, 0xF6, 0xB2, 0xC0, 0x2F, 0xC0, 0x18, 0x1F,
  0x2E, 0x90, 0x78, 0xFD, 0x6A, 0x10, 0xFC, 0xF9, 0x96, 0xFF, 0x80, 0xF6,
  0xB2, 0x00, 0xE0, 0xE8, 0xF0, 0x15, 0x00, 0x3F, 0x95, 0x20, 0xAD, 0x54,
  0xA0, 0x29, 0x10, 0x95, 0x25, 0x00, 0x69, 0x40, 0x56, 0x14, 0x7C, 0x15,
  0x14, 0x40,
};

const GFXglyph RobotoCondensed_Light8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 8, 4, 0, -7 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 0, -6 },
  { 17, 1, 8, 2, 1, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 4, 3, 0, -6 },
  { 22, 4, 4, 4, 0, -5 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 3, 6, 3, 0, -6 },
  { 30, 3, 6, 4, 0, -6 },
  { 33, 1, 6, 4, 1, -6 },
  { 34, 4, 6, 4, 0, -6 },
  { 37, 3, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 3, 6, 4, 1, -6 },
  { 46, 2, 6, 4, 1, -6 },
  { 48, 3, 6, 4, 0, -6 },
  { 51, 3, 6, 4, 0, -6 },
  { 54, 3, 6, 4, 0, -6 },
  { 57, 1, 4, 2, 0, -4 },
  { 58, 1, 5, 1, 0, -4 },
  { 59, 3, 3, 4, 0, -4 },
  { 61, 2, 2, 4, 1, -4 },
  { 62, 3, 3, 4, 0, -4 },
  { 64, 3, 6, 3, 0, -6 },
  { 67, 6, 8, 6, 0, -6 },
  { 73, 4, 6, 4, 0, -6 },
  { 76, 3, 6, 4, 1, -6 },
  { 79, 3, 6, 5, 1, -6 },
  { 82, 3, 6, 5, 1, -6 },
  { 85, 3, 6, 4, 1, -6 },
  { 88, 3, 6, 4, 1, -6 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 1, 6, 2, 0, -6 },
  { 98, 3, 6, 4, 0, -6 },
  { 101, 3, 6, 4, 1, -6 },
  { 104, 2, 6, 4, 1, -6 },
  { 106, 4, 6, 6, 1, -6 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 3, 6, 4, 1, -6 },
  { 118, 4, 7, 5, 0, -6 },
  { 122, 3, 6, 4, 1, -6 },
  { 125, 4, 6, 4, 0, -6 },
  { 128, 4, 6, 4, 0, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 4, 6, 4, 0, -6 },
  { 137, 6, 6, 6, 0, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 4, 6, 4, 0, -6 },
  { 148, 4, 6, 4, 0, -6 },
  { 151, 1, 8, 2, 1, -7 },
  { 152, 3, 6, 3, 0, -6 },
  { 155, 1, 8, 2, 0, -7 },
  { 156, 3, 3, 3, 0, -6 },
  { 158, 3, 1, 3, 0, 0 },
  { 159, 2, 1, 2, 0, -6 },
  { 160, 3, 4, 4, 0, -4 },
  { 162, 2, 6, 4, 1, -6 },
  { 164, 3, 4, 4, 0, -4 },
  { 166, 3, 6, 4, 0, -6 },
  { 169, 3, 4, 4, 0, -4 },
  { 171, 2, 6, 2, 0, -6 },
  { 173, 3, 6, 4, 0, -4 },
  { 176, 2, 6, 4, 1, -6 },
  { 178, 1, 6, 2, 0, -6 },
  { 179, 1, 8, 2, 0, -6 },
  { 180, 2, 6, 3, 1, -6 },
  { 182, 1, 6, 2, 0, -6 },
  { 183, 5, 4, 6, 1, -4 },
  { 186, 2, 4, 4, 1, -4 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 2, 6, 4, 1, -4 },
  { 191, 3, 6, 4, 0, -4 },
  { 194, 1, 4, 2, 1, -4 },
  { 195, 3, 4, 4, 0, -4 },
  { 197, 2, 5, 2, 0, -5 },
  { 199, 2, 4, 4, 1, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 5, 4, 5, 0, -4 },
  { 205, 3, 4, 3, 0, -4 },
  { 207, 3, 6, 3, 0, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 2, 8, 2, 0, -6 },
  { 214, 1, 7, 2, 0, -6 },
  { 215, 2, 8, 2, 0, -6 },
  { 217, 3, 1, 5, 1, -3 },
};

const GFXfont RobotoCondensed_Light8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_LIGHT8PT7B_H_
