#ifndef _ROBOTOCONDENSED_EXTRALIGHT64PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight64pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xD8, 0x00, 0x00, 0x00, 0x7F, 0xD0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x30, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xC0,
  0x01, 0xC3, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x38, 0x00,
  0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x70, 0x78, 0x03, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x04, 0x03, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x60, 0x03,
  0x00, 0x30, 0x30, 0x00, 0xE0, 0x18, 0x1C, 0x00, 0x18, 0x0E, 0x06, 0x00,
  0x03, 0x07, 0x03, 0x80, 0x00, 0xFF, 0x80, 0xC0, 0x00, 0x0F, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xF0, 0x00, 0x07, 0x03, 0xFE, 0x00,
  0x01, 0x81, 0xC1, 0xC0, 0x00, 0xC0, 0x60, 0x38, 0x00, 0x30, 0x30, 0x06,
  0x00, 0x18, 0x0C, 0x01, 0x80, 0x06, 0x07, 0x00, 0x30, 0x03, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x03, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x70, 0x10, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0,
  0x0C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x03, 0x80, 0x0C,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0xC3, 0x00, 0xE0, 0x06, 0x38, 0x03, 0x80, 0x31, 0x80, 0x0E, 0x01,
  0x9C, 0x00, 0x30, 0x1C, 0xC0, 0x01, 0xC0, 0xC6, 0x00, 0x07, 0x06, 0x30,
  0x00, 0x1C, 0x31, 0x80, 0x00, 0xE3, 0x8C, 0x00, 0x03, 0x98, 0x60, 0x00,
  0x0F, 0xC3, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x07, 0x60, 0x70, 0x00, 0xF3, 0x81,
  0xE0, 0x0F, 0x0E, 0x07, 0xFF, 0xE0, 0x38, 0x1F, 0xFE, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xDB, 0x6C, 0x00, 0x10, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x40, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0xFC,
  0x06, 0x07, 0xDF, 0xC3, 0x0F, 0xC1, 0xF9, 0xBF, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x04, 0x00,
  0x10, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE7, 0x18, 0x60, 0xFF, 0xFF, 0xFF, 0xC0,
  0xEF, 0xF6, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x0E,
  0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x18, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0xF0, 0x1E, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xF7, 0x1F, 0x1F, 0xF0, 0x7F,
  0x01, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x00,
  0x70, 0x38, 0x00, 0x30, 0x70, 0x00, 0x38, 0x60, 0x00, 0x18, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70, 0x00,
  0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0x70,
  0x00, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x61, 0xFC, 0x00, 0xCF,
  0xFE, 0x01, 0xFC, 0x3F, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x18, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x70,
  0x07, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x7F, 0x00, 0x61, 0xFF, 0xC0, 0xE7, 0xE3, 0xE0, 0xEF, 0x00, 0x70, 0xEC,
  0x00, 0x38, 0xD8, 0x00, 0x18, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x03,
  0xF7, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x1F, 0x00, 0xE0, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x06, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x80, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x0F, 0x87, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x03, 0x83,
  0x80, 0x00, 0xE1, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x07, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x83, 0x80,
  0x03, 0x80, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x30, 0x00, 0x0F, 0x38, 0x00, 0x1B, 0x1C, 0x00, 0x1B, 0x1C,
  0x00, 0x33, 0x0F, 0x00, 0xE7, 0x07, 0xC3, 0xC7, 0x03, 0xFF, 0x86, 0x00,
  0xFE, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x60, 0x3C, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x39, 0xC6, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0xC3, 0x80,
  0x1C, 0xE0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x38, 0x00, 0x0F, 0x80, 0x03, 0x06, 0x00,
  0x07, 0xFC, 0x00, 0x31, 0xC0, 0x03, 0xC3, 0xC0, 0x06, 0x30, 0x00, 0xE0,
  0x1C, 0x00, 0xC6, 0x00, 0x18, 0x01, 0x80, 0x19, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xB0, 0x01, 0xC0, 0x06, 0x00, 0x36, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xD8, 0x01, 0x80, 0x07, 0x00, 0x1F, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x78, 0x01, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x60, 0x01, 0xE0, 0x06, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x18, 0x00, 0x30, 0x00,
  0xF0, 0x03, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0,
  0x0C, 0x00, 0x18, 0x00, 0x78, 0x01, 0x80, 0x03, 0x00, 0x1B, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x60, 0x06, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0xC0, 0x03,
  0x80, 0x0D, 0x80, 0x18, 0x00, 0xF0, 0x03, 0x38, 0x03, 0x00, 0x1E, 0x00,
  0x63, 0x00, 0x70, 0x06, 0xC0, 0x18, 0x60, 0x06, 0x01, 0x9C, 0x03, 0x0C,
  0x00, 0xE0, 0x71, 0x80, 0xC1, 0xC0, 0x0F, 0x7C, 0x3C, 0x70, 0x18, 0x00,
  0xFF, 0x03, 0xFC, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x01, 0xF8, 0x18, 0x00, 0x1E, 0x0C,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x0E, 0x0C, 0x00, 0x3E, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0x80,
  0x01, 0xE0, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x18, 0x00, 0x7E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x0F,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x7E, 0x03, 0x00, 0x03, 0xE0,
  0xC0, 0x00, 0x3C, 0x30, 0x00, 0x07, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x1E,
  0x30, 0x00, 0x0F, 0x0C, 0x00, 0x0F, 0x83, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x06, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC3, 0x80, 0x0F, 0x07, 0x80,
  0x78, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x0C,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x60,
  0x01, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x07, 0x00,
  0x06, 0x01, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87, 0x80, 0x00,
  0x31, 0xF8, 0x00, 0x06, 0x73, 0x80, 0x00, 0xDC, 0x70, 0x00, 0x1F, 0x07,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x0C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1B, 0xD8, 0x00, 0x00, 0x01, 0xBD, 0xC0, 0x00, 0x00, 0x3B, 0xCC,
  0x00, 0x00, 0x03, 0x3C, 0xC0, 0x00, 0x00, 0x73, 0xCE, 0x00, 0x00, 0x07,
  0x3C, 0x60, 0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0x0E, 0x3C, 0x70, 0x00,
  0x00, 0xC3, 0xC3, 0x00, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0x01, 0xC3, 0xC3,
  0x80, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x00, 0x38,
  0x3C, 0x1C, 0x00, 0x03, 0x03, 0xC0, 0xC0, 0x00, 0x30, 0x3C, 0x0E, 0x00,
  0x07, 0x03, 0xC0, 0x60, 0x00, 0x60, 0x3C, 0x06, 0x00, 0x0E, 0x03, 0xC0,
  0x70, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0x0C, 0x03, 0xC0, 0x30, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x3C, 0x01, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x30, 0x03, 0xC0,
  0x0C, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x60, 0x03, 0xC0, 0x06, 0x06, 0x00,
  0x3C, 0x00, 0x70, 0xE0, 0x03, 0xC0, 0x03, 0x0C, 0x00, 0x3C, 0x00, 0x30,
  0xC0, 0x03, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0x00, 0x19, 0x80, 0x03, 0xC0,
  0x01, 0xB8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7D, 0x80, 0x00, 0x07, 0xDC,
  0x00, 0x00, 0x7C, 0xC0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x7C, 0x60, 0x00,
  0x07, 0xC7, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x07, 0xC1, 0x80, 0x00, 0x7C,
  0x1C, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0xC0, 0x60,
  0x00, 0x7C, 0x07, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x7C, 0x01, 0x80, 0x07,
  0xC0, 0x1C, 0x00, 0x7C, 0x00, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00,
  0x60, 0x07, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0x38, 0x07, 0xC0, 0x03, 0x80,
  0x7C, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0xC0, 0x7C, 0x00, 0x0E, 0x07, 0xC0,
  0x00, 0x60, 0x7C, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x38, 0x7C, 0x00, 0x03,
  0x87, 0xC0, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x0E, 0x7C,
  0x00, 0x00, 0x67, 0xC0, 0x00, 0x07, 0x7C, 0x00, 0x00, 0x37, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00,
  0x78, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x30, 0x00, 0xFC, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x0E, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x78, 0xC0, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x3F, 0x03, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x83,
  0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0C, 0x00, 0x38,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0E, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x66, 0x00, 0x00, 0x78,
  0x00, 0x01, 0x98, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x07,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60,
  0x70, 0x00, 0x61, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x38,
  0x00, 0xC0, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x1C, 0x03, 0x80,
  0x18, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x70, 0x06, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x30,
  0x03, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x38, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x60, 0x01,
  0x81, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x1C,
  0x18, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xE6, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x98, 0x00, 0x06, 0x70, 0x00,
  0x06, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x70, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0x60, 0x00, 0xDC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x06, 0x38,
  0x03, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x70, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xE0, 0xE0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0xC7, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x70, 0x07, 0x81, 0xC0,
  0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x60, 0x00,
  0x1C, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0x00, 0x30, 0xF0, 0x00, 0x63, 0x80, 0x00, 0xCE,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0,
  0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x98, 0x00, 0x1B, 0x38, 0x00, 0x66, 0x38, 0x03, 0x8C, 0x3F, 0xFE,
  0x18, 0x3F, 0xF8, 0x38, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xF0, 0x0C, 0x3F, 0xF8,
  0x31, 0xFF, 0xF0, 0xCE, 0x01, 0xE3, 0x60, 0x01, 0xCF, 0x00, 0x03, 0x3C,
  0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B,
  0x80, 0x00, 0x6E, 0x00, 0x03, 0xBC, 0x00, 0x0C, 0xD8, 0x00, 0x73, 0x38,
  0x07, 0x8C, 0x7F, 0xFC, 0x30, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xC0, 0x03,
  0x87, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x77, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8E, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x70, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x03, 0xE0, 0x30, 0x7F, 0xF0, 0xC3,
  0xFF, 0xE3, 0x1E, 0x01, 0xCC, 0xE0, 0x01, 0xB3, 0x00, 0x03, 0xDC, 0x00,
  0x0F, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x77, 0x00, 0x01, 0xCC, 0x00, 0x0F, 0x38, 0x00, 0x6C, 0x78, 0x07,
  0x30, 0xFF, 0xF8, 0xC1, 0xFF, 0xC3, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xC0, 0x03, 0x83,
  0x00, 0x03, 0x0E, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x02, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x38, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x30, 0xFF, 0xF8, 0xC7, 0x80,
  0x73, 0x38, 0x00, 0x6C, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xD8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0xC0, 0x00,
  0x73, 0x00, 0x03, 0xCE, 0x00, 0x1B, 0x1E, 0x01, 0xCC, 0x3F, 0xFE, 0x30,
  0x7F, 0xF0, 0xC0, 0x3E, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x03,
  0x8E, 0x00, 0x0C, 0x1C, 0x00, 0xF0, 0x3E, 0x0F, 0x80, 0x7F, 0xF8, 0x00,
  0x3F, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x1E, 0x03, 0x07, 0xFE, 0x18, 0x7F, 0xF8, 0xC7, 0x01, 0xE6, 0x60,
  0x03, 0x36, 0x00, 0x1D, 0xB0, 0x00, 0x6F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x87, 0x9F, 0xE1, 0xF0, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0, 0x01, 0xC6, 0x00, 0x1C, 0x30,
  0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0xE0, 0x60, 0x0E, 0x03, 0x00, 0xE0,
  0x18, 0x0E, 0x00, 0xC0, 0xE0, 0x06, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0x87,
  0x00, 0x0C, 0x70, 0x00, 0x67, 0xC0, 0x03, 0x7E, 0x00, 0x1F, 0x38, 0x00,
  0xF0, 0xE0, 0x07, 0x03, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x60, 0x0E, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x07, 0x06,
  0x00, 0x1C, 0x30, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x60, 0x00,
  0x3B, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0xC3, 0xFF,
  0xC0, 0xFF, 0xF8, 0xCE, 0x01, 0xE1, 0xC0, 0x3C, 0xCC, 0x00, 0xE3, 0x80,
  0x1C, 0xD8, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x00, 0x36, 0x00, 0x06, 0xF0,
  0x00, 0x3C, 0x00, 0x06, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x3C, 0x06, 0x0F, 0xFC,
  0x30, 0xFF, 0xF1, 0x8E, 0x03, 0xCC, 0xC0, 0x06, 0x6C, 0x00, 0x3B, 0x60,
  0x00, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x38, 0x00, 0x01,
  0x9C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x78, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0x0F,
  0xFE, 0x0C, 0x7F, 0xFC, 0x33, 0x80, 0x78, 0xD8, 0x00, 0x73, 0xC0, 0x00,
  0xCF, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEF, 0x00, 0x03, 0x36, 0x00, 0x1C,
  0xCE, 0x01, 0xE3, 0x1F, 0xFF, 0x0C, 0x3F, 0xF8, 0x30, 0x1F, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xFC, 0x30, 0xFF, 0xF8, 0xC7, 0x80, 0x73, 0x38, 0x00, 0x6C, 0xE0, 0x00,
  0xF7, 0x00, 0x03, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x00, 0x03, 0xCE, 0x00, 0x1B,
  0x1E, 0x01, 0xCC, 0x3F, 0xFE, 0x30, 0x7F, 0xF0, 0xC0, 0x3E, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x7E, 0x1F, 0xF1,
  0xFF, 0x9C, 0x0D, 0xC0, 0x6C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0x00, 0x78, 0x38, 0x00, 0x70, 0xC0, 0x00, 0xC7, 0x00, 0x03,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x67, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x67, 0x00, 0x03, 0x8E, 0x00, 0x1C, 0x1C, 0x00, 0xF0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x07, 0xB8,
  0x00, 0x7C, 0xE0, 0x07, 0x67, 0x80, 0x73, 0x1F, 0xFF, 0x18, 0x7F, 0xF0,
  0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B,
  0x00, 0x00, 0x67, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x38, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xE0,
  0x03, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x18, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xE1, 0x80,
  0x00, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x07, 0x70, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1B, 0x00, 0x03,
  0x80, 0x01, 0xDC, 0x00, 0x1E, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0x00, 0x63,
  0x00, 0x07, 0x80, 0x03, 0x18, 0x00, 0x7C, 0x00, 0x38, 0xE0, 0x03, 0x70,
  0x01, 0xC7, 0x00, 0x19, 0x80, 0x0C, 0x18, 0x00, 0xCC, 0x00, 0x60, 0xC0,
  0x0E, 0x70, 0x03, 0x07, 0x00, 0x63, 0x80, 0x38, 0x38, 0x03, 0x0C, 0x01,
  0xC0, 0xC0, 0x38, 0x60, 0x0C, 0x06, 0x01, 0x83, 0x80, 0x60, 0x30, 0x0C,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0x60, 0x38, 0x06, 0x07, 0x03, 0x01, 0x80,
  0x30, 0x30, 0x1C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0xE0, 0x0E, 0x0C, 0x03,
  0x07, 0x00, 0x30, 0xE0, 0x18, 0x30, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x0C,
  0x30, 0x03, 0x1C, 0x00, 0x71, 0x80, 0x18, 0xE0, 0x01, 0x98, 0x00, 0xC6,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0xDC, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0x80, 0x0E,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x60, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x00,
  0x06, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x1D, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x60,
  0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x03, 0x01, 0xC0, 0x07, 0x03, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x0C,
  0x70, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38,
  0x18, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x06, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x81, 0x80,
  0x01, 0x83, 0x80, 0x01, 0x83, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xCF, 0x3E, 0x00, 0x0E, 0xE0, 0x78,
  0x00, 0x66, 0x00, 0xE0, 0x03, 0x70, 0x03, 0x80, 0x1B, 0x00, 0x0E, 0x01,
  0xD8, 0x00, 0x78, 0x1C, 0xC0, 0x00, 0xF1, 0xC6, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 47, 13, 5, -46 },
  { 19, 9, 13, 17, 5, -48 },
  { 34, 30, 46, 32, 2, -46 },
  { 207, 23, 60, 31, 4, -53 },
  { 380, 34, 48, 41, 4, -47 },
  { 584, 29, 48, 34, 4, -47 },
  { 758, 3, 13, 11, 4, -48 },
  { 763, 13, 66, 18, 4, -51 },
  { 871, 13, 66, 18, 1, -51 },
  { 979, 25, 25, 27, 1, -46 },
  { 1058, 26, 32, 32, 3, -37 },
  { 1162, 6, 13, 12, 2, -5 },
  { 1172, 13, 2, 17, 2, -21 },
  { 1176, 4, 4, 14, 5, -3 },
  { 1178, 18, 50, 22, 2, -46 },
  { 1291, 23, 48, 31, 4, -47 },
  { 1429, 14, 46, 31, 5, -46 },
  { 1510, 24, 47, 31, 4, -47 },
  { 1651, 24, 48, 31, 3, -47 },
  { 1795, 27, 46, 31, 3, -46 },
  { 1951, 23, 47, 31, 5, -46 },
  { 2087, 24, 47, 31, 4, -46 },
  { 2228, 25, 46, 31, 3, -46 },
  { 2372, 25, 48, 31, 3, -47 },
  { 2522, 24, 47, 31, 3, -47 },
  { 2663, 4, 33, 12, 4, -32 },
  { 2680, 6, 40, 11, 2, -32 },
  { 2710, 22, 26, 29, 3, -34 },
  { 2782, 22, 14, 31, 5, -28 },
  { 2821, 22, 26, 29, 4, -34 },
  { 2893, 19, 48, 25, 3, -47 },
  { 3007, 43, 58, 51, 4, -44 },
  { 3319, 32, 46, 34, 1, -46 },
  { 3503, 25, 46, 34, 6, -46 },
  { 3647, 28, 48, 36, 4, -47 },
  { 3815, 26, 46, 37, 6, -46 },
  { 3965, 23, 46, 32, 6, -46 },
  { 4098, 23, 46, 32, 6, -46 },
  { 4231, 28, 48, 38, 5, -47 },
  { 4399, 28, 46, 39, 6, -46 },
  { 4560, 2, 46, 15, 7, -46 },
  { 4572, 22, 47, 31, 3, -46 },
  { 4702, 27, 46, 35, 6, -46 },
  { 4858, 21, 46, 29, 6, -46 },
  { 4979, 36, 46, 48, 6, -46 },
  { 5186, 28, 46, 40, 6, -46 },
  { 5347, 29, 48, 38, 4, -47 },
  { 5521, 25, 46, 34, 6, -46 },
  { 5665, 29, 55, 38, 4, -47 },
  { 5865, 26, 46, 36, 6, -46 },
  { 6015, 27, 48, 33, 3, -47 },
  { 6177, 30, 46, 34, 2, -46 },
  { 6350, 27, 47, 37, 5, -46 },
  { 6509, 32, 46, 34, 1, -46 },
  { 6693, 46, 46, 50, 2, -46 },
  { 6958, 30, 46, 34, 2, -46 },
  { 7131, 31, 46, 34, 1, -46 },
  { 7310, 28, 46, 34, 3, -46 },
  { 7471, 8, 62, 14, 5, -52 },
  { 7533, 18, 50, 22, 2, -46 },
  { 7646, 8, 62, 14, 1, -52 },
  { 7708, 18, 23, 24, 3, -46 },
  { 7760, 22, 2, 24, 1, 0 },
  { 7766, 9, 8, 17, 4, -48 },
  { 7775, 23, 36, 30, 3, -35 },
  { 7879, 22, 49, 31, 5, -48 },
  { 8014, 23, 36, 29, 3, -35 },
  { 8118, 22, 49, 31, 4, -48 },
  { 8253, 23, 36, 29, 3, -35 },
  { 8357, 17, 49, 19, 2, -49 },
  { 8462, 22, 48, 31, 4, -35 },
  { 8594, 21, 48, 31, 5, -48 },
  { 8720, 3, 46, 13, 5, -46 },
  { 8738, 11, 59, 13, -3, -46 },
  { 8820, 21, 48, 27, 5, -48 },
  { 8946, 3, 48, 13, 5, -48 },
  { 8964, 40, 35, 49, 5, -35 },
  { 9139, 21, 35, 31, 5, -35 },
  { 9231, 25, 36, 31, 3, -35 },
  { 9344, 22, 48, 31, 5, -35 },
  { 9476, 22, 48, 31, 4, -35 },
  { 9608, 13, 35, 19, 5, -35 },
  { 9665, 22, 36, 28, 3, -35 },
  { 9764, 15, 44, 18, 1, -43 },
  { 9847, 21, 35, 31, 5, -34 },
  { 9939, 23, 34, 27, 2, -34 },
  { 10037, 37, 34, 42, 2, -34 },
  { 10195, 23, 34, 27, 2, -34 },
  { 10293, 24, 47, 27, 2, -34 },
  { 10434, 22, 34, 27, 3, -34 },
  { 10528, 16, 63, 19, 2, -50 },
  { 10654, 2, 54, 13, 6, -46 },
  { 10668, 15, 63, 19, 1, -50 },
  { 10787, 29, 11, 38, 5, -25 },
};

const GFXfont RobotoCondensed_ExtraLight64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT64PT7B_H_
