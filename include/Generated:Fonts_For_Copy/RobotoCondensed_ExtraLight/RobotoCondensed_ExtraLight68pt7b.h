#ifndef _ROBOTOCONDENSED_EXTRALIGHT68PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight68pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0xFF, 0x60, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x60, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x0F,
  0x03, 0x80, 0x03, 0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x1C, 0x60, 0x00, 0x06, 0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x03, 0x8F, 0x00, 0x03, 0x83, 0xC0, 0x03, 0xC0, 0xF8, 0x07, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x10, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x60,
  0x00, 0x70, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0xC0, 0x00, 0x1F, 0xF0,
  0x1C, 0x00, 0x00, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x01,
  0x80, 0xFF, 0x80, 0x00, 0x38, 0x1C, 0x1C, 0x00, 0x03, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x30, 0x06, 0x00, 0x06, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x60,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x07, 0x00, 0x80,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0xC0, 0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x01, 0x87, 0x00, 0xE0, 0x07, 0x0C, 0x00, 0xE0,
  0x0E, 0x38, 0x00, 0xE0, 0x1C, 0x60, 0x00, 0xE0, 0x39, 0xC0, 0x01, 0xC0,
  0x63, 0x80, 0x01, 0xC0, 0xC6, 0x00, 0x01, 0xC3, 0x8C, 0x00, 0x03, 0x87,
  0x18, 0x00, 0x03, 0x8C, 0x30, 0x00, 0x03, 0xB8, 0x60, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x3F, 0x03, 0x80, 0x00, 0xEE, 0x07, 0x80, 0x07, 0x8E, 0x07,
  0xC0, 0x3E, 0x0E, 0x07, 0xFF, 0xF8, 0x0E, 0x03, 0xFF, 0xC0, 0x1C, 0x00,
  0x78, 0x00, 0x00, 0x6D, 0xB7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x08, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x3B, 0xF0, 0x38,
  0x1F, 0xBF, 0xC7, 0x1F, 0xC0, 0xFE, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0xC6, 0x31, 0x8C, 0xE7, 0x39, 0x9D, 0xCE, 0x20, 0xFF, 0xFF, 0xFF, 0xC0,
  0x2F, 0xFF, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x18,
  0x00, 0x03, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x30, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0,
  0x1F, 0xC1, 0xFF, 0x1F, 0x1F, 0xF0, 0x7F, 0x01, 0xF0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x38,
  0x0F, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0xC0,
  0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x1C,
  0x00, 0x07, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0xFE, 0x00, 0x73, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7C, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x70, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x0C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x0F, 0x00,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x18, 0x3F, 0xF8, 0x0C, 0x7F, 0x7F,
  0x06, 0x78, 0x03, 0xC7, 0x70, 0x00, 0xE3, 0xF0, 0x00, 0x39, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x03,
  0x81, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x0C, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x1F,
  0xDF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x78, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x38, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x60, 0x00, 0x07, 0xB8, 0x00, 0x07,
  0xCC, 0x00, 0x07, 0xE7, 0x00, 0x03, 0x71, 0xC0, 0x07, 0x30, 0x78, 0x07,
  0x98, 0x1F, 0xBF, 0x0C, 0x07, 0xFF, 0x06, 0x00, 0xFE, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x23, 0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xF7, 0xFE, 0xE0,
  0x08, 0x78, 0xF9, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x70,
  0xE1, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xC0,
  0x01, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0x07, 0x00, 0x03,
  0xFF, 0x00, 0x0E, 0x18, 0x00, 0x1E, 0x1E, 0x00, 0x18, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x63, 0x80, 0x07, 0x00, 0x30, 0x01, 0x8C, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0D, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x37, 0x00, 0x18, 0x00, 0x30, 0x00, 0xD8, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0D, 0x80, 0x0C, 0x00, 0x1C, 0x00,
  0x3E, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0xE0, 0x07, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3C,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x06, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3C, 0x00,
  0x60, 0x00, 0x60, 0x01, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x06, 0xC0, 0x06,
  0x00, 0x0E, 0x00, 0x1B, 0x80, 0x18, 0x00, 0x38, 0x00, 0x6E, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xB8, 0x01, 0x80, 0x07, 0x80, 0x0C, 0x60, 0x06, 0x00,
  0x1E, 0x00, 0x31, 0x80, 0x1C, 0x00, 0xD8, 0x01, 0xC6, 0x00, 0x30, 0x03,
  0x60, 0x06, 0x1C, 0x00, 0xE0, 0x19, 0xC0, 0x30, 0x70, 0x03, 0xC0, 0xC3,
  0x81, 0xC0, 0xC0, 0x07, 0xFE, 0x0F, 0xBE, 0x03, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x1F, 0xE0, 0x70, 0x00, 0x3E, 0x0E,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x07, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x7C, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x8E, 0x00, 0x01, 0xE1, 0xC0, 0x07, 0xF8, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07,
  0x80, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xE0, 0x07, 0xF8, 0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1F,
  0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x3E, 0x00,
  0x00, 0x39, 0xFC, 0x00, 0x00, 0xE7, 0x38, 0x00, 0x03, 0xB8, 0xE0, 0x00,
  0x0F, 0xC1, 0xC0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFD, 0x80, 0x00, 0x00, 0x03, 0xFB, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0x00,
  0x00, 0x00, 0x1B, 0xE6, 0x00, 0x00, 0x00, 0x37, 0xCE, 0x00, 0x00, 0x00,
  0xEF, 0x9C, 0x00, 0x00, 0x01, 0x9F, 0x18, 0x00, 0x00, 0x07, 0x3E, 0x38,
  0x00, 0x00, 0x0E, 0x7C, 0x70, 0x00, 0x00, 0x18, 0xF8, 0x60, 0x00, 0x00,
  0x71, 0xF0, 0xE0, 0x00, 0x00, 0xE3, 0xF0, 0xC0, 0x00, 0x01, 0x87, 0xE1,
  0x80, 0x00, 0x07, 0x0F, 0xC3, 0x80, 0x00, 0x0C, 0x1F, 0x83, 0x00, 0x00,
  0x18, 0x3F, 0x07, 0x00, 0x00, 0x70, 0x7E, 0x0E, 0x00, 0x00, 0xC0, 0xFC,
  0x0C, 0x00, 0x03, 0x81, 0xF8, 0x1C, 0x00, 0x07, 0x03, 0xF0, 0x38, 0x00,
  0x0C, 0x07, 0xE0, 0x30, 0x00, 0x38, 0x0F, 0xC0, 0x70, 0x00, 0x70, 0x1F,
  0x80, 0x60, 0x00, 0xC0, 0x3F, 0x00, 0xC0, 0x03, 0x80, 0x7E, 0x01, 0xC0,
  0x06, 0x00, 0xFC, 0x01, 0x80, 0x0C, 0x01, 0xF8, 0x03, 0x80, 0x38, 0x03,
  0xF0, 0x07, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0xC0, 0x0F, 0xC0, 0x0E,
  0x03, 0x80, 0x1F, 0x80, 0x1C, 0x06, 0x00, 0x3F, 0x00, 0x18, 0x1C, 0x00,
  0x7E, 0x00, 0x38, 0x38, 0x00, 0xFC, 0x00, 0x30, 0x60, 0x01, 0xF8, 0x00,
  0x61, 0xC0, 0x03, 0xF0, 0x00, 0xE3, 0x00, 0x07, 0xE0, 0x00, 0xC6, 0x00,
  0x0F, 0xC0, 0x01, 0x9C, 0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00, 0x3F, 0x00,
  0x03, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0xC0, 0x00,
  0x01, 0xFB, 0x80, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x1F, 0x9C, 0x00, 0x00,
  0x7E, 0x38, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x1F,
  0x83, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x01, 0xF8, 0x1C, 0x00, 0x07, 0xE0,
  0x70, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x7E, 0x03, 0x80, 0x01, 0xF8, 0x07,
  0x00, 0x07, 0xE0, 0x0C, 0x00, 0x1F, 0x80, 0x38, 0x00, 0x7E, 0x00, 0x70,
  0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x0E, 0x00,
  0x7E, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0x30, 0x07, 0xE0, 0x00, 0xE0, 0x1F,
  0x80, 0x01, 0xC0, 0x7E, 0x00, 0x07, 0x01, 0xF8, 0x00, 0x0E, 0x07, 0xE0,
  0x00, 0x18, 0x1F, 0x80, 0x00, 0x70, 0x7E, 0x00, 0x00, 0xE1, 0xF8, 0x00,
  0x03, 0x87, 0xE0, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x1C, 0x7E, 0x00, 0x00,
  0x39, 0xF8, 0x00, 0x00, 0x67, 0xE0, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x03, 0x80, 0x0F, 0xF0, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x7F, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x03, 0xFC, 0x0C, 0x00, 0x03, 0xE0,
  0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xF0, 0xC0, 0x00,
  0x1E, 0x0C, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x78, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x18, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x18, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x03,
  0x80, 0x01, 0xC3, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x70, 0x00, 0x70,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x18,
  0x07, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x03, 0x80, 0x0E,
  0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x03, 0x00,
  0x60, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x18,
  0x0C, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x00, 0xC1, 0xC0, 0x00,
  0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x60, 0x00,
  0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x38, 0x00,
  0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0x80,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xCE, 0x00, 0x18, 0xC0, 0x07, 0x18,
  0x00, 0xC3, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC0, 0xE0, 0x18, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x38, 0x18, 0x03, 0x07, 0x00, 0x70, 0xC0, 0x0E,
  0x18, 0x00, 0xC7, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x0C,
  0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0xE0, 0x06, 0x1F, 0x00, 0x06, 0x3C, 0x00, 0x06,
  0x38, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x1F, 0x70, 0x00, 0x37, 0x38, 0x00, 0x77,
  0x3C, 0x01, 0xE7, 0x1F, 0xFF, 0x87, 0x07, 0xFF, 0x03, 0x01, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0xE1, 0xFF, 0xC0,
  0xE3, 0xFF, 0xE0, 0xE7, 0x00, 0xF0, 0xEC, 0x00, 0x38, 0xF8, 0x00, 0x1C,
  0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0xFC, 0x00, 0x38,
  0xEF, 0x00, 0xF0, 0xE7, 0xFF, 0xE0, 0xE1, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x0F,
  0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x60, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0xE0,
  0x1E, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x07, 0x03, 0xFF, 0x87, 0x07,
  0xFF, 0xC7, 0x0F, 0x00, 0xE7, 0x1C, 0x00, 0x37, 0x38, 0x00, 0x1F, 0x38,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x37, 0x0F,
  0x00, 0xF7, 0x07, 0xFF, 0xE7, 0x03, 0xFF, 0x87, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x30, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x02, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0x87, 0x07, 0xFF, 0xC7, 0x1F, 0x00, 0xE7, 0x1C, 0x00, 0x37, 0x38, 0x00,
  0x1F, 0x38, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x1C, 0x00,
  0x37, 0x0F, 0x00, 0xF7, 0x07, 0xFF, 0xE7, 0x03, 0xFF, 0x87, 0x00, 0x7C,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x1C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x07, 0xE7, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x70,
  0x7F, 0xE0, 0xE1, 0xFF, 0xE1, 0xC7, 0x01, 0xE3, 0x98, 0x00, 0xE7, 0x60,
  0x01, 0xCF, 0xC0, 0x01, 0xDF, 0x00, 0x03, 0xBC, 0x00, 0x03, 0x78, 0x00,
  0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0xEF, 0xF6, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x3C, 0xDF, 0x8F, 0xF0, 0x7C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE3, 0x80,
  0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0,
  0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00,
  0x77, 0xC0, 0x00, 0xEF, 0xC0, 0x01, 0xF9, 0xC0, 0x03, 0xE1, 0xC0, 0x07,
  0x83, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x18, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x63, 0xC0, 0x78, 0x3C, 0x07, 0x8C, 0xE0, 0x03, 0x8E,
  0x00, 0x39, 0xD8, 0x00, 0x73, 0x80, 0x07, 0x3E, 0x00, 0x07, 0x60, 0x00,
  0x77, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xDE,
  0x00, 0x01, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x38, 0x00, 0x03, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0x01, 0xC1, 0xFF, 0x83,
  0x87, 0xFF, 0x87, 0x1C, 0x07, 0x8E, 0x60, 0x03, 0x9D, 0x80, 0x07, 0x3F,
  0x00, 0x07, 0x7C, 0x00, 0x0E, 0xF0, 0x00, 0x0D, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x30, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF,
  0xE0, 0xE7, 0x00, 0xF0, 0xEC, 0x00, 0x38, 0xF8, 0x00, 0x1C, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0xFC, 0x00, 0x38, 0xEF, 0x00,
  0xF0, 0xE7, 0xFF, 0xE0, 0xE1, 0xFF, 0xC0, 0xE0, 0x3E, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x87, 0x0F, 0xFF, 0xC7, 0x1F, 0x00,
  0xE7, 0x1C, 0x00, 0x37, 0x38, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x0F, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x3F, 0x0F, 0x00, 0xF7, 0x07, 0xFF,
  0xE7, 0x03, 0xFF, 0x87, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x3F,
  0x87, 0xFE, 0x3F, 0xF9, 0xC0, 0xEE, 0x03, 0xB0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0x00, 0x78, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8, 0x00,
  0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x39, 0xE0, 0x01,
  0xE3, 0xC0, 0x0F, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x76, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00,
  0x0F, 0x9C, 0x00, 0x3F, 0x38, 0x00, 0xEE, 0x3C, 0x03, 0x9C, 0x3F, 0xFE,
  0x38, 0x3F, 0xF8, 0x70, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x1B, 0x80, 0x01,
  0xE0, 0x00, 0x73, 0x00, 0x03, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0xC0, 0x01,
  0xCE, 0x00, 0x0F, 0x80, 0x03, 0x1C, 0x00, 0x3B, 0x00, 0x06, 0x38, 0x00,
  0x66, 0x00, 0x1C, 0x30, 0x00, 0xCE, 0x00, 0x38, 0x70, 0x01, 0x9C, 0x00,
  0x60, 0xE0, 0x07, 0x18, 0x00, 0xC1, 0xC0, 0x0C, 0x30, 0x03, 0x81, 0x80,
  0x18, 0x70, 0x07, 0x03, 0x80, 0x70, 0xE0, 0x0C, 0x07, 0x00, 0xE0, 0xC0,
  0x18, 0x0E, 0x01, 0x81, 0x80, 0x70, 0x0C, 0x03, 0x03, 0x80, 0xE0, 0x1C,
  0x0E, 0x03, 0x01, 0x80, 0x38, 0x18, 0x06, 0x03, 0x00, 0x70, 0x30, 0x0E,
  0x0E, 0x00, 0x60, 0x60, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x01,
  0xC3, 0x00, 0x30, 0x60, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x03, 0x1C, 0x00,
  0x63, 0x80, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00,
  0x1C, 0xC0, 0x03, 0x98, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x36, 0x00,
  0x06, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x18, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x83, 0x00, 0x01,
  0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x18, 0x00, 0xE0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18,
  0x00, 0x70, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x07,
  0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18,
  0xE0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x9F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1C,
  0xFF, 0xF0, 0x00, 0x39, 0xC0, 0xF0, 0x00, 0x77, 0x00, 0xF0, 0x00, 0xCC,
  0x00, 0x70, 0x01, 0xB8, 0x00, 0x70, 0x07, 0x60, 0x00, 0x70, 0x1C, 0xC0,
  0x00, 0x7D, 0xF1, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 49, 13, 5, -48 },
  { 26, 10, 14, 18, 5, -51 },
  { 44, 31, 48, 34, 3, -48 },
  { 230, 25, 62, 33, 4, -55 },
  { 424, 36, 50, 44, 4, -49 },
  { 649, 31, 50, 36, 4, -49 },
  { 843, 3, 14, 11, 4, -51 },
  { 849, 13, 70, 19, 5, -54 },
  { 963, 12, 70, 19, 2, -54 },
  { 1068, 27, 27, 29, 1, -48 },
  { 1160, 28, 35, 34, 3, -40 },
  { 1283, 5, 14, 13, 3, -6 },
  { 1292, 13, 2, 18, 2, -23 },
  { 1296, 4, 5, 15, 5, -4 },
  { 1299, 19, 52, 24, 2, -48 },
  { 1423, 25, 50, 33, 4, -49 },
  { 1580, 14, 48, 33, 6, -48 },
  { 1664, 26, 49, 33, 4, -49 },
  { 1824, 26, 50, 33, 3, -49 },
  { 1987, 28, 48, 33, 3, -48 },
  { 2155, 24, 49, 33, 6, -48 },
  { 2302, 25, 49, 33, 4, -48 },
  { 2456, 26, 48, 33, 3, -48 },
  { 2612, 26, 50, 33, 4, -49 },
  { 2775, 25, 49, 33, 4, -49 },
  { 2929, 5, 36, 13, 4, -35 },
  { 2952, 7, 43, 12, 2, -35 },
  { 2990, 23, 28, 31, 3, -36 },
  { 3071, 23, 15, 33, 5, -30 },
  { 3115, 24, 28, 31, 4, -36 },
  { 3199, 21, 50, 27, 3, -49 },
  { 3331, 46, 62, 54, 4, -47 },
  { 3688, 33, 48, 36, 2, -48 },
  { 3886, 27, 48, 36, 6, -48 },
  { 4048, 29, 50, 39, 5, -49 },
  { 4230, 28, 48, 39, 6, -48 },
  { 4398, 25, 48, 34, 6, -48 },
  { 4548, 25, 48, 34, 6, -48 },
  { 4698, 30, 50, 41, 5, -49 },
  { 4886, 30, 48, 42, 6, -48 },
  { 5066, 3, 48, 16, 7, -48 },
  { 5084, 24, 49, 33, 3, -48 },
  { 5231, 30, 48, 38, 6, -48 },
  { 5411, 23, 48, 31, 6, -48 },
  { 5549, 39, 48, 51, 6, -48 },
  { 5783, 30, 48, 42, 6, -48 },
  { 5963, 30, 50, 40, 5, -49 },
  { 6151, 27, 48, 36, 6, -48 },
  { 6313, 31, 58, 40, 4, -49 },
  { 6538, 28, 48, 38, 6, -48 },
  { 6706, 29, 50, 35, 3, -49 },
  { 6888, 31, 48, 36, 2, -48 },
  { 7074, 28, 49, 39, 6, -48 },
  { 7246, 33, 48, 36, 2, -48 },
  { 7444, 49, 48, 53, 2, -48 },
  { 7738, 32, 48, 36, 2, -48 },
  { 7930, 33, 48, 36, 1, -48 },
  { 8128, 29, 48, 36, 3, -48 },
  { 8302, 9, 65, 14, 5, -55 },
  { 8376, 20, 52, 23, 2, -48 },
  { 8506, 8, 65, 14, 1, -55 },
  { 8571, 19, 24, 25, 3, -48 },
  { 8628, 24, 2, 26, 1, 0 },
  { 8634, 10, 9, 19, 4, -51 },
  { 8646, 24, 38, 32, 3, -37 },
  { 8760, 24, 52, 33, 5, -51 },
  { 8916, 25, 38, 31, 3, -37 },
  { 9035, 24, 52, 33, 4, -51 },
  { 9191, 25, 38, 31, 3, -37 },
  { 9310, 18, 52, 20, 2, -52 },
  { 9427, 24, 51, 33, 4, -37 },
  { 9580, 23, 51, 33, 5, -51 },
  { 9727, 4, 49, 14, 5, -49 },
  { 9752, 12, 63, 14, -3, -49 },
  { 9847, 23, 51, 29, 5, -51 },
  { 9994, 2, 51, 14, 6, -51 },
  { 10007, 43, 37, 53, 5, -37 },
  { 10206, 23, 37, 33, 5, -37 },
  { 10313, 25, 38, 33, 4, -37 },
  { 10432, 24, 51, 33, 5, -37 },
  { 10585, 24, 51, 33, 4, -37 },
  { 10738, 14, 37, 21, 5, -37 },
  { 10803, 22, 38, 30, 4, -37 },
  { 10908, 16, 46, 20, 1, -45 },
  { 11000, 23, 37, 33, 5, -36 },
  { 11107, 25, 36, 29, 2, -36 },
  { 11220, 39, 36, 45, 3, -36 },
  { 11396, 25, 36, 29, 2, -36 },
  { 11509, 25, 50, 29, 2, -36 },
  { 11666, 24, 36, 29, 3, -36 },
  { 11774, 16, 67, 20, 3, -53 },
  { 11908, 3, 57, 14, 6, -48 },
  { 11930, 16, 67, 20, 1, -53 },
  { 12064, 31, 11, 41, 5, -25 },
};

const GFXfont RobotoCondensed_ExtraLight68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT68PT7B_H_
