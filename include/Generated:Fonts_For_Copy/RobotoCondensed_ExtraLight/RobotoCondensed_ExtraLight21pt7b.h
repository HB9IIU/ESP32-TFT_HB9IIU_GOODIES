#ifndef _ROBOTOCONDENSED_EXTRALIGHT21PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight21pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x54, 0x04, 0x99, 0x99, 0x09, 0x08, 0x84, 0x42, 0x2F,
  0xF8, 0x90, 0x48, 0x44, 0x22, 0x11, 0x3F, 0xE4, 0x82, 0x42, 0x21, 0x10,
  0x08, 0x08, 0x3C, 0x42, 0x41, 0x41, 0x40, 0x40, 0x20, 0x18, 0x06, 0x01,
  0x01, 0x81, 0x81, 0x42, 0x3C, 0x08, 0x08, 0x70, 0x11, 0x02, 0x22, 0x44,
  0x88, 0x91, 0x14, 0x1C, 0x80, 0x20, 0x04, 0xC1, 0x24, 0x28, 0x89, 0x11,
  0x22, 0x02, 0x40, 0x30, 0x1C, 0x09, 0x04, 0x21, 0x08, 0x44, 0x0A, 0x01,
  0x00, 0xC0, 0x48, 0xA1, 0x28, 0x4A, 0x0A, 0x81, 0x10, 0xA3, 0xC8, 0xF0,
  0x11, 0x22, 0x44, 0x44, 0x88, 0x88, 0x88, 0x44, 0x44, 0x22, 0x11, 0x84,
  0x22, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x08, 0x04,
  0x02, 0x0F, 0xE0, 0x80, 0xA0, 0x88, 0x44, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x5A, 0xF0, 0x40, 0x08, 0x20, 0x84,
  0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x20, 0x3C, 0x42, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x42, 0x3C,
  0x1F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x10, 0x3C, 0x42, 0x82, 0x81,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFF, 0x3C,
  0x42, 0x81, 0x81, 0x01, 0x01, 0x02, 0x1C, 0x02, 0x01, 0x01, 0x81, 0x81,
  0x42, 0x3C, 0x06, 0x03, 0x02, 0x81, 0x41, 0x20, 0x90, 0x88, 0x84, 0x42,
  0x41, 0x3F, 0xE0, 0x40, 0x20, 0x10, 0x08, 0x7F, 0x02, 0x04, 0x08, 0x1F,
  0x21, 0x01, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x9E, 0x00, 0x0C, 0x30, 0x20,
  0x40, 0x40, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C,
  0xFF, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x41, 0x42, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x01, 0x02, 0x02, 0x04, 0x38, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x16, 0x80, 0x02, 0x18, 0xC6, 0x0C, 0x06, 0x03, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x06, 0x18, 0x60,
  0x80, 0x39, 0x18, 0x61, 0x04, 0x10, 0x42, 0x10, 0x42, 0x00, 0x00, 0x03,
  0x00, 0x07, 0xE0, 0x10, 0x20, 0x40, 0x21, 0x00, 0x24, 0x38, 0x48, 0x88,
  0x91, 0x11, 0x44, 0x21, 0x88, 0x43, 0x10, 0x86, 0x21, 0x0C, 0x42, 0x28,
  0x84, 0x51, 0x18, 0x91, 0xCE, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x7E, 0x00, 0x04, 0x00, 0xC0, 0x28, 0x05, 0x00, 0x90, 0x22, 0x04,
  0x40, 0x84, 0x20, 0x84, 0x10, 0xFE, 0x20, 0x24, 0x04, 0x80, 0x90, 0x08,
  0xFC, 0x82, 0x82, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x1E, 0x08, 0x64, 0x09, 0x01, 0x80, 0x60, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x05, 0x01, 0x40, 0x88, 0x21, 0xF0, 0xFC, 0x41,
  0x20, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28,
  0x14, 0x13, 0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x20, 0xA0,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x8F, 0xC0, 0x60, 0x30, 0x18, 0x0A,
  0x0C, 0xF8, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0xFF, 0xFE, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x38, 0xCE, 0x00, 0x81,
  0x41, 0x21, 0x10, 0x88, 0x84, 0x82, 0x81, 0xA0, 0x90, 0x44, 0x21, 0x10,
  0x88, 0x24, 0x0A, 0x02, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0x80, 0x18, 0x03, 0xC0, 0x3C, 0x05,
  0xA0, 0x5A, 0x05, 0xA0, 0x99, 0x09, 0x90, 0x99, 0x11, 0x89, 0x18, 0x91,
  0x8A, 0x18, 0x61, 0x84, 0x10, 0x80, 0xE0, 0x70, 0x34, 0x1A, 0x0C, 0x86,
  0x43, 0x11, 0x84, 0xC2, 0x60, 0xB0, 0x58, 0x1C, 0x0E, 0x02, 0x1E, 0x08,
  0x64, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05,
  0x01, 0x40, 0x88, 0x21, 0xF0, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x08, 0x64, 0x09,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40,
  0x88, 0x61, 0xE0, 0x04, 0x00, 0x80, 0x10, 0xFC, 0x41, 0x20, 0x50, 0x28,
  0x14, 0x0A, 0x05, 0x04, 0xFC, 0x42, 0x21, 0x10, 0x48, 0x24, 0x0A, 0x04,
  0x3E, 0x20, 0xA0, 0x30, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x30, 0x18, 0x0A, 0x08, 0xF8, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43,
  0x3C, 0x40, 0x28, 0x09, 0x01, 0x20, 0x22, 0x08, 0x41, 0x08, 0x20, 0x88,
  0x11, 0x02, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x08, 0x01, 0x00, 0x81, 0x03,
  0x06, 0x0A, 0x0C, 0x14, 0x14, 0x24, 0x28, 0x48, 0x90, 0x91, 0x22, 0x22,
  0x24, 0x24, 0x48, 0x50, 0x90, 0xA1, 0x41, 0x41, 0x82, 0x83, 0x02, 0x06,
  0x04, 0x0C, 0x00, 0x80, 0xA0, 0x90, 0x44, 0x42, 0x20, 0xA0, 0x30, 0x10,
  0x14, 0x0A, 0x08, 0x84, 0x44, 0x14, 0x06, 0x02, 0x40, 0x48, 0x08, 0x82,
  0x10, 0x41, 0x10, 0x22, 0x02, 0x80, 0x50, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x03, 0xFE, 0xEA, 0xAA,
  0xAA, 0xAA, 0xAB, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0x04,
  0x08, 0x20, 0x81, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0xF0, 0x20,
  0xC5, 0x12, 0x4A, 0x28, 0x40, 0xFF, 0x48, 0x80, 0x3C, 0x86, 0x08, 0x10,
  0x27, 0xD0, 0xC1, 0x83, 0x0D, 0xE8, 0x81, 0x02, 0x04, 0x08, 0x1F, 0x21,
  0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x3C, 0x42, 0x82, 0x81,
  0x80, 0x80, 0x80, 0x81, 0x82, 0x42, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C,
  0x42, 0x82, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x42, 0x3C, 0x39, 0x10,
  0x84, 0x79, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x3D, 0x43, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x42, 0x3C, 0x81,
  0x02, 0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x40, 0x55, 0x55, 0x54, 0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x12, 0xE0, 0x81, 0x02, 0x04, 0x08, 0x10, 0xA2, 0x48, 0xA1, 0x82,
  0x84, 0x89, 0x11, 0x21, 0x42, 0xFF, 0xFF, 0xB8, 0xE6, 0x28, 0xA0, 0x83,
  0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60,
  0x82, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x3C,
  0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xF9, 0x0A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0B, 0xE4, 0x08, 0x10, 0x20, 0x00,
  0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01,
  0x01, 0x01, 0x01, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x80, 0x3C, 0x86, 0x0C,
  0x06, 0x03, 0x01, 0x01, 0x83, 0x05, 0xF0, 0x21, 0x09, 0xF2, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x0C, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x87,
  0x0D, 0xE8, 0x83, 0x06, 0x0A, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x20, 0x40,
  0x84, 0x18, 0x61, 0x86, 0x24, 0xA2, 0x49, 0x24, 0x92, 0x49, 0x43, 0x14,
  0x30, 0xC3, 0x0C, 0x20, 0x80, 0x82, 0x89, 0x11, 0x42, 0x82, 0x0A, 0x14,
  0x45, 0x0A, 0x08, 0x83, 0x06, 0x0A, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x20,
  0x40, 0x82, 0x04, 0x30, 0x00, 0xFE, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10,
  0x41, 0x03, 0xF8, 0x08, 0x88, 0x42, 0x10, 0x84, 0x44, 0x10, 0x42, 0x10,
  0x84, 0x21, 0x04, 0x10, 0xFF, 0xFF, 0xC0, 0xC1, 0x08, 0x42, 0x10, 0x84,
  0x10, 0x44, 0x22, 0x10, 0x84, 0x21, 0x09, 0x80, 0x60, 0xC8, 0x62, 0x30,
  0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 15, 4, 1, -15 },
  { 5, 4, 4, 6, 1, -16 },
  { 7, 9, 15, 10, 1, -15 },
  { 24, 8, 19, 10, 1, -17 },
  { 43, 11, 15, 14, 1, -15 },
  { 64, 10, 15, 11, 1, -15 },
  { 83, 1, 4, 4, 1, -16 },
  { 84, 4, 22, 6, 1, -17 },
  { 95, 4, 22, 6, 0, -17 },
  { 106, 9, 8, 9, 0, -15 },
  { 115, 8, 11, 10, 1, -13 },
  { 126, 2, 4, 4, 1, -2 },
  { 127, 4, 1, 6, 1, -7 },
  { 128, 2, 1, 5, 1, -1 },
  { 129, 6, 16, 7, 1, -15 },
  { 141, 8, 15, 10, 1, -15 },
  { 156, 4, 15, 10, 2, -15 },
  { 164, 8, 15, 10, 1, -15 },
  { 179, 8, 15, 10, 1, -15 },
  { 194, 9, 15, 10, 1, -15 },
  { 211, 7, 15, 10, 2, -15 },
  { 225, 8, 15, 10, 1, -15 },
  { 240, 8, 15, 10, 1, -15 },
  { 255, 8, 15, 10, 1, -15 },
  { 270, 8, 15, 10, 1, -15 },
  { 285, 2, 11, 4, 1, -11 },
  { 288, 2, 13, 4, 1, -11 },
  { 292, 7, 8, 10, 1, -11 },
  { 299, 8, 6, 10, 1, -10 },
  { 305, 8, 8, 10, 1, -11 },
  { 313, 6, 15, 8, 1, -15 },
  { 325, 15, 20, 17, 1, -15 },
  { 363, 11, 15, 11, 0, -15 },
  { 384, 8, 15, 11, 2, -15 },
  { 399, 10, 15, 12, 1, -15 },
  { 418, 9, 15, 12, 2, -15 },
  { 435, 8, 15, 11, 2, -15 },
  { 450, 8, 15, 10, 2, -15 },
  { 465, 9, 15, 13, 2, -15 },
  { 482, 9, 15, 13, 2, -15 },
  { 499, 1, 15, 5, 2, -15 },
  { 501, 7, 15, 10, 1, -15 },
  { 515, 9, 15, 12, 2, -15 },
  { 532, 7, 15, 10, 2, -15 },
  { 546, 12, 15, 16, 2, -15 },
  { 569, 9, 15, 13, 2, -15 },
  { 586, 10, 15, 12, 1, -15 },
  { 605, 8, 15, 11, 2, -15 },
  { 620, 10, 18, 12, 1, -15 },
  { 643, 9, 15, 12, 2, -15 },
  { 660, 9, 15, 11, 1, -15 },
  { 677, 9, 15, 11, 1, -15 },
  { 694, 8, 15, 12, 2, -15 },
  { 709, 11, 15, 11, 0, -15 },
  { 730, 15, 15, 16, 1, -15 },
  { 759, 9, 15, 11, 1, -15 },
  { 776, 11, 15, 11, 0, -15 },
  { 797, 9, 15, 11, 1, -15 },
  { 814, 2, 20, 4, 2, -17 },
  { 819, 6, 16, 7, 1, -15 },
  { 831, 3, 20, 4, 0, -17 },
  { 839, 6, 7, 8, 1, -15 },
  { 845, 8, 1, 8, 0, 0 },
  { 846, 3, 3, 6, 1, -16 },
  { 848, 7, 11, 10, 1, -11 },
  { 858, 7, 16, 10, 2, -16 },
  { 872, 8, 11, 9, 1, -11 },
  { 883, 8, 16, 10, 1, -16 },
  { 899, 8, 11, 10, 1, -11 },
  { 910, 5, 16, 6, 1, -16 },
  { 920, 8, 15, 10, 1, -11 },
  { 935, 7, 16, 10, 2, -16 },
  { 949, 2, 15, 4, 1, -15 },
  { 953, 4, 19, 4, -1, -15 },
  { 963, 7, 16, 9, 2, -16 },
  { 977, 1, 16, 4, 2, -16 },
  { 979, 13, 11, 16, 2, -11 },
  { 997, 7, 11, 10, 2, -11 },
  { 1007, 8, 11, 10, 1, -11 },
  { 1018, 7, 15, 10, 2, -11 },
  { 1032, 8, 15, 10, 1, -11 },
  { 1047, 4, 11, 6, 2, -11 },
  { 1053, 7, 11, 9, 1, -11 },
  { 1063, 5, 14, 6, 0, -14 },
  { 1072, 7, 11, 10, 2, -11 },
  { 1082, 7, 11, 9, 1, -11 },
  { 1092, 12, 11, 14, 1, -11 },
  { 1109, 7, 11, 9, 1, -11 },
  { 1119, 7, 15, 9, 1, -11 },
  { 1133, 7, 11, 9, 1, -11 },
  { 1143, 5, 20, 6, 1, -16 },
  { 1156, 1, 18, 4, 2, -15 },
  { 1159, 5, 20, 6, 0, -16 },
  { 1172, 9, 4, 13, 2, -8 },
};

const GFXfont RobotoCondensed_ExtraLight21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT21PT7B_H_
