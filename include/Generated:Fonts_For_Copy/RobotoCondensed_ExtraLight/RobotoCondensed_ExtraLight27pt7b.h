#ifndef _ROBOTOCONDENSED_EXTRALIGHT27PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x60, 0x99, 0x99, 0x99, 0x04, 0x20, 0x44, 0x04, 0x40,
  0x84, 0x08, 0x47, 0xFF, 0x08, 0x40, 0x84, 0x08, 0x80, 0x88, 0x10, 0x81,
  0x08, 0x10, 0x8F, 0xFF, 0x11, 0x01, 0x10, 0x21, 0x02, 0x10, 0x21, 0x00,
  0x08, 0x02, 0x00, 0x80, 0xF8, 0x61, 0x10, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xA0, 0x18, 0x0B,
  0x02, 0x61, 0x0F, 0x80, 0x80, 0x20, 0x38, 0x00, 0x88, 0x01, 0x08, 0x44,
  0x10, 0x88, 0x22, 0x10, 0x48, 0x10, 0x90, 0x22, 0x40, 0x38, 0x80, 0x02,
  0x00, 0x04, 0xE0, 0x12, 0x20, 0x24, 0x20, 0x88, 0x42, 0x10, 0x84, 0x21,
  0x10, 0x42, 0x00, 0xC8, 0x00, 0xE0, 0x0E, 0x00, 0x88, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x80, 0x48, 0x02, 0x80, 0x08, 0x00, 0xA0, 0x09, 0x04,
  0x84, 0x24, 0x11, 0x20, 0xCA, 0x02, 0x88, 0x0C, 0x40, 0x61, 0x0D, 0x87,
  0xC4, 0xFC, 0x08, 0x84, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x20, 0x84, 0x20, 0x84, 0x10, 0x82, 0x84, 0x10, 0x42, 0x10, 0x42,
  0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x44, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x0E, 0x4E, 0x3E, 0x01, 0x80, 0x50, 0x19,
  0x02, 0x10, 0x82, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x55, 0x60, 0xF8, 0xB0, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x00, 0x1E,
  0x31, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0x31, 0x87, 0x80, 0x0C, 0xDC, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40,
  0x1F, 0x04, 0x31, 0x03, 0x20, 0x24, 0x05, 0x80, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0xFF, 0x80, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x24, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x01, 0x81, 0xE0, 0x02, 0x00, 0x20, 0x05, 0x00, 0xB0, 0x12,
  0x02, 0x40, 0x46, 0x10, 0x7C, 0x00, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40,
  0x48, 0x09, 0x02, 0x20, 0xC4, 0x10, 0x84, 0x10, 0x82, 0x20, 0x44, 0x09,
  0xFF, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xD0, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x78, 0x61, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x18, 0x06, 0x02, 0x40, 0x98, 0x61, 0xE0, 0x07, 0x06, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x78, 0xA1, 0x30, 0x28, 0x0A, 0x03,
  0x80, 0x60, 0x18, 0x0E, 0x02, 0x40, 0x98, 0x41, 0xE0, 0xFF, 0xE0, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x00,
  0x1F, 0x06, 0x31, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x13, 0x02, 0x30,
  0x81, 0xE0, 0xC2, 0x20, 0x24, 0x07, 0x00, 0x60, 0x0A, 0x03, 0x40, 0x44,
  0x10, 0x7C, 0x00, 0x1F, 0x0C, 0x66, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06,
  0x01, 0x40, 0x50, 0x14, 0x0C, 0x85, 0x1E, 0x40, 0x10, 0x04, 0x02, 0x01,
  0x80, 0xC1, 0xC0, 0xA0, 0x00, 0x00, 0xA0, 0x50, 0x00, 0x00, 0x55, 0x60,
  0x00, 0x80, 0xC1, 0x83, 0x06, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x20, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x20, 0x00, 0x1C, 0x62, 0x41,
  0x81, 0x81, 0x01, 0x01, 0x01, 0x02, 0x06, 0x0C, 0x08, 0x08, 0x08, 0x00,
  0x00, 0x00, 0x08, 0x18, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80, 0x20, 0xC0,
  0x04, 0x20, 0x00, 0x90, 0x00, 0x24, 0x0E, 0x0A, 0x04, 0x41, 0x82, 0x10,
  0x61, 0x04, 0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10, 0x61, 0x04, 0x18,
  0x41, 0x06, 0x10, 0x42, 0x84, 0x30, 0xA1, 0x14, 0x48, 0x38, 0xE1, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x40, 0x07, 0xE0,
  0x00, 0x02, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x22,
  0x02, 0x10, 0x10, 0x80, 0x82, 0x08, 0x10, 0x40, 0x83, 0xFE, 0x20, 0x11,
  0x00, 0x88, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x02, 0xFF, 0x10, 0x32, 0x01,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x9F, 0xE2, 0x03, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x1B, 0xFC, 0x00, 0x1F,
  0x03, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x24, 0x02, 0x40,
  0x23, 0x0C, 0x1F, 0x00, 0xFF, 0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x18, 0xFF, 0x00, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F, 0x83, 0x04,
  0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x83, 0xF8, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x01, 0x60, 0x13, 0x06,
  0x0F, 0x80, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xFF, 0xE0, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x18, 0x07, 0x02, 0x40, 0x98, 0x41, 0xE0, 0x80, 0x28,
  0x04, 0x80, 0x88, 0x18, 0x81, 0x08, 0x20, 0x84, 0x08, 0x80, 0x98, 0x0B,
  0x80, 0xE4, 0x0C, 0x60, 0x82, 0x08, 0x10, 0x80, 0x88, 0x0C, 0x80, 0x48,
  0x02, 0x80, 0x30, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xFC, 0xC0, 0x03, 0xC0, 0x03, 0xA0, 0x07, 0xA0, 0x05, 0xA0,
  0x05, 0x90, 0x09, 0x90, 0x09, 0x90, 0x09, 0x88, 0x11, 0x88, 0x11, 0x84,
  0x11, 0x84, 0x21, 0x84, 0x21, 0x82, 0x41, 0x82, 0x41, 0x82, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC0, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90,
  0x19, 0x81, 0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x83, 0x18, 0x11, 0x80,
  0x98, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x03, 0x80, 0x10, 0x1F, 0x83,
  0x0C, 0x40, 0x2C, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x02, 0x40, 0x23,
  0x0C, 0x1F, 0x00, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x50, 0x1B, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x02, 0x0C, 0x40, 0x2C, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x02, 0x40, 0x23, 0x0C, 0x1F, 0x80, 0x04,
  0x00, 0x20, 0x01, 0xFF, 0x08, 0x0C, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x0C, 0xFF, 0x08, 0x10, 0x81, 0x08, 0x08,
  0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x30, 0x0F, 0x83, 0x04, 0x40,
  0x24, 0x02, 0x40, 0x14, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x02, 0x00, 0x38, 0x01, 0x80, 0x14, 0x01, 0x40, 0x23, 0x06, 0x0F,
  0x80, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0E, 0x01, 0x40, 0x64, 0x18, 0x7E, 0x00, 0x80, 0x1C, 0x00,
  0xB0, 0x04, 0x80, 0x24, 0x02, 0x20, 0x10, 0x80, 0x84, 0x08, 0x20, 0x40,
  0x82, 0x04, 0x20, 0x21, 0x00, 0x88, 0x04, 0x80, 0x24, 0x00, 0xA0, 0x05,
  0x00, 0x30, 0x00, 0x80, 0x80, 0x40, 0x30, 0x08, 0x07, 0x02, 0x80, 0xA0,
  0x50, 0x24, 0x0A, 0x04, 0x81, 0x20, 0x90, 0x44, 0x11, 0x08, 0x86, 0x21,
  0x10, 0x84, 0x21, 0x10, 0x88, 0x22, 0x09, 0x04, 0x41, 0x20, 0x90, 0x24,
  0x0A, 0x05, 0x01, 0x40, 0xA0, 0x28, 0x0C, 0x05, 0x01, 0x80, 0x40, 0x20,
  0x08, 0x00, 0xC0, 0x14, 0x02, 0x20, 0x22, 0x04, 0x10, 0xC1, 0x08, 0x09,
  0x00, 0xD0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x90, 0x08, 0x81, 0x08, 0x30,
  0x42, 0x04, 0x60, 0x24, 0x03, 0x80, 0x10, 0x80, 0x16, 0x00, 0x90, 0x08,
  0xC0, 0x42, 0x04, 0x10, 0x20, 0x42, 0x02, 0x10, 0x09, 0x00, 0x48, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x7F, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x02, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x18, 0x18, 0x18, 0x24, 0x24, 0x24,
  0x42, 0x42, 0x42, 0x82, 0xFF, 0xC0, 0x84, 0x62, 0x1F, 0x08, 0x64, 0x09,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x7F, 0x60, 0x50, 0x18, 0x06, 0x03, 0xC0,
  0xD0, 0xD3, 0xC4, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xE2,
  0x84, 0xC0, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80,
  0xA0, 0x2C, 0x0A, 0x84, 0x9E, 0x00, 0x1F, 0x08, 0x64, 0x09, 0x01, 0x80,
  0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x05, 0x01, 0x40, 0x88, 0x61,
  0xF0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xF2, 0x85, 0x81, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x68, 0x73,
  0xC8, 0x1F, 0x08, 0x64, 0x09, 0x01, 0x80, 0x60, 0x1F, 0xFE, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x0C, 0x21, 0xF0, 0x0E, 0x20, 0x81, 0x02,
  0x04, 0x3F, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x3C, 0xA1, 0x60, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x1A, 0x1C, 0xF2, 0x01, 0x00, 0x80, 0xD0,
  0x47, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0x42, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0xA0, 0x0A, 0xAA, 0xAA, 0xAA, 0x80, 0x10, 0x80, 0x00, 0x00,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x37,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x05, 0x04, 0x86, 0x46,
  0x22, 0x12, 0x0B, 0x06, 0x82, 0x21, 0x10, 0x84, 0x41, 0x20, 0x90, 0x28,
  0x08, 0xFF, 0xFF, 0xF8, 0x9E, 0x1E, 0x50, 0x90, 0xB0, 0x70, 0x70, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02,
  0x9E, 0x50, 0xB0, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x1F, 0x06, 0x31, 0x81, 0x20, 0x24, 0x04,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x01, 0x20, 0x26, 0x04, 0x61,
  0x07, 0xC0, 0x9E, 0x28, 0x4C, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x06, 0x01,
  0x80, 0x60, 0x28, 0x0A, 0x02, 0xC0, 0xB8, 0x49, 0xE2, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x3C, 0xA1, 0x60, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x1A, 0x1C, 0xF2, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x9E, 0x8C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x00, 0x1E, 0x30, 0x90, 0x28, 0x14, 0x03, 0x00, 0xC0, 0x1C, 0x01,
  0x00, 0x40, 0x30, 0x14, 0x0B, 0x0C, 0x78, 0x20, 0x82, 0x3E, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x70, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x1A,
  0x14, 0xF2, 0x80, 0x60, 0x2C, 0x09, 0x02, 0x41, 0x10, 0x42, 0x10, 0x88,
  0x22, 0x04, 0x81, 0x20, 0x50, 0x0C, 0x03, 0x00, 0x80, 0x81, 0x02, 0x81,
  0x82, 0x41, 0x82, 0x42, 0x82, 0x42, 0x86, 0x42, 0x44, 0x22, 0x44, 0x24,
  0x44, 0x24, 0x44, 0x24, 0x28, 0x14, 0x28, 0x18, 0x28, 0x18, 0x28, 0x18,
  0x10, 0x18, 0x10, 0xC0, 0x90, 0x66, 0x10, 0x8C, 0x12, 0x05, 0x00, 0xC0,
  0x20, 0x1C, 0x05, 0x82, 0x20, 0x84, 0x41, 0x10, 0x28, 0x08, 0x80, 0x60,
  0x2C, 0x09, 0x02, 0x41, 0x18, 0x42, 0x10, 0x88, 0x22, 0x04, 0x81, 0x40,
  0x50, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x04, 0x03, 0x03, 0x80, 0x7F,
  0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x0F, 0xFC, 0x06, 0x10, 0x60, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x18, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x18, 0x10, 0x18, 0xFF, 0xFF, 0xFE, 0xC0, 0x40, 0xC0,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x80, 0xC2, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x43, 0x00, 0x38, 0x14, 0xC1,
  0x86, 0x18, 0x32, 0x81, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 4, 6, 7, 2, -20 },
  { 7, 12, 19, 13, 1, -19 },
  { 36, 10, 24, 13, 2, -22 },
  { 66, 15, 19, 17, 1, -19 },
  { 102, 13, 19, 14, 1, -19 },
  { 133, 1, 6, 5, 2, -20 },
  { 134, 5, 27, 8, 2, -21 },
  { 151, 5, 27, 8, 1, -21 },
  { 168, 11, 11, 11, 0, -19 },
  { 184, 11, 14, 13, 1, -15 },
  { 204, 2, 6, 5, 1, -2 },
  { 206, 5, 1, 7, 1, -9 },
  { 207, 2, 2, 6, 2, -2 },
  { 208, 7, 21, 9, 1, -19 },
  { 227, 9, 19, 13, 2, -19 },
  { 249, 6, 19, 13, 2, -19 },
  { 264, 11, 19, 13, 1, -19 },
  { 291, 11, 19, 13, 1, -19 },
  { 318, 11, 19, 13, 1, -19 },
  { 345, 10, 19, 13, 2, -19 },
  { 369, 10, 19, 13, 2, -19 },
  { 393, 11, 19, 13, 1, -19 },
  { 420, 11, 19, 13, 1, -19 },
  { 447, 10, 19, 13, 1, -19 },
  { 471, 2, 14, 5, 2, -14 },
  { 475, 2, 18, 5, 1, -14 },
  { 480, 9, 11, 12, 1, -14 },
  { 493, 9, 6, 13, 2, -12 },
  { 500, 9, 11, 12, 2, -14 },
  { 513, 8, 19, 11, 1, -19 },
  { 532, 18, 25, 22, 2, -19 },
  { 589, 13, 19, 14, 1, -19 },
  { 620, 11, 19, 14, 2, -19 },
  { 647, 12, 19, 15, 2, -19 },
  { 676, 12, 19, 15, 2, -19 },
  { 705, 10, 19, 14, 2, -19 },
  { 729, 10, 19, 13, 2, -19 },
  { 753, 12, 19, 16, 2, -19 },
  { 782, 12, 19, 17, 2, -19 },
  { 811, 1, 19, 7, 3, -19 },
  { 814, 10, 19, 13, 1, -19 },
  { 838, 12, 19, 15, 2, -19 },
  { 867, 10, 19, 12, 2, -19 },
  { 891, 16, 19, 20, 2, -19 },
  { 929, 12, 19, 17, 2, -19 },
  { 958, 12, 19, 16, 2, -19 },
  { 987, 11, 19, 14, 2, -19 },
  { 1014, 12, 22, 16, 2, -19 },
  { 1047, 12, 19, 15, 2, -19 },
  { 1076, 12, 19, 14, 1, -19 },
  { 1105, 12, 19, 14, 1, -19 },
  { 1134, 11, 19, 16, 2, -19 },
  { 1161, 13, 19, 14, 1, -19 },
  { 1192, 19, 19, 21, 1, -19 },
  { 1238, 12, 19, 14, 1, -19 },
  { 1267, 13, 19, 14, 1, -19 },
  { 1298, 12, 19, 14, 1, -19 },
  { 1327, 4, 26, 6, 2, -22 },
  { 1340, 8, 21, 9, 1, -19 },
  { 1361, 4, 26, 6, 0, -22 },
  { 1374, 8, 10, 10, 1, -19 },
  { 1384, 10, 1, 10, 0, 0 },
  { 1386, 4, 4, 7, 2, -21 },
  { 1388, 10, 15, 13, 1, -15 },
  { 1407, 10, 21, 13, 2, -21 },
  { 1434, 10, 15, 12, 1, -15 },
  { 1453, 9, 21, 13, 2, -21 },
  { 1477, 10, 15, 12, 1, -15 },
  { 1496, 7, 21, 8, 1, -21 },
  { 1515, 9, 20, 13, 2, -15 },
  { 1538, 9, 21, 13, 2, -21 },
  { 1562, 2, 21, 5, 2, -21 },
  { 1568, 5, 26, 6, -1, -21 },
  { 1585, 9, 21, 12, 2, -21 },
  { 1609, 1, 21, 5, 2, -21 },
  { 1612, 17, 15, 21, 2, -15 },
  { 1644, 9, 15, 13, 2, -15 },
  { 1661, 11, 15, 13, 1, -15 },
  { 1682, 10, 20, 13, 2, -15 },
  { 1707, 9, 20, 13, 2, -15 },
  { 1730, 6, 15, 8, 2, -15 },
  { 1742, 9, 15, 12, 1, -15 },
  { 1759, 6, 18, 8, 1, -18 },
  { 1773, 9, 15, 13, 2, -15 },
  { 1790, 10, 15, 11, 1, -15 },
  { 1809, 16, 15, 18, 1, -15 },
  { 1839, 10, 15, 12, 1, -15 },
  { 1858, 10, 20, 11, 1, -15 },
  { 1883, 10, 15, 12, 1, -15 },
  { 1902, 7, 27, 8, 1, -21 },
  { 1926, 1, 23, 6, 2, -19 },
  { 1929, 7, 27, 8, 0, -21 },
  { 1953, 12, 5, 16, 2, -11 },
};

const GFXfont RobotoCondensed_ExtraLight27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT27PT7B_H_
