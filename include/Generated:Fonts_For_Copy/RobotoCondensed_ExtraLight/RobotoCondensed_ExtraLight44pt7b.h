#ifndef _ROBOTOCONDENSED_EXTRALIGHT44PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight44pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x92, 0x49, 0x24, 0x80, 0x00, 0x0D,
  0xF0, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC4, 0x00, 0x81, 0x80, 0x08,
  0x18, 0x00, 0x81, 0x80, 0x18, 0x10, 0x01, 0x81, 0x00, 0x18, 0x10, 0x01,
  0x03, 0x00, 0x10, 0x30, 0x01, 0x03, 0x07, 0xFF, 0xFF, 0x03, 0x02, 0x00,
  0x30, 0x20, 0x02, 0x02, 0x00, 0x20, 0x60, 0x02, 0x06, 0x00, 0x20, 0x60,
  0x06, 0x04, 0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x0C,
  0x0F, 0xFF, 0xFE, 0x0C, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x00, 0x81,
  0x80, 0x08, 0x18, 0x00, 0x81, 0x80, 0x18, 0x10, 0x01, 0x81, 0x00, 0x18,
  0x10, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xE0,
  0x1F, 0xF8, 0x38, 0x1C, 0x60, 0x0C, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x1C, 0x1F, 0xF8, 0x07, 0xE0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x40, 0x20, 0xC0,
  0x40, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0x60, 0x80, 0xC0, 0x61, 0x80, 0xC0,
  0x41, 0x00, 0x40, 0x43, 0x00, 0x40, 0xC2, 0x00, 0x60, 0xC6, 0x00, 0x3B,
  0x84, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x78, 0x00,
  0x30, 0xFC, 0x00, 0x21, 0x86, 0x00, 0x63, 0x02, 0x00, 0x43, 0x03, 0x00,
  0xC2, 0x01, 0x00, 0x82, 0x01, 0x01, 0x82, 0x01, 0x03, 0x02, 0x01, 0x02,
  0x02, 0x01, 0x06, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0C, 0x18,
  0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x40, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x08, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x06,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x01,
  0x04, 0x02, 0x30, 0x60, 0x26, 0x03, 0x02, 0x60, 0x18, 0x64, 0x01, 0x86,
  0xC0, 0x0C, 0x6C, 0x00, 0x6C, 0xC0, 0x03, 0xC4, 0x00, 0x38, 0x60, 0x03,
  0x83, 0x00, 0x7C, 0x38, 0x0E, 0x61, 0xFF, 0x86, 0x07, 0xE0, 0x30, 0xFF,
  0xEA, 0x80, 0x01, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x02,
  0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x08, 0x18, 0x10, 0x20, 0x60, 0xC0, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x04, 0x04, 0x07, 0x82, 0x1E, 0xF9,
  0x3C, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x4C, 0x00, 0x63, 0x00,
  0x60, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x24, 0x96, 0xDE, 0x80, 0xFF, 0xFF, 0xC0, 0x5F, 0x80,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xF0,
  0x38, 0x18, 0x30, 0x0C, 0x60, 0x0C, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x02,
  0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0x40, 0x06,
  0x60, 0x0C, 0x30, 0x0C, 0x38, 0x18, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0x83,
  0xC7, 0x7E, 0x3C, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0xE0, 0x07,
  0xFC, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x19, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF,
  0xFD, 0xFF, 0xFE, 0x03, 0xF0, 0x07, 0xFC, 0x06, 0x03, 0x06, 0x00, 0xC2,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x02, 0x40, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x98, 0x00,
  0xC6, 0x00, 0x41, 0x80, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x04,
  0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x08, 0x30,
  0x06, 0x0C, 0x01, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFE, 0x7F, 0xFC, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x3E, 0x05, 0xFF, 0x0E, 0x07, 0x30, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x33, 0x00, 0x63,
  0x01, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC3, 0xE0, 0xCF, 0xF8, 0x98, 0x1C, 0xB0, 0x0C,
  0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x06,
  0x30, 0x0C, 0x18, 0x1C, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x06, 0x03, 0x86, 0x00, 0xC2, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x04, 0xC0, 0x02, 0x60, 0x01, 0x30, 0x00, 0x98,
  0x00, 0xC4, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x60, 0x3F, 0xE0, 0x0F, 0xF0,
  0x1C, 0x1C, 0x18, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x34, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x46,
  0x00, 0x63, 0x80, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xE0, 0x07, 0xFC,
  0x06, 0x07, 0x06, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0x80,
  0x06, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1A,
  0x00, 0x0D, 0x00, 0x0E, 0xC0, 0x07, 0x60, 0x07, 0x98, 0x02, 0x86, 0x06,
  0x41, 0xFE, 0x20, 0x7E, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x7F, 0x00,
  0x3C, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0D, 0xF0, 0x67,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x66, 0x66,
  0xC8, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0x0C, 0x0C, 0xC0,
  0x34, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0x80, 0x18, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x1F, 0x00, 0x46, 0x00,
  0xEF, 0x01, 0x98, 0x06, 0x04, 0x06, 0x40, 0x30, 0x10, 0x09, 0x00, 0x80,
  0x40, 0x2C, 0x06, 0x01, 0x00, 0xB0, 0x10, 0x04, 0x02, 0x80, 0xC0, 0x10,
  0x0A, 0x03, 0x00, 0xC0, 0x28, 0x0C, 0x03, 0x00, 0xA0, 0x20, 0x0C, 0x02,
  0x80, 0x80, 0x30, 0x0A, 0x02, 0x00, 0xC0, 0x28, 0x08, 0x03, 0x00, 0xA0,
  0x20, 0x08, 0x06, 0x80, 0x80, 0x60, 0x12, 0x03, 0x01, 0xC0, 0x4C, 0x0C,
  0x0F, 0x03, 0x30, 0x18, 0x64, 0x18, 0xC0, 0x7F, 0x1D, 0xC1, 0x00, 0xF8,
  0x3E, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x16, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x23,
  0x00, 0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC0, 0x80,
  0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x10, 0x01, 0x80, 0x60, 0x04,
  0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x04, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x03, 0x18,
  0x00, 0xCC, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x63, 0xFF,
  0xE1, 0xFF, 0xF0, 0xC0, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x2C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x0E, 0x1C, 0x00, 0xC3, 0x00, 0x0C, 0xC0,
  0x00, 0x98, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x08, 0xC0, 0x03, 0x1C, 0x00, 0xC1, 0xC0, 0x38, 0x1F, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03,
  0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0C, 0x01, 0x81, 0x80,
  0x0C, 0x30, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x03, 0x40,
  0x00, 0x34, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80,
  0x06, 0x0E, 0x01, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x63,
  0x01, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x00,
  0x0C, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x30, 0x06, 0x06, 0x01,
  0x80, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x0C, 0x30,
  0x01, 0x8C, 0x00, 0x33, 0x80, 0x06, 0xD8, 0x00, 0xF1, 0x80, 0x1C, 0x30,
  0x03, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF4, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x7D, 0x80,
  0x00, 0x2E, 0x40, 0x00, 0x37, 0x30, 0x00, 0x1B, 0x88, 0x00, 0x09, 0xC6,
  0x00, 0x0C, 0xF3, 0x00, 0x06, 0x78, 0x80, 0x02, 0x3C, 0x60, 0x03, 0x1E,
  0x30, 0x01, 0x0F, 0x08, 0x01, 0x87, 0x86, 0x00, 0xC3, 0xC3, 0x00, 0x41,
  0xE0, 0x80, 0x60, 0xF0, 0x60, 0x30, 0x78, 0x10, 0x10, 0x3C, 0x0C, 0x18,
  0x1E, 0x06, 0x0C, 0x0F, 0x01, 0x04, 0x07, 0x80, 0xC6, 0x03, 0xC0, 0x62,
  0x01, 0xE0, 0x13, 0x00, 0xF0, 0x0D, 0x80, 0x78, 0x02, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x20, 0x06, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xB0, 0x00, 0x72, 0x00,
  0x0E, 0x60, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x00, 0xE1, 0x80,
  0x1C, 0x18, 0x03, 0x81, 0x00, 0x70, 0x30, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x06, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0x83, 0x80, 0x18,
  0x70, 0x01, 0x8E, 0x00, 0x31, 0xC0, 0x03, 0x38, 0x00, 0x67, 0x00, 0x06,
  0xE0, 0x00, 0x5C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x01, 0xF8,
  0x00, 0xFF, 0xE0, 0x1C, 0x03, 0x83, 0x00, 0x1C, 0x30, 0x00, 0xC6, 0x00,
  0x06, 0x40, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00,
  0x66, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x30, 0x03, 0x98, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x0D,
  0x80, 0x1C, 0xFF, 0xFC, 0x7F, 0xF8, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x1C, 0x03, 0x83, 0x00, 0x18, 0x30, 0x00, 0xC6, 0x00,
  0x06, 0x40, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00,
  0x66, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x1C, 0x03, 0x80, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0xFF, 0xF0, 0x3F, 0xFF, 0x08,
  0x00, 0xE2, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0x68, 0x00, 0x1A, 0x00,
  0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01,
  0xA0, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x38, 0xFF, 0xFC, 0x3F, 0xFC, 0x08,
  0x03, 0x02, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0xC2, 0x00,
  0x18, 0x80, 0x06, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x06, 0x80, 0x01,
  0xA0, 0x00, 0x38, 0x00, 0x0C, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x0C,
  0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x13, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x68, 0x00, 0x0D, 0x80, 0x03, 0x18, 0x00, 0xE1,
  0xC0, 0x38, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19, 0x80, 0x0C, 0x38, 0x07, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x26, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x30, 0x10, 0x01, 0x80, 0xC0,
  0x08, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00,
  0x10, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x04, 0x00, 0x10, 0x60, 0x00, 0x83,
  0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00,
  0x36, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x80, 0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x16, 0x00, 0x14, 0x00, 0x64, 0x00, 0x68, 0x00, 0xC8, 0x00, 0xD0, 0x01,
  0x98, 0x01, 0x30, 0x02, 0x30, 0x02, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x18,
  0x40, 0x18, 0x80, 0x30, 0xC0, 0x21, 0x80, 0x61, 0x80, 0x43, 0x00, 0x83,
  0x01, 0x82, 0x03, 0x02, 0x03, 0x04, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x10, 0x18, 0x30, 0x10, 0x20, 0x30, 0x60, 0x20, 0xC0, 0x20,
  0x80, 0x61, 0x80, 0x63, 0x00, 0xC3, 0x00, 0xC6, 0x00, 0x84, 0x01, 0x8C,
  0x01, 0x18, 0x01, 0x10, 0x03, 0x30, 0x02, 0x60, 0x06, 0x60, 0x06, 0xC0,
  0x04, 0x80, 0x0D, 0x80, 0x09, 0x00, 0x1A, 0x00, 0x1E, 0x00, 0x14, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x0D, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x06,
  0xC0, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x10, 0x60, 0x01, 0x83, 0x00,
  0x18, 0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x06, 0x00,
  0x30, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00,
  0x06, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x87, 0xFE, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0xFF,
  0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x07,
  0x00, 0xF0, 0x09, 0x01, 0x98, 0x19, 0x81, 0x08, 0x30, 0xC3, 0x0C, 0x20,
  0x46, 0x06, 0x60, 0x64, 0x02, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x0C, 0x20,
  0x06, 0x60, 0x06, 0x40, 0x06, 0x40, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x07, 0xFE, 0x1F, 0x82, 0x30, 0x02, 0x60, 0x02, 0x40, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0x40, 0x0A, 0x60, 0x32, 0x3F,
  0xE2, 0x1F, 0x83, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3,
  0xE0, 0xCF, 0xF8, 0xD8, 0x0C, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0,
  0x06, 0xE0, 0x0C, 0xD8, 0x1C, 0xCF, 0xF8, 0xC7, 0xE0, 0x07, 0xE0, 0x1F,
  0xF8, 0x38, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x40, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x06, 0x30,
  0x06, 0x38, 0x0C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x07, 0xE3, 0x1F, 0xFB, 0x38, 0x0F, 0x30, 0x07, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x30, 0x07, 0x18, 0x0F, 0x1F, 0xFB, 0x07,
  0xE3, 0x03, 0xE0, 0x0F, 0xF8, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x02, 0x18, 0x06, 0x0F, 0xFC, 0x03, 0xF0, 0x03,
  0xE0, 0xFC, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x03, 0xFE, 0x7F, 0xC1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x07, 0xE3, 0x1F,
  0xFB, 0x38, 0x0F, 0x30, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x03, 0x30,
  0x07, 0x38, 0x0F, 0x1F, 0xFB, 0x07, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x30, 0x06, 0x38, 0x0C, 0x0F, 0xF8, 0x03,
  0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x0F, 0x86, 0x3F, 0xCC,
  0x81, 0xDA, 0x01, 0xBC, 0x01, 0x70, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x06, 0x5F, 0x00, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x02, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x0C, 0xFC, 0xF0, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x36, 0x00, 0xCC, 0x03, 0x18, 0x0C, 0x30, 0x30,
  0x60, 0xE0, 0xC1, 0x81, 0x86, 0x03, 0x18, 0x06, 0x60, 0x0D, 0xC0, 0x1E,
  0xC0, 0x38, 0xC0, 0x60, 0x80, 0xC1, 0x81, 0x81, 0x83, 0x01, 0x86, 0x03,
  0x0C, 0x03, 0x18, 0x03, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xC3, 0xE0, 0x1F, 0x0C, 0xFF, 0x87, 0xFC, 0xD8, 0x1C,
  0xC0, 0xED, 0x00, 0xD8, 0x06, 0xE0, 0x05, 0x00, 0x2E, 0x00, 0x70, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x30,
  0xC3, 0xE1, 0x8F, 0xF3, 0x20, 0x76, 0x80, 0x6F, 0x00, 0x5C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x80, 0x03, 0xF0, 0x07, 0xFE,
  0x06, 0x03, 0x86, 0x00, 0xC2, 0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x06, 0x80, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x88, 0x00,
  0xC6, 0x00, 0xC1, 0x80, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xC7, 0xE0, 0xCF,
  0xF8, 0xD8, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xE0,
  0x04, 0xF0, 0x1C, 0xCF, 0xF8, 0xC7, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x07, 0xE3, 0x1F, 0xFB, 0x38, 0x0F, 0x30, 0x07, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x30, 0x07, 0x18, 0x0F, 0x1F, 0xFB, 0x07, 0xE3, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0xC3, 0xE7, 0xF6, 0x1A, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xC0,
  0x63, 0x00, 0x66, 0x00, 0x48, 0x00, 0xD8, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x23, 0x01, 0xC3, 0xFF,
  0x03, 0xF8, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFB,
  0xFE, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xC0, 0x1F, 0x03, 0xC0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06,
  0x80, 0x0D, 0x80, 0x3B, 0x00, 0x73, 0x01, 0x63, 0xFE, 0xC3, 0xF1, 0x80,
  0xC0, 0x01, 0x20, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x10, 0x20, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x02, 0x06, 0x01,
  0x83, 0x00, 0xC1, 0x00, 0x20, 0x80, 0x10, 0xC0, 0x0C, 0x40, 0x02, 0x20,
  0x01, 0x30, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x48, 0x02,
  0x80, 0x66, 0x03, 0x40, 0x33, 0x01, 0xB0, 0x19, 0x80, 0x98, 0x08, 0x40,
  0x44, 0x0C, 0x30, 0x62, 0x06, 0x18, 0x31, 0x83, 0x0C, 0x10, 0xC1, 0x02,
  0x18, 0x20, 0x81, 0x8C, 0x10, 0xC0, 0xC6, 0x0C, 0x60, 0x62, 0x06, 0x20,
  0x13, 0x01, 0x10, 0x09, 0x80, 0xD8, 0x06, 0x80, 0x6C, 0x03, 0x40, 0x14,
  0x00, 0xE0, 0x0A, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0x80, 0x60, 0x03, 0x20, 0x06, 0x30, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x0C,
  0x18, 0x04, 0x30, 0x06, 0x30, 0x03, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x10, 0x0C,
  0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0,
  0x01, 0x20, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x10, 0x20, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x02, 0x02, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x20, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x02, 0x20, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x40, 0x70, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0xE0, 0x38, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x70, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x38, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x70, 0x30,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x38, 0x08,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x01, 0x60, 0xC0, 0x34, 0x06, 0x03, 0xC0,
  0x30, 0x6C, 0x01, 0xFE, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLight44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 6, 9, 12, 3, -33 },
  { 20, 20, 31, 22, 2, -31 },
  { 98, 16, 39, 21, 3, -35 },
  { 176, 24, 31, 28, 2, -31 },
  { 269, 20, 31, 24, 2, -31 },
  { 347, 2, 9, 7, 3, -33 },
  { 350, 8, 45, 12, 3, -35 },
  { 395, 8, 45, 13, 1, -35 },
  { 440, 17, 17, 19, 1, -31 },
  { 477, 18, 24, 22, 2, -27 },
  { 531, 3, 9, 8, 2, -4 },
  { 535, 9, 2, 12, 1, -15 },
  { 538, 3, 3, 10, 3, -3 },
  { 540, 13, 34, 15, 1, -31 },
  { 596, 16, 31, 21, 3, -31 },
  { 658, 9, 31, 21, 4, -31 },
  { 693, 17, 31, 21, 2, -31 },
  { 759, 17, 31, 21, 2, -31 },
  { 825, 18, 31, 21, 2, -31 },
  { 895, 15, 31, 21, 4, -31 },
  { 954, 16, 31, 21, 3, -31 },
  { 1016, 17, 31, 21, 2, -31 },
  { 1082, 17, 31, 21, 2, -31 },
  { 1148, 17, 31, 21, 2, -31 },
  { 1214, 3, 23, 8, 3, -23 },
  { 1223, 4, 28, 8, 2, -23 },
  { 1237, 15, 18, 20, 2, -23 },
  { 1271, 15, 11, 21, 3, -20 },
  { 1292, 15, 18, 20, 3, -23 },
  { 1326, 13, 31, 17, 2, -31 },
  { 1377, 30, 40, 35, 3, -30 },
  { 1527, 22, 31, 24, 1, -31 },
  { 1613, 17, 31, 23, 4, -31 },
  { 1679, 19, 31, 25, 3, -31 },
  { 1753, 18, 31, 25, 4, -31 },
  { 1823, 16, 31, 22, 4, -31 },
  { 1885, 16, 31, 22, 4, -31 },
  { 1947, 20, 31, 26, 3, -31 },
  { 2025, 19, 31, 27, 4, -31 },
  { 2099, 2, 31, 11, 4, -31 },
  { 2107, 15, 31, 21, 2, -31 },
  { 2166, 19, 31, 24, 4, -31 },
  { 2240, 15, 31, 20, 4, -31 },
  { 2299, 25, 31, 33, 4, -31 },
  { 2396, 19, 31, 27, 4, -31 },
  { 2470, 20, 31, 26, 3, -31 },
  { 2548, 17, 31, 23, 4, -31 },
  { 2614, 20, 37, 26, 3, -31 },
  { 2707, 18, 31, 25, 4, -31 },
  { 2777, 19, 31, 23, 2, -31 },
  { 2851, 21, 31, 23, 1, -31 },
  { 2933, 18, 31, 25, 4, -31 },
  { 3003, 21, 31, 23, 1, -31 },
  { 3085, 31, 31, 34, 2, -31 },
  { 3206, 21, 31, 23, 1, -31 },
  { 3288, 21, 31, 23, 1, -31 },
  { 3370, 19, 31, 23, 2, -31 },
  { 3444, 5, 43, 9, 4, -36 },
  { 3471, 13, 34, 15, 1, -31 },
  { 3527, 6, 43, 9, 0, -36 },
  { 3560, 12, 16, 16, 2, -31 },
  { 3584, 16, 2, 17, 0, 0 },
  { 3588, 6, 6, 12, 3, -33 },
  { 3593, 16, 23, 21, 2, -23 },
  { 3639, 16, 33, 21, 3, -33 },
  { 3705, 16, 23, 20, 2, -23 },
  { 3751, 16, 33, 21, 2, -33 },
  { 3817, 16, 23, 20, 2, -23 },
  { 3863, 11, 33, 13, 2, -33 },
  { 3909, 16, 32, 21, 2, -23 },
  { 3973, 15, 33, 21, 3, -33 },
  { 4035, 3, 32, 9, 3, -32 },
  { 4047, 8, 41, 9, -2, -32 },
  { 4088, 15, 33, 19, 3, -33 },
  { 4150, 1, 33, 9, 4, -33 },
  { 4155, 28, 23, 34, 3, -23 },
  { 4236, 15, 23, 21, 3, -23 },
  { 4280, 17, 23, 21, 2, -23 },
  { 4329, 16, 32, 21, 3, -23 },
  { 4393, 16, 32, 21, 2, -23 },
  { 4457, 9, 23, 13, 3, -23 },
  { 4483, 15, 23, 20, 2, -23 },
  { 4527, 10, 29, 13, 1, -29 },
  { 4564, 15, 23, 21, 3, -23 },
  { 4608, 17, 23, 19, 1, -23 },
  { 4657, 25, 23, 29, 2, -23 },
  { 4729, 16, 23, 19, 1, -23 },
  { 4775, 17, 32, 19, 1, -23 },
  { 4843, 15, 23, 19, 2, -23 },
  { 4887, 10, 43, 13, 2, -34 },
  { 4941, 2, 37, 9, 4, -31 },
  { 4951, 10, 43, 13, 1, -34 },
  { 5005, 20, 7, 26, 3, -16 },
};

const GFXfont RobotoCondensed_ExtraLight44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT44PT7B_H_
