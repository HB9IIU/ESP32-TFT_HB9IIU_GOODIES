#ifndef _ROBOTOCONDENSED_EXTRALIGHT29PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight29pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA8, 0x03, 0xC0, 0x99, 0x99, 0x99, 0x04, 0x20,
  0x21, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x11, 0xFF, 0xE1, 0x08, 0x08,
  0x40, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x08, 0x43, 0xFF, 0xE2, 0x10,
  0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x02, 0x10, 0x00, 0x04, 0x01, 0x00,
  0x40, 0x7C, 0x21, 0x90, 0x3C, 0x06, 0x01, 0x80, 0x60, 0x04, 0x01, 0x80,
  0x30, 0x03, 0x80, 0x30, 0x02, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x70,
  0x36, 0x18, 0x7C, 0x04, 0x01, 0x00, 0x40, 0x78, 0x01, 0x90, 0x02, 0x10,
  0x04, 0x20, 0x88, 0x42, 0x10, 0x84, 0x21, 0x10, 0x42, 0x60, 0xC8, 0x80,
  0xF2, 0x00, 0x04, 0x00, 0x11, 0xC0, 0x24, 0x40, 0x88, 0x41, 0x10, 0x84,
  0x41, 0x08, 0x82, 0x20, 0x84, 0x41, 0x08, 0x02, 0x20, 0x03, 0x80, 0x1E,
  0x01, 0x98, 0x08, 0x40, 0x81, 0x04, 0x18, 0x20, 0x80, 0x8C, 0x04, 0xC0,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xC8, 0x04, 0x61, 0x41, 0x0A, 0x04, 0x50,
  0x16, 0x80, 0xE4, 0x03, 0x30, 0x38, 0xC3, 0x63, 0xE1, 0x00, 0xFC, 0x08,
  0x44, 0x22, 0x11, 0x08, 0x46, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0C,
  0x21, 0x08, 0x21, 0x0C, 0x20, 0x84, 0x84, 0x10, 0x42, 0x10, 0x42, 0x10,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x88, 0x42, 0x31, 0x08, 0x88,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x21, 0x72, 0x60, 0xF8, 0x06, 0x00,
  0xD0, 0x09, 0x81, 0x0C, 0x20, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x6D, 0xA5, 0x00, 0xFC, 0xF0, 0x01, 0x03,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x1E, 0x08, 0x44,
  0x09, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x34, 0x08, 0x84, 0x1E, 0x00,
  0x04, 0x7E, 0x61, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x1E, 0x0C, 0x23, 0x02, 0x40, 0x68, 0x05, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x0F, 0xFE, 0x0F, 0x06, 0x18,
  0x81, 0x20, 0x14, 0x02, 0x80, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x3C,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0E, 0x01, 0x40, 0x28, 0x05, 0x81, 0x98,
  0x60, 0xF0, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x2C, 0x02, 0xC0, 0x4C, 0x04,
  0xC0, 0x8C, 0x18, 0xC1, 0x0C, 0x30, 0xC2, 0x0C, 0x40, 0xC4, 0x0C, 0xFF,
  0xF0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3F, 0xC4,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x5F, 0x0C, 0x31,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x40, 0x48, 0x09, 0x81,
  0x18, 0x41, 0xF0, 0x07, 0x03, 0x80, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x04, 0xF8, 0xB1, 0x98, 0x1A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xE0, 0x1C,
  0x02, 0x80, 0x48, 0x09, 0x02, 0x18, 0xC1, 0xE0, 0xFF, 0xE0, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x1E, 0x0C, 0x31, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x40, 0x84, 0x30, 0x78, 0x30, 0xCC, 0x0D, 0x00, 0xA0, 0x1C, 0x01, 0x80,
  0x70, 0x0B, 0x01, 0x30, 0xC3, 0xF0, 0x0F, 0x06, 0x10, 0x81, 0x20, 0x34,
  0x02, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x28, 0x05, 0x01, 0x90, 0x33, 0x0A,
  0x1E, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x02, 0x01, 0x81, 0xC0, 0xF0,
  0x00, 0x00, 0x2C, 0x4C, 0x00, 0x00, 0x00, 0x00, 0x92, 0x4A, 0x00, 0x00,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x38, 0x38, 0x38, 0x38, 0x08, 0x00,
  0x1E, 0x31, 0x90, 0x78, 0x1C, 0x08, 0x04, 0x02, 0x01, 0x01, 0x01, 0x81,
  0x80, 0x80, 0x80, 0x40, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x80,
  0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x20, 0x06, 0x08, 0x00, 0x42, 0x00, 0x04,
  0x40, 0x00, 0x90, 0x1C, 0x0A, 0x0C, 0x41, 0x81, 0x08, 0x30, 0x41, 0x06,
  0x08, 0x20, 0xC2, 0x04, 0x18, 0x40, 0x83, 0x08, 0x10, 0x61, 0x02, 0x0C,
  0x20, 0x41, 0x84, 0x18, 0x30, 0x83, 0x0A, 0x08, 0xA3, 0x20, 0xE3, 0x84,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x08, 0x00,
  0x7E, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x40, 0x04, 0x80, 0x32,
  0x00, 0x88, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x02, 0x04, 0x08, 0x20,
  0x20, 0x80, 0xC3, 0xFF, 0x10, 0x04, 0x40, 0x11, 0x00, 0x2C, 0x00, 0xA0,
  0x02, 0x80, 0x04, 0xFE, 0x10, 0x32, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0x90, 0x33, 0xFC, 0x40, 0x48, 0x05, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x40, 0x4F, 0xF0, 0x0F, 0x81, 0x83, 0x18,
  0x08, 0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03, 0x40, 0x12,
  0x00, 0x98, 0x08, 0x60, 0xC0, 0xF8, 0x00, 0xFE, 0x08, 0x18, 0x80, 0xC8,
  0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0xC8,
  0x18, 0xFE, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0F, 0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFA, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0x83,
  0x08, 0x04, 0x80, 0x24, 0x00, 0xE0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x03, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x48, 0x06, 0x30, 0x60, 0xFC, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF,
  0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1C, 0x02, 0x80, 0x48, 0x09, 0x03, 0x10, 0xC1, 0xF0,
  0x80, 0x28, 0x04, 0x80, 0xC8, 0x18, 0x81, 0x08, 0x20, 0x84, 0x08, 0xC0,
  0x98, 0x09, 0x00, 0xB8, 0x0C, 0xC0, 0x84, 0x08, 0x20, 0x83, 0x08, 0x10,
  0x80, 0x88, 0x0C, 0x80, 0x48, 0x02, 0x80, 0x30, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xF8, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x05, 0xA0, 0x05, 0xA0, 0x05, 0xA0, 0x09, 0x90, 0x09,
  0x90, 0x09, 0x90, 0x11, 0x88, 0x11, 0x88, 0x11, 0x88, 0x21, 0x84, 0x21,
  0x84, 0x61, 0x86, 0x41, 0x82, 0x41, 0x82, 0xC1, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xA0, 0x19, 0x01, 0x90,
  0x18, 0x81, 0x88, 0x18, 0x41, 0x86, 0x18, 0x21, 0x81, 0x18, 0x11, 0x80,
  0x98, 0x09, 0x80, 0x58, 0x07, 0x80, 0x38, 0x03, 0x80, 0x10, 0x0F, 0x81,
  0x83, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x1A, 0x00, 0x98, 0x0C, 0x60, 0xC0, 0xF8, 0x00, 0xFF, 0x10, 0x12,
  0x01, 0x40, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0A, 0x03,
  0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x0F, 0x81, 0x83, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x1A, 0x00, 0x98, 0x0C, 0x60, 0xC0, 0xFC,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0xFF, 0x08, 0x18, 0x80, 0x48,
  0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0x80, 0x8F,
  0xF0, 0x83, 0x08, 0x10, 0x81, 0x88, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x68,
  0x02, 0x80, 0x30, 0x0F, 0x81, 0x83, 0x08, 0x0C, 0x80, 0x24, 0x01, 0x20,
  0x05, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0xD8, 0x04, 0x60, 0xC0,
  0xFC, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x14, 0x01, 0x60, 0x33, 0x06, 0x0F, 0x80, 0x80, 0x0E, 0x00,
  0x2C, 0x00, 0x90, 0x02, 0x40, 0x11, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20,
  0x20, 0x40, 0x81, 0x06, 0x04, 0x10, 0x08, 0x40, 0x21, 0x00, 0x88, 0x03,
  0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x20,
  0x1C, 0x03, 0x00, 0x90, 0x14, 0x04, 0x80, 0xA0, 0x24, 0x05, 0x01, 0x20,
  0x48, 0x11, 0x82, 0x40, 0x84, 0x11, 0x04, 0x20, 0x88, 0x21, 0x08, 0x43,
  0x08, 0x42, 0x10, 0x22, 0x08, 0x81, 0x10, 0x44, 0x09, 0x82, 0x20, 0x48,
  0x13, 0x02, 0x40, 0x50, 0x0A, 0x02, 0x80, 0x50, 0x14, 0x03, 0x00, 0xA0,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x0A, 0x00, 0x88, 0x04, 0x40,
  0x41, 0x06, 0x0C, 0x20, 0x23, 0x01, 0x90, 0x05, 0x00, 0x18, 0x00, 0x80,
  0x0E, 0x00, 0x58, 0x04, 0x40, 0x23, 0x02, 0x08, 0x30, 0x21, 0x01, 0x18,
  0x04, 0x80, 0x3C, 0x00, 0x80, 0x80, 0x0B, 0x00, 0x24, 0x01, 0x18, 0x04,
  0x20, 0x20, 0xC0, 0x81, 0x04, 0x04, 0x10, 0x08, 0x80, 0x22, 0x00, 0x50,
  0x01, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x7F, 0xF0, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x0F, 0xFF, 0x80, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x0C, 0x04, 0x04,
  0x06, 0x02, 0x02, 0x02, 0x01, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x18, 0x14, 0x14,
  0x24, 0x22, 0x22, 0x42, 0x41, 0xC1, 0xFF, 0xE0, 0xC4, 0x23, 0x1F, 0x06,
  0x11, 0x01, 0x20, 0x20, 0x04, 0x00, 0x80, 0x10, 0xFE, 0x30, 0x48, 0x09,
  0x01, 0x60, 0x2C, 0x04, 0x81, 0x98, 0x51, 0xF3, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x09, 0xF2, 0x86, 0xC0, 0xF0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x03, 0xA1, 0xA7, 0xC0,
  0x1F, 0x06, 0x19, 0x81, 0x20, 0x34, 0x03, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x14, 0x06, 0xC0, 0x8C, 0x20, 0xF8, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x13, 0xE5, 0x85, 0xC0, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x03, 0x61,
  0x4F, 0x90, 0x0F, 0x06, 0x11, 0x81, 0x20, 0x24, 0x03, 0x80, 0x60, 0x0F,
  0xFF, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x30, 0x7C,
  0x0E, 0x20, 0x41, 0x02, 0x04, 0x3F, 0x90, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3E, 0x58, 0x5C, 0x0E,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x70, 0x36, 0x14, 0xF9, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x61, 0x87, 0x80,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0xF2, 0xC6, 0xA0, 0xB0,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0xF0, 0x0A, 0xAA, 0xAA, 0xAA, 0xA0, 0x18, 0xC0,
  0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x8D, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x0A, 0x04, 0x82, 0x21, 0x88, 0xC2, 0x20, 0x90, 0x2C, 0x0C, 0x82, 0x30,
  0x84, 0x20, 0x88, 0x32, 0x04, 0x80, 0xA0, 0x30, 0xFF, 0xFF, 0xFC, 0x8F,
  0x0F, 0x2C, 0x64, 0x2A, 0x0A, 0x07, 0x03, 0x01, 0x80, 0x40, 0x60, 0x10,
  0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06,
  0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x8F,
  0x2C, 0x6A, 0x0B, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x1E, 0x0C, 0x31, 0x02, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x28,
  0x04, 0x81, 0x18, 0x60, 0xF0, 0x9F, 0x28, 0x6C, 0x0F, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x3A, 0x1A,
  0x7C, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x3E, 0x58, 0x5C,
  0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x36, 0x14, 0xF9, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x9E, 0xCC, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x1F, 0x08, 0x64, 0x0D, 0x01, 0x40, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x04, 0x01, 0x40, 0x50, 0x16, 0x08, 0x7C, 0x20, 0x82, 0x3F,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0xC0,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0xD0, 0x36, 0x14, 0xF9, 0x80, 0x50, 0x09, 0x01,
  0x20, 0x44, 0x08, 0xC1, 0x08, 0x61, 0x08, 0x21, 0x02, 0x20, 0x48, 0x09,
  0x00, 0xA0, 0x18, 0x03, 0x00, 0x20, 0x80, 0x80, 0xE0, 0x40, 0x90, 0x50,
  0x48, 0x28, 0x24, 0x14, 0x13, 0x0A, 0x18, 0x88, 0x88, 0x44, 0x44, 0x22,
  0x22, 0x11, 0x13, 0x05, 0x05, 0x02, 0x82, 0x81, 0x41, 0x40, 0xA0, 0xA0,
  0x20, 0x20, 0x10, 0x10, 0xC0, 0x50, 0x22, 0x08, 0x84, 0x13, 0x04, 0x80,
  0xE0, 0x30, 0x0C, 0x02, 0x81, 0x20, 0xC4, 0x21, 0x18, 0x24, 0x0E, 0x01,
  0x80, 0x50, 0x09, 0x01, 0x20, 0x44, 0x08, 0xC1, 0x08, 0x61, 0x08, 0x31,
  0x02, 0x20, 0x48, 0x09, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x30, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x04, 0x03, 0xFF, 0x02, 0x08, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x30, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x30, 0x20, 0x20, 0x20, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x40, 0xC0,
  0x81, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x80, 0x80, 0x86, 0x08,
  0x10, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC3, 0x0C, 0x00, 0x38,
  0x0A, 0x20, 0x70, 0x83, 0x02, 0x28, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 4, 6, 8, 2, -22 },
  { 10, 13, 21, 14, 1, -21 },
  { 45, 10, 27, 14, 2, -24 },
  { 79, 15, 21, 19, 2, -21 },
  { 119, 13, 21, 16, 2, -21 },
  { 154, 1, 6, 5, 2, -22 },
  { 155, 5, 30, 8, 2, -23 },
  { 174, 5, 30, 8, 1, -23 },
  { 193, 12, 11, 12, 0, -21 },
  { 210, 12, 15, 14, 1, -17 },
  { 233, 3, 6, 6, 1, -2 },
  { 236, 6, 1, 8, 1, -10 },
  { 237, 2, 2, 7, 2, -2 },
  { 238, 8, 23, 10, 1, -21 },
  { 261, 10, 21, 14, 2, -21 },
  { 288, 6, 21, 14, 2, -21 },
  { 304, 11, 21, 14, 2, -21 },
  { 333, 11, 21, 14, 1, -21 },
  { 362, 12, 21, 14, 1, -21 },
  { 394, 11, 21, 14, 2, -21 },
  { 423, 11, 21, 14, 2, -21 },
  { 452, 11, 21, 14, 1, -21 },
  { 481, 11, 21, 14, 2, -21 },
  { 510, 11, 21, 14, 1, -21 },
  { 539, 2, 15, 5, 2, -15 },
  { 543, 3, 19, 5, 1, -15 },
  { 551, 10, 11, 13, 1, -15 },
  { 565, 10, 7, 14, 2, -13 },
  { 574, 10, 11, 13, 2, -15 },
  { 588, 9, 21, 11, 1, -21 },
  { 612, 19, 26, 23, 2, -20 },
  { 674, 14, 21, 16, 1, -21 },
  { 711, 11, 21, 15, 3, -21 },
  { 740, 13, 21, 16, 2, -21 },
  { 775, 12, 21, 17, 3, -21 },
  { 807, 10, 21, 15, 3, -21 },
  { 834, 10, 21, 14, 3, -21 },
  { 861, 13, 21, 17, 2, -21 },
  { 896, 12, 21, 18, 3, -21 },
  { 928, 1, 21, 7, 3, -21 },
  { 931, 11, 21, 14, 1, -21 },
  { 960, 12, 21, 16, 3, -21 },
  { 992, 9, 21, 13, 3, -21 },
  { 1016, 16, 21, 22, 3, -21 },
  { 1058, 12, 21, 18, 3, -21 },
  { 1090, 13, 21, 17, 2, -21 },
  { 1125, 11, 21, 15, 3, -21 },
  { 1154, 13, 25, 17, 2, -21 },
  { 1195, 12, 21, 16, 3, -21 },
  { 1227, 13, 21, 15, 1, -21 },
  { 1262, 13, 21, 15, 1, -21 },
  { 1297, 12, 21, 17, 2, -21 },
  { 1329, 14, 21, 15, 1, -21 },
  { 1366, 21, 21, 23, 1, -21 },
  { 1422, 13, 21, 15, 1, -21 },
  { 1457, 14, 21, 15, 1, -21 },
  { 1494, 13, 21, 15, 1, -21 },
  { 1529, 4, 28, 6, 2, -24 },
  { 1543, 8, 23, 10, 1, -21 },
  { 1566, 4, 28, 6, 0, -24 },
  { 1580, 8, 10, 11, 1, -21 },
  { 1590, 11, 1, 11, 0, 0 },
  { 1592, 4, 4, 8, 2, -22 },
  { 1594, 11, 16, 14, 1, -16 },
  { 1616, 10, 22, 14, 2, -22 },
  { 1644, 11, 16, 13, 1, -16 },
  { 1666, 10, 22, 14, 2, -22 },
  { 1694, 11, 16, 13, 1, -16 },
  { 1716, 7, 22, 8, 1, -22 },
  { 1736, 10, 22, 14, 2, -16 },
  { 1764, 10, 22, 14, 2, -22 },
  { 1792, 2, 22, 6, 2, -22 },
  { 1798, 5, 28, 6, -1, -22 },
  { 1816, 10, 22, 12, 2, -22 },
  { 1844, 1, 22, 6, 2, -22 },
  { 1847, 18, 16, 22, 2, -16 },
  { 1883, 10, 16, 14, 2, -16 },
  { 1903, 11, 16, 14, 2, -16 },
  { 1925, 10, 22, 14, 2, -16 },
  { 1953, 10, 22, 14, 2, -16 },
  { 1981, 6, 16, 9, 2, -16 },
  { 1993, 10, 16, 13, 1, -16 },
  { 2013, 6, 19, 8, 1, -19 },
  { 2028, 10, 16, 14, 2, -16 },
  { 2048, 11, 16, 12, 1, -16 },
  { 2070, 17, 16, 19, 1, -16 },
  { 2104, 10, 16, 12, 1, -16 },
  { 2124, 11, 22, 12, 1, -16 },
  { 2155, 10, 16, 12, 1, -16 },
  { 2175, 7, 29, 9, 1, -23 },
  { 2201, 1, 25, 6, 3, -21 },
  { 2205, 7, 29, 9, 0, -23 },
  { 2231, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_ExtraLight29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT29PT7B_H_
