#ifndef _ROBOTOCONDENSED_EXTRALIGHT40PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x8E, 0x38, 0xE3, 0x8E,
  0x28, 0xA2, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x0C, 0x18, 0x03,
  0x06, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x10, 0x7F, 0xFF, 0xC0, 0x83,
  0x00, 0x60, 0xC0, 0x18, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80,
  0x10, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x00, 0x81, 0x03, 0xFF, 0xFE, 0x08,
  0x10, 0x02, 0x04, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x10, 0x20, 0x04, 0x08,
  0x01, 0x02, 0x00, 0x40, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x7E, 0x03, 0xCE, 0x0E, 0x06, 0x18, 0x06, 0x60, 0x04, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x1B, 0x00, 0x36, 0x00, 0xC6,
  0x03, 0x87, 0x9E, 0x03, 0xF0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1E, 0x00, 0x00, 0xCC, 0x00, 0x04, 0x18, 0x00, 0x10, 0x20, 0x00,
  0xC0, 0x80, 0x82, 0x02, 0x04, 0x08, 0x08, 0x30, 0x20, 0x20, 0x80, 0xC0,
  0x86, 0x01, 0x02, 0x10, 0x04, 0x18, 0xC0, 0x0C, 0xC2, 0x00, 0x1E, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x78, 0x00, 0x43, 0x30,
  0x03, 0x18, 0x60, 0x08, 0x40, 0x80, 0x61, 0x03, 0x01, 0x04, 0x0C, 0x08,
  0x10, 0x30, 0x20, 0x40, 0xC1, 0x01, 0x03, 0x04, 0x04, 0x08, 0x00, 0x18,
  0x60, 0x00, 0x33, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xB8, 0x01, 0x83,
  0x00, 0x40, 0x40, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x40, 0x40,
  0x10, 0x20, 0x06, 0x18, 0x00, 0x8C, 0x00, 0x36, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x01, 0x90, 0x00, 0xC6, 0x02, 0x20, 0xC0, 0x98, 0x18, 0x24, 0x02,
  0x0B, 0x00, 0xC6, 0xC0, 0x19, 0xB0, 0x03, 0x4C, 0x00, 0x71, 0x00, 0x18,
  0x60, 0x0F, 0x0C, 0x06, 0x61, 0xEF, 0x08, 0x3F, 0x03, 0xFF, 0x02, 0x0C,
  0x10, 0x41, 0x82, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x60,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x06, 0x04, 0x08,
  0x10, 0x30, 0x20, 0x40, 0xC0, 0x81, 0x81, 0x01, 0x03, 0x02, 0x81, 0x81,
  0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x60,
  0x81, 0x06, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x60, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x10, 0x20, 0x7C, 0x47, 0x9E,
  0xB8, 0x07, 0xC0, 0x07, 0x00, 0x1B, 0x00, 0x22, 0x00, 0xC6, 0x03, 0x06,
  0x0C, 0x06, 0x18, 0x04, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x6D, 0xB6,
  0xB4, 0xFF, 0x1F, 0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xC0,
  0x1D, 0xE0, 0x60, 0x61, 0x80, 0x42, 0x00, 0xCC, 0x00, 0x90, 0x01, 0x20,
  0x03, 0x40, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1A, 0x00, 0x34,
  0x00, 0x68, 0x00, 0x98, 0x01, 0x10, 0x06, 0x30, 0x08, 0x30, 0x30, 0x3B,
  0xC0, 0x3E, 0x00, 0x01, 0x83, 0xCF, 0x7E, 0x38, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x07,
  0xC0, 0x1E, 0xF0, 0x30, 0x18, 0x60, 0x08, 0x40, 0x0C, 0xC0, 0x04, 0xC0,
  0x04, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x07, 0xE0, 0x3D, 0xE0, 0xC0,
  0x61, 0x00, 0x66, 0x00, 0x48, 0x00, 0x90, 0x01, 0xE0, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0xFC, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xA0, 0x02, 0x60, 0x0C, 0x60, 0x30, 0x79, 0xC0, 0x3F, 0x00,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x78, 0x00, 0x58, 0x00, 0xD8, 0x00, 0x98,
  0x01, 0x98, 0x01, 0x18, 0x03, 0x18, 0x02, 0x18, 0x06, 0x18, 0x0C, 0x18,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x18, 0x30, 0x18, 0x20, 0x18, 0x60, 0x18,
  0xC0, 0x18, 0xC0, 0x18, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x3F, 0xFC, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x7C, 0x1F, 0xFC, 0x70, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xC0, 0x07, 0x00, 0x14, 0x00,
  0x58, 0x03, 0x60, 0x08, 0xC0, 0x61, 0xEF, 0x01, 0xF0, 0x01, 0xE0, 0x1F,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x7C, 0x27, 0xBC, 0xB0, 0x33, 0x80, 0x6C, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3C,
  0x00, 0xD0, 0x02, 0x60, 0x18, 0xC0, 0xC1, 0xCE, 0x01, 0xF0, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x07, 0xE0, 0x3D, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00,
  0x48, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0x40, 0x06, 0xC0, 0x08, 0x80, 0x31,
  0x80, 0xC1, 0xE7, 0x01, 0xFC, 0x06, 0x0E, 0x18, 0x06, 0x60, 0x04, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0, 0x03,
  0x60, 0x04, 0x60, 0x18, 0x79, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3D, 0xE0,
  0xC0, 0x61, 0x00, 0x46, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0x60, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x68, 0x00, 0xD8, 0x03,
  0xB0, 0x07, 0x30, 0x36, 0x39, 0xCC, 0x1E, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0x00, 0xF0,
  0x00, 0x4D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x36, 0x07, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x33, 0x32, 0x64, 0x00, 0x08,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x0F, 0x83, 0x9C, 0x60, 0x64, 0x02,
  0xC0, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x40,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x04, 0x10, 0x07, 0x80, 0x43, 0x01, 0xCE, 0x06, 0x20,
  0x10, 0x20, 0x26, 0x02, 0x02, 0x02, 0x60, 0x60, 0x20, 0x24, 0x04, 0x02,
  0x02, 0x40, 0x40, 0x20, 0x24, 0x0C, 0x02, 0x02, 0x40, 0x80, 0x60, 0x2C,
  0x08, 0x06, 0x02, 0xC0, 0x80, 0x60, 0x2C, 0x08, 0x06, 0x02, 0xC0, 0x80,
  0x60, 0x2C, 0x08, 0x04, 0x02, 0x40, 0x80, 0x40, 0x64, 0x08, 0x0C, 0x04,
  0x40, 0xC0, 0xE0, 0x44, 0x04, 0x12, 0x08, 0x60, 0x67, 0x33, 0x86, 0x03,
  0xC1, 0xE0, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0B, 0x00, 0x01, 0x90, 0x00, 0x19,
  0x00, 0x01, 0x18, 0x00, 0x11, 0x80, 0x03, 0x08, 0x00, 0x20, 0xC0, 0x02,
  0x0C, 0x00, 0x60, 0x40, 0x04, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x01, 0x80, 0x10, 0x18, 0x01, 0x01, 0xFF, 0xF8,
  0x30, 0x00, 0x83, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x60, 0x00,
  0x44, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xFF, 0xC1, 0x03, 0xE2,
  0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x01, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x0D, 0x00, 0x1A, 0x00, 0x24, 0x00, 0xC8, 0x0F, 0x1F, 0xFC, 0x20, 0x0E,
  0x40, 0x06, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0D, 0x00, 0x32, 0x03, 0xC7, 0xFF,
  0x00, 0x03, 0xF0, 0x07, 0x9E, 0x0E, 0x01, 0x86, 0x00, 0x66, 0x00, 0x12,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0D,
  0x00, 0x06, 0xC0, 0x02, 0x30, 0x03, 0x1C, 0x03, 0x03, 0xDF, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x81, 0xF0, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x06, 0x80,
  0x06, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x18, 0x81, 0xF0, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xE8, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xE8, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03,
  0xF8, 0x03, 0xCF, 0x81, 0x80, 0x70, 0xC0, 0x0C, 0x60, 0x01, 0x98, 0x00,
  0x24, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x01, 0xC6, 0x00, 0xE0, 0xFB, 0xE0,
  0x0F, 0xE0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x02, 0x40, 0x19, 0x80, 0xC3, 0xDE, 0x03, 0xE0, 0x80, 0x03,
  0x40, 0x03, 0x20, 0x03, 0x10, 0x03, 0x08, 0x03, 0x04, 0x01, 0x02, 0x01,
  0x81, 0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x10, 0x80, 0x08,
  0xC0, 0x04, 0xE0, 0x02, 0xD8, 0x01, 0xC6, 0x00, 0xC1, 0x80, 0x40, 0xC0,
  0x20, 0x30, 0x10, 0x0C, 0x08, 0x02, 0x04, 0x01, 0x82, 0x00, 0x61, 0x00,
  0x18, 0x80, 0x04, 0x40, 0x03, 0x20, 0x00, 0xD0, 0x00, 0x30, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xA0, 0x00, 0x16, 0xC0, 0x00,
  0xDB, 0x00, 0x02, 0x64, 0x00, 0x09, 0x98, 0x00, 0x66, 0x20, 0x01, 0x18,
  0x80, 0x0C, 0x63, 0x00, 0x31, 0x84, 0x00, 0x86, 0x10, 0x06, 0x18, 0x60,
  0x10, 0x60, 0x80, 0x41, 0x83, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x20,
  0x60, 0x61, 0x81, 0x80, 0x84, 0x06, 0x02, 0x30, 0x18, 0x0C, 0xC0, 0x60,
  0x12, 0x01, 0x80, 0x78, 0x06, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0C,
  0x80, 0x06, 0x60, 0x03, 0x10, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x60, 0x80,
  0x30, 0x60, 0x18, 0x10, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80,
  0x60, 0xC0, 0x10, 0x60, 0x0C, 0x30, 0x02, 0x18, 0x01, 0x8C, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x03, 0xF0, 0x03, 0xDF, 0x03, 0x80, 0x60, 0x80, 0x0C, 0x60, 0x01,
  0x90, 0x00, 0x6C, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xB0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x06, 0x20, 0x03, 0x0E, 0x01, 0x80,
  0xF7, 0xC0, 0x1F, 0xC0, 0xFF, 0xE1, 0x01, 0xF2, 0x00, 0x74, 0x00, 0x68,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xD0, 0x03, 0xA0, 0x3E, 0x7F, 0xF0, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xDF, 0x03, 0x80, 0x60, 0x80, 0x0C, 0x60, 0x01, 0x30, 0x00, 0x6C, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00,
  0x19, 0x80, 0x04, 0x20, 0x03, 0x0E, 0x01, 0x80, 0xF7, 0xC0, 0x1F, 0xF0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0xFF, 0xE0, 0x60, 0x3C, 0x30, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x66, 0x00, 0x63, 0x01, 0xE1, 0xFF, 0xC0, 0xC0, 0x20,
  0x60, 0x18, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x19, 0x80, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x30,
  0x07, 0xF0, 0x0F, 0x9E, 0x0E, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x32, 0x00,
  0x09, 0x00, 0x06, 0x80, 0x03, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x06, 0x80, 0x03, 0x60, 0x03, 0x18, 0x03, 0x07, 0xCF, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x02, 0x60, 0x03,
  0x1C, 0x03, 0x07, 0xDF, 0x00, 0xFE, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0D,
  0x00, 0x01, 0xB0, 0x00, 0x26, 0x00, 0x0C, 0x40, 0x01, 0x8C, 0x00, 0x21,
  0x80, 0x0C, 0x10, 0x01, 0x83, 0x00, 0x20, 0x60, 0x0C, 0x04, 0x01, 0x80,
  0x80, 0x20, 0x18, 0x04, 0x01, 0x01, 0x80, 0x20, 0x20, 0x06, 0x04, 0x00,
  0x41, 0x80, 0x08, 0x20, 0x01, 0x84, 0x00, 0x31, 0x80, 0x02, 0x30, 0x00,
  0x64, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x40, 0x03, 0x00, 0x1A, 0x00, 0x18, 0x00, 0xD8, 0x01, 0xC0,
  0x04, 0xC0, 0x0A, 0x00, 0x26, 0x00, 0x58, 0x03, 0x10, 0x02, 0xC0, 0x18,
  0x80, 0x32, 0x00, 0x86, 0x01, 0x10, 0x04, 0x30, 0x08, 0xC0, 0x60, 0x80,
  0x46, 0x03, 0x04, 0x06, 0x10, 0x18, 0x30, 0x20, 0x80, 0x81, 0x81, 0x06,
  0x04, 0x0C, 0x18, 0x30, 0x60, 0x20, 0xC0, 0x83, 0x01, 0x04, 0x04, 0x10,
  0x0C, 0x20, 0x30, 0x80, 0x63, 0x01, 0x8C, 0x01, 0x18, 0x04, 0x60, 0x08,
  0x80, 0x23, 0x00, 0x64, 0x01, 0x90, 0x03, 0x60, 0x0C, 0x80, 0x1B, 0x00,
  0x2C, 0x00, 0x50, 0x01, 0x60, 0x02, 0x80, 0x0E, 0x00, 0x14, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x4C, 0x00,
  0x18, 0xC0, 0x06, 0x08, 0x00, 0xC1, 0x80, 0x30, 0x18, 0x04, 0x03, 0x01,
  0x80, 0x30, 0x60, 0x02, 0x0C, 0x00, 0x63, 0x00, 0x04, 0x40, 0x00, 0xD8,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x80, 0x01, 0xB0,
  0x00, 0x63, 0x00, 0x0C, 0x20, 0x03, 0x06, 0x00, 0x40, 0x60, 0x18, 0x0C,
  0x02, 0x00, 0xC0, 0xC0, 0x08, 0x30, 0x01, 0x86, 0x00, 0x11, 0x80, 0x03,
  0x20, 0x00, 0x30, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x80, 0x03, 0x10, 0x00,
  0x43, 0x00, 0x18, 0x20, 0x02, 0x06, 0x00, 0xC0, 0x40, 0x10, 0x0C, 0x06,
  0x00, 0x80, 0x80, 0x18, 0x30, 0x01, 0x04, 0x00, 0x31, 0x80, 0x02, 0x20,
  0x00, 0x6C, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF0, 0xFE, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xE0, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04, 0x01, 0x80,
  0x38, 0x0D, 0x01, 0x20, 0x26, 0x0C, 0x41, 0x0C, 0x21, 0x8C, 0x11, 0x03,
  0x20, 0x6C, 0x05, 0x00, 0xC0, 0xFF, 0xFE, 0x60, 0xC1, 0x06, 0x0C, 0x0F,
  0xC0, 0x73, 0xC3, 0x01, 0x98, 0x02, 0x40, 0x0B, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x3F, 0xF3, 0xE0, 0xD8, 0x03, 0x40, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x76, 0x02, 0xDF, 0xF3, 0x1F, 0x0C,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x1F, 0x0D, 0xCF, 0x3C, 0x0E, 0xE0, 0x1B, 0x00,
  0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xBC,
  0x0C, 0x9E, 0xF2, 0x1F, 0x00, 0x0F, 0xC0, 0x73, 0xC3, 0x01, 0x98, 0x02,
  0x40, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x40, 0x0D, 0x80,
  0x23, 0x01, 0x87, 0xBC, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x3F, 0x11,
  0xCE, 0x4C, 0x05, 0x60, 0x0D, 0x80, 0x34, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x40, 0x05, 0x80, 0x16, 0x00, 0xCC, 0x05, 0x1E, 0xF4, 0x3F, 0x10, 0x07,
  0xC0, 0x73, 0xC3, 0x01, 0x98, 0x02, 0x40, 0x0F, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0xC7, 0xBE, 0x07, 0xE0,
  0x03, 0xE0, 0xE0, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x1F, 0xF0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0F, 0xC4, 0x73, 0x93, 0x01, 0x58,
  0x03, 0x60, 0x0D, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x60, 0x05,
  0x80, 0x33, 0x01, 0x47, 0xBD, 0x0F, 0xC4, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x80, 0x33, 0x01, 0x87, 0x1C, 0x07, 0xE0, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x3E, 0x33, 0xBD, 0xA0, 0x6E, 0x01, 0xF0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x04, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08,
  0x34, 0xEF, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xB0, 0x0D, 0x80, 0xCC, 0x0C,
  0x60, 0xC3, 0x0C, 0x18, 0xC0, 0xCC, 0x06, 0xC0, 0x36, 0x01, 0xD8, 0x0E,
  0x60, 0x61, 0x83, 0x0C, 0x18, 0x30, 0xC0, 0xC6, 0x02, 0x30, 0x19, 0x80,
  0x6C, 0x01, 0x60, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x87, 0xC0, 0x7C, 0x4E, 0x70, 0xE7, 0x24, 0x0C, 0xC0, 0xD4, 0x03, 0xC0,
  0x2E, 0x01, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x20, 0x07, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0xC7, 0xC6, 0x77, 0xB4, 0x0D, 0xC0,
  0x3E, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x80, 0x07, 0xC0, 0x3C, 0xE0, 0xC0, 0x61, 0x00,
  0x66, 0x00, 0x48, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xA0, 0x03, 0x60,
  0x04, 0x40, 0x18, 0xC0, 0x60, 0xF7, 0x80, 0x7C, 0x00, 0x87, 0xC2, 0x73,
  0xCF, 0x03, 0xB8, 0x06, 0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0B, 0x00, 0x6E, 0x03, 0x37, 0xFC, 0xCF, 0xC3, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x0F, 0xC4, 0x73, 0x93, 0x01, 0x58, 0x03, 0x60, 0x0D, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x50, 0x01, 0x60, 0x05, 0x80, 0x33, 0x01, 0xC7, 0xBD, 0x0F,
  0xC4, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0xC7, 0xDF, 0xF0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x0F, 0xC1, 0xE7, 0x18, 0x0C, 0x80, 0x34, 0x00, 0xA0, 0x05, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x01, 0xC0, 0x0A, 0x00, 0xD8, 0x06, 0x79, 0xE0, 0xFC, 0x00, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC3, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x08, 0x07, 0x41, 0xE0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1A, 0x00, 0xD8,
  0x0A, 0x7B, 0x91, 0xF8, 0x80, 0xC0, 0x06, 0x80, 0x09, 0x00, 0x13, 0x00,
  0x62, 0x00, 0x84, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x10, 0x10, 0x30, 0x60,
  0x60, 0xC0, 0x41, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x10, 0x03, 0x60, 0x06,
  0xC0, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x80, 0x30, 0x05,
  0x00, 0x60, 0x0B, 0x00, 0xC0, 0x36, 0x03, 0xC0, 0x64, 0x07, 0x80, 0x88,
  0x09, 0x01, 0x18, 0x12, 0x06, 0x30, 0x66, 0x0C, 0x20, 0xC4, 0x10, 0x41,
  0x08, 0x20, 0xC2, 0x18, 0xC1, 0x8C, 0x31, 0x81, 0x10, 0x22, 0x02, 0x20,
  0x44, 0x06, 0xC0, 0xC8, 0x0D, 0x80, 0xB0, 0x0A, 0x01, 0x60, 0x14, 0x02,
  0x80, 0x38, 0x07, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x60, 0x0C,
  0xC0, 0x18, 0xC0, 0x60, 0x80, 0x81, 0x83, 0x01, 0x04, 0x03, 0x18, 0x03,
  0x60, 0x02, 0x80, 0x07, 0x00, 0x06, 0x00, 0x14, 0x00, 0x6C, 0x00, 0x88,
  0x03, 0x18, 0x04, 0x18, 0x18, 0x30, 0x60, 0x30, 0x80, 0x23, 0x00, 0x64,
  0x00, 0x60, 0xC0, 0x06, 0x80, 0x09, 0x00, 0x13, 0x00, 0x62, 0x00, 0xC4,
  0x01, 0x0C, 0x06, 0x08, 0x0C, 0x10, 0x10, 0x30, 0x60, 0x20, 0xC0, 0x41,
  0x00, 0xC6, 0x00, 0x8C, 0x01, 0x10, 0x03, 0x60, 0x02, 0xC0, 0x05, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0x00, 0x81,
  0xC1, 0x80, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x38, 0x18, 0x07, 0x00, 0x80, 0x60,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x1C, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x40, 0x1C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06,
  0x00, 0xC0, 0x1C, 0x03, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x60,
  0x10, 0x1C, 0x04, 0x00, 0x1E, 0x00, 0x5D, 0xC0, 0x14, 0x18, 0x0F, 0x03,
  0x02, 0xC0, 0x61, 0xA0, 0x0E, 0xC8, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 28, 8, 3, -28 },
  { 8, 6, 8, 11, 3, -30 },
  { 14, 18, 28, 20, 2, -28 },
  { 77, 15, 36, 19, 2, -32 },
  { 145, 22, 28, 26, 2, -28 },
  { 222, 18, 28, 21, 2, -28 },
  { 285, 1, 8, 7, 3, -30 },
  { 286, 7, 41, 11, 3, -32 },
  { 322, 7, 41, 11, 1, -32 },
  { 358, 15, 16, 17, 1, -28 },
  { 388, 16, 21, 20, 2, -24 },
  { 430, 3, 8, 8, 2, -3 },
  { 433, 8, 1, 11, 1, -13 },
  { 434, 3, 3, 9, 3, -3 },
  { 436, 11, 30, 14, 1, -28 },
  { 478, 15, 28, 19, 2, -28 },
  { 531, 9, 28, 19, 3, -28 },
  { 563, 16, 28, 19, 2, -28 },
  { 619, 15, 28, 19, 2, -28 },
  { 672, 16, 28, 19, 2, -28 },
  { 728, 14, 28, 19, 3, -28 },
  { 777, 14, 28, 19, 3, -28 },
  { 826, 15, 28, 19, 2, -28 },
  { 879, 15, 28, 19, 2, -28 },
  { 932, 15, 28, 19, 2, -28 },
  { 985, 3, 21, 7, 2, -21 },
  { 993, 4, 26, 7, 1, -21 },
  { 1006, 13, 16, 18, 2, -21 },
  { 1032, 14, 8, 20, 3, -17 },
  { 1046, 14, 16, 18, 2, -21 },
  { 1074, 12, 28, 16, 2, -28 },
  { 1116, 28, 37, 32, 2, -28 },
  { 1246, 20, 28, 21, 1, -28 },
  { 1316, 15, 28, 21, 4, -28 },
  { 1369, 17, 28, 23, 3, -28 },
  { 1429, 16, 28, 23, 4, -28 },
  { 1485, 14, 28, 20, 4, -28 },
  { 1534, 14, 28, 20, 4, -28 },
  { 1583, 18, 28, 24, 3, -28 },
  { 1646, 17, 28, 25, 4, -28 },
  { 1706, 2, 28, 10, 4, -28 },
  { 1713, 14, 28, 19, 2, -28 },
  { 1762, 17, 28, 22, 4, -28 },
  { 1822, 13, 28, 18, 4, -28 },
  { 1868, 22, 28, 30, 4, -28 },
  { 1945, 17, 28, 25, 4, -28 },
  { 2005, 18, 28, 23, 3, -28 },
  { 2068, 15, 28, 21, 4, -28 },
  { 2121, 18, 33, 23, 3, -28 },
  { 2196, 17, 28, 23, 3, -28 },
  { 2256, 17, 28, 21, 2, -28 },
  { 2316, 19, 28, 21, 1, -28 },
  { 2383, 17, 28, 23, 3, -28 },
  { 2443, 19, 28, 21, 1, -28 },
  { 2510, 29, 28, 31, 1, -28 },
  { 2612, 19, 28, 21, 1, -28 },
  { 2679, 19, 28, 21, 1, -28 },
  { 2746, 17, 28, 21, 2, -28 },
  { 2806, 5, 39, 8, 3, -33 },
  { 2831, 12, 30, 14, 1, -28 },
  { 2876, 5, 39, 8, 0, -33 },
  { 2901, 11, 14, 15, 2, -28 },
  { 2921, 15, 1, 15, 0, 0 },
  { 2923, 6, 5, 11, 2, -30 },
  { 2927, 14, 21, 19, 2, -21 },
  { 2964, 14, 30, 19, 3, -30 },
  { 3017, 14, 21, 18, 2, -21 },
  { 3054, 14, 30, 19, 2, -30 },
  { 3107, 14, 21, 18, 2, -21 },
  { 3144, 11, 30, 12, 1, -30 },
  { 3186, 14, 29, 19, 2, -21 },
  { 3237, 13, 30, 19, 3, -30 },
  { 3286, 2, 29, 8, 3, -29 },
  { 3294, 7, 37, 8, -2, -29 },
  { 3327, 13, 30, 17, 3, -30 },
  { 3376, 2, 30, 8, 3, -30 },
  { 3384, 25, 21, 31, 3, -21 },
  { 3450, 13, 21, 19, 3, -21 },
  { 3485, 15, 21, 19, 2, -21 },
  { 3525, 14, 29, 19, 3, -21 },
  { 3576, 14, 29, 19, 2, -21 },
  { 3627, 8, 21, 12, 3, -21 },
  { 3648, 13, 21, 18, 2, -21 },
  { 3683, 9, 27, 12, 1, -27 },
  { 3714, 13, 21, 19, 3, -21 },
  { 3749, 15, 21, 17, 1, -21 },
  { 3789, 23, 21, 26, 2, -21 },
  { 3850, 15, 21, 17, 1, -21 },
  { 3890, 15, 29, 17, 1, -21 },
  { 3945, 14, 21, 17, 2, -21 },
  { 3982, 9, 39, 12, 2, -31 },
  { 4026, 2, 33, 8, 3, -28 },
  { 4035, 10, 39, 12, 0, -31 },
  { 4084, 18, 7, 24, 3, -16 },
};

const GFXfont RobotoCondensed_ExtraLight40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT40PT7B_H_
