#ifndef _ROBOTOCONDENSED_EXTRALIGHT60PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight60pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x70, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x60, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1E,
  0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0x80, 0x01, 0x87, 0x00,
  0x03, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x1E,
  0x07, 0x80, 0x78, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x18, 0x03, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x60, 0x01,
  0x80, 0x30, 0x30, 0x00, 0xC0, 0x30, 0x30, 0x00, 0x70, 0x18, 0x18, 0x00,
  0x18, 0x1C, 0x18, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x01, 0xFC, 0x0C, 0x00,
  0x00, 0x10, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x81,
  0xFC, 0x00, 0x01, 0x81, 0xEF, 0x00, 0x00, 0xC1, 0xC1, 0xC0, 0x00, 0xC0,
  0xC0, 0x60, 0x00, 0x60, 0xC0, 0x18, 0x00, 0x60, 0x60, 0x0C, 0x00, 0x30,
  0x30, 0x06, 0x00, 0x30, 0x18, 0x01, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x0E,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x60, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x01,
  0xC1, 0xC0, 0x0C, 0x38, 0x0E, 0x00, 0xC3, 0x00, 0x70, 0x0C, 0x70, 0x03,
  0x00, 0xC6, 0x00, 0x38, 0x0C, 0x60, 0x01, 0xC1, 0xCE, 0x00, 0x0E, 0x18,
  0xE0, 0x00, 0x61, 0x8E, 0x00, 0x07, 0x38, 0xE0, 0x00, 0x3B, 0x0E, 0x00,
  0x01, 0xF0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1F,
  0x03, 0x80, 0x03, 0xB0, 0x3C, 0x00, 0x73, 0x81, 0xE0, 0x1E, 0x1C, 0x0F,
  0xFF, 0xC0, 0xE0, 0x3F, 0xF0, 0x06, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x20, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x02, 0x40, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x18, 0x02, 0xF0, 0x18, 0x1E, 0xFE, 0x18,
  0x7C, 0x1F, 0x9B, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xC3, 0x00, 0x01, 0x83,
  0x80, 0x03, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x0C, 0x00,
  0x70, 0x0C, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x39, 0x9C,
  0xC4, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x70, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x00, 0x06,
  0x1C, 0x00, 0x1C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCE, 0x00, 0x03, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6E, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x31, 0xC0,
  0x01, 0xC3, 0x00, 0x06, 0x0E, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x38, 0x0E,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x10, 0x0F,
  0x03, 0xF0, 0xFB, 0x3E, 0x3F, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x70,
  0x0F, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x67, 0x00, 0x00,
  0xCE, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xC0, 0x07, 0x07,
  0x00, 0x06, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x39, 0x80, 0x00, 0x33, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x06, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xE0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC6, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x71, 0xFC, 0x03,
  0xBF, 0xF8, 0x1B, 0x81, 0xE0, 0xF0, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x66, 0x00, 0x03, 0x38, 0x00, 0x38, 0xC0, 0x01, 0x87, 0x00, 0x1C,
  0x1E, 0x01, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x3F, 0x80, 0xC3, 0xFF, 0x83, 0x1E, 0x0F,
  0x0C, 0xE0, 0x0E, 0x36, 0x00, 0x1C, 0xF0, 0x00, 0x33, 0x80, 0x00, 0xEE,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x07, 0x00,
  0x38, 0x0F, 0x01, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xC0, 0x07, 0x03,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x9C, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x70, 0x00,
  0x70, 0x70, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x78, 0x3C, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x70,
  0xC0, 0x00, 0x63, 0x80, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x9C, 0x00,
  0x07, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x1F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x60, 0x01, 0xC3,
  0x80, 0x03, 0x0C, 0x00, 0x0E, 0x70, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCC, 0x00,
  0x0F, 0x38, 0x00, 0x7C, 0x70, 0x01, 0xB1, 0xE0, 0x1C, 0xC3, 0xC1, 0xE3,
  0x03, 0xFF, 0x0C, 0x07, 0xF0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xE4,
  0x38, 0xF3, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x18, 0x61, 0x86,
  0x18, 0xE3, 0x8C, 0x73, 0x84, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x30, 0x03,
  0x1C, 0x00, 0xE6, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xF8,
  0x00, 0x30, 0xE0, 0x01, 0xFF, 0x00, 0x18, 0x60, 0x01, 0xC1, 0xC0, 0x0C,
  0x30, 0x01, 0xC0, 0x70, 0x06, 0x30, 0x01, 0xC0, 0x18, 0x01, 0x98, 0x00,
  0xC0, 0x0C, 0x00, 0xCC, 0x00, 0xC0, 0x06, 0x00, 0x66, 0x00, 0x60, 0x03,
  0x00, 0x36, 0x00, 0x60, 0x01, 0x80, 0x1B, 0x00, 0x30, 0x01, 0x80, 0x0D,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x60, 0x0C,
  0x00, 0x30, 0x01, 0xB0, 0x06, 0x00, 0x18, 0x00, 0xD8, 0x03, 0x00, 0x0C,
  0x00, 0x6C, 0x01, 0x80, 0x06, 0x00, 0x36, 0x00, 0xC0, 0x03, 0x00, 0x1B,
  0x00, 0x60, 0x01, 0x80, 0x0D, 0x80, 0x30, 0x00, 0xC0, 0x06, 0xC0, 0x18,
  0x00, 0x60, 0x02, 0x60, 0x0C, 0x00, 0x70, 0x03, 0x30, 0x06, 0x00, 0x38,
  0x01, 0x98, 0x03, 0x00, 0x1C, 0x00, 0xCC, 0x01, 0x80, 0x1E, 0x00, 0xC6,
  0x00, 0xE0, 0x1B, 0x00, 0x63, 0x80, 0x30, 0x0D, 0x80, 0x60, 0xC0, 0x1C,
  0x1C, 0x60, 0x60, 0x60, 0x07, 0xFC, 0x3D, 0xF0, 0x30, 0x01, 0xFC, 0x0F,
  0xE0, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x01, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x03, 0xE0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0,
  0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x03, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x38, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00, 0xF0,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0xE0, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0xF8, 0x1C,
  0x00, 0x1E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x01, 0xE0, 0xE0, 0x07, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x07,
  0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6E, 0x00,
  0x07, 0x30, 0x00, 0x31, 0xC0, 0x03, 0x87, 0x00, 0x38, 0x1C, 0x03, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x39, 0xB8, 0x00, 0x0E, 0xE7, 0x00, 0x03, 0xF0,
  0xE0, 0x00, 0xF8, 0x18, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFD, 0x80, 0x00, 0x00, 0x3F, 0xB0, 0x00, 0x00, 0x0F, 0xF7,
  0x00, 0x00, 0x01, 0xBE, 0x60, 0x00, 0x00, 0x37, 0xCC, 0x00, 0x00, 0x0E,
  0xF9, 0xC0, 0x00, 0x01, 0x9F, 0x18, 0x00, 0x00, 0x33, 0xE3, 0x00, 0x00,
  0x0E, 0x7C, 0x30, 0x00, 0x01, 0x8F, 0xC6, 0x00, 0x00, 0x31, 0xF8, 0xE0,
  0x00, 0x0C, 0x3F, 0x0C, 0x00, 0x01, 0x87, 0xE1, 0x80, 0x00, 0x30, 0xFC,
  0x38, 0x00, 0x0C, 0x1F, 0x83, 0x00, 0x01, 0x83, 0xF0, 0x60, 0x00, 0x70,
  0x7E, 0x0E, 0x00, 0x0C, 0x0F, 0xC0, 0xC0, 0x01, 0x81, 0xF8, 0x18, 0x00,
  0x70, 0x3F, 0x01, 0x80, 0x0C, 0x07, 0xE0, 0x30, 0x01, 0x80, 0xFC, 0x06,
  0x00, 0x70, 0x1F, 0x80, 0x60, 0x0C, 0x03, 0xF0, 0x0C, 0x01, 0x80, 0x7E,
  0x01, 0xC0, 0x60, 0x0F, 0xC0, 0x18, 0x0C, 0x01, 0xF8, 0x03, 0x01, 0x80,
  0x3F, 0x00, 0x70, 0x60, 0x07, 0xE0, 0x06, 0x0C, 0x00, 0xFC, 0x00, 0xC3,
  0x80, 0x1F, 0x80, 0x1C, 0x60, 0x03, 0xF0, 0x01, 0x8C, 0x00, 0x7E, 0x00,
  0x33, 0x80, 0x0F, 0xC0, 0x03, 0x60, 0x01, 0xF8, 0x00, 0x6C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x1F, 0x80, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFB, 0x00, 0x00, 0x3F, 0x70, 0x00, 0x07, 0xE6, 0x00, 0x00,
  0xFC, 0x60, 0x00, 0x1F, 0x8E, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x7E, 0x1C,
  0x00, 0x0F, 0xC1, 0x80, 0x01, 0xF8, 0x38, 0x00, 0x3F, 0x03, 0x00, 0x07,
  0xE0, 0x70, 0x00, 0xFC, 0x07, 0x00, 0x1F, 0x80, 0x60, 0x03, 0xF0, 0x0E,
  0x00, 0x7E, 0x00, 0xC0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x01, 0x80, 0x3F,
  0x00, 0x38, 0x07, 0xE0, 0x03, 0x80, 0xFC, 0x00, 0x30, 0x1F, 0x80, 0x07,
  0x03, 0xF0, 0x00, 0x60, 0x7E, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0xC1, 0xF8,
  0x00, 0x1C, 0x3F, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x18, 0xFC, 0x00, 0x03,
  0x9F, 0x80, 0x00, 0x33, 0xF0, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x6F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xE0, 0x01,
  0xF0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x01,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x43, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x7C, 0x18, 0x00, 0x0F, 0x0C, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0xC6, 0x00, 0x01, 0xC3, 0x00, 0x07, 0xC1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0E, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3C, 0x00,
  0xF0, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x1F, 0x00, 0x78, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x30, 0x00, 0x07, 0x00, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00,
  0x0C, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x8C, 0x00, 0x06, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xD8, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xC6, 0x00, 0x0E, 0x0C, 0x00, 0x18,
  0xC0, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x07, 0x00, 0x18, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x30,
  0x03, 0x01, 0x80, 0x18, 0x07, 0x00, 0x60, 0x30, 0x07, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x38, 0x0C, 0x01, 0x80, 0xE0, 0x07, 0x03, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x70, 0x00, 0x39, 0x80, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0E,
  0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x38, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x01,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x60,
  0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x30, 0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0x60, 0x06,
  0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3C, 0x03, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x39, 0xC0, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xF0, 0xF8, 0x01, 0x8F, 0x00, 0x0C, 0xE0, 0x00, 0x66, 0x00,
  0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x1D, 0xC0, 0x00, 0xE6, 0x00, 0x0F, 0x38, 0x00,
  0xD8, 0xE0, 0x1C, 0xE7, 0xFF, 0xC7, 0x0F, 0xF8, 0x18, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x61, 0xFF,
  0x03, 0x3F, 0xFE, 0x1B, 0x80, 0x78, 0xD8, 0x01, 0xC7, 0x80, 0x07, 0x38,
  0x00, 0x19, 0x80, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x01, 0xDC, 0x00, 0x0C, 0xE0, 0x00, 0xE7,
  0xC0, 0x0E, 0x37, 0x00, 0xE1, 0x9F, 0xFF, 0x0C, 0x3F, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x03, 0x81,
  0x80, 0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0xCC, 0x00, 0x07, 0x60, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xE0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x78, 0x07, 0x81, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0xF8, 0x70, 0x7F, 0xF9,
  0xC3, 0x80, 0x77, 0x1C, 0x00, 0xFC, 0xE0, 0x01, 0xF3, 0x00, 0x03, 0xDC,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xCC, 0x00, 0x0F, 0x38, 0x00, 0x3C,
  0x70, 0x01, 0xF0, 0xE0, 0x1D, 0xC1, 0xFF, 0xE7, 0x03, 0xFE, 0x1C, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0x80,
  0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0E,
  0x60, 0x00, 0x1B, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x10, 0x70, 0x00,
  0xE0, 0xF0, 0x0F, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x01, 0xFC, 0x07, 0xF8, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x3F, 0xFF, 0x7F, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xC1, 0xFF, 0xE6, 0x3C,
  0x03, 0xB1, 0xC0, 0x0D, 0x9C, 0x00, 0x3C, 0xC0, 0x00, 0xEE, 0x00, 0x03,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xDC,
  0x00, 0x06, 0x60, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x3C, 0x38, 0x07,
  0x60, 0xFF, 0xF3, 0x03, 0xFE, 0x18, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x62, 0x00, 0x06,
  0x38, 0x00, 0x70, 0xE0, 0x07, 0x03, 0xC0, 0xF8, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x83, 0xFC, 0x31,
  0xFF, 0xE6, 0x70, 0x1C, 0xDC, 0x01, 0xDB, 0x00, 0x1B, 0xC0, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x06, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x01,
  0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x07, 0x03, 0x8F, 0xE3, 0xE0, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00,
  0x38, 0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x1C, 0x0C, 0x03, 0x80, 0xC0,
  0x70, 0x0C, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xC3, 0x80, 0x0C,
  0x70, 0x00, 0xCE, 0x00, 0x0D, 0xF0, 0x00, 0xDB, 0x00, 0x0F, 0x38, 0x00,
  0xE1, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xE0, 0x0C, 0x07, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00,
  0x70, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x03, 0x83, 0xFC, 0x01, 0xFF, 0x0E,
  0x3F, 0xF8, 0x1F, 0xFE, 0x39, 0xC0, 0x70, 0xE0, 0x1C, 0xEC, 0x00, 0xE7,
  0x00, 0x3B, 0xE0, 0x01, 0x98, 0x00, 0xEF, 0x80, 0x07, 0xC0, 0x01, 0xBC,
  0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x00, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xE0,
  0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x00,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0x80,
  0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x03, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00,
  0x0F, 0x80, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00,
  0x0C, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x3F, 0xC3, 0x1F, 0xFE, 0x67, 0x01,
  0xCD, 0xC0, 0x1D, 0xB0, 0x01, 0xBC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xC0, 0x07,
  0x03, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xE0, 0x00,
  0x18, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x80, 0x0E,
  0x03, 0xC0, 0x78, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x06, 0x1F, 0xF0, 0x33, 0xFF, 0xE1, 0xB8, 0x07, 0x8D, 0x80,
  0x1C, 0x78, 0x00, 0x73, 0x80, 0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0xC0,
  0x00, 0xCE, 0x00, 0x0E, 0x78, 0x00, 0xE3, 0x70, 0x0E, 0x19, 0xFF, 0xF0,
  0xC3, 0xFE, 0x06, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0xC3, 0xFF, 0xE6, 0x3C, 0x03, 0xB1, 0xC0, 0x0F,
  0x9C, 0x00, 0x3C, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x06, 0x60, 0x00,
  0x73, 0x80, 0x03, 0x8E, 0x00, 0x3C, 0x38, 0x07, 0x60, 0xFF, 0xF3, 0x03,
  0xFE, 0x18, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x3F, 0xC7, 0xFC, 0xE0, 0xD8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xC0, 0x3C, 0x38, 0x00,
  0xE7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00,
  0x67, 0x00, 0x0E, 0x3C, 0x01, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x02,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0xFF, 0xFB, 0xFF, 0xE0, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x20, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x0F, 0x38,
  0x01, 0xF1, 0xC0, 0x3B, 0x0F, 0xFF, 0x30, 0x7F, 0xC3, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6E, 0x00, 0x01, 0x98, 0x00, 0x0E, 0x60,
  0x00, 0x31, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x38, 0x00,
  0x60, 0x60, 0x01, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x30, 0x07, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x06, 0x03, 0x80, 0x18,
  0x0C, 0x00, 0x70, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0E, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x1C, 0x00,
  0x1D, 0x80, 0x03, 0x80, 0x03, 0x38, 0x00, 0x78, 0x00, 0x67, 0x00, 0x1B,
  0x00, 0x1C, 0x60, 0x03, 0x60, 0x03, 0x8C, 0x00, 0x6C, 0x00, 0x61, 0x80,
  0x0D, 0xC0, 0x0C, 0x38, 0x03, 0x18, 0x03, 0x83, 0x00, 0x63, 0x00, 0x70,
  0x60, 0x0C, 0x60, 0x0C, 0x0C, 0x01, 0x8E, 0x01, 0x81, 0xC0, 0x60, 0xC0,
  0x30, 0x18, 0x0C, 0x18, 0x0E, 0x03, 0x01, 0x83, 0x01, 0x80, 0x60, 0x70,
  0x30, 0x30, 0x0E, 0x0C, 0x06, 0x06, 0x00, 0xC1, 0x80, 0xC1, 0xC0, 0x18,
  0x30, 0x18, 0x30, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x71, 0x80, 0x30, 0xC0,
  0x06, 0x30, 0x06, 0x38, 0x00, 0xC6, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x0C,
  0xC0, 0x03, 0xB0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x33, 0x00, 0x06, 0xC0,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x39, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0E, 0x00, 0x18, 0x1C,
  0x00, 0xE0, 0x30, 0x07, 0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0, 0x07, 0x03,
  0x00, 0x0C, 0x1C, 0x00, 0x38, 0x60, 0x00, 0x73, 0x00, 0x00, 0xDC, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x73, 0x00, 0x01, 0x8E, 0x00, 0x0C, 0x1C,
  0x00, 0x70, 0x30, 0x01, 0x80, 0xE0, 0x0E, 0x01, 0x80, 0x30, 0x07, 0x01,
  0xC0, 0x0C, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x71, 0xC0, 0x00, 0xC6, 0x00,
  0x03, 0xB8, 0x00, 0x06, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0,
  0x70, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x01, 0xC0, 0x07, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x1C, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x73,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x01, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0x3C, 0x78, 0x00, 0x63, 0x01, 0xC0, 0x06, 0x60,
  0x0E, 0x00, 0x66, 0x00, 0x70, 0x0E, 0x60, 0x03, 0x80, 0xCC, 0x00, 0x1E,
  0x3C, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLight60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 44, 12, 4, -43 },
  { 23, 9, 13, 16, 4, -45 },
  { 38, 28, 43, 30, 2, -43 },
  { 189, 23, 56, 29, 3, -50 },
  { 350, 33, 45, 39, 3, -44 },
  { 536, 28, 45, 32, 3, -44 },
  { 694, 2, 12, 10, 4, -45 },
  { 697, 12, 62, 17, 4, -48 },
  { 790, 12, 62, 17, 1, -48 },
  { 883, 24, 23, 25, 1, -43 },
  { 952, 25, 31, 30, 2, -35 },
  { 1049, 5, 13, 11, 2, -5 },
  { 1058, 12, 2, 16, 2, -20 },
  { 1061, 4, 4, 14, 4, -3 },
  { 1063, 18, 47, 21, 1, -43 },
  { 1169, 22, 45, 29, 4, -44 },
  { 1293, 12, 43, 29, 5, -43 },
  { 1358, 23, 44, 29, 3, -44 },
  { 1485, 23, 45, 29, 3, -44 },
  { 1615, 26, 43, 29, 2, -43 },
  { 1755, 21, 44, 29, 5, -43 },
  { 1871, 22, 44, 29, 4, -43 },
  { 1992, 24, 43, 29, 2, -43 },
  { 2121, 23, 45, 29, 3, -44 },
  { 2251, 22, 44, 29, 3, -44 },
  { 2372, 4, 32, 11, 4, -31 },
  { 2388, 6, 39, 11, 2, -31 },
  { 2418, 20, 25, 27, 3, -32 },
  { 2481, 21, 14, 29, 4, -27 },
  { 2518, 20, 25, 27, 4, -32 },
  { 2581, 18, 45, 24, 3, -44 },
  { 2683, 41, 54, 48, 3, -41 },
  { 2960, 30, 43, 32, 1, -43 },
  { 3122, 24, 43, 32, 5, -43 },
  { 3251, 26, 45, 34, 4, -44 },
  { 3398, 25, 43, 34, 5, -43 },
  { 3533, 22, 43, 30, 5, -43 },
  { 3652, 23, 43, 30, 5, -43 },
  { 3776, 26, 45, 36, 5, -44 },
  { 3923, 27, 43, 37, 5, -43 },
  { 4069, 2, 43, 15, 6, -43 },
  { 4080, 21, 44, 29, 3, -43 },
  { 4196, 26, 43, 33, 5, -43 },
  { 4336, 21, 43, 28, 5, -43 },
  { 4449, 35, 43, 45, 5, -43 },
  { 4638, 27, 43, 37, 5, -43 },
  { 4784, 27, 45, 35, 4, -44 },
  { 4936, 24, 43, 32, 5, -43 },
  { 5065, 27, 52, 35, 4, -44 },
  { 5241, 25, 43, 34, 5, -43 },
  { 5376, 26, 45, 31, 3, -44 },
  { 5523, 28, 43, 31, 2, -43 },
  { 5674, 25, 44, 35, 5, -43 },
  { 5812, 30, 43, 32, 1, -43 },
  { 5974, 43, 43, 47, 2, -43 },
  { 6206, 28, 43, 32, 2, -43 },
  { 6357, 29, 43, 31, 1, -43 },
  { 6513, 26, 43, 31, 3, -43 },
  { 6653, 7, 58, 13, 5, -49 },
  { 6704, 17, 47, 21, 2, -43 },
  { 6804, 8, 58, 13, 0, -49 },
  { 6862, 16, 21, 22, 3, -43 },
  { 6904, 21, 2, 23, 1, 0 },
  { 6910, 8, 8, 16, 4, -45 },
  { 6918, 21, 34, 28, 3, -33 },
  { 7008, 21, 46, 29, 5, -45 },
  { 7129, 21, 34, 27, 3, -33 },
  { 7219, 22, 46, 29, 3, -45 },
  { 7346, 22, 34, 27, 3, -33 },
  { 7440, 15, 46, 18, 2, -46 },
  { 7527, 21, 45, 29, 3, -33 },
  { 7646, 19, 45, 29, 5, -45 },
  { 7753, 4, 44, 12, 4, -44 },
  { 7775, 10, 56, 12, -2, -44 },
  { 7845, 20, 45, 26, 5, -45 },
  { 7958, 2, 45, 12, 5, -45 },
  { 7970, 38, 33, 46, 4, -33 },
  { 8127, 19, 33, 29, 5, -33 },
  { 8206, 23, 34, 29, 3, -33 },
  { 8304, 21, 45, 29, 5, -33 },
  { 8423, 21, 45, 29, 3, -33 },
  { 8542, 12, 33, 18, 5, -33 },
  { 8592, 20, 34, 27, 3, -33 },
  { 8677, 14, 41, 17, 1, -40 },
  { 8749, 20, 33, 29, 4, -32 },
  { 8832, 22, 32, 25, 2, -32 },
  { 8920, 35, 32, 39, 2, -32 },
  { 9060, 22, 32, 26, 2, -32 },
  { 9148, 23, 44, 25, 1, -32 },
  { 9275, 21, 32, 26, 3, -32 },
  { 9359, 15, 60, 18, 2, -47 },
  { 9472, 3, 51, 13, 5, -43 },
  { 9492, 14, 60, 18, 1, -47 },
  { 9597, 28, 10, 36, 4, -23 },
};

const GFXfont RobotoCondensed_ExtraLight60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT60PT7B_H_
