#ifndef _ROBOTOCONDENSED_EXTRALIGHT45PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight45pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x00,
  0xBB, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE2, 0xC4, 0x00, 0xC0, 0x80,
  0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x81, 0x00, 0x10, 0x10, 0x01, 0x01, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x30, 0x30, 0x03, 0x02, 0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x60, 0x02, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x04,
  0x04, 0x00, 0x40, 0x40, 0xFF, 0xFF, 0xE0, 0x40, 0xC0, 0x0C, 0x0C, 0x00,
  0xC0, 0x80, 0x0C, 0x08, 0x00, 0x80, 0x80, 0x08, 0x18, 0x00, 0x81, 0x80,
  0x18, 0x18, 0x01, 0x81, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x0E, 0x60, 0x06, 0x60,
  0x02, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x38,
  0x0C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x08,
  0x00, 0x04, 0x06, 0x02, 0x02, 0x03, 0x01, 0x03, 0x01, 0x81, 0x81, 0x80,
  0xC1, 0x80, 0xC0, 0x60, 0x80, 0x20, 0x30, 0xC0, 0x10, 0x18, 0x40, 0x0C,
  0x08, 0x60, 0x02, 0x0C, 0x20, 0x01, 0xDC, 0x30, 0x00, 0x3C, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x3E, 0x00, 0x0C, 0x3B,
  0x80, 0x04, 0x30, 0x60, 0x06, 0x10, 0x10, 0x02, 0x08, 0x08, 0x03, 0x0C,
  0x06, 0x01, 0x06, 0x03, 0x01, 0x83, 0x01, 0x80, 0x81, 0x80, 0xC0, 0xC0,
  0xC0, 0x60, 0xC0, 0x20, 0x20, 0x20, 0x10, 0x10, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0x07,
  0x00, 0x18, 0x18, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x60, 0x10, 0x03,
  0x00, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0xE0,
  0x00, 0x6E, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0C,
  0xC0, 0x00, 0xC6, 0x01, 0x8C, 0x18, 0x0C, 0x60, 0x60, 0x66, 0x01, 0x83,
  0x30, 0x0C, 0x11, 0x00, 0x31, 0x98, 0x00, 0xCC, 0xC0, 0x06, 0x42, 0x00,
  0x1E, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x3C, 0x1C, 0x07, 0x30,
  0x7F, 0xF0, 0xC0, 0xFE, 0x03, 0xFF, 0xFA, 0x80, 0x01, 0x00, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x08,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C,
  0x0C, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x03, 0x02, 0x07, 0xF1, 0x1F, 0x1F, 0xBC, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x23, 0x00, 0x31, 0x80, 0x30, 0x60,
  0x30, 0x18, 0x18, 0x0E, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x33, 0x33, 0x26, 0x6C, 0x80, 0xFF, 0xFF, 0xC0, 0x7D, 0x80, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x0F, 0xF0,
  0x18, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x02,
  0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x18, 0x18, 0x0F, 0xF0, 0x07, 0xE0,
  0x00, 0x83, 0xC7, 0xEE, 0x3C, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0xF0, 0x03, 0xFE, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x00, 0x04, 0x40, 0x01, 0x30, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFD, 0xFF, 0xFF,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x86, 0x00, 0xC3, 0x00, 0x33, 0x00,
  0x09, 0x80, 0x04, 0xC0, 0x03, 0x40, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x63,
  0x00, 0x30, 0xC0, 0x30, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0xC8, 0x00, 0x19,
  0x00, 0x06, 0x20, 0x00, 0xC4, 0x00, 0x30, 0x80, 0x04, 0x10, 0x01, 0x82,
  0x00, 0x20, 0x40, 0x0C, 0x08, 0x03, 0x01, 0x00, 0x60, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x80, 0xC0, 0x10, 0x18, 0x02, 0x06, 0x00, 0x40, 0xC0, 0x08,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x3F, 0xFE, 0x3F, 0xFE, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x47, 0xE0, 0x5F, 0xF0, 0x70, 0x18, 0x40, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x18,
  0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x78, 0x01, 0xF8, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC3, 0xE0, 0xCF, 0xF8, 0xD8, 0x0C, 0xF0, 0x06, 0xE0, 0x06,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x06,
  0x30, 0x06, 0x18, 0x1C, 0x0F, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xC0,
  0x1C, 0x30, 0x03, 0x18, 0x00, 0x46, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x06, 0x03, 0x80,
  0xFF, 0x80, 0x1F, 0xE0, 0x1C, 0x0C, 0x0C, 0x01, 0xC2, 0x00, 0x31, 0x80,
  0x06, 0x40, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xD0, 0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x30, 0x03, 0x06, 0x01, 0x80,
  0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0x03, 0x06, 0x00,
  0xC3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x03, 0x40, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06,
  0xC0, 0x03, 0x60, 0x03, 0x98, 0x01, 0xCC, 0x01, 0xE3, 0x01, 0xB0, 0xFF,
  0x98, 0x3F, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0xDF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xBE, 0x67, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x22, 0x66, 0x6C, 0x80,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x83,
  0x03, 0x18, 0x06, 0x40, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x18, 0xC0, 0x0F, 0x80, 0x22, 0x00, 0xFF, 0x00, 0x98, 0x06, 0x06,
  0x02, 0x60, 0x10, 0x18, 0x0D, 0x00, 0xC0, 0x60, 0x3C, 0x02, 0x01, 0x80,
  0x70, 0x18, 0x06, 0x01, 0xC0, 0x40, 0x18, 0x06, 0x01, 0x00, 0x60, 0x18,
  0x0C, 0x01, 0x00, 0x60, 0x30, 0x04, 0x01, 0x80, 0xC0, 0x10, 0x06, 0x03,
  0x00, 0x40, 0x18, 0x08, 0x01, 0x00, 0xE0, 0x20, 0x0C, 0x03, 0x80, 0xC0,
  0x30, 0x0A, 0x03, 0x00, 0xC0, 0x2C, 0x0C, 0x07, 0x01, 0xB0, 0x10, 0x14,
  0x04, 0xC0, 0x60, 0x98, 0x31, 0x00, 0xFE, 0x3B, 0x86, 0x01, 0xE0, 0x78,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x48, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x21, 0x00,
  0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x20, 0x00, 0x40, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x08, 0x00, 0x40,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x04, 0x00, 0x08, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x0C, 0x00,
  0xE3, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x04,
  0xC0, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30,
  0x03, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xC0, 0x0E, 0x30, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30,
  0x01, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1C,
  0x03, 0x81, 0x80, 0x0C, 0x30, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x64,
  0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x06, 0x60,
  0x00, 0x63, 0x00, 0x04, 0x18, 0x00, 0xC0, 0xC0, 0x38, 0x07, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0x00, 0x38, 0x60, 0x03, 0x8C,
  0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x58,
  0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x02, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x71, 0x80,
  0x1C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xF9, 0xFF, 0xFC, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFC,
  0xFF, 0xFE, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x70, 0x0E, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05,
  0x80, 0x00, 0xB0, 0x00, 0x13, 0x00, 0x0E, 0x38, 0x07, 0x83, 0xFF, 0xC0,
  0x0F, 0xE0, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C,
  0x30, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0,
  0x03, 0x8C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x70, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00,
  0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0xF0, 0x00, 0xDB, 0x00,
  0x0F, 0x18, 0x00, 0xE0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x06, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x02, 0xF4, 0x00, 0x01, 0xBD, 0x80, 0x00,
  0x6F, 0x60, 0x00, 0x13, 0xC8, 0x00, 0x0C, 0xF3, 0x00, 0x03, 0x3C, 0xC0,
  0x00, 0x8F, 0x10, 0x00, 0x63, 0xC6, 0x00, 0x10, 0xF1, 0x80, 0x0C, 0x3C,
  0x20, 0x03, 0x0F, 0x0C, 0x00, 0x83, 0xC1, 0x00, 0x60, 0xF0, 0x60, 0x18,
  0x3C, 0x18, 0x04, 0x0F, 0x02, 0x03, 0x03, 0xC0, 0xC0, 0xC0, 0xF0, 0x30,
  0x20, 0x3C, 0x04, 0x18, 0x0F, 0x01, 0x86, 0x03, 0xC0, 0x63, 0x00, 0xF0,
  0x08, 0xC0, 0x3C, 0x03, 0x20, 0x0F, 0x00, 0x58, 0x03, 0xC0, 0x16, 0x00,
  0xF0, 0x07, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3D, 0x80,
  0x03, 0xC8, 0x00, 0x3C, 0xC0, 0x03, 0xC6, 0x00, 0x3C, 0x60, 0x03, 0xC3,
  0x00, 0x3C, 0x30, 0x03, 0xC1, 0x80, 0x3C, 0x08, 0x03, 0xC0, 0xC0, 0x3C,
  0x06, 0x03, 0xC0, 0x60, 0x3C, 0x03, 0x03, 0xC0, 0x30, 0x3C, 0x01, 0x83,
  0xC0, 0x08, 0x3C, 0x00, 0xC3, 0xC0, 0x06, 0x3C, 0x00, 0x63, 0xC0, 0x03,
  0x3C, 0x00, 0x33, 0xC0, 0x01, 0xBC, 0x00, 0x0B, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1C,
  0x03, 0x83, 0x80, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x34,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0xC1, 0xC0, 0x38, 0x07, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x0C, 0xC0, 0x07, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1C, 0x03, 0x83, 0x80, 0x0C,
  0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x38, 0x00, 0xC1, 0xC0, 0x38, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x02, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0xC6, 0x00, 0x30, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0x00, 0xC0, 0x60, 0x0C,
  0x0C, 0x01, 0x81, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x03, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x0E,
  0x18, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x80, 0x01, 0xB8, 0x00, 0x33,
  0x00, 0x0C, 0x38, 0x07, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x06,
  0x70, 0x03, 0x8E, 0x01, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xC0, 0x00, 0x0D,
  0x00, 0x00, 0x26, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x80, 0x06, 0x02, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x08, 0x04, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x04, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x61, 0x80, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x12, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x02, 0xC0, 0x03, 0x80,
  0x06, 0xC0, 0x02, 0x80, 0x06, 0x40, 0x02, 0xC0, 0x06, 0x60, 0x06, 0xC0,
  0x04, 0x60, 0x06, 0x40, 0x0C, 0x60, 0x04, 0x40, 0x0C, 0x60, 0x04, 0x60,
  0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x20, 0x08, 0x30, 0x08, 0x20,
  0x18, 0x30, 0x08, 0x30, 0x18, 0x10, 0x18, 0x30, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x18, 0x10, 0x10, 0x30, 0x18, 0x10, 0x18, 0x30, 0x18, 0x30, 0x18,
  0x30, 0x08, 0x30, 0x08, 0x30, 0x0C, 0x20, 0x08, 0x20, 0x0C, 0x20, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x04, 0x60, 0x04, 0x60, 0x04, 0x40, 0x04,
  0x40, 0x06, 0x40, 0x06, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x02, 0x80, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x19,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x06, 0x00,
  0x60, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x61, 0x80, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x18, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x20,
  0x06, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x40, 0x00, 0x23, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3F, 0xF0, 0x40, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x3F, 0xFF, 0x06, 0x00, 0x60, 0x07, 0x00, 0xD0, 0x09, 0x00, 0x98,
  0x18, 0x81, 0x08, 0x10, 0xC3, 0x04, 0x20, 0x62, 0x06, 0x60, 0x24, 0x03,
  0xC0, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0x83, 0x0C, 0x18,
  0x30, 0x07, 0xF0, 0x1F, 0xF8, 0x38, 0x0C, 0x30, 0x06, 0x60, 0x02, 0x60,
  0x02, 0x40, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xFF, 0x1F,
  0xFF, 0x38, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x60, 0x0B, 0x70, 0x3B, 0x3F, 0xE3, 0x0F,
  0xC3, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xE0, 0xCF,
  0xF8, 0xD8, 0x0C, 0xF0, 0x06, 0xE0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x06, 0xF0, 0x06, 0xD8, 0x0C, 0xCF, 0xF8, 0xC3, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x38, 0x0C, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x30, 0x06, 0x18, 0x0C, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x3F, 0x08, 0xFF, 0x93, 0x01, 0xAC, 0x01, 0x50,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x28, 0x00, 0xD8, 0x03, 0x98, 0x0D, 0x1F, 0xF2, 0x1F,
  0x84, 0x03, 0xF0, 0x0F, 0xF8, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x03, 0x60,
  0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x02, 0x18, 0x06, 0x0F, 0xFC, 0x03,
  0xF0, 0x03, 0xE0, 0xFC, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x03, 0xFF, 0x7F, 0xE1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x0F, 0xC2, 0x3F, 0xE4, 0xC0, 0x6B, 0x00, 0x5C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0A,
  0x00, 0x36, 0x00, 0xE6, 0x03, 0x47, 0xFC, 0x87, 0xE1, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x6C, 0x01, 0x8C, 0x07, 0x0F, 0xFC,
  0x07, 0xE0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x0F, 0xC6, 0x3F,
  0xCC, 0xC0, 0xDB, 0x00, 0xBC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x04, 0x5D, 0x80, 0x00, 0x09, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x02, 0x07, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x0C, 0xFC,
  0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0xC0,
  0x1C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0x80, 0xC3,
  0x00, 0xC6, 0x00, 0xCE, 0x00, 0xCC, 0x00, 0xDE, 0x00, 0xF3, 0x00, 0xE3,
  0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC3, 0xF0, 0x1F, 0x86, 0x3F, 0xC1, 0xFE, 0x36, 0x03, 0x38,
  0x19, 0xA0, 0x19, 0x00, 0x6F, 0x00, 0x78, 0x03, 0x70, 0x03, 0x80, 0x0B,
  0x80, 0x1C, 0x00, 0x58, 0x00, 0x40, 0x02, 0xC0, 0x02, 0x00, 0x1E, 0x00,
  0x10, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x20,
  0x01, 0xE0, 0x01, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x78, 0x00, 0x40, 0x03,
  0xC0, 0x02, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x80,
  0x04, 0x00, 0x3C, 0x00, 0x20, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0x00, 0x08,
  0x00, 0x78, 0x00, 0x40, 0x03, 0xC3, 0xF1, 0x8F, 0xF3, 0x30, 0x36, 0xC0,
  0x2F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x86, 0x00, 0xE3, 0x00,
  0x33, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x63, 0x00, 0x30, 0xE0,
  0x70, 0x3F, 0xF0, 0x07, 0xE0, 0xC3, 0xF0, 0xCF, 0xF8, 0xD8, 0x0C, 0xF0,
  0x06, 0xE0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x06, 0xE0, 0x06, 0xD8,
  0x0C, 0xCF, 0xF8, 0xC3, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0F,
  0xC2, 0x3F, 0xE4, 0xC0, 0x6B, 0x00, 0x74, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00,
  0x36, 0x00, 0xE6, 0x03, 0x47, 0xFC, 0x87, 0xE1, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0xC3, 0xF3, 0xFD, 0x83, 0x40, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xC0,
  0x73, 0x00, 0x66, 0x00, 0x68, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x36, 0x00, 0x66, 0x01,
  0x87, 0xFE, 0x03, 0xF0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F,
  0xFF, 0xFF, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xC0, 0x30, 0x07, 0xC0, 0xF0, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x36, 0x00, 0xA6, 0x03, 0x47,
  0xFC, 0x87, 0xE1, 0xC0, 0x01, 0xA0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x62,
  0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x04, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x81, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x10, 0x40, 0x0C,
  0x60, 0x06, 0x30, 0x01, 0x10, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x14, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00,
  0x6C, 0x01, 0xC0, 0x19, 0x00, 0x70, 0x06, 0x60, 0x16, 0x01, 0x98, 0x0D,
  0x80, 0x46, 0x03, 0x20, 0x30, 0x80, 0xC8, 0x0C, 0x30, 0x23, 0x03, 0x0C,
  0x18, 0xC0, 0x83, 0x06, 0x10, 0x60, 0x41, 0x06, 0x18, 0x18, 0x41, 0x86,
  0x06, 0x30, 0x61, 0x01, 0x8C, 0x08, 0xC0, 0x22, 0x03, 0x30, 0x08, 0x80,
  0xCC, 0x03, 0x60, 0x12, 0x00, 0xD8, 0x04, 0x80, 0x14, 0x01, 0xE0, 0x05,
  0x00, 0x78, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0xC0, 0x10, 0x60, 0x0C, 0x60, 0x03, 0x20, 0x01, 0xB0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0B, 0x00, 0x0D, 0x80, 0x0C, 0x60, 0x06, 0x10,
  0x06, 0x0C, 0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0x61, 0x80, 0x31, 0x80,
  0x0C, 0xC0, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x62,
  0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x04, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x81, 0x00, 0xC1, 0x80, 0x20, 0xC0, 0x18, 0x40, 0x0C,
  0x60, 0x02, 0x30, 0x01, 0x90, 0x00, 0xD8, 0x00, 0x2C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x40, 0x18, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x78, 0x18, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x03, 0x80,
  0x40, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0xD8, 0x30, 0x06, 0x80, 0xC0,
  0x24, 0x03, 0x03, 0x60, 0x0C, 0x1B, 0x00, 0x3F, 0x80, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_ExtraLight45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 32, 9, 3, -32 },
  { 13, 7, 9, 12, 3, -34 },
  { 21, 20, 32, 22, 2, -32 },
  { 101, 16, 40, 22, 3, -36 },
  { 181, 25, 32, 29, 2, -32 },
  { 281, 21, 32, 24, 2, -32 },
  { 365, 2, 9, 8, 3, -34 },
  { 368, 9, 46, 13, 3, -36 },
  { 420, 9, 46, 13, 1, -36 },
  { 472, 17, 18, 19, 1, -32 },
  { 511, 18, 24, 22, 2, -27 },
  { 565, 4, 9, 9, 2, -4 },
  { 570, 9, 2, 12, 1, -16 },
  { 573, 3, 3, 10, 3, -3 },
  { 575, 13, 35, 16, 1, -32 },
  { 632, 16, 32, 22, 3, -32 },
  { 696, 9, 32, 22, 4, -32 },
  { 732, 18, 32, 22, 2, -32 },
  { 804, 17, 32, 22, 2, -32 },
  { 872, 19, 32, 22, 2, -32 },
  { 948, 16, 32, 22, 4, -32 },
  { 1012, 16, 32, 22, 3, -32 },
  { 1076, 17, 32, 22, 2, -32 },
  { 1144, 18, 32, 22, 2, -32 },
  { 1216, 17, 32, 22, 2, -32 },
  { 1284, 3, 24, 8, 3, -24 },
  { 1293, 4, 29, 8, 2, -24 },
  { 1308, 15, 19, 20, 2, -24 },
  { 1344, 16, 11, 22, 3, -20 },
  { 1366, 15, 18, 21, 3, -24 },
  { 1400, 14, 32, 18, 2, -32 },
  { 1456, 30, 41, 36, 3, -31 },
  { 1610, 22, 32, 24, 1, -32 },
  { 1698, 18, 32, 24, 4, -32 },
  { 1770, 20, 32, 26, 3, -32 },
  { 1850, 19, 32, 26, 4, -32 },
  { 1926, 17, 32, 23, 4, -32 },
  { 1994, 17, 32, 22, 4, -32 },
  { 2062, 19, 32, 27, 4, -32 },
  { 2138, 20, 32, 28, 4, -32 },
  { 2218, 1, 32, 11, 5, -32 },
  { 2222, 16, 32, 22, 2, -32 },
  { 2286, 20, 32, 25, 4, -32 },
  { 2366, 15, 32, 21, 4, -32 },
  { 2426, 26, 32, 34, 4, -32 },
  { 2530, 20, 32, 28, 4, -32 },
  { 2610, 20, 32, 26, 3, -32 },
  { 2690, 18, 32, 24, 4, -32 },
  { 2762, 20, 38, 26, 3, -32 },
  { 2857, 19, 32, 25, 4, -32 },
  { 2933, 19, 32, 23, 2, -32 },
  { 3009, 21, 32, 24, 1, -32 },
  { 3093, 18, 32, 26, 4, -32 },
  { 3165, 22, 32, 24, 1, -32 },
  { 3253, 32, 32, 35, 2, -32 },
  { 3381, 21, 32, 24, 1, -32 },
  { 3465, 22, 32, 24, 1, -32 },
  { 3553, 19, 32, 24, 2, -32 },
  { 3629, 5, 44, 10, 4, -37 },
  { 3657, 13, 35, 16, 1, -32 },
  { 3714, 6, 44, 10, 0, -37 },
  { 3747, 12, 16, 17, 2, -32 },
  { 3771, 17, 2, 17, 0, 0 },
  { 3776, 6, 6, 12, 3, -34 },
  { 3781, 16, 24, 21, 2, -24 },
  { 3829, 16, 34, 22, 3, -34 },
  { 3897, 16, 24, 20, 2, -24 },
  { 3945, 15, 34, 22, 3, -34 },
  { 4009, 16, 24, 20, 2, -24 },
  { 4057, 11, 34, 13, 2, -34 },
  { 4104, 15, 33, 22, 3, -24 },
  { 4166, 15, 34, 22, 3, -34 },
  { 4230, 3, 33, 9, 3, -33 },
  { 4243, 8, 42, 9, -2, -33 },
  { 4285, 16, 34, 19, 3, -34 },
  { 4353, 1, 34, 9, 4, -34 },
  { 4358, 29, 24, 35, 3, -24 },
  { 4445, 15, 24, 22, 3, -24 },
  { 4490, 17, 24, 22, 2, -24 },
  { 4541, 16, 33, 22, 3, -24 },
  { 4607, 15, 33, 22, 3, -24 },
  { 4669, 10, 24, 14, 3, -24 },
  { 4699, 15, 24, 20, 2, -24 },
  { 4744, 10, 30, 13, 1, -30 },
  { 4782, 15, 24, 22, 3, -24 },
  { 4827, 17, 24, 19, 1, -24 },
  { 4878, 26, 24, 30, 2, -24 },
  { 4956, 17, 24, 19, 1, -24 },
  { 5007, 17, 33, 19, 1, -24 },
  { 5078, 16, 24, 19, 2, -24 },
  { 5126, 11, 44, 13, 2, -35 },
  { 5187, 2, 38, 9, 4, -32 },
  { 5197, 11, 44, 13, 1, -35 },
  { 5258, 21, 8, 27, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLight45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT45PT7B_H_
