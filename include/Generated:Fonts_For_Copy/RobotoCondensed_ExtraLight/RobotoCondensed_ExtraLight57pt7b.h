#ifndef _ROBOTOCONDENSED_EXTRALIGHT57PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x20, 0x00, 0x20, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x1C,
  0x70, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x1C, 0xC0, 0x00, 0x6E, 0x00,
  0x03, 0x70, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x80, 0x01, 0xCE, 0x00, 0x0C,
  0x38, 0x00, 0xE1, 0xE0, 0x1E, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x03, 0x03, 0x00, 0x18, 0x06, 0x0C,
  0x00, 0x30, 0x18, 0x18, 0x00, 0x30, 0x30, 0x60, 0x00, 0x79, 0xC0, 0xC0,
  0x00, 0x7F, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x07, 0xE0, 0x00, 0x18, 0x1C, 0xF0, 0x00, 0x30, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x60, 0x01, 0x83, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x80,
  0x0C, 0x0C, 0x01, 0x80, 0x30, 0x10, 0x03, 0x00, 0x60, 0x20, 0x06, 0x01,
  0x80, 0x40, 0x0C, 0x03, 0x00, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18,
  0x03, 0x00, 0x60, 0x60, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x18, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x07, 0x18, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x18, 0x01, 0x8C,
  0x03, 0x00, 0x67, 0x00, 0xE0, 0x31, 0x80, 0x1C, 0x0C, 0x60, 0x03, 0x03,
  0x38, 0x00, 0x60, 0xCC, 0x00, 0x1C, 0x33, 0x00, 0x03, 0x18, 0xC0, 0x00,
  0x66, 0x30, 0x00, 0x1F, 0x8E, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x70, 0x60,
  0x00, 0x3C, 0x1C, 0x00, 0x1F, 0x83, 0x80, 0x0E, 0x70, 0x70, 0x07, 0x0C,
  0x0F, 0xFF, 0x83, 0x80, 0xFF, 0x80, 0x70, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x40, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x08, 0x40, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x30, 0x0C, 0x03, 0xF8, 0x30, 0x7C, 0xF8, 0xC7, 0xC0, 0x7F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0xC0, 0x00, 0x71,
  0x80, 0x03, 0x87, 0x00, 0x0C, 0x0E, 0x00, 0x60, 0x18, 0x03, 0x80, 0x30,
  0x1C, 0x00, 0xE0, 0x20, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x18, 0xC6, 0x31, 0x8C, 0xE6, 0x33, 0xB8, 0x80, 0xFF, 0xFF, 0xFC, 0x6F,
  0xF0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x0C,
  0x0C, 0x00, 0x70, 0xE0, 0x01, 0x86, 0x00, 0x0E, 0x30, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x3B, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x06,
  0x0C, 0x00, 0x70, 0x70, 0x03, 0x01, 0xC0, 0x70, 0x07, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xF7, 0x7C, 0x7E,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF8, 0x07, 0x80, 0xF0, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x87, 0x00,
  0x06, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1C, 0x03,
  0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00,
  0x76, 0x00, 0x03, 0x18, 0x00, 0x38, 0xE0, 0x01, 0x83, 0xC0, 0x38, 0x0F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x03, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x1F, 0x80, 0x6F, 0xFE, 0x07, 0xC0, 0xF0, 0x70, 0x03, 0x86, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0,
  0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x80,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x03, 0xF0, 0x18, 0xFF,
  0xE0, 0xCF, 0x07, 0x86, 0xE0, 0x0E, 0x3E, 0x00, 0x31, 0xE0, 0x00, 0xCE,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x18, 0xE0, 0x00, 0xC3, 0x80, 0x0E, 0x0C, 0x00, 0xE0, 0x38,
  0x0E, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x01,
  0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x39, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0x60, 0x01, 0x81, 0xC0, 0x0C,
  0x03, 0xC0, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x3C, 0x07,
  0x00, 0x38, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x39, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x78, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x70, 0xC0,
  0x01, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x76,
  0x00, 0x03, 0xB8, 0x00, 0x3C, 0xC0, 0x01, 0xE7, 0x00, 0x1B, 0x1C, 0x01,
  0x98, 0x70, 0x38, 0xC1, 0xFF, 0x86, 0x03, 0xF0, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xA0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x39, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0xC6, 0x31, 0x9C, 0xE6, 0x33, 0x38, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x01, 0xC7, 0x00,
  0x63, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x01, 0xF0,
  0x00, 0xC3, 0x00, 0x0F, 0xF8, 0x01, 0x86, 0x00, 0x38, 0x38, 0x03, 0x18,
  0x00, 0xC0, 0x30, 0x02, 0x30, 0x03, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00,
  0xC0, 0x0D, 0x80, 0x18, 0x01, 0x80, 0x1B, 0x00, 0x30, 0x03, 0x00, 0x36,
  0x00, 0xC0, 0x06, 0x00, 0x6C, 0x01, 0x80, 0x0C, 0x00, 0xD8, 0x03, 0x00,
  0x18, 0x01, 0xB0, 0x0C, 0x00, 0x30, 0x03, 0x40, 0x18, 0x00, 0x60, 0x07,
  0x80, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x01, 0x00, 0x1E, 0x00, 0xC0,
  0x02, 0x00, 0x3C, 0x01, 0x80, 0x0C, 0x00, 0x78, 0x03, 0x00, 0x18, 0x00,
  0x90, 0x06, 0x00, 0x30, 0x03, 0x20, 0x0C, 0x00, 0x60, 0x06, 0x60, 0x18,
  0x01, 0xC0, 0x0C, 0xC0, 0x30, 0x03, 0x80, 0x31, 0x80, 0x70, 0x0F, 0x00,
  0x63, 0x00, 0x60, 0x13, 0x01, 0x86, 0x00, 0xE0, 0xE6, 0x07, 0x06, 0x00,
  0xFF, 0x87, 0x3C, 0x0C, 0x00, 0xFC, 0x07, 0xF0, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x07, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x30,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x7C, 0x30, 0x00, 0x38, 0xC0,
  0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x8C, 0x00, 0x3C, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0x00, 0x07,
  0x8C, 0x00, 0x07, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xCC, 0x00, 0x1E, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x60, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xC0, 0x07, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0xE0, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x0F, 0x00, 0x3C, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xE0, 0x00, 0xC3, 0x00, 0x0E, 0x1C,
  0x00, 0xE0, 0x70, 0x0E, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x80, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x01,
  0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x18, 0xF8, 0x00, 0x0C, 0xEC, 0x00, 0x06, 0xE7, 0x00, 0x03, 0x61, 0xC0,
  0x01, 0xE0, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0x00,
  0x7F, 0x60, 0x00, 0x00, 0x6F, 0xB8, 0x00, 0x00, 0x37, 0xCC, 0x00, 0x00,
  0x1B, 0xE6, 0x00, 0x00, 0x19, 0xF1, 0x80, 0x00, 0x0C, 0xF8, 0xC0, 0x00,
  0x0E, 0x7C, 0x60, 0x00, 0x06, 0x3E, 0x18, 0x00, 0x03, 0x1F, 0x0C, 0x00,
  0x03, 0x8F, 0x86, 0x00, 0x01, 0x87, 0xC1, 0x80, 0x00, 0xC3, 0xE0, 0xC0,
  0x00, 0xE1, 0xF0, 0x60, 0x00, 0x60, 0xF8, 0x18, 0x00, 0x30, 0x7C, 0x0C,
  0x00, 0x30, 0x3E, 0x07, 0x00, 0x18, 0x1F, 0x01, 0x80, 0x0C, 0x0F, 0x80,
  0xC0, 0x0C, 0x07, 0xC0, 0x30, 0x06, 0x03, 0xE0, 0x18, 0x03, 0x01, 0xF0,
  0x0C, 0x03, 0x00, 0xF8, 0x03, 0x01, 0x80, 0x7C, 0x01, 0x81, 0xC0, 0x3E,
  0x00, 0xC0, 0xC0, 0x1F, 0x00, 0x30, 0x60, 0x0F, 0x80, 0x18, 0x70, 0x07,
  0xC0, 0x0C, 0x30, 0x03, 0xE0, 0x03, 0x18, 0x01, 0xF0, 0x01, 0x98, 0x00,
  0xF8, 0x00, 0xEC, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x07,
  0x98, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x3C, 0x18, 0x00, 0x1E, 0x06, 0x00, 0x0F, 0x03, 0x00,
  0x07, 0x80, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x18, 0x00, 0xF0, 0x0E,
  0x00, 0x78, 0x03, 0x00, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00,
  0x18, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x03, 0x01, 0xE0, 0x01, 0xC0, 0xF0,
  0x00, 0x60, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0C, 0x1E, 0x00, 0x03, 0x0F,
  0x00, 0x01, 0x87, 0x80, 0x00, 0x63, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x0C,
  0xF0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xBC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x01, 0xE0,
  0x1C, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0x00, 0x07, 0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00,
  0x00, 0x66, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x18, 0x00, 0x3C, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0x3C, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x87,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xC0, 0x03, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x70, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x78,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x67, 0x00, 0x01, 0xC7, 0x00, 0x07,
  0x07, 0x80, 0x3C, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80,
  0x1C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x98, 0x00,
  0x07, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x80, 0x00, 0x66, 0x00, 0x03, 0x40,
  0x00, 0x73, 0x00, 0x01, 0xB0, 0x00, 0x31, 0xC0, 0x00, 0xD8, 0x00, 0x18,
  0x60, 0x00, 0xCC, 0x00, 0x0C, 0x30, 0x00, 0x62, 0x00, 0x06, 0x18, 0x00,
  0x31, 0x80, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x03, 0x07, 0x00, 0x18, 0x60,
  0x01, 0x81, 0x80, 0x0C, 0x10, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0xE0,
  0x60, 0x03, 0x06, 0x00, 0x60, 0x38, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x01,
  0x80, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x30,
  0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0x30, 0x18, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x06, 0x1C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x1A, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x07,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x18, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF,
  0x80, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x1C, 0x18,
  0x18, 0x0C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x03, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x81, 0xC0, 0x3C, 0x38, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00,
  0x06, 0xE0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1E, 0x00, 0x63,
  0x80, 0x06, 0x70, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xE0, 0x01,
  0xE6, 0x00, 0x36, 0x70, 0x0E, 0x63, 0xFF, 0xC7, 0x1F, 0xF8, 0x30, 0x10,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x3F, 0xE0,
  0xC7, 0xFF, 0x8C, 0xC0, 0x3C, 0xD8, 0x00, 0xCF, 0x00, 0x0E, 0xE0, 0x00,
  0x6E, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x6E, 0x00, 0x06,
  0xF0, 0x00, 0xED, 0x80, 0x0C, 0xCC, 0x03, 0xCC, 0x7F, 0xF8, 0xC3, 0xFE,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xC0,
  0x3C, 0x38, 0x00, 0xC7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x63, 0x80,
  0x0C, 0x1C, 0x01, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x7F, 0xC3, 0x0F, 0xFF,
  0x31, 0xC0, 0x3B, 0x38, 0x00, 0xF3, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x03, 0x30, 0x00,
  0x73, 0x80, 0x0F, 0x1C, 0x03, 0xB0, 0xFF, 0xF3, 0x03, 0xFC, 0x30, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xC0, 0x3C, 0x38,
  0x00, 0xC3, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x23, 0x80, 0x06, 0x1E,
  0x00, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x10, 0x01,
  0xF8, 0x07, 0xF0, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x3F,
  0xFE, 0x7F, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC3, 0x0F, 0xFF, 0x31, 0xC0, 0x3B, 0x38, 0x00, 0xF3, 0x00, 0x07, 0x70,
  0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00,
  0x07, 0x30, 0x00, 0x73, 0x80, 0x0F, 0x1C, 0x03, 0xB0, 0xFF, 0xF3, 0x07,
  0xFC, 0x30, 0x04, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x0C,
  0x0E, 0x03, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0x01, 0x83, 0xFC, 0x30, 0xFF, 0xE6, 0x30, 0x1C, 0xCC, 0x01,
  0xDB, 0x00, 0x1B, 0x40, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0x5F, 0xB0, 0x00, 0x00, 0x36, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x01, 0x01, 0xC0, 0xE0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x03, 0x83, 0x9F, 0x8F, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x07, 0x18,
  0x01, 0xC3, 0x00, 0x70, 0x60, 0x1C, 0x0C, 0x07, 0x01, 0x81, 0xC0, 0x30,
  0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x3C, 0x00, 0x6F,
  0xC0, 0x0F, 0x98, 0x01, 0xE1, 0x80, 0x38, 0x38, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x07, 0x03, 0x00, 0x70, 0x60, 0x06, 0x0C, 0x00, 0xE1, 0x80,
  0x0E, 0x30, 0x00, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0xD8, 0x00, 0x1B, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1F, 0xE0, 0x1F, 0xF0, 0xC7, 0xFF,
  0x03, 0xFF, 0x8C, 0xE0, 0x38, 0x70, 0x1C, 0xCC, 0x01, 0xCC, 0x00, 0xED,
  0x80, 0x0D, 0x80, 0x06, 0xF0, 0x00, 0xF8, 0x00, 0x6F, 0x00, 0x07, 0x00,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x18,
  0x3F, 0xC3, 0x0F, 0xFE, 0x63, 0x01, 0xCC, 0xC0, 0x1D, 0xB0, 0x01, 0xB4,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80,
  0x07, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x3F, 0xE0, 0xC7, 0xFF, 0x8C, 0xC0,
  0x3C, 0xD8, 0x00, 0xCF, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xF0, 0x00, 0xED, 0x80,
  0x0C, 0xDC, 0x03, 0xCC, 0x7F, 0xF8, 0xC3, 0xFE, 0x0C, 0x02, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0x0F, 0xFF, 0x31, 0xC0,
  0x3B, 0x38, 0x00, 0xF3, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x03, 0x30, 0x00, 0x73, 0x80,
  0x0F, 0x1C, 0x03, 0xB0, 0xFF, 0xF3, 0x03, 0xFE, 0x30, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x0C, 0x3F, 0xC7, 0xFC, 0xE0, 0xD8, 0x0D, 0x80,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1C, 0x01, 0xC7,
  0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x07, 0x60, 0x00, 0xEC,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1D, 0x80, 0x03, 0x38, 0x00, 0xE3, 0x80, 0x38, 0x3F,
  0xFE, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x80, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xEE, 0x00, 0x3C,
  0xC0, 0x0F, 0x9C, 0x03, 0xB1, 0xFF, 0xE6, 0x1F, 0xF0, 0xC0, 0x20, 0x00,
  0x60, 0x00, 0x1D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x38, 0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x07, 0x18,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xB0, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0x70, 0x00, 0xCC,
  0x00, 0x3C, 0x00, 0x67, 0x00, 0x36, 0x00, 0x31, 0x80, 0x1B, 0x00, 0x38,
  0xC0, 0x0D, 0x80, 0x18, 0x60, 0x06, 0xE0, 0x0C, 0x38, 0x06, 0x30, 0x06,
  0x0C, 0x03, 0x18, 0x07, 0x06, 0x01, 0x8C, 0x03, 0x03, 0x00, 0xC3, 0x01,
  0x81, 0x80, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0xC0, 0x60, 0x30, 0x30, 0x60,
  0x60, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x03, 0x0C, 0x06,
  0x0C, 0x01, 0x86, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x63, 0x00, 0x19, 0x80, 0x31, 0x80, 0x0C, 0xC0, 0x0D, 0x80, 0x06, 0xC0,
  0x06, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x00, 0xB0, 0x01, 0xB0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x70,
  0x01, 0x81, 0x80, 0x18, 0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0xE0,
  0x07, 0x06, 0x00, 0x18, 0x60, 0x00, 0xE7, 0x00, 0x03, 0x30, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0xC0, 0x00, 0x67, 0x00, 0x06, 0x18, 0x00, 0x70, 0xE0, 0x03, 0x03,
  0x00, 0x38, 0x0C, 0x01, 0x80, 0x70, 0x18, 0x01, 0x81, 0xC0, 0x0E, 0x0C,
  0x00, 0x30, 0xE0, 0x00, 0xC6, 0x00, 0x07, 0x70, 0x00, 0x18, 0x60, 0x00,
  0x1D, 0x80, 0x00, 0x67, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30,
  0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7C, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x33, 0x87, 0x00, 0x0D,
  0xC0, 0xE0, 0x03, 0x60, 0x1C, 0x00, 0x98, 0x03, 0x80, 0x6C, 0x00, 0x70,
  0x3B, 0x00, 0x0E, 0x1C, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 42, 11, 4, -41 },
  { 17, 8, 12, 15, 4, -43 },
  { 29, 26, 41, 28, 2, -41 },
  { 163, 21, 53, 28, 3, -47 },
  { 303, 31, 43, 37, 3, -42 },
  { 470, 26, 43, 31, 3, -42 },
  { 610, 2, 12, 10, 4, -43 },
  { 613, 11, 58, 16, 4, -45 },
  { 693, 11, 58, 16, 1, -45 },
  { 773, 22, 22, 24, 1, -41 },
  { 834, 24, 30, 28, 2, -34 },
  { 924, 5, 12, 11, 2, -5 },
  { 932, 11, 2, 15, 2, -19 },
  { 935, 4, 4, 13, 4, -3 },
  { 937, 17, 44, 20, 1, -41 },
  { 1031, 21, 43, 28, 3, -42 },
  { 1144, 12, 41, 28, 5, -41 },
  { 1206, 22, 42, 28, 3, -42 },
  { 1322, 21, 43, 28, 3, -42 },
  { 1435, 24, 41, 28, 2, -41 },
  { 1558, 20, 42, 28, 5, -41 },
  { 1663, 21, 42, 28, 4, -41 },
  { 1774, 23, 41, 28, 2, -41 },
  { 1892, 22, 43, 28, 3, -42 },
  { 2011, 21, 42, 28, 3, -42 },
  { 2122, 3, 30, 11, 4, -29 },
  { 2134, 5, 36, 10, 2, -29 },
  { 2157, 20, 23, 26, 2, -30 },
  { 2215, 20, 13, 28, 4, -25 },
  { 2248, 20, 23, 26, 3, -30 },
  { 2306, 17, 43, 23, 3, -42 },
  { 2398, 39, 52, 45, 3, -39 },
  { 2652, 28, 41, 31, 1, -41 },
  { 2796, 22, 41, 30, 5, -41 },
  { 2909, 25, 43, 32, 4, -42 },
  { 3044, 24, 41, 33, 5, -41 },
  { 3167, 21, 41, 29, 5, -41 },
  { 3275, 21, 41, 28, 5, -41 },
  { 3383, 25, 43, 34, 4, -42 },
  { 3518, 25, 41, 35, 5, -41 },
  { 3647, 2, 41, 14, 6, -41 },
  { 3658, 21, 42, 28, 2, -41 },
  { 3769, 25, 41, 32, 5, -41 },
  { 3898, 19, 41, 26, 5, -41 },
  { 3996, 33, 41, 43, 5, -41 },
  { 4166, 25, 41, 35, 5, -41 },
  { 4295, 26, 43, 33, 4, -42 },
  { 4435, 23, 41, 30, 5, -41 },
  { 4553, 26, 49, 33, 4, -42 },
  { 4713, 24, 41, 32, 5, -41 },
  { 4836, 24, 43, 30, 3, -42 },
  { 4965, 26, 41, 30, 2, -41 },
  { 5099, 23, 42, 33, 5, -41 },
  { 5220, 28, 41, 30, 1, -41 },
  { 5364, 41, 41, 44, 2, -41 },
  { 5575, 26, 41, 30, 2, -41 },
  { 5709, 28, 41, 30, 1, -41 },
  { 5853, 24, 41, 30, 3, -41 },
  { 5976, 7, 55, 12, 5, -46 },
  { 6025, 16, 44, 20, 2, -41 },
  { 6113, 8, 55, 12, 0, -46 },
  { 6168, 16, 20, 21, 2, -41 },
  { 6208, 20, 2, 21, 1, 0 },
  { 6213, 8, 8, 16, 4, -43 },
  { 6221, 20, 32, 27, 3, -31 },
  { 6301, 20, 44, 28, 4, -43 },
  { 6411, 20, 32, 26, 3, -31 },
  { 6491, 20, 44, 28, 3, -43 },
  { 6601, 20, 32, 26, 3, -31 },
  { 6681, 15, 44, 17, 2, -44 },
  { 6764, 20, 43, 28, 3, -31 },
  { 6872, 19, 43, 27, 4, -43 },
  { 6975, 3, 41, 11, 4, -41 },
  { 6991, 9, 53, 12, -2, -41 },
  { 7051, 19, 43, 24, 4, -43 },
  { 7154, 2, 43, 11, 5, -43 },
  { 7165, 36, 31, 44, 4, -31 },
  { 7305, 19, 31, 28, 4, -31 },
  { 7379, 22, 32, 28, 3, -31 },
  { 7467, 20, 43, 28, 4, -31 },
  { 7575, 20, 43, 28, 3, -31 },
  { 7683, 12, 31, 17, 4, -31 },
  { 7730, 19, 32, 25, 3, -31 },
  { 7806, 13, 39, 16, 1, -38 },
  { 7870, 19, 31, 28, 4, -30 },
  { 7944, 22, 30, 24, 1, -30 },
  { 8027, 33, 30, 37, 2, -30 },
  { 8151, 21, 30, 24, 2, -30 },
  { 8230, 22, 42, 24, 1, -30 },
  { 8346, 20, 30, 24, 3, -30 },
  { 8421, 14, 56, 17, 2, -44 },
  { 8519, 2, 49, 12, 5, -41 },
  { 8532, 14, 56, 17, 1, -44 },
  { 8630, 26, 10, 34, 4, -22 },
};

const GFXfont RobotoCondensed_ExtraLight57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT57PT7B_H_
