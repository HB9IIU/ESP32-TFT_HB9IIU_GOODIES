#ifndef _ROBOTOCONDENSED_EXTRALIGHT53PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight53pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60,
  0x00, 0x00, 0x0F, 0xC0, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xE3, 0xC7,
  0x8E, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x20, 0x10, 0x00,
  0x60, 0x10, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x60, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x60, 0x00,
  0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x02, 0x01, 0x00, 0x06, 0x01, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x04, 0x02, 0x00, 0x04,
  0x02, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03,
  0xFE, 0x00, 0xF9, 0xF0, 0x1C, 0x03, 0x81, 0x80, 0x1C, 0x30, 0x00, 0xC3,
  0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0E,
  0x38, 0x00, 0xC1, 0xC0, 0x38, 0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x40, 0xC0, 0x30,
  0x0C, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x30, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x60, 0x0C, 0x03,
  0x04, 0x00, 0x60, 0x20, 0xC0, 0x06, 0x06, 0x08, 0x00, 0x38, 0xC1, 0x80,
  0x01, 0xF8, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x1F, 0x80, 0x01, 0x83,
  0x8C, 0x00, 0x18, 0x60, 0x60, 0x03, 0x06, 0x03, 0x00, 0x30, 0x40, 0x30,
  0x06, 0x0C, 0x01, 0x00, 0x60, 0xC0, 0x10, 0x0C, 0x0C, 0x01, 0x00, 0xC0,
  0xC0, 0x10, 0x18, 0x0C, 0x01, 0x01, 0x80, 0xC0, 0x10, 0x30, 0x0C, 0x03,
  0x02, 0x00, 0x40, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x0E, 0x00,
  0x0C, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0x60, 0x00, 0x18, 0x30, 0x06, 0x30, 0x38, 0x06, 0x60, 0x1C, 0x06,
  0x60, 0x0C, 0x04, 0xC0, 0x06, 0x0C, 0xC0, 0x07, 0x0C, 0xC0, 0x03, 0x0C,
  0xC0, 0x01, 0x98, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0xF8, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x60, 0x00, 0xF8, 0x70, 0x01, 0xDC, 0x38, 0x03, 0x8C,
  0x1F, 0x1F, 0x06, 0x07, 0xFC, 0x07, 0x00, 0x40, 0x00, 0x55, 0xFF, 0xFC,
  0x00, 0x80, 0x70, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x20, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x20, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1C, 0x0C,
  0x06, 0xF8, 0x61, 0xF0, 0xFB, 0x3E, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xEC, 0x00, 0x06, 0x70, 0x00, 0x61, 0xC0, 0x07, 0x06,
  0x00, 0x30, 0x18, 0x03, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x80, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x39, 0xCE, 0x73, 0x18, 0xC6, 0x67, 0x10,
  0xFF, 0xFF, 0xF0, 0xFF, 0xA0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0x9E, 0x00, 0xC0, 0x70, 0x18, 0x03, 0x83, 0x00,
  0x18, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x01, 0x81, 0x80, 0x38, 0x0C, 0x07, 0x00, 0xF9, 0xE0, 0x03, 0xFC, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x8F, 0x37, 0x87, 0xC0, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x7F, 0xC0,
  0x0F, 0xBE, 0x01, 0xC0, 0x70, 0x30, 0x01, 0x87, 0x00, 0x1C, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0x9F, 0x01, 0xC0, 0x38, 0x38, 0x01, 0x83, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0x60, 0x00,
  0xC3, 0x00, 0x0C, 0x3C, 0x03, 0x80, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x05, 0x80, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x7E, 0x01, 0xBF, 0xF0,
  0x3C, 0x0F, 0x0E, 0x00, 0x70, 0x80, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x18, 0xE0, 0x06, 0x0E, 0x01, 0xC0,
  0xF9, 0xF0, 0x07, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x0F, 0xC0, 0x63, 0xFF, 0x06, 0xF0, 0x78, 0x5C,
  0x01, 0x8D, 0x80, 0x0C, 0xF0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x80, 0x0C, 0x18, 0x01, 0xC0, 0xE0,
  0x38, 0x07, 0x8F, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x9F, 0x01, 0xC0, 0x38, 0x38,
  0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x70, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x03, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00,
  0x06, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x76,
  0x00, 0x06, 0x60, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x03, 0x80, 0xF9, 0xF0,
  0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3C, 0xF8,
  0x0E, 0x03, 0x83, 0x80, 0x38, 0x60, 0x03, 0x18, 0x00, 0x33, 0x00, 0x06,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0E, 0x60, 0x03, 0xCE, 0x00, 0xD8,
  0xE0, 0x73, 0x0F, 0xFC, 0x60, 0x7E, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x03,
  0xE0, 0x00, 0x6F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x6F, 0xF0, 0x33, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x8C, 0x63, 0x19, 0xCC,
  0xE2, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xCF, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x06, 0x40, 0x03, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00,
  0x41, 0x80, 0x07, 0xC0, 0x06, 0x18, 0x01, 0xFF, 0x00, 0x63, 0x00, 0x38,
  0x38, 0x02, 0x30, 0x07, 0x01, 0x80, 0x22, 0x00, 0x60, 0x18, 0x03, 0x60,
  0x0C, 0x01, 0x80, 0x36, 0x00, 0xC0, 0x18, 0x03, 0x60, 0x18, 0x01, 0x80,
  0x34, 0x01, 0x80, 0x18, 0x03, 0x40, 0x18, 0x01, 0x80, 0x3C, 0x01, 0x00,
  0x18, 0x03, 0xC0, 0x30, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x18, 0x03, 0xC0,
  0x30, 0x01, 0x00, 0x3C, 0x03, 0x00, 0x10, 0x03, 0xC0, 0x30, 0x01, 0x00,
  0x3C, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x2C, 0x03, 0x00,
  0x30, 0x06, 0xC0, 0x30, 0x03, 0x00, 0x64, 0x03, 0x00, 0x70, 0x06, 0x40,
  0x30, 0x05, 0x00, 0xC6, 0x01, 0x80, 0xD8, 0x0C, 0x60, 0x18, 0x19, 0x81,
  0x86, 0x00, 0xE7, 0x0C, 0x70, 0x20, 0x07, 0xE0, 0x7E, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x08, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x10, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x07, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0C, 0x00, 0x78, 0xC0, 0x01,
  0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC,
  0x00, 0x38, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0x1F, 0x00, 0x70, 0x07, 0x81, 0x80, 0x03, 0x07, 0x00, 0x03,
  0x1C, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x60,
  0xC0, 0x01, 0x80, 0xE0, 0x07, 0x00, 0xF8, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x08, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0C, 0x00, 0xF8, 0x30, 0x00,
  0x70, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C,
  0x00, 0x1C, 0x30, 0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x70, 0x03,
  0x81, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x07,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x70, 0xF0, 0x03, 0xC0,
  0x7C, 0x7E, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x06,
  0x60, 0x00, 0xCE, 0x00, 0x38, 0xC0, 0x06, 0x1C, 0x03, 0x81, 0xFB, 0xE0,
  0x0F, 0xF8, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00,
  0x01, 0xC6, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x00, 0xE0,
  0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x70, 0x00,
  0x61, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x3E, 0x00, 0x06,
  0xEE, 0x00, 0x0F, 0x8C, 0x00, 0x1E, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x38, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x70, 0x30, 0x00, 0x60, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xE1, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0xCC, 0x00, 0x01, 0xD8, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x06, 0xF6,
  0x00, 0x00, 0x33, 0xD8, 0x00, 0x00, 0xCF, 0x30, 0x00, 0x03, 0x3C, 0xC0,
  0x00, 0x18, 0xF3, 0x00, 0x00, 0x63, 0xC6, 0x00, 0x01, 0x8F, 0x18, 0x00,
  0x0C, 0x3C, 0x30, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0xC3, 0xC3, 0x00, 0x06,
  0x0F, 0x06, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x60, 0xF0, 0x60, 0x03, 0x03,
  0xC0, 0xC0, 0x0C, 0x0F, 0x03, 0x00, 0x60, 0x3C, 0x0C, 0x01, 0x80, 0xF0,
  0x18, 0x06, 0x03, 0xC0, 0x60, 0x30, 0x0F, 0x00, 0x80, 0xC0, 0x3C, 0x03,
  0x03, 0x00, 0xF0, 0x0C, 0x18, 0x03, 0xC0, 0x18, 0x60, 0x0F, 0x00, 0x61,
  0x80, 0x3C, 0x01, 0x8C, 0x00, 0xF0, 0x03, 0x30, 0x03, 0xC0, 0x0C, 0xC0,
  0x0F, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7B, 0x00,
  0x00, 0xF6, 0x00, 0x01, 0xE6, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x8C, 0x00,
  0x0F, 0x1C, 0x00, 0x1E, 0x18, 0x00, 0x3C, 0x18, 0x00, 0x78, 0x30, 0x00,
  0xF0, 0x30, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x60, 0x07, 0x80, 0xE0, 0x0F,
  0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x01, 0x80, 0xF0,
  0x03, 0x81, 0xE0, 0x03, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x06, 0x0F, 0x00,
  0x06, 0x1E, 0x00, 0x0C, 0x3C, 0x00, 0x0C, 0x78, 0x00, 0x18, 0xF0, 0x00,
  0x19, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x37, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0E, 0x00, 0xF0, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x0C, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0E, 0x00,
  0xF0, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x30, 0x00, 0xE1, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x60,
  0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x30, 0x00, 0x39,
  0x80, 0x07, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x70, 0x07, 0x80, 0x1F, 0xBF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x10, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x10, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x78, 0x30, 0x00,
  0x70, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x30, 0x00, 0x06, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x00, 0x07,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x38, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFC, 0xFC, 0x07, 0x00, 0x38, 0x38, 0x00,
  0x71, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x77, 0x00, 0x01, 0x8E,
  0x00, 0x0C, 0x1C, 0x00, 0xF0, 0x3F, 0xBF, 0x00, 0x3F, 0xF8, 0x00, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x07, 0x00, 0x3C, 0x0F, 0xC7,
  0xC0, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x10, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1B, 0x00, 0x01, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x00,
  0x01, 0x98, 0x00, 0x1E, 0x00, 0x06, 0x60, 0x00, 0x58, 0x00, 0x19, 0x80,
  0x03, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x80, 0x03, 0x1C, 0x00, 0x33, 0x00,
  0x0C, 0x30, 0x00, 0x8C, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x01, 0xC3, 0x00,
  0x18, 0x40, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x18, 0x01, 0x06, 0x00,
  0x60, 0x60, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x20, 0x0C, 0x06, 0x00,
  0xC0, 0xC0, 0x30, 0x1C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x06,
  0x01, 0x81, 0x80, 0x18, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18,
  0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x13, 0x00,
  0x06, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x01, 0xB0, 0x00, 0x34, 0x00,
  0x06, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80,
  0x01, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0x81, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x38,
  0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x06, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xF8, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x16, 0x00, 0x6C, 0x00, 0xC8, 0x01, 0x18,
  0x06, 0x30, 0x0C, 0x20, 0x10, 0x60, 0x60, 0xC0, 0xC0, 0x81, 0x01, 0x86,
  0x03, 0x0C, 0x02, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x0B, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0x01, 0xF1, 0xE0, 0xE0, 0x0C, 0x70, 0x01, 0x98, 0x00,
  0x6E, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x03, 0x70,
  0x00, 0xD8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xB7, 0x00, 0xCC,
  0xFB, 0xE3, 0x1F, 0xF0, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x7F, 0xC1, 0x9E, 0x3C, 0x36, 0x01, 0xC7, 0x80, 0x1C, 0xE0, 0x01, 0x9C,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x70, 0x00, 0xCF, 0x00, 0x39, 0xB0,
  0x0E, 0x33, 0xC7, 0x86, 0x3F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x40, 0x01,
  0xFF, 0x01, 0xF1, 0xE0, 0xE0, 0x0C, 0x30, 0x01, 0x98, 0x00, 0x76, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x01, 0x8C, 0x00, 0x63, 0x80, 0x30, 0x7C, 0x78,
  0x07, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x30, 0x7F, 0x86,
  0x3E, 0x3C, 0xCE, 0x01, 0xD9, 0x80, 0x0B, 0x70, 0x01, 0xEC, 0x00, 0x1D,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x03, 0xB8, 0x00, 0x73, 0x00, 0x1E, 0x30, 0x06, 0xC7,
  0xCF, 0x98, 0x3F, 0xC3, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0,
  0x07, 0x8F, 0x00, 0xC0, 0x38, 0x18, 0x00, 0xC3, 0x00, 0x0E, 0x30, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06,
  0x0E, 0x00, 0xC0, 0x7C, 0x78, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0xF2, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x7F, 0xFB, 0xFF, 0xC1, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x0C, 0x7C, 0x79,
  0x9C, 0x03, 0xB3, 0x00, 0x16, 0xE0, 0x03, 0xD8, 0x00, 0x3B, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x07, 0x70, 0x00, 0xE6, 0x00, 0x3C, 0x60, 0x0D, 0x8F, 0x9F, 0x30,
  0x7F, 0x86, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x10, 0x00, 0xE3, 0x80, 0x18, 0x38, 0x0E, 0x03,
  0xFF, 0x80, 0x1F, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC3, 0xFC, 0x31, 0xE7, 0x8C,
  0xC0, 0x73, 0x60, 0x0E, 0xF0, 0x01, 0xBC, 0x00, 0x6E, 0x00, 0x1B, 0x80,
  0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0x80, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x38, 0x39, 0xF8, 0xF8, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0xE3, 0x00, 0x70, 0xC0, 0x18, 0x30,
  0x0C, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x30, 0xE0, 0x0C, 0x70,
  0x03, 0x38, 0x00, 0xCE, 0x00, 0x37, 0xC0, 0x0F, 0x30, 0x03, 0x86, 0x00,
  0xC0, 0xC0, 0x30, 0x38, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00,
  0x3B, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x40, 0x61, 0xFE, 0x03, 0xFE, 0x31, 0xC7, 0x83,
  0xC7, 0x99, 0x80, 0xE3, 0x00, 0xED, 0x80, 0x33, 0x00, 0x37, 0x80, 0x0F,
  0x00, 0x1B, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x78, 0x00,
  0x10, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x0F, 0x00,
  0x02, 0x00, 0x07, 0x80, 0x01, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x01, 0xE0,
  0x00, 0x40, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x78, 0x00, 0x10, 0x00, 0x3C,
  0x00, 0x08, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x07,
  0x80, 0x01, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x00, 0x40, 0x00,
  0xF0, 0x00, 0x20, 0x00, 0x78, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x00, 0x30, 0xFF, 0x0C, 0x79, 0xE3, 0x30, 0x1C, 0xD8, 0x03,
  0xBC, 0x00, 0x6F, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0x9F, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00,
  0xE6, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C,
  0x1C, 0x03, 0x80, 0xF9, 0xF0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0xFF, 0x83, 0x3C, 0x78, 0x6C, 0x03, 0x8F, 0x00, 0x39, 0xC0, 0x03,
  0x38, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xE0, 0x01, 0x9E, 0x00, 0x73,
  0x60, 0x1C, 0x67, 0x8F, 0x0C, 0x7F, 0xC1, 0x80, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0x0C, 0x7C, 0x79, 0x9C, 0x03, 0xB3, 0x00, 0x16, 0xE0, 0x03, 0xD8,
  0x00, 0x3B, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07, 0x70, 0x00, 0xE6, 0x00, 0x3C, 0x60,
  0x0D, 0x8F, 0x9F, 0x30, 0x7F, 0x86, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x58, 0xFF, 0x3E,
  0xEE, 0x0D, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x80, 0x07, 0xFC, 0x07, 0x8F, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xB0, 0x01, 0xDC, 0x01, 0xC7, 0xE7, 0xC0,
  0xFF, 0xC0, 0x04, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x39, 0x03, 0xF0, 0x04, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1D, 0x80, 0x0F, 0x70, 0x06, 0xCC, 0x03, 0xB3, 0xE7, 0xCC, 0x3F,
  0xC3, 0x01, 0x00, 0x00, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0C,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x40, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x00,
  0xD8, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x0D, 0xC0, 0x07, 0x00, 0x19, 0x80, 0x0E,
  0x00, 0x33, 0x00, 0x3C, 0x00, 0x66, 0x00, 0x68, 0x01, 0x8C, 0x00, 0xD8,
  0x03, 0x0C, 0x01, 0xB0, 0x06, 0x18, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x40,
  0x30, 0x60, 0x18, 0xC0, 0x60, 0x60, 0x21, 0x80, 0xC0, 0xC0, 0xC3, 0x01,
  0x81, 0x81, 0x83, 0x06, 0x03, 0x03, 0x06, 0x0C, 0x03, 0x04, 0x0C, 0x18,
  0x06, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x60, 0x31, 0x80,
  0x19, 0x80, 0x63, 0x00, 0x33, 0x00, 0x46, 0x00, 0x66, 0x00, 0xCC, 0x00,
  0xC8, 0x01, 0xB0, 0x00, 0xB0, 0x03, 0x60, 0x01, 0xE0, 0x02, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0x39, 0xC0, 0x06, 0x18, 0x01,
  0x81, 0x80, 0x30, 0x38, 0x0C, 0x03, 0x03, 0x80, 0x70, 0x60, 0x06, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xB0, 0x00, 0x63, 0x00, 0x18, 0x60,
  0x03, 0x06, 0x00, 0xC0, 0xC0, 0x38, 0x0C, 0x06, 0x01, 0xC1, 0xC0, 0x18,
  0x30, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x03, 0x60, 0x00, 0x70, 0xE0, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x67, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x0C, 0x38, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0xC0, 0x18, 0x0C,
  0x01, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x01, 0xC0, 0x38,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x38, 0x07,
  0x80, 0x3C, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x03, 0x80, 0x38, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0x70, 0xE0, 0x03, 0x60, 0x30, 0x03, 0xC0, 0x18, 0x06,
  0xC0, 0x1C, 0x06, 0xC0, 0x06, 0x0C, 0xC0, 0x03, 0xF8, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLight53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 39, 10, 4, -38 },
  { 16, 7, 11, 14, 4, -40 },
  { 26, 24, 38, 26, 2, -38 },
  { 140, 20, 50, 26, 3, -44 },
  { 265, 28, 40, 34, 3, -39 },
  { 405, 24, 40, 28, 3, -39 },
  { 525, 2, 11, 9, 3, -40 },
  { 528, 10, 54, 15, 4, -42 },
  { 596, 10, 54, 15, 1, -42 },
  { 664, 21, 21, 22, 1, -38 },
  { 720, 22, 28, 26, 2, -32 },
  { 797, 5, 11, 10, 2, -4 },
  { 804, 10, 2, 14, 2, -18 },
  { 807, 3, 4, 12, 4, -3 },
  { 809, 15, 41, 18, 1, -38 },
  { 886, 20, 40, 26, 3, -39 },
  { 986, 11, 38, 26, 4, -38 },
  { 1039, 20, 39, 26, 3, -39 },
  { 1137, 20, 40, 26, 3, -39 },
  { 1237, 22, 38, 26, 2, -38 },
  { 1342, 19, 39, 26, 4, -38 },
  { 1435, 20, 39, 26, 3, -38 },
  { 1533, 21, 38, 26, 2, -38 },
  { 1633, 20, 40, 26, 3, -39 },
  { 1733, 19, 39, 26, 3, -39 },
  { 1826, 4, 28, 10, 3, -27 },
  { 1840, 5, 34, 9, 2, -27 },
  { 1862, 18, 22, 24, 2, -28 },
  { 1912, 18, 13, 26, 4, -24 },
  { 1942, 18, 21, 24, 3, -28 },
  { 1990, 17, 40, 21, 2, -39 },
  { 2075, 36, 49, 42, 3, -37 },
  { 2296, 26, 38, 28, 1, -38 },
  { 2420, 20, 38, 28, 5, -38 },
  { 2515, 23, 40, 30, 4, -39 },
  { 2630, 22, 38, 30, 5, -38 },
  { 2735, 19, 38, 27, 5, -38 },
  { 2826, 19, 38, 26, 5, -38 },
  { 2917, 23, 40, 32, 4, -39 },
  { 3032, 23, 38, 33, 5, -38 },
  { 3142, 2, 38, 13, 5, -38 },
  { 3152, 19, 39, 26, 2, -38 },
  { 3245, 23, 38, 29, 5, -38 },
  { 3355, 18, 38, 24, 5, -38 },
  { 3441, 30, 38, 40, 5, -38 },
  { 3584, 23, 38, 33, 5, -38 },
  { 3694, 24, 40, 31, 4, -39 },
  { 3814, 21, 38, 28, 5, -38 },
  { 3914, 25, 46, 31, 3, -39 },
  { 4058, 22, 38, 30, 5, -38 },
  { 4163, 22, 40, 27, 3, -39 },
  { 4273, 24, 38, 28, 2, -38 },
  { 4387, 22, 39, 31, 4, -38 },
  { 4495, 26, 38, 28, 1, -38 },
  { 4619, 38, 38, 41, 2, -38 },
  { 4800, 24, 38, 28, 2, -38 },
  { 4914, 26, 38, 28, 1, -38 },
  { 5038, 23, 38, 28, 2, -38 },
  { 5148, 7, 51, 11, 4, -43 },
  { 5193, 15, 41, 18, 2, -38 },
  { 5270, 7, 51, 11, 0, -43 },
  { 5315, 15, 19, 20, 2, -38 },
  { 5351, 18, 2, 20, 1, 0 },
  { 5356, 8, 7, 14, 3, -40 },
  { 5363, 18, 30, 25, 3, -29 },
  { 5431, 19, 41, 26, 4, -40 },
  { 5529, 18, 30, 24, 3, -29 },
  { 5597, 19, 41, 26, 3, -40 },
  { 5695, 20, 30, 24, 2, -29 },
  { 5770, 13, 41, 16, 2, -41 },
  { 5837, 19, 40, 26, 3, -29 },
  { 5932, 18, 40, 26, 4, -40 },
  { 6022, 3, 38, 11, 4, -38 },
  { 6037, 9, 49, 11, -2, -38 },
  { 6093, 18, 40, 23, 4, -40 },
  { 6183, 2, 40, 11, 4, -40 },
  { 6193, 33, 29, 41, 4, -29 },
  { 6313, 18, 29, 26, 4, -29 },
  { 6379, 20, 30, 26, 3, -29 },
  { 6454, 19, 40, 26, 4, -29 },
  { 6549, 19, 40, 26, 3, -29 },
  { 6644, 11, 29, 16, 4, -29 },
  { 6684, 17, 30, 24, 3, -29 },
  { 6748, 12, 36, 15, 1, -35 },
  { 6802, 18, 29, 26, 4, -28 },
  { 6868, 20, 28, 22, 1, -28 },
  { 6938, 31, 28, 35, 2, -28 },
  { 7047, 19, 28, 23, 2, -28 },
  { 7114, 20, 39, 22, 1, -28 },
  { 7212, 19, 28, 23, 2, -28 },
  { 7279, 13, 52, 16, 2, -41 },
  { 7364, 2, 45, 11, 5, -38 },
  { 7376, 13, 52, 16, 1, -41 },
  { 7461, 24, 9, 32, 4, -20 },
};

const GFXfont RobotoCondensed_ExtraLight53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT53PT7B_H_
