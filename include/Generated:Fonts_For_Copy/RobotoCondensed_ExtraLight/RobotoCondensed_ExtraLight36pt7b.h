#ifndef _ROBOTOCONDENSED_EXTRALIGHT36PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight36pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0xB0, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0x40,
  0x10, 0x60, 0x08, 0x30, 0x04, 0x10, 0x7F, 0xFF, 0x81, 0x04, 0x00, 0x82,
  0x00, 0xC1, 0x00, 0x41, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04,
  0x10, 0x7F, 0xFF, 0x82, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x10, 0x40, 0x18, 0x20, 0x08, 0x30, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x1F, 0x81, 0x8E, 0x18, 0x19, 0x80, 0x48, 0x03, 0x40, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0x40, 0x0B, 0x00, 0xC8, 0x0C, 0x38, 0xC0, 0xFC, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x3C, 0x00, 0x0C, 0xC0, 0x01, 0x0C, 0x00, 0x40, 0x81, 0x08, 0x10,
  0x21, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x40, 0x81, 0x18, 0x08, 0x62,
  0x01, 0x98, 0xC0, 0x1E, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x21,
  0xE0, 0x04, 0x66, 0x01, 0x08, 0x60, 0x22, 0x04, 0x08, 0x40, 0x81, 0x08,
  0x10, 0x41, 0x02, 0x18, 0x20, 0x42, 0x04, 0x08, 0x00, 0x43, 0x00, 0x0C,
  0xC0, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0xC0, 0x10, 0x60, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x30, 0x40, 0x10, 0xC0, 0x19, 0x80, 0x0B,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x12, 0x00, 0x23, 0x02, 0x61, 0x82, 0x40,
  0x82, 0xC0, 0x42, 0x80, 0x66, 0x80, 0x34, 0x80, 0x14, 0xC0, 0x0C, 0x40,
  0x1C, 0x60, 0x36, 0x38, 0xE2, 0x0F, 0x83, 0xFF, 0xF8, 0x02, 0x0C, 0x10,
  0x40, 0x82, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1,
  0x83, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x02, 0x06, 0x04,
  0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x81, 0x81, 0x01, 0x03, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x04, 0x08, 0x30, 0x41,
  0x06, 0x08, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03,
  0x88, 0xF3, 0xEE, 0x01, 0xC0, 0x07, 0x00, 0x36, 0x00, 0x8C, 0x06, 0x10,
  0x30, 0x20, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x24, 0x92, 0xD2, 0xFE, 0xF0, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x0F, 0x80, 0xC7, 0x0C,
  0x08, 0xC0, 0x64, 0x01, 0x20, 0x0D, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x80, 0xC6, 0x04, 0x1C,
  0xE0, 0x7C, 0x00, 0x02, 0x1D, 0xCE, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x0F, 0x80, 0x63, 0x82, 0x03, 0x10, 0x0C, 0x40, 0x13, 0x00,
  0x68, 0x01, 0xA0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0xFF, 0xF0,
  0x0F, 0x80, 0xC7, 0x08, 0x0C, 0x80, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x01, 0xC0, 0xFC, 0x00, 0x30, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x05,
  0x00, 0x6C, 0x06, 0x38, 0xE0, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x50, 0x00, 0x50, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10, 0x03, 0x10, 0x02,
  0x10, 0x06, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x10, 0x30,
  0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F,
  0xF1, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x7C, 0x1E, 0x70, 0xC0, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x60, 0x09, 0x00,
  0xCC, 0x04, 0x39, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x1F, 0x0D,
  0xC6, 0x3C, 0x0C, 0xE0, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x02, 0x40, 0x09, 0x80, 0x62, 0x01, 0x0C, 0x0C,
  0x1C, 0x60, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x0F, 0x80, 0xE3, 0x82, 0x03, 0x18, 0x04,
  0x40, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0x40, 0x19, 0x80, 0x42, 0x03,
  0x06, 0x38, 0x0F, 0xC0, 0xC1, 0x86, 0x01, 0x10, 0x06, 0xC0, 0x0A, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x24, 0x01, 0x98, 0x0C, 0x38,
  0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xC6, 0x08, 0x08, 0xC0, 0x64, 0x01, 0x60,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x01,
  0xA0, 0x1D, 0x81, 0xA7, 0x19, 0x0F, 0x88, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x07, 0x80, 0xF0, 0x00, 0xEC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x22, 0x22, 0x26, 0x44, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0xE0, 0x08, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x0E, 0x31, 0x03, 0x60, 0x28,
  0x05, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x10,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0x40, 0xC0, 0x00,
  0x30, 0x40, 0x00, 0x08, 0x60, 0x3C, 0x06, 0x20, 0x33, 0x81, 0x30, 0x30,
  0x40, 0x90, 0x30, 0x20, 0x48, 0x10, 0x10, 0x24, 0x08, 0x08, 0x16, 0x0C,
  0x04, 0x0B, 0x04, 0x02, 0x07, 0x02, 0x03, 0x02, 0x81, 0x01, 0x81, 0x40,
  0x80, 0xC0, 0xA0, 0x40, 0x40, 0x50, 0x20, 0x20, 0x28, 0x10, 0x10, 0x36,
  0x08, 0x18, 0x11, 0x06, 0x1A, 0x18, 0x81, 0x99, 0x98, 0x40, 0x78, 0x78,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x16,
  0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0x60, 0x06, 0x10, 0x02, 0x08, 0x01,
  0x06, 0x01, 0x81, 0x00, 0x80, 0x80, 0x40, 0x60, 0x60, 0x10, 0x20, 0x08,
  0x10, 0x06, 0x1F, 0xFF, 0x0C, 0x00, 0x84, 0x00, 0x42, 0x00, 0x33, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0xFF, 0x83,
  0x03, 0x8C, 0x03, 0x30, 0x06, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xB0, 0x02,
  0xC0, 0x0B, 0x00, 0x6C, 0x03, 0x30, 0x38, 0xFF, 0xE3, 0x00, 0xCC, 0x01,
  0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xB0, 0x06, 0xC0, 0x73, 0xFF, 0x00, 0x07, 0xE0, 0x38, 0xF0,
  0xC0, 0x23, 0x00, 0x2C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x68,
  0x00, 0xD8, 0x01, 0x18, 0x04, 0x1C, 0x78, 0x0F, 0xC0, 0xFF, 0x81, 0x81,
  0xC3, 0x00, 0xE6, 0x00, 0x4C, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x58, 0x01, 0xB0, 0x02, 0x60, 0x1C, 0xC0, 0xE1, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xFF, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x07, 0xE0, 0x1C, 0x38, 0x30, 0x0C, 0x60, 0x06, 0x40,
  0x02, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60,
  0x03, 0x30, 0x06, 0x1C, 0x3C, 0x07, 0xF0, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x03,
  0xC0, 0x24, 0x06, 0x71, 0xC1, 0xF0, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18,
  0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0x80, 0xC3, 0x00,
  0xC2, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xDC, 0x00, 0xF6, 0x00, 0xE3, 0x00,
  0xC1, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x20, 0xC0, 0x30,
  0xC0, 0x18, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xE8, 0x00, 0x0F, 0x40, 0x00, 0x7B,
  0x00, 0x07, 0xC8, 0x00, 0x2E, 0x40, 0x01, 0x73, 0x00, 0x1B, 0xC8, 0x00,
  0x9E, 0x40, 0x0C, 0xF3, 0x00, 0x47, 0x88, 0x02, 0x3C, 0x40, 0x31, 0xE3,
  0x01, 0x0F, 0x08, 0x08, 0x78, 0x40, 0xC3, 0xC1, 0x04, 0x1E, 0x08, 0x20,
  0xF0, 0x63, 0x07, 0x81, 0x10, 0x3C, 0x08, 0x81, 0xE0, 0x6C, 0x0F, 0x01,
  0x40, 0x78, 0x0A, 0x03, 0xC0, 0x70, 0x1E, 0x01, 0x00, 0xC0, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xD0, 0x01, 0xD8, 0x01, 0xC8, 0x01,
  0xCC, 0x01, 0xC4, 0x01, 0xC6, 0x01, 0xC2, 0x01, 0xC1, 0x01, 0xC1, 0x81,
  0xC0, 0x81, 0xC0, 0xC1, 0xC0, 0x41, 0xC0, 0x61, 0xC0, 0x21, 0xC0, 0x31,
  0xC0, 0x19, 0xC0, 0x09, 0xC0, 0x0D, 0xC0, 0x05, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0x03, 0xF0, 0x07, 0x1C, 0x06, 0x03, 0x06, 0x00, 0x46, 0x00,
  0x32, 0x00, 0x09, 0x00, 0x04, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x24, 0x00, 0x13, 0x00,
  0x18, 0xC0, 0x08, 0x30, 0x08, 0x0E, 0x38, 0x01, 0xF8, 0x00, 0xFF, 0xC3,
  0x01, 0xCC, 0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1B, 0x01, 0xCF, 0xFC,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x07, 0x1C,
  0x06, 0x03, 0x06, 0x00, 0x46, 0x00, 0x32, 0x00, 0x09, 0x00, 0x05, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00,
  0x68, 0x00, 0x24, 0x00, 0x13, 0x00, 0x18, 0xC0, 0x08, 0x30, 0x18, 0x0E,
  0x38, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0xFF, 0xC1, 0x00, 0xE2, 0x00, 0x64, 0x00, 0x48, 0x00, 0xD0,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x34, 0x00,
  0x48, 0x01, 0x90, 0x0E, 0x3F, 0xF0, 0x40, 0x20, 0x80, 0x61, 0x00, 0x42,
  0x00, 0xC4, 0x00, 0x88, 0x01, 0x90, 0x01, 0x20, 0x03, 0x40, 0x02, 0x80,
  0x07, 0x00, 0x04, 0x07, 0xE0, 0x38, 0xE0, 0xC0, 0x23, 0x00, 0x24, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0xD0, 0x01, 0x18, 0x06,
  0x1C, 0x38, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x90, 0x03, 0x30, 0x0C, 0x3C, 0x70, 0x1F,
  0xC0, 0x80, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x26, 0x00, 0x11,
  0x00, 0x18, 0x80, 0x08, 0x60, 0x04, 0x30, 0x06, 0x08, 0x02, 0x04, 0x01,
  0x03, 0x01, 0x80, 0x80, 0x80, 0x40, 0x40, 0x30, 0x60, 0x08, 0x30, 0x04,
  0x10, 0x03, 0x08, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x22, 0x00, 0x1B, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x0C, 0x00,
  0xD0, 0x03, 0x00, 0x34, 0x00, 0xC0, 0x09, 0x00, 0x38, 0x02, 0x60, 0x1A,
  0x00, 0x98, 0x04, 0x80, 0x62, 0x01, 0x20, 0x10, 0x80, 0x4C, 0x04, 0x20,
  0x31, 0x01, 0x0C, 0x08, 0x40, 0xC1, 0x02, 0x10, 0x30, 0x40, 0x86, 0x08,
  0x10, 0x60, 0x82, 0x06, 0x10, 0x20, 0x81, 0x84, 0x08, 0x60, 0x21, 0x03,
  0x18, 0x08, 0xC0, 0x44, 0x02, 0x20, 0x11, 0x00, 0xC8, 0x04, 0x40, 0x12,
  0x01, 0xB0, 0x05, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0x80, 0x04, 0x00, 0x40, 0x01,
  0x30, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC1, 0x80, 0x40, 0x40, 0x60, 0x30,
  0x60, 0x08, 0x20, 0x06, 0x30, 0x01, 0x10, 0x00, 0xD8, 0x00, 0x28, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x06, 0xC0, 0x02, 0x30, 0x03, 0x08,
  0x03, 0x06, 0x01, 0x01, 0x01, 0x80, 0xC0, 0x80, 0x20, 0xC0, 0x18, 0x40,
  0x06, 0x60, 0x03, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0x98, 0x00,
  0xCC, 0x00, 0x43, 0x00, 0x61, 0x80, 0x20, 0x40, 0x30, 0x30, 0x10, 0x08,
  0x18, 0x06, 0x08, 0x01, 0x0C, 0x00, 0xC4, 0x00, 0x26, 0x00, 0x1A, 0x00,
  0x05, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x01, 0xFF, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x10, 0x04, 0x01,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x0F, 0xC0, 0x08, 0x03, 0x01, 0x40, 0x50, 0x36, 0x08,
  0x82, 0x21, 0x8C, 0x41, 0x10, 0x4C, 0x1A, 0x02, 0x80, 0x80, 0xFF, 0xF8,
  0x43, 0x0C, 0x20, 0x80, 0x0F, 0x83, 0x8E, 0x60, 0x24, 0x03, 0xC0, 0x1C,
  0x01, 0x00, 0x10, 0x01, 0x0F, 0xF3, 0x81, 0x60, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0xC0, 0x57, 0x19, 0x3F, 0x10, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x8B, 0x9C,
  0xE0, 0x6C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0xE0, 0x6B, 0x1C,
  0x8F, 0x80, 0x0F, 0x81, 0xC7, 0x18, 0x08, 0x80, 0x6C, 0x01, 0x40, 0x0A,
  0x00, 0x70, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x0F, 0x00, 0x48, 0x02, 0x60, 0x31, 0xC7, 0x03, 0xE0, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0F, 0x99,
  0xC6, 0xD8, 0x0E, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0D, 0x00, 0x68, 0x03,
  0x60, 0x39, 0xC6, 0xC3, 0xE6, 0x0F, 0x81, 0xC7, 0x18, 0x0C, 0x80, 0x2C,
  0x01, 0x40, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x11, 0xE7, 0x03, 0xF0,
  0x07, 0x86, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0x99, 0xC6, 0xD8, 0x0E,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x0D, 0x00, 0x68, 0x03, 0x60, 0x39, 0xC6,
  0xC3, 0xE6, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x4C, 0x06, 0x38, 0xE0,
  0x7C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x8F, 0x89, 0x8C, 0xA0, 0x6C, 0x02, 0xC0, 0x28, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0xE0, 0x02, 0xAA, 0xAA, 0xAA,
  0xAA, 0xA0, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x21, 0x8C, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x68, 0x0C, 0x81, 0x88, 0x30, 0x82, 0x08, 0x40,
  0x8C, 0x09, 0x80, 0xB8, 0x0E, 0x80, 0xCC, 0x08, 0x60, 0x82, 0x08, 0x30,
  0x81, 0x88, 0x08, 0x80, 0xC8, 0x06, 0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xE0,
  0x8F, 0x81, 0xE2, 0x67, 0x18, 0xEA, 0x06, 0xC0, 0xB0, 0x0A, 0x03, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x8F, 0x89, 0x8C, 0xA0, 0x6C, 0x02, 0xC0,
  0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x0F, 0x80,
  0xE3, 0x82, 0x03, 0x18, 0x06, 0x40, 0x1B, 0x00, 0x28, 0x00, 0xA0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0B, 0x00, 0x24, 0x01,
  0x98, 0x06, 0x20, 0x30, 0x63, 0x80, 0xF8, 0x00, 0x8F, 0x8B, 0x9C, 0xE0,
  0x6C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x6B, 0x1C, 0x8F,
  0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0x99, 0xC6, 0xD8, 0x0E, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0D, 0x00, 0x68,
  0x03, 0x60, 0x39, 0xC6, 0xC3, 0xE6, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x8F, 0x72, 0x86, 0x0C, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x1F,
  0x03, 0x9C, 0x40, 0x6C, 0x02, 0xC0, 0x3C, 0x00, 0x40, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x03, 0x40,
  0x27, 0x9C, 0x1F, 0x80, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x18, 0x0F, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0x07, 0x40, 0x77, 0x1B, 0x1F, 0x30, 0xC0, 0x0E, 0x00,
  0xD0, 0x06, 0x80, 0x26, 0x01, 0x10, 0x18, 0x80, 0x86, 0x04, 0x10, 0x60,
  0x82, 0x06, 0x10, 0x11, 0x80, 0x88, 0x06, 0x40, 0x16, 0x00, 0xA0, 0x07,
  0x00, 0x18, 0x00, 0x80, 0x40, 0x30, 0x0A, 0x01, 0x80, 0xD0, 0x1C, 0x06,
  0xC0, 0xA0, 0x22, 0x05, 0x81, 0x10, 0x24, 0x18, 0x83, 0x20, 0xC6, 0x11,
  0x04, 0x30, 0x8C, 0x20, 0x84, 0x23, 0x04, 0x61, 0x18, 0x32, 0x08, 0x81,
  0x90, 0x64, 0x04, 0x81, 0x60, 0x2C, 0x0B, 0x01, 0x40, 0x50, 0x0E, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x40, 0x1B, 0x01, 0x88, 0x08, 0x60,
  0xC1, 0x84, 0x04, 0x60, 0x32, 0x00, 0xB0, 0x07, 0x00, 0x18, 0x01, 0xC0,
  0x0B, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x86, 0x04, 0x20, 0x33, 0x00, 0xB0,
  0x06, 0xC0, 0x0E, 0x00, 0xD0, 0x06, 0xC0, 0x26, 0x01, 0x10, 0x18, 0x80,
  0x86, 0x04, 0x10, 0x60, 0x82, 0x06, 0x10, 0x11, 0x80, 0x88, 0x06, 0x40,
  0x16, 0x00, 0xA0, 0x07, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0xFF,
  0xF0, 0x00, 0x81, 0x81, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x38, 0x38, 0x06, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30,
  0x18, 0x04, 0x03, 0x00, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x40, 0x30, 0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x01, 0xC0, 0x60,
  0x40, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x18, 0x08, 0x18, 0x08, 0x00, 0x3C, 0x01, 0x66, 0x01, 0xC3,
  0x03, 0x81, 0x82, 0x80, 0xE6, 0x80, 0x3C,
};

const GFXglyph RobotoCondensed_ExtraLight36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 7, 3, -26 },
  { 8, 5, 8, 10, 3, -27 },
  { 13, 17, 26, 18, 1, -26 },
  { 69, 13, 32, 17, 2, -29 },
  { 121, 19, 26, 23, 2, -26 },
  { 183, 16, 26, 19, 2, -26 },
  { 235, 2, 7, 6, 2, -27 },
  { 237, 7, 37, 10, 2, -29 },
  { 270, 7, 37, 10, 1, -29 },
  { 303, 14, 14, 15, 1, -26 },
  { 328, 15, 19, 18, 1, -21 },
  { 364, 3, 8, 7, 1, -3 },
  { 367, 7, 1, 10, 1, -12 },
  { 368, 2, 2, 8, 3, -2 },
  { 369, 10, 28, 13, 1, -26 },
  { 404, 13, 26, 17, 2, -26 },
  { 447, 7, 26, 17, 3, -26 },
  { 470, 14, 26, 17, 2, -26 },
  { 516, 13, 26, 17, 2, -26 },
  { 559, 16, 26, 17, 1, -26 },
  { 611, 13, 26, 17, 3, -26 },
  { 654, 14, 26, 17, 2, -26 },
  { 700, 15, 26, 17, 1, -26 },
  { 749, 14, 26, 17, 2, -26 },
  { 795, 13, 26, 17, 2, -26 },
  { 838, 3, 19, 7, 2, -19 },
  { 846, 4, 24, 6, 1, -19 },
  { 858, 12, 15, 16, 2, -19 },
  { 881, 12, 8, 18, 3, -16 },
  { 893, 13, 15, 16, 2, -19 },
  { 918, 11, 26, 14, 2, -26 },
  { 954, 25, 33, 29, 2, -25 },
  { 1058, 17, 26, 19, 1, -26 },
  { 1114, 14, 26, 19, 3, -26 },
  { 1160, 15, 26, 20, 3, -26 },
  { 1209, 15, 26, 21, 3, -26 },
  { 1258, 13, 26, 18, 3, -26 },
  { 1301, 14, 26, 18, 3, -26 },
  { 1347, 16, 26, 22, 3, -26 },
  { 1399, 16, 26, 22, 3, -26 },
  { 1451, 1, 26, 9, 4, -26 },
  { 1455, 12, 26, 17, 2, -26 },
  { 1494, 16, 26, 20, 3, -26 },
  { 1546, 12, 26, 17, 3, -26 },
  { 1585, 21, 26, 27, 3, -26 },
  { 1654, 16, 26, 22, 3, -26 },
  { 1706, 17, 26, 21, 2, -26 },
  { 1762, 14, 26, 19, 3, -26 },
  { 1808, 17, 31, 21, 2, -26 },
  { 1874, 15, 26, 20, 3, -26 },
  { 1923, 15, 26, 19, 2, -26 },
  { 1972, 17, 26, 19, 1, -26 },
  { 2028, 15, 26, 21, 3, -26 },
  { 2077, 17, 26, 19, 1, -26 },
  { 2133, 26, 26, 28, 1, -26 },
  { 2218, 17, 26, 19, 1, -26 },
  { 2274, 17, 26, 19, 1, -26 },
  { 2330, 15, 26, 19, 2, -26 },
  { 2379, 4, 34, 8, 3, -29 },
  { 2396, 10, 28, 12, 1, -26 },
  { 2431, 5, 34, 8, 0, -29 },
  { 2453, 10, 13, 13, 2, -26 },
  { 2470, 13, 1, 14, 0, 0 },
  { 2472, 5, 5, 10, 2, -27 },
  { 2476, 12, 19, 17, 2, -19 },
  { 2505, 12, 27, 17, 3, -27 },
  { 2546, 13, 19, 16, 2, -19 },
  { 2577, 13, 27, 17, 2, -27 },
  { 2621, 13, 19, 16, 2, -19 },
  { 2652, 9, 27, 11, 1, -27 },
  { 2683, 13, 26, 17, 2, -19 },
  { 2726, 12, 27, 17, 3, -27 },
  { 2767, 2, 26, 7, 3, -26 },
  { 2774, 6, 33, 7, -1, -26 },
  { 2799, 12, 27, 15, 3, -27 },
  { 2840, 1, 27, 7, 3, -27 },
  { 2844, 22, 19, 28, 3, -19 },
  { 2897, 12, 19, 17, 3, -19 },
  { 2926, 14, 19, 18, 2, -19 },
  { 2960, 12, 26, 17, 3, -19 },
  { 2999, 13, 26, 18, 2, -19 },
  { 3042, 7, 19, 11, 3, -19 },
  { 3059, 12, 19, 16, 2, -19 },
  { 3088, 8, 24, 10, 1, -24 },
  { 3112, 12, 19, 17, 3, -19 },
  { 3141, 13, 19, 15, 1, -19 },
  { 3172, 21, 19, 24, 1, -19 },
  { 3222, 13, 19, 15, 1, -19 },
  { 3253, 13, 26, 15, 1, -19 },
  { 3296, 12, 19, 15, 2, -19 },
  { 3325, 9, 36, 11, 1, -28 },
  { 3366, 2, 31, 8, 3, -26 },
  { 3374, 9, 36, 11, 0, -28 },
  { 3415, 16, 6, 22, 3, -14 },
};

const GFXfont RobotoCondensed_ExtraLight36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT36PT7B_H_
