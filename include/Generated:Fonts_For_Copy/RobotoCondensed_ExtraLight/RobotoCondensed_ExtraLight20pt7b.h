#ifndef _ROBOTOCONDENSED_EXTRALIGHT20PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight20pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0x30, 0xB6, 0xD0, 0x11, 0x08, 0x84, 0x82, 0x4F,
  0xF9, 0x10, 0x88, 0x44, 0x24, 0x7F, 0x89, 0x04, 0x84, 0x42, 0x20, 0x08,
  0x08, 0x3C, 0x42, 0x42, 0x81, 0x40, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x81,
  0x81, 0x42, 0x3C, 0x08, 0x08, 0x70, 0x11, 0x02, 0x24, 0x44, 0x88, 0xA1,
  0x14, 0x1D, 0x00, 0x2E, 0x0A, 0x21, 0x44, 0x48, 0x91, 0x10, 0x22, 0x03,
  0x80, 0x38, 0x22, 0x11, 0x08, 0x84, 0x41, 0x40, 0xC0, 0xA0, 0x48, 0xC2,
  0x60, 0xD0, 0x64, 0x31, 0xE4, 0xF0, 0x11, 0x24, 0x44, 0x48, 0x88, 0x88,
  0x88, 0x44, 0x44, 0x21, 0x10, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x22, 0x24, 0x80, 0x08, 0x08, 0x08, 0x6F, 0x18, 0x14, 0x24, 0x42,
  0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0xF0,
  0xF0, 0xC0, 0x04, 0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x00, 0x3C, 0x42, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x42, 0x42, 0x3C, 0x3D, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3C,
  0x42, 0x82, 0x82, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0xFF, 0x3C, 0x42, 0x82, 0x82, 0x02, 0x02, 0x1C, 0x06, 0x02, 0x01, 0x81,
  0x82, 0x42, 0x3C, 0x04, 0x0C, 0x0C, 0x14, 0x14, 0x24, 0x44, 0x44, 0x84,
  0xFF, 0x04, 0x04, 0x04, 0x04, 0x7F, 0x02, 0x04, 0x08, 0x1F, 0x21, 0x01,
  0x02, 0x06, 0x0C, 0x18, 0x4F, 0x00, 0x1C, 0x20, 0x40, 0x40, 0x80, 0xBC,
  0xC2, 0x82, 0x81, 0x81, 0x81, 0x42, 0x42, 0x3C, 0xFF, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x3C, 0x42,
  0x82, 0x82, 0x82, 0x42, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xA3, 0x3A, 0x04, 0x08, 0x10, 0x47,
  0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x5A, 0x02, 0x18, 0xC2, 0x08, 0x08,
  0x0C, 0x06, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x40, 0x60,
  0x21, 0x84, 0x30, 0x80, 0x7A, 0x18, 0x61, 0x04, 0x10, 0x84, 0x20, 0x80,
  0x00, 0x00, 0x80, 0x07, 0xC0, 0x60, 0xC2, 0x01, 0x08, 0x02, 0x43, 0x89,
  0x11, 0x18, 0x84, 0x62, 0x11, 0x88, 0x46, 0x22, 0x18, 0x88, 0x62, 0x22,
  0x88, 0x89, 0x1D, 0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x04,
  0x03, 0x00, 0xA0, 0x28, 0x12, 0x04, 0x41, 0x10, 0x84, 0x20, 0x8F, 0xE4,
  0x09, 0x01, 0x40, 0x60, 0x10, 0xFC, 0x82, 0x82, 0x82, 0x82, 0x82, 0xFC,
  0x86, 0x82, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x1E, 0x10, 0x90, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x28, 0x12, 0x10, 0xF0, 0xFC,
  0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xFC, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x1F, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x00, 0x3C, 0x43, 0x81, 0x81, 0x80, 0x80, 0x80, 0x8F, 0x81,
  0x81, 0x81, 0x81, 0x41, 0x3E, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0xFF, 0xFC, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x4F, 0x00,
  0x81, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xA0, 0xD0, 0x88, 0x88, 0x84, 0x82,
  0x82, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x1F, 0xC0, 0x80, 0x30, 0x07, 0x01, 0xE0, 0x3A, 0x0B, 0x41, 0x68,
  0x2C, 0x89, 0x91, 0x32, 0x26, 0x28, 0xC5, 0x18, 0xC3, 0x08, 0x40, 0x80,
  0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x11, 0x84, 0xC2, 0x60, 0xB0,
  0x58, 0x1C, 0x04, 0x1E, 0x30, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x28, 0x16, 0x10, 0xF0, 0xFC, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x30, 0x90,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x16, 0x10,
  0xF0, 0x04, 0x01, 0x00, 0x80, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x82, 0x82,
  0xFC, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0x3E, 0x20, 0xA0, 0x50, 0x28,
  0x02, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x30, 0x24, 0x11, 0xF0, 0xFF,
  0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x7C, 0x40, 0x50, 0x14, 0x09, 0x02, 0x20, 0x88,
  0x22, 0x10, 0x44, 0x11, 0x04, 0x80, 0xA0, 0x28, 0x0C, 0x01, 0x00, 0x82,
  0x06, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x44, 0x89, 0x12, 0x24, 0x48, 0x92,
  0x24, 0x48, 0x50, 0xA1, 0x42, 0x85, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x80,
  0x80, 0xA0, 0x90, 0x84, 0x42, 0x40, 0xA0, 0x20, 0x30, 0x14, 0x12, 0x08,
  0x88, 0x28, 0x14, 0x04, 0x40, 0x50, 0x22, 0x08, 0x84, 0x11, 0x04, 0x80,
  0xA0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xFF, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x07, 0xFC, 0xEA, 0xAA, 0xAA, 0xAA, 0xAC, 0x84, 0x20, 0x84, 0x20, 0x84,
  0x20, 0x84, 0x20, 0x84, 0x20, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x27,
  0x80, 0x21, 0x14, 0xA4, 0xC6, 0x20, 0xFE, 0x48, 0x80, 0x3C, 0x86, 0x08,
  0x10, 0x2F, 0xE0, 0xC1, 0x83, 0x0D, 0xE8, 0x81, 0x02, 0x04, 0x0F, 0x90,
  0xA1, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x50, 0xBE, 0x00, 0x3C, 0x86, 0x0C,
  0x18, 0x10, 0x20, 0x40, 0x82, 0x84, 0xF0, 0x02, 0x04, 0x08, 0x13, 0xE8,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x28, 0x4F, 0x80, 0x3C, 0x86, 0x0C,
  0x1F, 0xF0, 0x20, 0x40, 0x80, 0x84, 0xF0, 0x3A, 0x10, 0x8F, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x00, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x84, 0xF8, 0x10, 0x28, 0x4F, 0x00, 0x82, 0x08, 0x20, 0xBB, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0xC0, 0x55, 0x55, 0x54, 0x30,
  0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0xC0, 0x82, 0x08, 0x20,
  0x86, 0x29, 0x28, 0xC2, 0x8A, 0x24, 0x8A, 0x28, 0x40, 0xFF, 0xFE, 0xBC,
  0xF6, 0x18, 0x70, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41,
  0x82, 0x0C, 0x10, 0x60, 0x82, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x40, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42,
  0x3C, 0xF9, 0x0A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0B, 0xE4, 0x08,
  0x10, 0x20, 0x00, 0x3E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84,
  0xF8, 0x10, 0x20, 0x40, 0x80, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x80, 0x79,
  0x0A, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x83, 0x09, 0xE0, 0x21, 0x3E, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x41, 0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x42, 0x8C, 0xE8, 0x83, 0x06, 0x14, 0x24, 0x49, 0x12, 0x14, 0x30,
  0x60, 0x40, 0x84, 0x30, 0x86, 0x28, 0xC5, 0x14, 0xA4, 0x94, 0x94, 0x52,
  0x8A, 0x31, 0x84, 0x10, 0x82, 0x00, 0x82, 0x89, 0x21, 0x43, 0x02, 0x0C,
  0x14, 0x45, 0x0A, 0x08, 0x41, 0x41, 0x42, 0x22, 0x22, 0x24, 0x24, 0x14,
  0x18, 0x08, 0x08, 0x08, 0x10, 0x10, 0x60, 0xFC, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x41, 0x03, 0xF8, 0x19, 0x08, 0x42, 0x10, 0x84, 0x44, 0x10,
  0x82, 0x10, 0x84, 0x21, 0x08, 0x30, 0xFF, 0xFF, 0x80, 0xC1, 0x08, 0x42,
  0x10, 0x84, 0x10, 0x44, 0x42, 0x10, 0x84, 0x21, 0x11, 0x00, 0x70, 0x53,
  0x28, 0x38,
};

const GFXglyph RobotoCondensed_ExtraLight20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 3, 4, 5, 1, -15 },
  { 7, 9, 14, 10, 1, -14 },
  { 23, 8, 18, 10, 1, -16 },
  { 41, 11, 14, 13, 1, -14 },
  { 61, 9, 14, 11, 1, -14 },
  { 77, 1, 4, 3, 1, -15 },
  { 78, 4, 21, 6, 1, -16 },
  { 89, 4, 21, 6, 0, -16 },
  { 100, 8, 8, 8, 0, -14 },
  { 108, 8, 11, 10, 1, -12 },
  { 119, 1, 4, 4, 1, -2 },
  { 120, 4, 1, 5, 1, -7 },
  { 121, 2, 1, 5, 1, -1 },
  { 122, 6, 15, 7, 0, -14 },
  { 134, 8, 14, 10, 1, -14 },
  { 148, 4, 14, 10, 2, -14 },
  { 155, 8, 14, 10, 1, -14 },
  { 169, 8, 14, 10, 1, -14 },
  { 183, 8, 14, 10, 1, -14 },
  { 197, 7, 14, 10, 2, -14 },
  { 210, 8, 14, 10, 1, -14 },
  { 224, 8, 14, 10, 1, -14 },
  { 238, 8, 14, 10, 1, -14 },
  { 252, 7, 14, 10, 1, -14 },
  { 265, 2, 10, 4, 1, -10 },
  { 268, 2, 12, 4, 1, -10 },
  { 271, 7, 9, 9, 1, -11 },
  { 279, 7, 5, 10, 1, -9 },
  { 284, 7, 9, 9, 1, -11 },
  { 292, 6, 14, 8, 1, -14 },
  { 303, 14, 18, 16, 1, -14 },
  { 335, 10, 14, 11, 0, -14 },
  { 353, 8, 14, 11, 2, -14 },
  { 367, 9, 14, 11, 1, -14 },
  { 383, 8, 14, 11, 2, -14 },
  { 397, 7, 14, 10, 2, -14 },
  { 410, 7, 14, 10, 2, -14 },
  { 423, 8, 14, 12, 2, -14 },
  { 437, 9, 14, 12, 2, -14 },
  { 453, 1, 14, 5, 2, -14 },
  { 455, 7, 14, 10, 1, -14 },
  { 468, 8, 14, 11, 2, -14 },
  { 482, 7, 14, 9, 2, -14 },
  { 495, 11, 14, 15, 2, -14 },
  { 515, 9, 14, 12, 2, -14 },
  { 531, 9, 14, 12, 1, -14 },
  { 547, 8, 14, 11, 2, -14 },
  { 561, 9, 17, 12, 1, -14 },
  { 581, 8, 14, 11, 2, -14 },
  { 595, 9, 14, 10, 1, -14 },
  { 611, 9, 14, 10, 1, -14 },
  { 627, 8, 14, 12, 2, -14 },
  { 641, 10, 14, 11, 0, -14 },
  { 659, 14, 14, 16, 1, -14 },
  { 684, 9, 14, 11, 1, -14 },
  { 700, 10, 14, 10, 0, -14 },
  { 718, 9, 14, 10, 1, -14 },
  { 734, 2, 19, 4, 2, -16 },
  { 739, 5, 15, 7, 1, -14 },
  { 749, 3, 19, 4, 0, -16 },
  { 757, 5, 7, 7, 1, -14 },
  { 762, 7, 1, 8, 0, 0 },
  { 763, 3, 3, 5, 1, -15 },
  { 765, 7, 11, 9, 1, -11 },
  { 775, 7, 15, 10, 2, -15 },
  { 789, 7, 11, 9, 1, -11 },
  { 799, 7, 15, 10, 1, -15 },
  { 813, 7, 11, 9, 1, -11 },
  { 823, 5, 15, 6, 1, -15 },
  { 833, 7, 15, 10, 1, -11 },
  { 847, 6, 15, 10, 2, -15 },
  { 859, 2, 15, 4, 1, -15 },
  { 863, 4, 19, 4, -1, -15 },
  { 873, 6, 15, 9, 2, -15 },
  { 885, 1, 15, 4, 2, -15 },
  { 887, 13, 11, 15, 1, -11 },
  { 905, 6, 11, 10, 2, -11 },
  { 914, 8, 11, 10, 1, -11 },
  { 925, 7, 15, 10, 2, -11 },
  { 939, 7, 15, 10, 1, -11 },
  { 953, 4, 11, 6, 2, -11 },
  { 959, 7, 11, 9, 1, -11 },
  { 969, 5, 13, 6, 0, -13 },
  { 978, 7, 11, 10, 1, -11 },
  { 988, 7, 11, 8, 1, -11 },
  { 998, 11, 11, 13, 1, -11 },
  { 1014, 7, 11, 9, 1, -11 },
  { 1024, 8, 15, 8, 0, -11 },
  { 1039, 7, 11, 9, 1, -11 },
  { 1049, 5, 20, 6, 1, -16 },
  { 1062, 1, 17, 4, 2, -14 },
  { 1065, 5, 20, 6, 0, -16 },
  { 1078, 10, 3, 12, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraLight20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT20PT7B_H_
