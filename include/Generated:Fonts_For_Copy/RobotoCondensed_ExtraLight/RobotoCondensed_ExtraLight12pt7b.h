#ifndef _ROBOTOCONDENSED_EXTRALIGHT12PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight12pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0x80, 0x74, 0x00, 0xA3, 0x8A, 0x28, 0xA5, 0x94, 0x40, 0x06,
  0x98, 0x86, 0x11, 0x96, 0x00, 0xC2, 0xAB, 0x34, 0x20, 0xB5, 0x55, 0x0C,
  0x64, 0xA8, 0x84, 0x56, 0x72, 0xE8, 0x40, 0x5A, 0xAA, 0xA9, 0x40, 0x89,
  0x22, 0x49, 0x29, 0x28, 0x21, 0x1C, 0xA5, 0x00, 0x01, 0x1C, 0x42, 0x00,
  0xE0, 0x40, 0x80, 0x11, 0x22, 0x24, 0x44, 0x88, 0x69, 0x99, 0x99, 0x99,
  0x60, 0x55, 0x55, 0x00, 0xE9, 0x11, 0x22, 0x48, 0xE0, 0xE1, 0x11, 0x21,
  0x11, 0xE0, 0x00, 0x42, 0x8A, 0x49, 0x2F, 0x82, 0x00, 0x68, 0x8E, 0x11,
  0x19, 0x70, 0x68, 0x8E, 0x99, 0x99, 0x60, 0x78, 0x42, 0x21, 0x08, 0x84,
  0x00, 0xE9, 0x99, 0x69, 0x99, 0xE0, 0xE9, 0x99, 0x9F, 0x11, 0x60, 0x82,
  0x40, 0x05, 0x80, 0x1B, 0x20, 0xC1, 0x80, 0x66, 0x86, 0x16, 0x80, 0xE4,
  0x92, 0x80, 0x40, 0x3C, 0x42, 0x91, 0xA1, 0xA5, 0xA9, 0xA9, 0xBE, 0x80,
  0x80, 0x78, 0x10, 0x43, 0x0A, 0x49, 0xE4, 0x61, 0x80, 0xF4, 0x63, 0x1F,
  0x46, 0x31, 0xF0, 0x74, 0x61, 0x08, 0x42, 0x11, 0x70, 0xF4, 0x63, 0x18,
  0xC6, 0x31, 0xF0, 0xE4, 0x21, 0x0E, 0x42, 0x10, 0xF0, 0xF4, 0x21, 0x0E,
  0x42, 0x10, 0x80, 0x7C, 0x21, 0x08, 0xC2, 0x31, 0x78, 0x84, 0x63, 0x1F,
  0xC6, 0x31, 0x80, 0xFF, 0x80, 0x08, 0x42, 0x10, 0x84, 0x21, 0x70, 0x8C,
  0xA9, 0x4C, 0x52, 0x52, 0x88, 0x88, 0x88, 0x88, 0x88, 0xE0, 0x83, 0x07,
  0x1E, 0x3C, 0xB5, 0x6A, 0xC9, 0x92, 0x84, 0x73, 0x5A, 0xCE, 0x71, 0x88,
  0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x80,
  0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x42, 0xF4, 0x63, 0x1F, 0x42, 0x51,
  0x88, 0x74, 0x61, 0x07, 0x04, 0x31, 0x70, 0x78, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x00, 0x04, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x86, 0x14, 0x52, 0x48,
  0xA3, 0x04, 0x10, 0x08, 0xC4, 0x53, 0x2A, 0xA5, 0x52, 0x98, 0x8C, 0x44,
  0x20, 0x00, 0x45, 0x22, 0x8C, 0x10, 0xC2, 0x92, 0x84, 0x85, 0x14, 0x8A,
  0x30, 0x41, 0x04, 0x00, 0x68, 0x84, 0x42, 0x22, 0x10, 0x70, 0x7F, 0xE0,
  0x04, 0x44, 0x42, 0x22, 0x11, 0x55, 0x55, 0x55, 0x5A, 0x90, 0x60, 0xC0,
  0xE1, 0x1D, 0x99, 0xF0, 0x08, 0xE9, 0x99, 0x99, 0x60, 0xE9, 0x88, 0x89,
  0xE0, 0x11, 0xF9, 0x99, 0x99, 0xF0, 0xE9, 0xF8, 0x88, 0xF0, 0x29, 0x24,
  0x92, 0x40, 0xF9, 0x99, 0x99, 0xF1, 0xE0, 0x08, 0xE9, 0x99, 0x99, 0x10,
  0x8F, 0x80, 0x40, 0x55, 0x56, 0x08, 0x9A, 0xCC, 0xAA, 0x10, 0x7F, 0x00,
  0x6F, 0x26, 0x4C, 0x99, 0x32, 0x44, 0x00, 0x69, 0x99, 0x99, 0x10, 0xE9,
  0x99, 0x99, 0xE0, 0x69, 0x99, 0x99, 0xE8, 0x00, 0xF9, 0x99, 0x99, 0xF1,
  0x10, 0x6A, 0xA0, 0xE9, 0x86, 0x11, 0xE0, 0x49, 0x24, 0x92, 0x19, 0x99,
  0x99, 0xF0, 0x8C, 0x54, 0xA5, 0x10, 0x80, 0x00, 0xA5, 0x6A, 0xD6, 0xA4,
  0x89, 0x00, 0x8A, 0x88, 0x45, 0x2A, 0x20, 0x8A, 0x54, 0xA5, 0x10, 0x84,
  0x40, 0x52, 0x24, 0x88, 0x60, 0x25, 0x24, 0x92, 0x48, 0x90, 0xFF, 0xE0,
  0x09, 0x24, 0x42, 0x49, 0x40, 0xE0, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLight12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 2, 1, -9 },
  { 3, 2, 3, 3, 1, -9 },
  { 4, 6, 9, 6, 0, -9 },
  { 11, 4, 11, 6, 1, -10 },
  { 17, 6, 9, 8, 1, -9 },
  { 24, 5, 9, 6, 1, -9 },
  { 30, 1, 3, 2, 1, -9 },
  { 31, 2, 13, 3, 1, -10 },
  { 35, 3, 13, 3, 0, -10 },
  { 40, 5, 5, 5, 0, -9 },
  { 44, 5, 6, 6, 0, -7 },
  { 48, 1, 3, 2, 0, -1 },
  { 49, 3, 1, 3, 0, -5 },
  { 50, 1, 1, 3, 1, -1 },
  { 51, 4, 10, 4, 0, -9 },
  { 56, 4, 9, 6, 1, -9 },
  { 61, 2, 9, 6, 1, -9 },
  { 64, 4, 9, 6, 1, -9 },
  { 69, 4, 9, 6, 1, -9 },
  { 74, 6, 9, 6, 0, -9 },
  { 81, 4, 9, 6, 1, -9 },
  { 86, 4, 9, 6, 1, -9 },
  { 91, 5, 9, 6, 0, -9 },
  { 97, 4, 9, 6, 1, -9 },
  { 102, 4, 9, 6, 1, -9 },
  { 107, 1, 7, 2, 1, -7 },
  { 108, 2, 9, 2, 0, -7 },
  { 111, 5, 5, 5, 0, -6 },
  { 115, 4, 2, 6, 1, -5 },
  { 116, 4, 5, 5, 1, -6 },
  { 119, 3, 9, 5, 1, -9 },
  { 123, 8, 11, 10, 1, -8 },
  { 134, 6, 9, 6, 0, -9 },
  { 141, 5, 9, 6, 1, -9 },
  { 147, 5, 9, 7, 1, -9 },
  { 153, 5, 9, 7, 1, -9 },
  { 159, 5, 9, 6, 1, -9 },
  { 165, 5, 9, 6, 1, -9 },
  { 171, 5, 9, 7, 1, -9 },
  { 177, 5, 9, 7, 1, -9 },
  { 183, 1, 9, 3, 1, -9 },
  { 185, 5, 9, 6, 0, -9 },
  { 191, 5, 9, 7, 1, -9 },
  { 197, 4, 9, 6, 1, -9 },
  { 202, 7, 9, 9, 1, -9 },
  { 210, 5, 9, 7, 1, -9 },
  { 216, 5, 9, 7, 1, -9 },
  { 222, 5, 9, 6, 1, -9 },
  { 228, 5, 11, 7, 1, -9 },
  { 235, 5, 9, 7, 1, -9 },
  { 241, 5, 9, 6, 1, -9 },
  { 247, 6, 9, 6, 0, -9 },
  { 254, 5, 9, 7, 1, -9 },
  { 260, 6, 9, 6, 0, -9 },
  { 267, 9, 9, 9, 0, -9 },
  { 278, 6, 9, 6, 0, -9 },
  { 285, 6, 9, 6, 0, -9 },
  { 292, 5, 9, 6, 1, -9 },
  { 298, 1, 12, 3, 1, -10 },
  { 300, 4, 10, 4, 0, -9 },
  { 305, 2, 12, 3, 0, -10 },
  { 308, 3, 4, 4, 1, -9 },
  { 310, 4, 1, 5, 0, 0 },
  { 311, 1, 2, 3, 1, -9 },
  { 312, 4, 7, 6, 1, -7 },
  { 316, 4, 9, 6, 1, -9 },
  { 321, 4, 7, 5, 1, -7 },
  { 325, 4, 9, 6, 1, -9 },
  { 330, 4, 7, 5, 1, -7 },
  { 334, 3, 9, 4, 0, -9 },
  { 338, 4, 9, 6, 1, -7 },
  { 343, 4, 9, 6, 1, -9 },
  { 348, 1, 10, 2, 1, -10 },
  { 350, 2, 12, 2, 0, -10 },
  { 353, 4, 9, 5, 1, -9 },
  { 358, 1, 9, 2, 1, -9 },
  { 360, 7, 7, 9, 1, -7 },
  { 367, 4, 7, 6, 1, -7 },
  { 371, 4, 7, 6, 1, -7 },
  { 375, 4, 9, 6, 1, -7 },
  { 380, 4, 9, 6, 1, -7 },
  { 385, 2, 7, 4, 1, -7 },
  { 387, 4, 7, 5, 1, -7 },
  { 391, 3, 8, 3, 0, -8 },
  { 394, 4, 7, 6, 1, -7 },
  { 398, 5, 7, 5, 0, -7 },
  { 403, 7, 7, 8, 0, -7 },
  { 410, 5, 7, 5, 0, -7 },
  { 415, 5, 9, 5, 0, -7 },
  { 421, 4, 7, 5, 1, -7 },
  { 425, 3, 12, 4, 0, -9 },
  { 430, 1, 11, 3, 1, -9 },
  { 432, 3, 12, 4, 0, -9 },
  { 437, 5, 2, 7, 1, -5 },
};

const GFXfont RobotoCondensed_ExtraLight12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT12PT7B_H_
