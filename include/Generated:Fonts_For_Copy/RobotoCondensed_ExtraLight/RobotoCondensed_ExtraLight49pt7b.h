#ifndef _ROBOTOCONDENSED_EXTRALIGHT49PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x43, 0x43,
  0x43, 0x43, 0x43, 0x42, 0x42, 0x42, 0x42, 0x42, 0x00, 0x60, 0x60, 0x01,
  0x01, 0x80, 0x04, 0x06, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x01,
  0x00, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0x80, 0xC0, 0x02, 0x03, 0x07,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x01, 0x80, 0x80, 0x06, 0x06, 0x00, 0x10,
  0x18, 0x00, 0x40, 0x60, 0x01, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x01,
  0x80, 0x80, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x60, 0x60, 0x01, 0x01,
  0x80, 0x04, 0x06, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00,
  0x0C, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x70, 0x38, 0x38, 0x03, 0x0C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0x30, 0x03, 0x8F, 0x01, 0xC0, 0xFF,
  0xE0, 0x0F, 0xC0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x01, 0x00,
  0x00, 0xC0, 0x60, 0x10, 0x20, 0x18, 0x04, 0x08, 0x06, 0x03, 0x02, 0x01,
  0x81, 0x80, 0x80, 0x60, 0x60, 0x20, 0x18, 0x30, 0x08, 0x06, 0x0C, 0x03,
  0x01, 0x86, 0x00, 0xC0, 0x41, 0x00, 0x18, 0x30, 0xC0, 0x03, 0xF8, 0x20,
  0x00, 0x7C, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0xF8, 0x00, 0x30, 0x7F, 0x00, 0x0C, 0x30, 0x60,
  0x06, 0x18, 0x08, 0x01, 0x06, 0x03, 0x00, 0xC1, 0x00, 0xC0, 0x20, 0x40,
  0x30, 0x18, 0x10, 0x0C, 0x04, 0x04, 0x03, 0x03, 0x01, 0x00, 0xC1, 0x80,
  0x40, 0x30, 0x60, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0xC1, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0,
  0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0x6C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xCC, 0x00, 0x06, 0x38,
  0x00, 0x30, 0x60, 0x19, 0x80, 0xC0, 0x66, 0x01, 0x81, 0xB0, 0x06, 0x04,
  0xC0, 0x0C, 0x33, 0x00, 0x18, 0xCC, 0x00, 0x33, 0x30, 0x00, 0xD8, 0xC0,
  0x01, 0xE3, 0x00, 0x03, 0x0E, 0x00, 0x1E, 0x18, 0x00, 0xF8, 0x30, 0x07,
  0x30, 0x70, 0x78, 0x60, 0xFF, 0x81, 0xC0, 0x20, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x80, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x20, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x30, 0x10, 0x1F, 0x82, 0x1F, 0x3E, 0x4F, 0x00, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x01, 0x83, 0x00,
  0x70, 0x60, 0x0C, 0x06, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x33, 0x33, 0x33, 0x66, 0xCC, 0xFF, 0xFF, 0xC0, 0xDF,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFE,
  0x01, 0xC0, 0xE0, 0xE0, 0x18, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x19,
  0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0x98, 0x00, 0xC3, 0x00, 0x30, 0xE0, 0x18, 0x1C, 0x0E, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x40, 0xF0, 0xFC, 0xF3, 0xF0, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xF0, 0x03, 0xFF, 0x03, 0x80, 0xE0, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00,
  0xCC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38,
  0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x04, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0xC0, 0x0C, 0x1E, 0x03,
  0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC,
  0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x60,
  0x06, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00,
  0x30, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x3F, 0xFF, 0x9F, 0xFF, 0xCC, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x1F, 0x81, 0xBF, 0xF0, 0xF0, 0x1C,
  0x60, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x34, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0C, 0x60, 0x0E, 0x1C, 0x0E,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x41, 0xF8, 0x31, 0xFF,
  0x0C, 0xC0, 0xE3, 0x60, 0x0C, 0xF0, 0x01, 0xB8, 0x00, 0x6C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0x98, 0x00,
  0x63, 0x00, 0x38, 0x60, 0x0C, 0x1C, 0x0E, 0x01, 0xFF, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xC0, 0x1C, 0x60, 0x03, 0x98,
  0x00, 0x64, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00,
  0x09, 0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x30, 0x70, 0x38,
  0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xC0, 0xE0, 0xC0, 0x0C, 0x60, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x19, 0xC0, 0x0E,
  0x38, 0x07, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01,
  0xC1, 0xC0, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x76,
  0x00, 0x3D, 0x80, 0x0B, 0x30, 0x06, 0xC6, 0x07, 0x20, 0xFF, 0x88, 0x1F,
  0x86, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x03, 0xF8, 0x00,
  0xF0, 0x00, 0xFD, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33,
  0x33, 0x33, 0x66, 0xC8, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xE0,
  0xE0, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x04, 0x00, 0x7C, 0x00, 0xC6,
  0x00, 0x7F, 0x80, 0x23, 0x00, 0x60, 0x60, 0x13, 0x00, 0x60, 0x30, 0x0D,
  0x80, 0x60, 0x18, 0x06, 0xC0, 0x30, 0x0C, 0x03, 0x40, 0x30, 0x06, 0x01,
  0xE0, 0x18, 0x03, 0x00, 0xF0, 0x0C, 0x01, 0x80, 0x38, 0x04, 0x00, 0xC0,
  0x1C, 0x06, 0x00, 0x60, 0x0E, 0x03, 0x00, 0x20, 0x0F, 0x01, 0x80, 0x10,
  0x07, 0x80, 0xC0, 0x08, 0x03, 0xC0, 0x60, 0x04, 0x01, 0xE0, 0x30, 0x02,
  0x00, 0xF0, 0x18, 0x03, 0x00, 0x58, 0x0C, 0x01, 0x80, 0x2C, 0x06, 0x00,
  0xC0, 0x36, 0x03, 0x00, 0xE0, 0x13, 0x00, 0x80, 0x50, 0x18, 0x80, 0x60,
  0x4C, 0x08, 0x60, 0x18, 0xE3, 0x1C, 0x30, 0x0F, 0xC1, 0xFC, 0x08, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x80, 0x80, 0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0x00, 0x1C,
  0x60, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x38, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3,
  0x00, 0x1C, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0E, 0xC0, 0x03, 0x9F,
  0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xE0,
  0x1E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00, 0x34, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x07, 0x00, 0x18, 0x0F, 0x01, 0xE0,
  0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x30,
  0x01, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x16,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x03, 0x18, 0x00, 0x70, 0xC0, 0x07, 0x07, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0x80, 0x70, 0x30, 0x00, 0xC3, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00,
  0x00, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x63, 0x80, 0x0F, 0x0E, 0x01, 0xE0,
  0x3F, 0xFE, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0C, 0x60, 0x0E, 0x38,
  0x0E, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C,
  0x00, 0x0E, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00,
  0x60, 0x30, 0x03, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x30,
  0xC0, 0x00, 0xC7, 0x00, 0x03, 0x36, 0x00, 0x0D, 0x8C, 0x00, 0x3C, 0x38,
  0x00, 0xE0, 0x60, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x30, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0D,
  0xD0, 0x00, 0x00, 0xDD, 0x80, 0x00, 0x0F, 0xD8, 0x00, 0x01, 0xBC, 0xC0,
  0x00, 0x1B, 0xCC, 0x00, 0x01, 0xBC, 0xC0, 0x00, 0x33, 0xC6, 0x00, 0x03,
  0x3C, 0x60, 0x00, 0x23, 0xC6, 0x00, 0x06, 0x3C, 0x30, 0x00, 0x63, 0xC3,
  0x00, 0x04, 0x3C, 0x10, 0x00, 0xC3, 0xC1, 0x80, 0x0C, 0x3C, 0x18, 0x01,
  0x83, 0xC0, 0x80, 0x18, 0x3C, 0x0C, 0x01, 0x83, 0xC0, 0xC0, 0x30, 0x3C,
  0x04, 0x03, 0x03, 0xC0, 0x60, 0x20, 0x3C, 0x06, 0x06, 0x03, 0xC0, 0x30,
  0x60, 0x3C, 0x03, 0x04, 0x03, 0xC0, 0x10, 0xC0, 0x3C, 0x01, 0x8C, 0x03,
  0xC0, 0x18, 0x80, 0x3C, 0x00, 0x98, 0x03, 0xC0, 0x0D, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00,
  0x30, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xD8, 0x00, 0x0F, 0x60, 0x00, 0x3C, 0xC0, 0x00, 0xF3, 0x00, 0x03, 0xC6,
  0x00, 0x0F, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0xF0, 0x60, 0x03, 0xC1, 0x80,
  0x0F, 0x03, 0x00, 0x3C, 0x0C, 0x00, 0xF0, 0x18, 0x03, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x3C, 0x01, 0x80, 0xF0, 0x06, 0x03, 0xC0, 0x0C, 0x0F, 0x00,
  0x30, 0x3C, 0x00, 0x60, 0xF0, 0x00, 0xC3, 0xC0, 0x03, 0x0F, 0x00, 0x06,
  0x3C, 0x00, 0x18, 0xF0, 0x00, 0x33, 0xC0, 0x00, 0xCF, 0x00, 0x01, 0xBC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x1E, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x61, 0x80, 0x03, 0x07, 0x00, 0x1C, 0x0F, 0x01, 0xE0, 0x0F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xC0, 0x03, 0x8C, 0x00,
  0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x38,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x18, 0x38, 0x00, 0x30, 0xC0, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x07, 0x00, 0x18, 0x0F,
  0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x08,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x30, 0x00, 0xE1, 0x80, 0x03, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x1C, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0x80, 0x70, 0x30, 0x01, 0xC3, 0x00, 0x07, 0x18, 0x00, 0x19,
  0x80, 0x00, 0x4C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x36, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0xC0, 0x00, 0xC7, 0x00, 0x0E, 0x1E, 0x01, 0xE0, 0x3F,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0x63, 0x80,
  0x0C, 0x1C, 0x03, 0xC0, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x62, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x1B, 0x00, 0x03, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x66,
  0x00, 0x1A, 0x00, 0x0C, 0xC0, 0x03, 0x40, 0x01, 0x18, 0x00, 0x4C, 0x00,
  0x63, 0x00, 0x19, 0x80, 0x0C, 0x20, 0x03, 0x10, 0x01, 0x86, 0x00, 0x62,
  0x00, 0x30, 0xC0, 0x08, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0x80, 0x30, 0x30, 0x0C, 0x10, 0x06, 0x06, 0x01, 0x03, 0x00, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x01, 0x01, 0x80, 0x80,
  0xC0, 0x30, 0x20, 0x18, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80,
  0x20, 0xC0, 0x18, 0x30, 0x04, 0x18, 0x01, 0x84, 0x00, 0xC3, 0x00, 0x31,
  0x80, 0x18, 0x40, 0x06, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x23, 0x00,
  0x08, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x19,
  0x00, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0A, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x67, 0x00, 0x03,
  0x8C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x03,
  0x00, 0x30, 0x06, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xCC, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x18, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x1B, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x78, 0x01, 0xE0, 0x04, 0x80, 0x33, 0x00, 0xCC, 0x02,
  0x10, 0x18, 0x60, 0x61, 0x83, 0x02, 0x0C, 0x0C, 0x30, 0x31, 0x80, 0x46,
  0x01, 0x90, 0x06, 0xC0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xC0, 0x70, 0xC0,
  0x0C, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0x00, 0x63,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x90, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0x40, 0x03, 0x98, 0x00, 0xE6, 0x00, 0x78, 0xC0, 0x76, 0x1F, 0xF1,
  0x83, 0xF8, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x7E, 0x0C, 0xFF, 0xC6, 0xC0, 0x73, 0xC0, 0x19, 0xC0,
  0x06, 0xC0, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xE0,
  0x03, 0x70, 0x03, 0x3E, 0x03, 0x91, 0xFF, 0x08, 0x3F, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xC0, 0x70, 0xE0, 0x0C, 0x30, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0x8C, 0x00, 0x63,
  0x80, 0x38, 0x70, 0x1C, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0xFC, 0x31, 0xFF,
  0x99, 0xC0, 0x6D, 0xC0, 0x1E, 0xC0, 0x07, 0x60, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x98, 0x03, 0xCE, 0x03, 0x63,
  0xFF, 0x30, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xC0, 0x70, 0xE0,
  0x0C, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x78, 0x0E, 0x07, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xFF, 0xEF, 0xFE,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x07, 0xE1, 0x8F, 0xFC, 0xCE, 0x03, 0x6E, 0x00, 0xF6, 0x00, 0x3B, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1C, 0xC0,
  0x1E, 0x70, 0x1B, 0x1F, 0xF9, 0x83, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x40, 0x06, 0x70, 0x03, 0x1C, 0x07,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC3, 0xF0, 0xC7, 0xF8, 0xDC, 0x0C, 0xD0, 0x06, 0xF0,
  0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x0E, 0xFC,
  0xF8, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0xE0, 0xC1,
  0xC0, 0xC1, 0x80, 0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xDC, 0x00, 0xF6,
  0x00, 0xE7, 0x00, 0xE3, 0x00, 0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x83, 0xF0, 0x0F, 0xC2, 0x3F, 0xE0, 0xFF, 0xC9, 0x80, 0xC7, 0x03,
  0xAC, 0x01, 0x98, 0x06, 0xA0, 0x06, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x30, 0xC3, 0xF0, 0xC7, 0xF8, 0xDC, 0x0C, 0xD0, 0x06, 0xF0,
  0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xC0, 0xE0, 0xC0, 0x0C, 0x60, 0x03, 0x98, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x02, 0x60, 0x01, 0x98, 0x00, 0xE3, 0x00, 0x30, 0x70,
  0x38, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x83, 0xF0, 0x47, 0xFE, 0x36, 0x03,
  0x9E, 0x00, 0xCE, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x2C, 0x00, 0x36, 0x00, 0x1B, 0x80, 0x19, 0xF0, 0x18, 0xCF, 0xF8, 0x63,
  0xF8, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xE1, 0x8F, 0xFC, 0xCE, 0x03, 0x6E, 0x00, 0xF6, 0x00, 0x3B, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1C, 0xC0, 0x1E,
  0x70, 0x1B, 0x1F, 0xF9, 0x83, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0xC3, 0xF3, 0xFD, 0x83, 0xC0, 0xE0, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x70, 0x1C, 0x60, 0x0E, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x70,
  0x1C, 0x3F, 0xF8, 0x0F, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x07, 0xFF, 0xFF, 0xE1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x3F, 0x01, 0xE0, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x60,
  0x0F, 0x70, 0x1B, 0x3F, 0xF3, 0x0F, 0xC3, 0xC0, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0x43, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x40,
  0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x40, 0x20, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x08, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x02, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x00, 0x88, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x68, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0x40, 0x06, 0x00, 0x26, 0x00, 0xF0, 0x06, 0x60,
  0x0F, 0x00, 0x66, 0x00, 0x90, 0x06, 0x20, 0x19, 0x80, 0x63, 0x01, 0x98,
  0x0C, 0x30, 0x19, 0x80, 0xC3, 0x01, 0x08, 0x0C, 0x30, 0x30, 0xC0, 0xC1,
  0x83, 0x0C, 0x18, 0x18, 0x30, 0xC1, 0x81, 0x82, 0x04, 0x18, 0x18, 0x60,
  0x61, 0x80, 0xC6, 0x06, 0x30, 0x0C, 0x40, 0x63, 0x00, 0xCC, 0x02, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0x6C, 0x03, 0x20, 0x06, 0x80, 0x16, 0x00, 0x68,
  0x01, 0x60, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x38, 0x60,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x03, 0x18,
  0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x60, 0xC0, 0x30,
  0x38, 0x0C, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x06, 0x70, 0x01,
  0x98, 0x00, 0x30, 0xC0, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x43, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x40, 0xC0, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x30, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x00, 0x88, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x28, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x0F,
  0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0F,
  0x00, 0xF0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x08, 0x00,
  0x1F, 0x00, 0x01, 0xFE, 0x00, 0x36, 0x0C, 0x00, 0xF0, 0x18, 0x02, 0xC0,
  0x30, 0x1A, 0x00, 0x70, 0xE8, 0x00, 0xFF, 0x00, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLight49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 35, 10, 4, -35 },
  { 10, 8, 10, 13, 3, -37 },
  { 20, 22, 35, 24, 2, -35 },
  { 117, 18, 44, 24, 3, -40 },
  { 216, 26, 35, 32, 3, -35 },
  { 330, 22, 36, 26, 3, -35 },
  { 429, 2, 10, 8, 3, -37 },
  { 432, 10, 50, 14, 3, -39 },
  { 495, 9, 50, 14, 1, -39 },
  { 552, 19, 19, 21, 1, -35 },
  { 598, 20, 26, 24, 2, -29 },
  { 663, 4, 10, 9, 2, -4 },
  { 668, 9, 2, 13, 2, -17 },
  { 671, 3, 3, 11, 4, -3 },
  { 673, 14, 38, 17, 1, -35 },
  { 740, 18, 35, 24, 3, -35 },
  { 819, 10, 35, 24, 4, -35 },
  { 863, 18, 35, 24, 3, -35 },
  { 942, 19, 35, 24, 2, -35 },
  { 1026, 21, 35, 24, 2, -35 },
  { 1118, 17, 35, 24, 4, -35 },
  { 1193, 18, 35, 24, 3, -35 },
  { 1272, 19, 35, 24, 2, -35 },
  { 1356, 18, 35, 24, 3, -35 },
  { 1435, 18, 35, 24, 3, -35 },
  { 1514, 3, 26, 9, 3, -26 },
  { 1524, 4, 32, 9, 2, -26 },
  { 1540, 17, 20, 22, 2, -26 },
  { 1583, 17, 12, 24, 3, -22 },
  { 1609, 17, 20, 22, 3, -26 },
  { 1652, 15, 35, 19, 2, -35 },
  { 1718, 33, 45, 39, 3, -34 },
  { 1904, 24, 35, 26, 1, -35 },
  { 2009, 19, 35, 26, 4, -35 },
  { 2093, 22, 35, 28, 3, -35 },
  { 2190, 21, 35, 28, 4, -35 },
  { 2282, 18, 35, 25, 4, -35 },
  { 2361, 19, 35, 24, 4, -35 },
  { 2445, 21, 35, 29, 4, -35 },
  { 2537, 22, 35, 30, 4, -35 },
  { 2634, 2, 35, 12, 5, -35 },
  { 2643, 17, 35, 24, 2, -35 },
  { 2718, 22, 35, 27, 4, -35 },
  { 2815, 17, 35, 23, 4, -35 },
  { 2890, 28, 35, 37, 4, -35 },
  { 3013, 22, 35, 30, 4, -35 },
  { 3110, 22, 35, 29, 3, -35 },
  { 3207, 20, 35, 26, 4, -35 },
  { 3295, 22, 41, 29, 3, -35 },
  { 3408, 21, 35, 28, 4, -35 },
  { 3500, 21, 35, 25, 2, -35 },
  { 3592, 22, 35, 26, 2, -35 },
  { 3689, 20, 35, 28, 4, -35 },
  { 3777, 24, 35, 26, 1, -35 },
  { 3882, 35, 35, 38, 2, -35 },
  { 4036, 22, 35, 26, 2, -35 },
  { 4133, 24, 35, 26, 1, -35 },
  { 4238, 21, 35, 26, 2, -35 },
  { 4330, 6, 47, 10, 4, -40 },
  { 4366, 14, 38, 17, 2, -35 },
  { 4433, 7, 47, 10, 0, -40 },
  { 4475, 14, 17, 18, 2, -35 },
  { 4505, 18, 2, 18, 0, 0 },
  { 4510, 7, 6, 13, 3, -36 },
  { 4516, 18, 26, 23, 2, -26 },
  { 4575, 17, 37, 24, 4, -37 },
  { 4654, 18, 26, 22, 2, -26 },
  { 4713, 17, 37, 24, 3, -37 },
  { 4792, 18, 26, 22, 2, -26 },
  { 4851, 12, 38, 14, 2, -38 },
  { 4908, 17, 36, 24, 3, -26 },
  { 4985, 16, 37, 24, 4, -37 },
  { 5059, 2, 35, 10, 4, -35 },
  { 5068, 8, 45, 10, -2, -35 },
  { 5113, 16, 37, 21, 4, -37 },
  { 5187, 2, 37, 10, 4, -37 },
  { 5197, 30, 26, 38, 4, -26 },
  { 5295, 16, 26, 24, 4, -26 },
  { 5347, 18, 26, 24, 3, -26 },
  { 5406, 17, 36, 24, 4, -26 },
  { 5483, 17, 36, 24, 3, -26 },
  { 5560, 10, 26, 15, 4, -26 },
  { 5593, 16, 26, 22, 3, -26 },
  { 5645, 11, 33, 14, 1, -33 },
  { 5691, 16, 26, 24, 4, -26 },
  { 5743, 19, 26, 21, 1, -26 },
  { 5805, 28, 26, 32, 2, -26 },
  { 5896, 18, 26, 21, 1, -26 },
  { 5955, 19, 36, 21, 1, -26 },
  { 6041, 17, 26, 21, 2, -26 },
  { 6097, 12, 48, 14, 2, -38 },
  { 6169, 2, 41, 10, 4, -35 },
  { 6180, 12, 48, 14, 1, -38 },
  { 6252, 22, 8, 29, 4, -18 },
};

const GFXfont RobotoCondensed_ExtraLight49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT49PT7B_H_
