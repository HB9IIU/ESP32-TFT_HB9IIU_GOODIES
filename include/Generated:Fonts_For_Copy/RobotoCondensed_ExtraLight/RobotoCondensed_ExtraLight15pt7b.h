#ifndef _ROBOTOCONDENSED_EXTRALIGHT15PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xF8, 0x20, 0xA2, 0xBF, 0x49, 0x24, 0xBF, 0x51, 0x41,
  0x00, 0x23, 0xA3, 0x18, 0x20, 0xC1, 0x0C, 0x62, 0xE2, 0x00, 0xE0, 0xA0,
  0x94, 0xA8, 0xE8, 0x10, 0x16, 0x29, 0x29, 0x49, 0x06, 0x70, 0x92, 0x22,
  0x86, 0x0C, 0x25, 0x4A, 0x8D, 0x19, 0xD0, 0xE0, 0x29, 0x49, 0x24, 0x92,
  0x44, 0x88, 0x89, 0x12, 0x49, 0x24, 0x94, 0xA0, 0x10, 0x4F, 0xC4, 0x29,
  0x20, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0xE0, 0xE0, 0x80, 0x08,
  0x84, 0x22, 0x10, 0x84, 0x42, 0x11, 0x00, 0x74, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x5C, 0x3C, 0x92, 0x49, 0x24, 0x80, 0x72, 0x28, 0x82, 0x08, 0x41,
  0x08, 0x41, 0x0F, 0xC0, 0x74, 0x62, 0x10, 0x98, 0x21, 0x8C, 0x5C, 0x10,
  0x42, 0x8A, 0x49, 0x28, 0xBF, 0x08, 0x20, 0x80, 0x79, 0x04, 0x20, 0x70,
  0x20, 0x41, 0x86, 0x27, 0x00, 0x32, 0x21, 0x0F, 0x46, 0x31, 0x8C, 0x5C,
  0xF8, 0x42, 0x11, 0x08, 0x84, 0x22, 0x10, 0x72, 0x28, 0xA2, 0x89, 0xC8,
  0xA1, 0x86, 0x27, 0x00, 0x74, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0x5C, 0x81,
  0x81, 0xC0, 0x19, 0x31, 0x82, 0x0C, 0xF8, 0x01, 0xF0, 0x83, 0x06, 0x36,
  0x40, 0x69, 0x91, 0x12, 0x24, 0x00, 0x40, 0x1F, 0x08, 0x24, 0x06, 0x39,
  0x92, 0x64, 0x9A, 0x26, 0x89, 0x92, 0x67, 0x68, 0x01, 0x00, 0x3E, 0x00,
  0x10, 0x18, 0x18, 0x24, 0x24, 0x24, 0x22, 0x7E, 0x42, 0x42, 0x81, 0xFA,
  0x18, 0x61, 0x87, 0xE8, 0x61, 0x86, 0x1F, 0x80, 0x79, 0x0A, 0x0C, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x88, 0xE0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x0B, 0xE0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F,
  0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x08, 0x00, 0x3C, 0x86,
  0x0C, 0x08, 0x11, 0xE0, 0xC1, 0x82, 0x84, 0xF0, 0x83, 0x06, 0x0C, 0x18,
  0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0xFF, 0xE0, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x8C, 0x5C, 0x85, 0x12, 0x24, 0x8A, 0x1C, 0x24, 0x44, 0x89, 0x0A,
  0x08, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E, 0x80, 0xE0, 0x70, 0x74,
  0x3A, 0x2D, 0x16, 0x4B, 0x29, 0x94, 0xC4, 0x62, 0x20, 0x83, 0x87, 0x0D,
  0x19, 0x32, 0x62, 0xC5, 0x87, 0x06, 0x08, 0x79, 0x0A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x09, 0xE0, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82,
  0x08, 0x00, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0,
  0x20, 0x20, 0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x22, 0x44, 0x85, 0x0A, 0x08,
  0x7A, 0x18, 0x60, 0x40, 0xC0, 0xC1, 0x86, 0x17, 0x80, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x17, 0x80, 0x81, 0x42, 0x42, 0x42, 0x44, 0x24, 0x24, 0x24,
  0x18, 0x18, 0x00, 0x88, 0x63, 0x18, 0xC6, 0x31, 0x94, 0xA4, 0xA5, 0x29,
  0x4A, 0x62, 0x88, 0x42, 0x10, 0x42, 0x84, 0x91, 0x21, 0x82, 0x06, 0x12,
  0x24, 0x85, 0x08, 0x82, 0x42, 0x44, 0x24, 0x24, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFC, 0x10, 0x84, 0x10, 0x82, 0x10, 0x42, 0x0F, 0xC0, 0xEA,
  0xAA, 0xAA, 0xB0, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0xD5,
  0x55, 0x55, 0x70, 0x46, 0xAA, 0x90, 0xFC, 0x90, 0x74, 0x42, 0xF8, 0xC6,
  0x3F, 0x84, 0x21, 0x0F, 0x46, 0x31, 0x8C, 0x63, 0xE0, 0x74, 0x63, 0x08,
  0x46, 0x2E, 0x08, 0x42, 0x17, 0xC6, 0x31, 0x8C, 0x62, 0xF0, 0x74, 0x63,
  0xF8, 0x42, 0x0E, 0x6A, 0x4F, 0x24, 0x92, 0x40, 0x7C, 0x63, 0x18, 0xC6,
  0x2F, 0x08, 0x5C, 0x84, 0x21, 0x0F, 0x46, 0x31, 0x8C, 0x63, 0x10, 0x9F,
  0xE0, 0x20, 0x12, 0x49, 0x24, 0x93, 0x80, 0x84, 0x21, 0x08, 0xCA, 0x98,
  0xA4, 0xA5, 0x10, 0xFF, 0xF0, 0xF3, 0xA3, 0x18, 0x86, 0x21, 0x88, 0x62,
  0x18, 0x86, 0x21, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x74, 0x63, 0x18, 0xC6,
  0x2E, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20, 0x7C, 0x63, 0x18, 0xC6,
  0x2F, 0x08, 0x42, 0xF2, 0x49, 0x24, 0x74, 0x60, 0xC1, 0x06, 0x2E, 0x44,
  0xF4, 0x44, 0x44, 0x43, 0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x85, 0x14, 0x92,
  0x28, 0xC3, 0x04, 0x81, 0x99, 0x99, 0xA9, 0xA6, 0x66, 0x46, 0x40, 0x45,
  0x22, 0x84, 0x10, 0xA4, 0x91, 0x85, 0x14, 0x92, 0x28, 0xC1, 0x04, 0x10,
  0x84, 0x00, 0xF8, 0x84, 0x44, 0x22, 0x1F, 0x29, 0x24, 0x94, 0x89, 0x24,
  0x88, 0xFF, 0xF8, 0x84, 0x42, 0x22, 0x21, 0x22, 0x22, 0x24, 0x80, 0x63,
  0x26, 0x30,
};

const GFXglyph RobotoCondensed_ExtraLight15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 2, 3, 4, 1, -11 },
  { 4, 6, 11, 7, 1, -11 },
  { 13, 5, 13, 7, 1, -12 },
  { 22, 8, 11, 10, 1, -11 },
  { 33, 7, 11, 8, 1, -11 },
  { 43, 1, 3, 3, 1, -11 },
  { 44, 3, 15, 4, 1, -12 },
  { 50, 3, 15, 4, 0, -12 },
  { 56, 6, 6, 6, 0, -11 },
  { 61, 6, 9, 7, 1, -10 },
  { 68, 1, 3, 3, 1, -1 },
  { 69, 3, 1, 4, 0, -6 },
  { 70, 1, 1, 3, 1, -1 },
  { 71, 5, 12, 5, 0, -11 },
  { 79, 5, 11, 7, 1, -11 },
  { 86, 3, 11, 7, 1, -11 },
  { 91, 6, 11, 7, 1, -11 },
  { 100, 5, 11, 7, 1, -11 },
  { 107, 6, 11, 7, 1, -11 },
  { 116, 6, 11, 7, 1, -11 },
  { 125, 5, 11, 7, 1, -11 },
  { 132, 5, 11, 7, 1, -11 },
  { 139, 6, 11, 7, 1, -11 },
  { 148, 5, 11, 7, 1, -11 },
  { 155, 1, 8, 3, 1, -8 },
  { 156, 1, 10, 3, 1, -8 },
  { 158, 5, 6, 7, 1, -8 },
  { 162, 5, 4, 7, 1, -7 },
  { 165, 5, 6, 7, 1, -8 },
  { 169, 4, 11, 6, 1, -11 },
  { 175, 10, 13, 12, 1, -10 },
  { 192, 8, 11, 8, 0, -11 },
  { 203, 6, 11, 8, 1, -11 },
  { 212, 7, 11, 9, 1, -11 },
  { 222, 7, 11, 9, 1, -11 },
  { 232, 6, 11, 8, 1, -11 },
  { 241, 6, 11, 7, 1, -11 },
  { 250, 7, 11, 9, 1, -11 },
  { 260, 7, 11, 9, 1, -11 },
  { 270, 1, 11, 4, 1, -11 },
  { 272, 5, 11, 7, 1, -11 },
  { 279, 7, 11, 8, 1, -11 },
  { 289, 5, 11, 7, 1, -11 },
  { 296, 9, 11, 11, 1, -11 },
  { 309, 7, 11, 9, 1, -11 },
  { 319, 7, 11, 9, 1, -11 },
  { 329, 6, 11, 8, 1, -11 },
  { 338, 7, 13, 9, 1, -11 },
  { 350, 7, 11, 8, 1, -11 },
  { 360, 6, 11, 8, 1, -11 },
  { 369, 7, 11, 8, 0, -11 },
  { 379, 6, 11, 9, 1, -11 },
  { 388, 8, 11, 8, 0, -11 },
  { 399, 10, 11, 12, 1, -11 },
  { 413, 7, 11, 8, 0, -11 },
  { 423, 8, 11, 8, 0, -11 },
  { 434, 6, 11, 8, 1, -11 },
  { 443, 2, 14, 3, 1, -12 },
  { 447, 5, 12, 5, 0, -11 },
  { 455, 2, 14, 3, 0, -12 },
  { 459, 4, 5, 6, 1, -11 },
  { 462, 6, 1, 6, 0, 0 },
  { 463, 2, 2, 4, 1, -11 },
  { 464, 5, 8, 7, 1, -8 },
  { 469, 5, 12, 7, 1, -12 },
  { 477, 5, 8, 7, 1, -8 },
  { 482, 5, 12, 7, 1, -12 },
  { 490, 5, 8, 7, 1, -8 },
  { 495, 3, 12, 4, 1, -12 },
  { 500, 5, 11, 7, 1, -8 },
  { 507, 5, 12, 7, 1, -12 },
  { 515, 1, 11, 3, 1, -11 },
  { 517, 3, 14, 3, -1, -11 },
  { 523, 5, 12, 6, 1, -12 },
  { 531, 1, 12, 3, 1, -12 },
  { 533, 10, 8, 12, 1, -8 },
  { 543, 5, 8, 7, 1, -8 },
  { 548, 5, 8, 7, 1, -8 },
  { 553, 5, 11, 7, 1, -8 },
  { 560, 5, 11, 7, 1, -8 },
  { 567, 3, 8, 5, 1, -8 },
  { 570, 5, 8, 7, 1, -8 },
  { 575, 4, 10, 4, 0, -10 },
  { 580, 5, 8, 7, 1, -8 },
  { 585, 6, 8, 6, 0, -8 },
  { 591, 8, 8, 10, 1, -8 },
  { 599, 6, 8, 6, 0, -8 },
  { 605, 6, 11, 6, 0, -8 },
  { 614, 5, 8, 6, 1, -8 },
  { 619, 3, 15, 4, 1, -12 },
  { 625, 1, 13, 3, 1, -11 },
  { 627, 4, 15, 4, 0, -12 },
  { 635, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_ExtraLight15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT15PT7B_H_
