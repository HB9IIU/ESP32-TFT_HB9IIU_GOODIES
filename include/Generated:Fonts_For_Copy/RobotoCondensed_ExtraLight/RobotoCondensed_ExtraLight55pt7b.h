#ifndef _ROBOTOCONDENSED_EXTRALIGHT55PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLight.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLight55pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60,
  0x00, 0x00, 0x05, 0xFA, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x02, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x10, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x0C, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x06, 0x01, 0x80,
  0x03, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x30, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x08, 0x06, 0x00, 0x04, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x20, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8,
  0x00, 0xFB, 0xF0, 0x0E, 0x01, 0xC0, 0xC0, 0x06, 0x0E, 0x00, 0x18, 0x60,
  0x00, 0xC3, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x70, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1F,
  0xBF, 0x00, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x60, 0x30, 0x06,
  0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x81,
  0x80, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x30, 0x03, 0x00, 0xC0, 0x80,
  0x06, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x10, 0x00, 0x38, 0xE0, 0xC0, 0x00,
  0x7F, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x03, 0xF0, 0x00, 0x0C, 0x1C, 0x70, 0x00, 0x60, 0xC0, 0xC0, 0x01, 0x83,
  0x01, 0x80, 0x0C, 0x18, 0x06, 0x00, 0x30, 0x60, 0x08, 0x01, 0x81, 0x80,
  0x30, 0x04, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x60, 0x0C,
  0x06, 0x01, 0x80, 0x30, 0x30, 0x06, 0x00, 0x80, 0xC0, 0x18, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x60,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x70, 0x70, 0x06, 0x30, 0x1C, 0x03,
  0x30, 0x06, 0x01, 0x98, 0x01, 0x81, 0x9C, 0x00, 0xE0, 0xCC, 0x00, 0x38,
  0x66, 0x00, 0x0C, 0x33, 0x00, 0x03, 0x31, 0x80, 0x01, 0xD8, 0xC0, 0x00,
  0x7C, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x83, 0x00,
  0x0E, 0xC1, 0xE0, 0x1E, 0x30, 0x3E, 0x7C, 0x0C, 0x0F, 0xFC, 0x07, 0x00,
  0x40, 0x00, 0x00, 0x6D, 0xB6, 0xDA, 0x5B, 0x00, 0x00, 0x40, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x40, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x06, 0x03,
  0xF0, 0x30, 0x7B, 0xF1, 0x9F, 0x83, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0x70, 0x00, 0x31, 0xC0, 0x03, 0x86, 0x00,
  0x38, 0x18, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0C, 0x04, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x18, 0xC6,
  0x33, 0x9C, 0xC6, 0x33, 0x38, 0x80, 0xFF, 0xFF, 0xFC, 0xEF, 0xE0, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xC0, 0x07, 0xDF, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xC1,
  0x80, 0x0C, 0x30, 0x00, 0xE3, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x07,
  0x60, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0xE1, 0x80, 0x0C, 0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0xDF,
  0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x9F, 0x3F,
  0x87, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0xC0, 0x38, 0x07, 0x03, 0x80,
  0x1C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x66,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x20, 0x00,
  0x3F, 0xE0, 0x0F, 0xDF, 0x01, 0xC0, 0x38, 0x38, 0x00, 0xC3, 0x00, 0x0E,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00,
  0x77, 0x00, 0x06, 0x38, 0x00, 0xE1, 0xC0, 0x1C, 0x0F, 0xDF, 0x80, 0x3F,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x60, 0x03, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x31, 0xF8, 0x03, 0x7F,
  0xE0, 0x3E, 0x07, 0x83, 0x80, 0x38, 0x30, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x67, 0x00, 0x06, 0x30, 0x00,
  0xC3, 0x80, 0x0C, 0x1C, 0x03, 0x80, 0xFD, 0xF0, 0x03, 0xFE, 0x00, 0x02,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x83, 0xF0, 0x0C, 0x7F, 0xE0, 0x67, 0x03, 0x83, 0x60, 0x0E,
  0x1E, 0x00, 0x39, 0xE0, 0x00, 0xCE, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80,
  0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x18, 0x38, 0x01, 0x80,
  0xE0, 0x1C, 0x03, 0xE7, 0xC0, 0x07, 0xF8, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x03, 0xF7, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x1C, 0x18,
  0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80,
  0x01, 0x86, 0x00, 0x0C, 0x38, 0x00, 0xC0, 0xE0, 0x0E, 0x03, 0x81, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0x03, 0xC0, 0x60, 0x07, 0x06, 0x00,
  0x1C, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xE0, 0x00, 0xE3, 0x80, 0x0E, 0x0E,
  0x00, 0xE0, 0x3F, 0x7E, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00,
  0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x07,
  0x60, 0x00, 0x77, 0x00, 0x0F, 0x30, 0x01, 0xB1, 0x80, 0x3B, 0x1E, 0x07,
  0x30, 0x7F, 0xC3, 0x03, 0xF0, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x00,
  0xF8, 0x00, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF7, 0x00, 0x3B, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x39, 0xCE, 0x73, 0x98,
  0xCE, 0x67, 0x10, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x78,
  0x38, 0x1C, 0x60, 0x0E, 0xE0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x06, 0x00, 0x0F, 0x80,
  0x0C, 0x18, 0x00, 0xFF, 0x80, 0x10, 0xE0, 0x07, 0x07, 0x00, 0x63, 0x00,
  0x38, 0x0C, 0x01, 0x8C, 0x00, 0xC0, 0x30, 0x06, 0x20, 0x06, 0x00, 0xC0,
  0x19, 0x80, 0x30, 0x03, 0x00, 0x26, 0x00, 0xC0, 0x0C, 0x00, 0x98, 0x03,
  0x00, 0x30, 0x02, 0x60, 0x18, 0x00, 0xC0, 0x09, 0x00, 0x60, 0x03, 0x00,
  0x2C, 0x01, 0x80, 0x0C, 0x00, 0xB0, 0x06, 0x00, 0x30, 0x02, 0xC0, 0x18,
  0x00, 0xC0, 0x0B, 0x00, 0x40, 0x02, 0x00, 0x2C, 0x03, 0x00, 0x08, 0x00,
  0xB0, 0x0C, 0x00, 0x60, 0x06, 0xC0, 0x30, 0x01, 0x80, 0x1B, 0x00, 0xC0,
  0x06, 0x00, 0x6C, 0x03, 0x00, 0x18, 0x01, 0x90, 0x04, 0x00, 0x60, 0x0C,
  0x60, 0x18, 0x03, 0x80, 0x31, 0x80, 0x60, 0x0A, 0x00, 0x86, 0x01, 0x80,
  0x6C, 0x06, 0x18, 0x03, 0x03, 0x30, 0x30, 0x30, 0x0F, 0x78, 0x73, 0x80,
  0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0x00, 0x08, 0x00, 0x80, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x18, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x30, 0x01, 0xE1, 0x80, 0x03,
  0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x01, 0xC6, 0x00,
  0x3C, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0C, 0x00, 0x3C, 0x60, 0x00, 0x73,
  0x00, 0x01, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x01,
  0xCC, 0x00, 0x3C, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x0E, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x78, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x30, 0x00, 0x07, 0x70, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x3E, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x76, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80,
  0x1C, 0x1C, 0x03, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC3,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x80, 0x00, 0xCD, 0xC0, 0x00, 0xDC,
  0xE0, 0x00, 0xF8, 0x60, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFB, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x0D, 0xEC, 0x00, 0x00, 0x1B,
  0xCC, 0x00, 0x00, 0x67, 0x98, 0x00, 0x00, 0xCF, 0x30, 0x00, 0x01, 0x9E,
  0x30, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x0C, 0x78, 0xE0, 0x00, 0x38, 0xF0,
  0xC0, 0x00, 0x61, 0xE1, 0x80, 0x00, 0xC3, 0xC1, 0x80, 0x03, 0x07, 0x83,
  0x00, 0x06, 0x0F, 0x06, 0x00, 0x0C, 0x1E, 0x06, 0x00, 0x30, 0x3C, 0x0C,
  0x00, 0x60, 0x78, 0x18, 0x00, 0xC0, 0xF0, 0x18, 0x03, 0x01, 0xE0, 0x30,
  0x06, 0x03, 0xC0, 0x60, 0x0C, 0x07, 0x80, 0x60, 0x30, 0x0F, 0x00, 0xC0,
  0x60, 0x1E, 0x00, 0xC1, 0xC0, 0x3C, 0x01, 0x83, 0x00, 0x78, 0x03, 0x06,
  0x00, 0xF0, 0x03, 0x18, 0x01, 0xE0, 0x06, 0x30, 0x03, 0xC0, 0x0C, 0x60,
  0x07, 0x80, 0x0D, 0x80, 0x0F, 0x00, 0x1B, 0x00, 0x1E, 0x00, 0x36, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x60, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCC, 0x00,
  0x03, 0xC6, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC3, 0x80,
  0x03, 0xC1, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x60,
  0x03, 0xC0, 0x60, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x06,
  0x03, 0xC0, 0x03, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0x83, 0xC0, 0x01,
  0xC3, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x63, 0xC0, 0x00,
  0x33, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x87,
  0x00, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x78, 0x03, 0x80, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x0C, 0x00, 0x3C, 0x30, 0x00, 0x38, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x30,
  0x00, 0x38, 0xC0, 0x03, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x70,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x03, 0x81,
  0xC0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0xE3, 0x00, 0x03, 0x86, 0x00, 0x1E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x38, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x71, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xBF, 0x80,
  0xF0, 0x07, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x80, 0x00, 0xE3, 0x80,
  0x03, 0x83, 0xC0, 0x0E, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x0E, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xE0,
  0x07, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x1C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x3B, 0x00, 0x01, 0x40, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00,
  0x0D, 0x80, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x03, 0x18, 0x00, 0x32, 0x00,
  0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x30, 0xC0,
  0x03, 0x18, 0x00, 0x61, 0xC0, 0x06, 0x10, 0x01, 0xC1, 0x80, 0x18, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0x80, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xE0, 0x60, 0x0C, 0x0E, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x03, 0x03, 0x00, 0x20, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x73, 0x00, 0x06, 0x30,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0xB0,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x1C,
  0x1C, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x70, 0x1C,
  0x00, 0x30, 0x06, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x70, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F,
  0xFF, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x70,
  0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7E,
  0xFC, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x37, 0x00,
  0x06, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3C, 0x00, 0xCE, 0x00,
  0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x80, 0x0F, 0xB8, 0x07,
  0x33, 0xFF, 0xC6, 0x3F, 0xE0, 0xC0, 0x40, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC3, 0xFE, 0x0C, 0xF9, 0xF0, 0xDC, 0x03, 0x8D, 0x80, 0x1C,
  0xF0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6E,
  0x00, 0x0C, 0xE0, 0x00, 0xCF, 0x00, 0x1C, 0xDC, 0x03, 0x8C, 0xFF, 0xF0,
  0xC3, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3E, 0x7C,
  0x0E, 0x01, 0xC3, 0x00, 0x1C, 0xE0, 0x01, 0x98, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0x60, 0x00, 0x6E, 0x00, 0x18, 0xC0, 0x07, 0x0E, 0x01, 0xC0,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x7F, 0xC6, 0x1F, 0x7C, 0xC7, 0x00, 0xD9, 0xC0, 0x0F, 0x30, 0x00, 0xEC,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x33, 0x00, 0x0E, 0x70,
  0x03, 0xC7, 0x00, 0xD8, 0x7D, 0xF1, 0x07, 0xFC, 0x20, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x3E, 0xFC, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0xE0,
  0x01, 0x98, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0x0E, 0x00, 0xE0, 0xFD, 0xF8, 0x07, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x3E, 0xC1, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03,
  0xFF, 0xCF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x8C, 0x3E, 0xF9, 0x8E, 0x01,
  0xB3, 0x80, 0x1E, 0x60, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x66, 0x00, 0x1C, 0xE0, 0x07, 0x8E, 0x01, 0xB0, 0xFB, 0xE6,
  0x0F, 0xF8, 0xC0, 0x10, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x33, 0x00, 0x0C, 0x70, 0x03, 0x87, 0x81, 0xE0,
  0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC1, 0xFE, 0x31, 0xF7,
  0xCC, 0xE0, 0x3B, 0x60, 0x06, 0xD8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x1C, 0xFC,
  0x7C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x19, 0x80, 0x07, 0x30,
  0x01, 0xC6, 0x00, 0x70, 0xC0, 0x1C, 0x18, 0x07, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x38, 0x00, 0xCE,
  0x00, 0x1B, 0xE0, 0x03, 0x6E, 0x00, 0x78, 0xC0, 0x0E, 0x0C, 0x01, 0x81,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x38, 0x18, 0x03, 0x03, 0x00,
  0x30, 0x60, 0x07, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xE6, 0x00,
  0x0E, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x18, 0x7F, 0xC0, 0x7F, 0xC3,
  0x1E, 0xFC, 0x1F, 0x7C, 0x66, 0x01, 0xC6, 0x01, 0xCD, 0x80, 0x19, 0x80,
  0x19, 0xA0, 0x03, 0xE0, 0x03, 0xBC, 0x00, 0x3C, 0x00, 0x37, 0x00, 0x07,
  0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x18, 0x00, 0x1B, 0x00,
  0x03, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x0F,
  0x80, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x06, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x0F, 0x80,
  0x01, 0x80, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x07,
  0xC0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x1F, 0x00, 0x03, 0x00,
  0x03, 0xE0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x7F, 0x8C, 0x7D, 0xF3, 0x38, 0x0E,
  0xD8, 0x01, 0xB6, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x03, 0xF7, 0xC0, 0x38, 0x07, 0x83, 0x80, 0x0C,
  0x18, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x37, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x70, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x70, 0x00, 0x61, 0x80, 0x07, 0x0E, 0x00, 0x30, 0x38, 0x07,
  0x00, 0xFD, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x3F, 0xE0, 0xCF, 0xBF, 0x0D, 0xC0, 0x38, 0xD0, 0x01, 0xCF, 0x00, 0x0C,
  0xE0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0, 0x00, 0xCE,
  0x00, 0x0C, 0xF0, 0x01, 0xCD, 0xC0, 0x38, 0xCF, 0xFF, 0x0C, 0x3F, 0xE0,
  0xC0, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x84, 0x3E, 0xF9, 0x8E,
  0x01, 0xB3, 0x80, 0x1E, 0x60, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x66, 0x00, 0x1C, 0xE0, 0x07, 0x8E, 0x01, 0xF0, 0xFB,
  0xF6, 0x0F, 0xF8, 0xC0, 0x10, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x7F, 0x1F, 0xE6, 0x0D,
  0x81, 0xA0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98,
  0x00, 0x66, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x76, 0x00,
  0x18, 0xE0, 0x0E, 0x1F, 0x3F, 0x03, 0xFF, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF,
  0xF7, 0xFF, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xB0, 0x1F, 0x80, 0x20,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0D, 0x80, 0x07, 0x60, 0x01, 0xDC, 0x00, 0xF3, 0x80,
  0x6C, 0x7D, 0xF3, 0x0F, 0xF8, 0xC0, 0x20, 0x00, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00,
  0x70, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00,
  0xC0, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x60, 0x01, 0x80, 0x06, 0x60, 0x03, 0xC0,
  0x06, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x30, 0x02, 0xC0,
  0x0C, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x60,
  0x0C, 0x38, 0x0C, 0x60, 0x18, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x0C, 0x30,
  0x18, 0x18, 0x0C, 0x30, 0x18, 0x1C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18,
  0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0E, 0x30, 0x0C,
  0x60, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x20, 0x0C,
  0x60, 0x07, 0x60, 0x06, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0x60, 0x06,
  0xC0, 0x03, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x66,
  0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80, 0x18, 0x18, 0x03, 0x81, 0xC0, 0x30,
  0x0C, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x98,
  0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x70, 0xC0, 0x06,
  0x0E, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x38, 0x01, 0x83,
  0x00, 0x1C, 0x70, 0x00, 0xC6, 0x00, 0x0E, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x07, 0x18,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x70, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x1B,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0xDC, 0x1C, 0x00, 0x6C, 0x07, 0x00, 0x3C,
  0x01, 0xC0, 0x36, 0x00, 0x70, 0x1B, 0x00, 0x1C, 0x19, 0x80, 0x07, 0xF8,
  0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLight55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 40, 11, 4, -39 },
  { 16, 8, 12, 15, 4, -41 },
  { 28, 25, 39, 27, 2, -39 },
  { 150, 21, 51, 27, 3, -45 },
  { 284, 30, 41, 36, 3, -40 },
  { 438, 25, 41, 30, 3, -40 },
  { 567, 3, 11, 9, 3, -41 },
  { 572, 10, 57, 15, 4, -44 },
  { 644, 11, 57, 16, 1, -44 },
  { 723, 21, 22, 23, 1, -39 },
  { 781, 23, 28, 27, 2, -32 },
  { 862, 5, 12, 10, 2, -5 },
  { 870, 11, 2, 15, 2, -19 },
  { 873, 4, 4, 12, 4, -3 },
  { 875, 16, 42, 19, 1, -39 },
  { 959, 20, 41, 27, 3, -40 },
  { 1062, 11, 39, 27, 5, -39 },
  { 1116, 21, 40, 27, 3, -40 },
  { 1221, 20, 41, 27, 3, -40 },
  { 1324, 23, 39, 27, 2, -39 },
  { 1437, 20, 40, 27, 4, -39 },
  { 1537, 21, 40, 27, 3, -39 },
  { 1642, 22, 39, 27, 2, -39 },
  { 1750, 21, 41, 27, 3, -40 },
  { 1858, 20, 40, 27, 3, -40 },
  { 1958, 4, 29, 10, 3, -28 },
  { 1973, 5, 35, 10, 2, -28 },
  { 1995, 19, 22, 25, 2, -29 },
  { 2048, 19, 12, 27, 4, -24 },
  { 2077, 19, 22, 25, 3, -29 },
  { 2130, 16, 41, 22, 3, -40 },
  { 2212, 38, 50, 44, 3, -38 },
  { 2450, 27, 39, 29, 1, -39 },
  { 2582, 21, 39, 29, 5, -39 },
  { 2685, 24, 41, 31, 4, -40 },
  { 2808, 23, 39, 31, 5, -39 },
  { 2921, 20, 39, 28, 5, -39 },
  { 3019, 20, 39, 27, 5, -39 },
  { 3117, 24, 41, 33, 4, -40 },
  { 3240, 24, 39, 34, 5, -39 },
  { 3357, 2, 39, 13, 6, -39 },
  { 3367, 20, 40, 27, 2, -39 },
  { 3467, 24, 39, 30, 5, -39 },
  { 3584, 19, 39, 25, 5, -39 },
  { 3677, 31, 39, 41, 5, -39 },
  { 3829, 24, 39, 34, 5, -39 },
  { 3946, 25, 41, 32, 4, -40 },
  { 4075, 22, 39, 29, 5, -39 },
  { 4183, 25, 47, 32, 4, -40 },
  { 4330, 23, 39, 31, 5, -39 },
  { 4443, 23, 41, 29, 3, -40 },
  { 4561, 25, 39, 29, 2, -39 },
  { 4683, 23, 40, 32, 4, -39 },
  { 4798, 27, 39, 29, 1, -39 },
  { 4930, 39, 39, 43, 2, -39 },
  { 5121, 25, 39, 29, 2, -39 },
  { 5243, 27, 39, 29, 1, -39 },
  { 5375, 23, 39, 29, 3, -39 },
  { 5488, 7, 53, 12, 4, -45 },
  { 5535, 16, 42, 19, 2, -39 },
  { 5619, 7, 53, 12, 0, -45 },
  { 5666, 16, 20, 20, 2, -39 },
  { 5706, 19, 2, 21, 1, 0 },
  { 5711, 8, 7, 15, 3, -41 },
  { 5718, 19, 31, 26, 3, -30 },
  { 5792, 20, 42, 27, 4, -41 },
  { 5897, 19, 31, 25, 3, -30 },
  { 5971, 19, 42, 27, 3, -41 },
  { 6071, 19, 31, 25, 3, -30 },
  { 6145, 14, 42, 16, 2, -42 },
  { 6219, 19, 41, 27, 3, -30 },
  { 6317, 18, 41, 27, 4, -41 },
  { 6410, 3, 39, 11, 4, -39 },
  { 6425, 9, 50, 11, -2, -39 },
  { 6482, 19, 41, 23, 4, -41 },
  { 6580, 2, 41, 11, 5, -41 },
  { 6591, 35, 30, 42, 4, -30 },
  { 6723, 18, 30, 27, 4, -30 },
  { 6791, 21, 31, 27, 3, -30 },
  { 6873, 20, 41, 27, 4, -30 },
  { 6976, 19, 41, 27, 3, -30 },
  { 7074, 11, 30, 17, 4, -30 },
  { 7116, 18, 31, 24, 3, -30 },
  { 7186, 13, 38, 16, 1, -37 },
  { 7248, 18, 30, 27, 4, -29 },
  { 7316, 21, 29, 23, 1, -29 },
  { 7393, 32, 29, 36, 2, -29 },
  { 7509, 20, 29, 23, 2, -29 },
  { 7582, 21, 40, 23, 1, -29 },
  { 7687, 20, 29, 23, 2, -29 },
  { 7760, 14, 54, 16, 2, -43 },
  { 7855, 2, 46, 12, 5, -39 },
  { 7867, 13, 54, 16, 1, -43 },
  { 7955, 25, 9, 33, 4, -21 },
};

const GFXfont RobotoCondensed_ExtraLight55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLight55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLight55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_EXTRALIGHT55PT7B_H_
