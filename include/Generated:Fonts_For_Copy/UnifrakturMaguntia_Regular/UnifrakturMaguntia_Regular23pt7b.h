#ifndef _UNIFRAKTURMAGUNTIA_REGULAR23PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0xFE, 0xE6, 0x44, 0x44, 0x40, 0x00, 0x4E, 0x40, 0x44, 0xEF,
  0x66, 0x62, 0x44, 0x84, 0x19, 0x06, 0x41, 0x33, 0xFF, 0xFF, 0xCC, 0xC3,
  0x30, 0xCC, 0xFF, 0xBF, 0xE2, 0x20, 0x98, 0x66, 0x00, 0x10, 0x10, 0x3C,
  0x62, 0xC2, 0xC2, 0xC2, 0xF0, 0x78, 0x3E, 0x1E, 0x87, 0xC3, 0x83, 0x82,
  0x46, 0x38, 0x10, 0x10, 0x70, 0x07, 0x90, 0x13, 0x30, 0x26, 0x60, 0x8C,
  0xC2, 0x19, 0x88, 0x32, 0x20, 0x38, 0x9C, 0x02, 0x6C, 0x0C, 0xD8, 0x13,
  0xB8, 0x47, 0x31, 0x0E, 0xE4, 0x0D, 0x90, 0x1B, 0x40, 0x1C, 0x0E, 0x01,
  0xB0, 0x31, 0x03, 0x30, 0x3A, 0x01, 0xCE, 0x3C, 0x45, 0xC4, 0xCE, 0x4C,
  0xE8, 0xC7, 0x8E, 0x79, 0xE3, 0xE7, 0xDC, 0x27, 0x32, 0x24, 0x19, 0x88,
  0xC6, 0x31, 0x9C, 0xE7, 0x39, 0xC6, 0x31, 0x84, 0x20, 0x82, 0x41, 0x04,
  0x21, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x62, 0x31, 0x10, 0x10, 0x38,
  0xD7, 0x76, 0x6E, 0xD6, 0x5D, 0x30, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x08, 0x06, 0xF3, 0x22, 0x40, 0x7D, 0xE7, 0xBC, 0x06, 0xF2, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x00, 0x0E,
  0x0C, 0xC3, 0x19, 0xC7, 0x71, 0xDC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x77,
  0x1D, 0xC7, 0x71, 0xCC, 0x63, 0x10, 0x38, 0x08, 0x30, 0xE3, 0xC9, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0F, 0x3F, 0x1F, 0x0F, 0xE6,
  0x39, 0x07, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x21,
  0x30, 0x4F, 0xF7, 0xFF, 0xFF, 0x1F, 0x18, 0xE8, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x70, 0x7E, 0x01, 0xC0, 0x70, 0x0D, 0x83, 0xE0, 0xD8, 0x27, 0x18,
  0x78, 0x03, 0x01, 0xC0, 0x70, 0x3C, 0x17, 0x09, 0xC2, 0x71, 0x1C, 0x87,
  0x3F, 0xFF, 0xFC, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x7F, 0x3B, 0x8F, 0xC3,
  0xE0, 0x80, 0x20, 0x17, 0xC3, 0xF8, 0xFF, 0x61, 0xD0, 0x30, 0x0D, 0x03,
  0xE0, 0xD8, 0x27, 0x18, 0x78, 0x0F, 0x04, 0x63, 0x18, 0xC7, 0x70, 0x98,
  0x06, 0xF1, 0xC6, 0x71, 0xDC, 0x76, 0x1D, 0xC7, 0x71, 0xDC, 0x63, 0x10,
  0x78, 0x7F, 0xDF, 0xE4, 0x0A, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x1F, 0x08, 0x26,
  0x09, 0x83, 0x70, 0x9E, 0x63, 0xE0, 0x7C, 0x27, 0x90, 0x74, 0x0F, 0x03,
  0xC0, 0xD0, 0x36, 0x18, 0x7C, 0x1E, 0x0C, 0xC6, 0x19, 0x86, 0x61, 0xF8,
  0x7E, 0x1D, 0x87, 0x73, 0xCD, 0x71, 0x9C, 0x06, 0x21, 0x98, 0x67, 0x10,
  0xCC, 0x1E, 0x00, 0x46, 0xF4, 0x00, 0x00, 0x6F, 0x20, 0x46, 0xF4, 0x00,
  0x00, 0x6F, 0x32, 0x24, 0x04, 0x23, 0x1C, 0xE1, 0xC3, 0x02, 0x04, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0x83, 0x06, 0x1C, 0x63, 0x18, 0x80,
  0x3E, 0xC7, 0x83, 0xC3, 0xE3, 0x07, 0x0F, 0x3E, 0x70, 0x60, 0x62, 0x62,
  0x3C, 0x00, 0x08, 0x1C, 0x08, 0x07, 0xC0, 0x60, 0xC3, 0x01, 0x18, 0x02,
  0x63, 0xE9, 0x1B, 0x2C, 0xCC, 0xB3, 0x32, 0xD9, 0x91, 0x66, 0xC6, 0xFE,
  0xC8, 0x06, 0x18, 0x30, 0x3F, 0x00, 0x3F, 0x03, 0x23, 0xC7, 0x20, 0xF7,
  0x90, 0x39, 0xC8, 0x1C, 0xE4, 0x06, 0x73, 0x83, 0x38, 0xF3, 0x9C, 0x39,
  0x8E, 0x08, 0x87, 0x00, 0x83, 0x80, 0x81, 0xC1, 0xE0, 0xE1, 0xF8, 0xF0,
  0x1F, 0xBE, 0x07, 0x8C, 0x00, 0x00, 0x00, 0x0E, 0x06, 0x03, 0xF8, 0xF8,
  0x7F, 0xD3, 0xC6, 0x1E, 0x1C, 0xC0, 0xE1, 0xC8, 0x06, 0x0E, 0x80, 0x60,
  0x84, 0x06, 0x3C, 0x62, 0x6F, 0xE1, 0xC4, 0x1F, 0x00, 0x80, 0x70, 0x10,
  0x07, 0x07, 0x80, 0x30, 0xFC, 0x02, 0x03, 0xE0, 0x40, 0x1F, 0x88, 0x00,
  0x7F, 0x00, 0x0E, 0x20, 0xC5, 0xF2, 0x0F, 0xD8, 0xC4, 0xE6, 0x03, 0xB8,
  0x0E, 0xF0, 0x39, 0xE0, 0xE3, 0xC3, 0x87, 0x8E, 0x0E, 0x3C, 0x38, 0x70,
  0x41, 0xE2, 0x03, 0xF0, 0x07, 0xE7, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0xF8,
  0x0F, 0xFF, 0x0E, 0x27, 0xCC, 0x20, 0xF4, 0x30, 0x3A, 0x1C, 0x0D, 0x0F,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xD0, 0x30, 0x67, 0x98, 0x30, 0x08, 0x10,
  0x78, 0x08, 0xFE, 0x08, 0x8F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0E,
  0x20, 0x62, 0xF8, 0x83, 0xF3, 0x18, 0x8E, 0x60, 0x1D, 0xC0, 0x3B, 0xCE,
  0x73, 0xFF, 0xE3, 0xDD, 0xC3, 0xC3, 0x83, 0x87, 0x87, 0x07, 0x04, 0x0F,
  0x10, 0x0F, 0xC0, 0x0F, 0xCE, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x26, 0x0F, 0xE6, 0x05, 0xE2, 0x06, 0x01, 0x03, 0x00, 0x83, 0xC6,
  0x40, 0xF7, 0xA0, 0x7D, 0x8C, 0x5E, 0x81, 0xC7, 0x83, 0x81, 0xC0, 0x60,
  0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x18, 0x0E, 0x0C, 0x03, 0x0C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x38, 0x30, 0xFC, 0x61, 0x1E, 0x62, 0x0E,
  0xE6, 0x08, 0xE7, 0x18, 0xE7, 0x3E, 0xE7, 0xCE, 0xE3, 0xC7, 0xE1, 0xC7,
  0xE0, 0xC7, 0xF0, 0xC7, 0x70, 0x86, 0x3B, 0x06, 0x1C, 0x0C, 0x0F, 0x10,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x04, 0xF8, 0x08, 0x70,
  0x18, 0x00, 0x18, 0x08, 0x1C, 0x3C, 0x1E, 0x7E, 0x0F, 0x9E, 0x0F, 0x0F,
  0x07, 0x87, 0x03, 0x87, 0x01, 0x83, 0x31, 0x83, 0x78, 0x83, 0xBF, 0x06,
  0x1C, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x0F, 0x80, 0x3F, 0xC0,
  0xC3, 0xC1, 0x03, 0xF6, 0x00, 0x8C, 0x02, 0x18, 0x0C, 0x10, 0x38, 0x10,
  0x78, 0x1F, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC6, 0x03,
  0xBE, 0x02, 0x9E, 0x04, 0x1F, 0x10, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0xE0,
  0x30, 0xF0, 0x20, 0x7E, 0x40, 0x08, 0x40, 0x10, 0x40, 0x30, 0x20, 0x30,
  0x10, 0x38, 0x0F, 0xB8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x18, 0x06, 0x7E, 0x04, 0x9F, 0x04,
  0x0F, 0x88, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x80, 0x40, 0x67, 0x08, 0x33,
  0xF3, 0x0D, 0x1C, 0x47, 0x43, 0x90, 0xF0, 0xF4, 0x3C, 0x1B, 0x0F, 0x08,
  0x81, 0xEF, 0xC0, 0x39, 0xE0, 0x07, 0x38, 0x31, 0x8E, 0x1E, 0x21, 0xCB,
  0xD0, 0x7C, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xC1, 0x8C, 0x0C,
  0xE0, 0x67, 0x83, 0xBC, 0x18, 0xF0, 0xC7, 0xBC, 0x1C, 0x00, 0x60, 0x02,
  0x00, 0x20, 0x03, 0xC0, 0x7F, 0x0C, 0x3F, 0xC0, 0xFC, 0x3E, 0x3C, 0x78,
  0x7F, 0xFE, 0xBC, 0xC7, 0xCF, 0x1C, 0x81, 0xC7, 0x1C, 0x81, 0xE3, 0x8E,
  0x80, 0xE3, 0x8F, 0x80, 0xE3, 0x88, 0xF8, 0x63, 0x88, 0x7C, 0x61, 0x90,
  0x04, 0x61, 0x30, 0x00, 0x41, 0x30, 0x00, 0x43, 0x70, 0x10, 0x82, 0x38,
  0x7C, 0xF4, 0x3D, 0x9F, 0xFC, 0x1E, 0x1E, 0x38, 0x0C, 0x00, 0x00, 0x00,
  0x3E, 0x0F, 0x0F, 0xF2, 0xE3, 0x1F, 0x8E, 0x40, 0xE1, 0xC8, 0x1E, 0x3D,
  0x01, 0xC3, 0xA0, 0x38, 0x47, 0xE3, 0x10, 0x7C, 0x66, 0x00, 0x8C, 0xC0,
  0x01, 0x38, 0x00, 0x27, 0x01, 0x88, 0x70, 0xF9, 0x0F, 0x67, 0xC0, 0xF0,
  0xF0, 0x08, 0x01, 0xE0, 0x01, 0xFC, 0x03, 0x3F, 0x06, 0x07, 0xC6, 0x00,
  0xF3, 0x00, 0x39, 0xC0, 0x0C, 0xFC, 0x06, 0x3F, 0x01, 0x07, 0x80, 0x80,
  0xC0, 0x42, 0x40, 0x23, 0xC0, 0x27, 0xF8, 0x20, 0x3F, 0x20, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x03, 0x03, 0xF8, 0xE0, 0x43, 0xFF, 0x08, 0x1E,
  0x78, 0x80, 0xE7, 0xC8, 0x0E, 0x3E, 0x80, 0xE1, 0xE4, 0x2E, 0x07, 0x3C,
  0xE0, 0x70, 0x0E, 0x03, 0x00, 0x60, 0x20, 0x06, 0x02, 0x01, 0xE0, 0x20,
  0x3F, 0x84, 0x04, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0x3F, 0x80,
  0x33, 0xF0, 0x30, 0x3E, 0x18, 0x03, 0xC6, 0x00, 0x71, 0xC0, 0x0C, 0x7E,
  0x03, 0x0F, 0xC0, 0x40, 0xF0, 0x10, 0x0C, 0x04, 0x12, 0x09, 0x0F, 0x0F,
  0x8F, 0xF4, 0xE4, 0x3F, 0x3E, 0x03, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0xF0, 0x7F, 0x97, 0x8C, 0x7E, 0x3C, 0x81, 0xE1,
  0xC8, 0x0E, 0x1E, 0x80, 0xE0, 0xC8, 0x06, 0x10, 0x80, 0x62, 0x04, 0x26,
  0xF0, 0x3C, 0x67, 0x00, 0x06, 0x78, 0x00, 0x43, 0x81, 0x84, 0x38, 0x3C,
  0x83, 0xC5, 0xF0, 0x1F, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0xFE, 0x10, 0xFC, 0x20, 0x30, 0x40, 0x00, 0xC0, 0x30, 0x80, 0xFC, 0x8B,
  0xFE, 0xC7, 0xC2, 0xC3, 0x01, 0xE0, 0x01, 0xF0, 0x02, 0x78, 0x06, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0xE0, 0xC3, 0xF0, 0x81,
  0xFD, 0x82, 0x3E, 0x87, 0x08, 0x87, 0x80, 0x83, 0xC0, 0x79, 0xE0, 0x00,
  0xE0, 0x38, 0x60, 0xFC, 0xC0, 0x3E, 0x00, 0x1F, 0x04, 0x07, 0xCE, 0x03,
  0xF0, 0x0F, 0x02, 0x11, 0x0C, 0x31, 0x3C, 0x30, 0x1C, 0x38, 0x1C, 0x3C,
  0x1C, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x04, 0x1C, 0x08, 0x1C, 0x10,
  0x1C, 0x3C, 0x1C, 0x7E, 0x7C, 0x0F, 0x9F, 0x07, 0x0C, 0x00, 0x00, 0x00,
  0x04, 0x01, 0xF8, 0xF0, 0x3F, 0xD3, 0x86, 0x1E, 0x3C, 0x40, 0xE1, 0xE8,
  0x06, 0x08, 0x80, 0x61, 0x04, 0x06, 0x10, 0x22, 0x63, 0x81, 0xC4, 0x3C,
  0x00, 0x81, 0xE0, 0x10, 0x0E, 0x07, 0x80, 0x61, 0xFC, 0x06, 0x03, 0xE0,
  0x40, 0x0F, 0x88, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x9D, 0xF8, 0x3F, 0xE2, 0x3C, 0x61, 0xE4, 0x1C, 0x40, 0xE4, 0x1E, 0x80,
  0x66, 0x0E, 0x80, 0x6E, 0x08, 0x40, 0x67, 0x08, 0x42, 0x67, 0x9C, 0x3C,
  0x43, 0x9E, 0x00, 0x43, 0x9F, 0x00, 0x81, 0x87, 0x0F, 0x01, 0x03, 0x1F,
  0x81, 0x83, 0x23, 0xC3, 0xC2, 0x01, 0xFD, 0xE4, 0x00, 0xF0, 0xF8, 0x00,
  0x00, 0x1F, 0x0F, 0x3F, 0x9F, 0x61, 0xD6, 0x40, 0xE0, 0x40, 0xE0, 0x40,
  0xC0, 0x40, 0xFC, 0x3D, 0xFC, 0x02, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0x70, 0x3D, 0x7B, 0x3E, 0x3E, 0x5E, 0x1C, 0x00, 0x06, 0x03,
  0xF1, 0xF0, 0xFF, 0x4E, 0x30, 0xF0, 0xE4, 0x0E, 0x1D, 0x00, 0xC3, 0xE0,
  0x18, 0x22, 0x03, 0x08, 0x22, 0x63, 0x03, 0x88, 0x70, 0x01, 0x0E, 0x00,
  0x41, 0xE0, 0x10, 0x1C, 0x03, 0x13, 0xC0, 0xF4, 0x78, 0x6F, 0x06, 0x00,
  0xE0, 0xC1, 0x00, 0x30, 0x10, 0x0C, 0x01, 0x83, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x1F, 0xF0, 0x60, 0xE0, 0x80, 0xE1, 0x01, 0xC2, 0x03, 0x04, 0x06,
  0x06, 0x10, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xCE, 0x01, 0x3E, 0x02, 0x9E, 0x08, 0x1E, 0x20, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x00, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x08,
  0x0E, 0x07, 0x86, 0x46, 0x14, 0x04, 0xFF, 0xFF, 0xFC, 0xD9, 0x90, 0x10,
  0x0C, 0x0F, 0x89, 0xEC, 0x66, 0x33, 0x19, 0x8C, 0xC6, 0x73, 0x1F, 0xEE,
  0x60, 0x20, 0x04, 0x26, 0x07, 0x00, 0xC0, 0x32, 0x0C, 0xC3, 0xF8, 0xC6,
  0x31, 0xCC, 0x33, 0x0C, 0xC2, 0x31, 0x9E, 0x43, 0xE0, 0x30, 0x08, 0x00,
  0x08, 0x79, 0x36, 0x6C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0xF9, 0xC0, 0x00,
  0x40, 0x40, 0x30, 0x1E, 0x07, 0xC1, 0xF0, 0x5C, 0xC7, 0x61, 0xB0, 0xD8,
  0x6C, 0x36, 0x17, 0x88, 0xF8, 0x30, 0x08, 0x71, 0x76, 0x6C, 0xF9, 0x3C,
  0x60, 0xC1, 0xC1, 0xF9, 0xC0, 0x3A, 0x79, 0x02, 0x06, 0x1F, 0x9C, 0x38,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x08,
  0x0E, 0x0F, 0x88, 0xEC, 0x36, 0x13, 0x19, 0x8E, 0xC7, 0x73, 0x9D, 0xCF,
  0x74, 0x38, 0x1B, 0x0C, 0xC4, 0x3C, 0x00, 0x0E, 0x24, 0x07, 0x00, 0xC0,
  0x32, 0x0D, 0xC3, 0xB8, 0xCE, 0x31, 0x8C, 0x73, 0x1C, 0xC7, 0x31, 0x8C,
  0x67, 0xD8, 0xC4, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x38, 0xE3, 0x00, 0x21,
  0xC7, 0xAC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xC6, 0x18, 0x61, 0x00, 0x10,
  0xE7, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x78, 0x0F,
  0x31, 0xD9, 0xB3, 0x87, 0x3F, 0x98, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x9F,
  0x0C, 0x00, 0x0F, 0x31, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x9F, 0x0C, 0x00, 0x42, 0x21, 0xCE, 0xE3, 0xEE, 0xF3, 0x98,
  0xC7, 0x31, 0x8E, 0x63, 0x1C, 0xC6, 0x39, 0x8C, 0x73, 0x18, 0xE7, 0x33,
  0xDE, 0x79, 0x08, 0x60, 0x84, 0x39, 0x8E, 0xF9, 0xCC, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x1C, 0xCF, 0x3C, 0x86, 0x00, 0x00, 0x02, 0x0F, 0x1B,
  0xCC, 0xE6, 0x3B, 0x1D, 0x86, 0xC3, 0x61, 0x79, 0x0F, 0x03, 0x00, 0x40,
  0x10, 0x0E, 0x23, 0xCC, 0x7F, 0x8C, 0xE3, 0x1C, 0xC3, 0x30, 0xCC, 0x37,
  0x0B, 0xE4, 0xBE, 0x0F, 0x03, 0x00, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x08,
  0x06, 0x07, 0xC4, 0xF6, 0x33, 0x1B, 0x8D, 0xC6, 0x63, 0x39, 0x8F, 0xC6,
  0x60, 0x30, 0x08, 0x04, 0x02, 0x02, 0x00, 0x22, 0x76, 0x77, 0x3A, 0x32,
  0x30, 0x30, 0x30, 0x30, 0x3A, 0x7C, 0x08, 0x1F, 0x00, 0x42, 0x23, 0x96,
  0xF2, 0x11, 0x88, 0xEE, 0x7F, 0x11, 0xC8, 0x4F, 0x43, 0xC0, 0x40, 0x04,
  0x10, 0x20, 0x83, 0xFF, 0xCC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x4F, 0x86,
  0x00, 0x41, 0x38, 0xCE, 0x79, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x1C, 0xEF, 0xFC, 0x46, 0x40, 0x10, 0x8C, 0x73, 0xEE, 0x71, 0x9C, 0x73,
  0x1C, 0x43, 0x10, 0x88, 0x63, 0x91, 0xF8, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x0C, 0x01, 0x39, 0xCE, 0xFF, 0xF9, 0xCE, 0x77, 0x38, 0xDC, 0xE3, 0x73,
  0x8D, 0xCE, 0x37, 0x38, 0x9C, 0xF4, 0x71, 0xE0, 0x81, 0x02, 0x00, 0x00,
  0x31, 0x1D, 0x9F, 0xE3, 0x61, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0x0F,
  0x09, 0x08, 0x04, 0x01, 0x08, 0x7E, 0x00, 0x00, 0x40, 0x10, 0x06, 0x11,
  0xCC, 0x3F, 0x8E, 0x73, 0x9C, 0xE3, 0x38, 0xCE, 0x33, 0x8C, 0xE3, 0x7C,
  0x86, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x31, 0xEB, 0x86, 0x11, 0x9F,
  0x8E, 0x5E, 0x78, 0xE3, 0x8E, 0x28, 0xBC, 0x06, 0x30, 0x41, 0x83, 0x87,
  0x06, 0x08, 0x31, 0x80, 0xC0, 0xC1, 0x87, 0x0E, 0x18, 0x18, 0x10, 0x18,
  0xFF, 0xFF, 0xE0, 0xC0, 0x60, 0x40, 0xC3, 0x87, 0x0C, 0x08, 0x08, 0x0C,
  0x61, 0x83, 0x87, 0x0E, 0x0C, 0x10, 0x43, 0x00, 0xFF, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 17, 5, 1, -17 },
  { 10, 8, 6, 9, 1, -16 },
  { 16, 10, 13, 12, 1, -15 },
  { 33, 8, 19, 10, 1, -18 },
  { 52, 15, 16, 16, 1, -16 },
  { 82, 12, 14, 13, 1, -14 },
  { 103, 4, 6, 5, 0, -16 },
  { 106, 5, 19, 6, 0, -18 },
  { 118, 5, 19, 6, 0, -18 },
  { 130, 8, 8, 8, 0, -17 },
  { 138, 7, 8, 9, 1, -12 },
  { 145, 4, 7, 4, 0, -4 },
  { 149, 6, 4, 7, 1, -9 },
  { 152, 4, 4, 5, 0, -4 },
  { 154, 11, 18, 12, 1, -17 },
  { 179, 10, 16, 11, 0, -16 },
  { 199, 7, 16, 7, 0, -16 },
  { 213, 10, 16, 10, 0, -16 },
  { 233, 10, 16, 11, 0, -16 },
  { 253, 10, 16, 11, 0, -16 },
  { 273, 10, 16, 11, 0, -16 },
  { 293, 10, 16, 10, 0, -16 },
  { 313, 10, 16, 10, 0, -16 },
  { 333, 10, 16, 11, 0, -16 },
  { 353, 10, 17, 10, 0, -17 },
  { 375, 4, 11, 5, 0, -11 },
  { 381, 4, 14, 4, 0, -11 },
  { 388, 6, 9, 7, 0, -11 },
  { 395, 7, 6, 9, 1, -10 },
  { 401, 6, 9, 7, 0, -11 },
  { 408, 8, 17, 10, 1, -17 },
  { 425, 14, 14, 14, 0, -11 },
  { 450, 17, 17, 19, 1, -16 },
  { 487, 20, 17, 21, 0, -17 },
  { 530, 14, 17, 16, 1, -17 },
  { 560, 17, 18, 19, 1, -17 },
  { 599, 15, 17, 16, 1, -17 },
  { 631, 17, 20, 17, 0, -17 },
  { 674, 16, 18, 18, 1, -17 },
  { 710, 16, 21, 17, 0, -18 },
  { 752, 15, 19, 16, 0, -17 },
  { 788, 16, 22, 16, 0, -17 },
  { 832, 18, 17, 19, 0, -16 },
  { 871, 13, 16, 13, 0, -16 },
  { 897, 24, 17, 25, 1, -16 },
  { 948, 19, 16, 20, 1, -16 },
  { 986, 17, 17, 17, 0, -16 },
  { 1023, 20, 20, 21, 0, -16 },
  { 1073, 18, 19, 18, 0, -17 },
  { 1116, 20, 17, 21, 1, -17 },
  { 1159, 16, 17, 17, 1, -17 },
  { 1193, 16, 16, 17, 1, -16 },
  { 1225, 16, 17, 16, 0, -16 },
  { 1259, 20, 18, 20, 0, -17 },
  { 1304, 24, 17, 25, 0, -17 },
  { 1355, 16, 17, 17, 0, -17 },
  { 1389, 19, 21, 20, 0, -17 },
  { 1439, 15, 20, 15, 0, -17 },
  { 1477, 4, 18, 4, 0, -17 },
  { 1486, 14, 16, 2, -4, -15 },
  { 1514, 4, 18, 4, 0, -17 },
  { 1523, 9, 6, 10, 0, -16 },
  { 1530, 11, 2, 10, 0, 2 },
  { 1533, 3, 4, 12, 4, -16 },
  { 1535, 9, 13, 11, 1, -12 },
  { 1550, 10, 17, 10, 0, -16 },
  { 1572, 7, 13, 8, 1, -12 },
  { 1584, 9, 16, 10, 1, -16 },
  { 1602, 7, 12, 8, 1, -12 },
  { 1613, 7, 20, 6, 0, -16 },
  { 1631, 9, 17, 11, 1, -12 },
  { 1651, 10, 20, 10, 0, -16 },
  { 1676, 6, 16, 6, 0, -16 },
  { 1688, 6, 20, 6, -1, -16 },
  { 1703, 7, 17, 7, 0, -16 },
  { 1718, 7, 17, 6, 0, -16 },
  { 1733, 15, 12, 16, 1, -12 },
  { 1756, 10, 13, 12, 1, -12 },
  { 1773, 9, 12, 10, 0, -12 },
  { 1787, 10, 19, 10, 0, -14 },
  { 1811, 9, 17, 10, 0, -12 },
  { 1831, 8, 12, 8, 0, -12 },
  { 1843, 9, 14, 10, 0, -14 },
  { 1859, 7, 16, 7, 0, -15 },
  { 1873, 10, 12, 12, 1, -12 },
  { 1888, 10, 13, 10, 0, -13 },
  { 1905, 14, 15, 16, 1, -14 },
  { 1932, 9, 17, 9, 0, -12 },
  { 1952, 10, 18, 11, 0, -14 },
  { 1975, 6, 16, 8, 1, -12 },
  { 1987, 7, 19, 8, 0, -18 },
  { 2004, 1, 19, 4, 1, -18 },
  { 2007, 7, 19, 8, 0, -18 },
  { 2024, 7, 2, 8, 1, -8 },
};

const GFXfont UnifrakturMaguntia_Regular23pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular23pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular23pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR23PT7B_H_
