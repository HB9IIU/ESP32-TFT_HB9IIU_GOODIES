#ifndef _UNIFRAKTURMAGUNTIA_REGULAR53PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x03, 0x01, 0xE0, 0xFC, 0x7F, 0xDF, 0xE3, 0xF8, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x30, 0x1E, 0x0F, 0xC7, 0xF8, 0x7C, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x40, 0x70, 0x1C, 0x1F, 0x07, 0xC7,
  0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0,
  0xC0, 0x30, 0x18, 0x06, 0x02, 0x00, 0x80, 0xC0, 0x30, 0x10, 0x04, 0x04,
  0x01, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x1E, 0x0E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE0, 0xE0, 0xF0, 0x1C, 0x38,
  0x03, 0x1E, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x01,
  0xE7, 0xE0, 0x39, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x20,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x39, 0x80, 0x0E, 0x70, 0x07, 0x8E, 0x03, 0xC1, 0xC1, 0xE0,
  0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0C, 0x3F, 0xC0, 0x00, 0x03, 0x0F, 0x3C, 0x00, 0x00, 0xC3, 0xC3, 0xC0,
  0x00, 0x30, 0xF8, 0x78, 0x00, 0x0E, 0x1F, 0x0F, 0x80, 0x03, 0x83, 0xE1,
  0xF0, 0x00, 0xE0, 0x7C, 0x3E, 0x00, 0x18, 0x1F, 0x87, 0xC0, 0x06, 0x03,
  0xF0, 0xF8, 0x01, 0x80, 0x7E, 0x1F, 0x00, 0x60, 0x07, 0xC3, 0xE0, 0x1C,
  0x00, 0xF8, 0x7C, 0x07, 0x00, 0x1F, 0x0F, 0x81, 0xC0, 0x03, 0xE1, 0xE0,
  0x70, 0x00, 0x3C, 0x3C, 0x0C, 0x00, 0x03, 0xCF, 0x03, 0x00, 0x00, 0x3F,
  0xC0, 0xC1, 0xF0, 0x03, 0xE0, 0x30, 0x7F, 0x80, 0x00, 0x0E, 0x1E, 0x78,
  0x00, 0x03, 0x87, 0x87, 0x80, 0x00, 0xE1, 0xF0, 0xF0, 0x00, 0x18, 0x3E,
  0x1F, 0x00, 0x06, 0x07, 0xC3, 0xE0, 0x01, 0x80, 0xF8, 0x7C, 0x00, 0x60,
  0x3F, 0x0F, 0x80, 0x1C, 0x07, 0xE1, 0xF0, 0x07, 0x00, 0xFC, 0x3E, 0x01,
  0xC0, 0x1F, 0x87, 0xC0, 0x70, 0x01, 0xF0, 0xF8, 0x0C, 0x00, 0x3E, 0x1F,
  0x03, 0x00, 0x07, 0xC3, 0xC0, 0xC0, 0x00, 0x78, 0x78, 0x30, 0x00, 0x07,
  0x9E, 0x0E, 0x00, 0x00, 0x7F, 0x81, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x87,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x3F, 0x0F, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0xFC, 0x70,
  0x00, 0x0F, 0xDE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x7F, 0xC0, 0x7E, 0x0F, 0xF8, 0x3F, 0xE0, 0x7C, 0x0F, 0xFC, 0x07,
  0x03, 0x9F, 0xC0, 0xC0, 0xE3, 0xF8, 0x18, 0x3C, 0x3F, 0x83, 0x07, 0x87,
  0xF0, 0x41, 0xF0, 0x7F, 0x08, 0x3E, 0x0F, 0xE3, 0x07, 0xC0, 0xFE, 0xC0,
  0xF8, 0x1F, 0xD8, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7E, 0x03,
  0xF8, 0x17, 0xE0, 0x7F, 0x86, 0xFE, 0x07, 0xFF, 0x8F, 0xE1, 0xFF, 0xE0,
  0xFF, 0xF3, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x18, 0x1C, 0x3E, 0xFF,
  0x7F, 0x1F, 0x0F, 0x0E, 0x0E, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x80, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x1B, 0xF4, 0x3E, 0x79, 0xF7, 0x8C,
  0xF9, 0xF3, 0x7E, 0x7E, 0x9F, 0x18, 0xFC, 0x44, 0x1E, 0x11, 0xFB, 0xFC,
  0x7C, 0xDF, 0x9F, 0x33, 0xEF, 0x9C, 0xF8, 0x67, 0xB1, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x06, 0x07, 0x8F, 0xE7, 0xF9, 0xFC, 0x3C, 0x1E, 0x07, 0x03, 0x01, 0x81,
  0x80, 0x80, 0xC0, 0x00, 0x1E, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFC, 0x00, 0x08, 0x0C,
  0x0F, 0x0F, 0xCF, 0xF1, 0xE0, 0x70, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07,
  0xEF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01,
  0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xE3, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3E, 0x1F, 0xF0, 0xE0,
  0x1F, 0xE7, 0x00, 0x3F, 0x98, 0x00, 0xFE, 0x40, 0x01, 0xFB, 0x00, 0x07,
  0xEC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x30, 0x1C, 0x00, 0xC0,
  0xE0, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x70, 0x7F, 0x81, 0xC0, 0x3F, 0x86,
  0x00, 0x3F, 0x88, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF9, 0x80, 0x03, 0xE7, 0x80, 0x07, 0xDF,
  0x80, 0x0F, 0xBF, 0x00, 0x1E, 0x7E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xFC,
  0x01, 0xC0, 0xF8, 0x07, 0x00, 0xF8, 0x18, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x6F, 0xC0, 0x00, 0x9F,
  0x80, 0x03, 0x3F, 0x00, 0x0C, 0x7E, 0x00, 0x10, 0xFC, 0x00, 0x61, 0xF8,
  0x00, 0x83, 0xF0, 0x03, 0x07, 0xE0, 0x0C, 0x0F, 0xC0, 0x10, 0x1F, 0x80,
  0x60, 0x3F, 0x01, 0x80, 0x7E, 0x02, 0x00, 0xFC, 0x0C, 0x01, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x18, 0x00, 0x30, 0x1F, 0x07,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x02, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x9F, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xF8,
  0x1F, 0xF1, 0xC0, 0x0F, 0xE3, 0x00, 0x0F, 0xC4, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF9, 0x80, 0x03, 0xE7, 0x80, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1E,
  0x7E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xFC, 0x01, 0xC0, 0xF8, 0x07, 0x00,
  0xF8, 0x18, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x1F, 0x00,
  0x38, 0x3E, 0x01, 0xC0, 0x7C, 0x0F, 0x01, 0xF8, 0x3C, 0x07, 0xE1, 0xF0,
  0x1F, 0x87, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0x83, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xFC, 0x1F,
  0x9F, 0xF8, 0xFE, 0xC3, 0xF3, 0xFE, 0x0F, 0xEF, 0xF8, 0x1F, 0xBF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3E, 0x7E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0xC0, 0x3C, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0x78, 0x18, 0x00, 0xE0, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x38, 0x00, 0x1B, 0x80, 0x01, 0x98, 0x00, 0x0C, 0x80, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0x03, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x83, 0xC0,
  0x07, 0x07, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x7C, 0x00,
  0x38, 0xF8, 0x00, 0xF1, 0xF8, 0x01, 0xC3, 0xFC, 0x03, 0x83, 0xFE, 0x0E,
  0x07, 0xFE, 0x38, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x73, 0xFF, 0x81, 0xC1, 0xFF, 0x87,
  0x00, 0xFF, 0x1E, 0x00, 0xFF, 0x38, 0x00, 0xFE, 0xF0, 0x00, 0xFD, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x70, 0x01,
  0xE0, 0x70, 0x03, 0x80, 0x78, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x0C, 0x3C, 0x00, 0x70, 0x78, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0xF0, 0x0F, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x01, 0xF9, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF7,
  0xE0, 0x3F, 0xDF, 0xC1, 0xFF, 0x3F, 0x8D, 0xFC, 0x7F, 0xE7, 0xE0, 0xFF,
  0x9F, 0x81, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x3C, 0x01, 0xF1, 0xF8, 0x07, 0x87, 0xE0, 0x3E, 0x1F,
  0x80, 0xF0, 0x7E, 0x03, 0xC0, 0xF8, 0x0E, 0x01, 0xF0, 0x70, 0x03, 0xC3,
  0x80, 0x03, 0xF8, 0x00, 0x08, 0x0C, 0x0F, 0x0F, 0xCF, 0xF1, 0xE0, 0x60,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x06, 0x07, 0x87, 0xE7, 0xF8, 0xF0, 0x38, 0x18, 0x00, 0x00, 0x04, 0x03,
  0x01, 0xE0, 0xFC, 0x7F, 0x87, 0x80, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x78, 0x7F,
  0x1F, 0xE3, 0xF8, 0x3C, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xE0,
  0xF0, 0x38, 0x07, 0xC7, 0x00, 0x3C, 0xE0, 0x03, 0xEE, 0x00, 0x3E, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x78, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x10, 0x1E, 0x01, 0x81, 0xE0, 0x10, 0x0F, 0x03, 0x00, 0x78,
  0x60, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x03, 0xFF, 0x38, 0xF0, 0x0F, 0xFC,
  0x71, 0xE0, 0x7C, 0xF8, 0xE3, 0x81, 0xF1, 0xF1, 0xCF, 0x03, 0xC3, 0xC3,
  0x9E, 0x0F, 0x07, 0x87, 0x3C, 0x3E, 0x1F, 0x0E, 0x78, 0x7C, 0x3E, 0x1C,
  0xE1, 0xF0, 0x78, 0x39, 0xC3, 0xE0, 0xF0, 0xE3, 0x87, 0x83, 0xE1, 0xC7,
  0x9F, 0x07, 0xC7, 0x8F, 0x3E, 0x1F, 0x0E, 0x0E, 0x3C, 0x7E, 0x38, 0x1C,
  0x79, 0xFC, 0xE0, 0x3C, 0xFF, 0x7F, 0x87, 0x38, 0xF8, 0xFC, 0x1C, 0x78,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0x01, 0xE1,
  0xFF, 0xE0, 0x3F, 0x80, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x60, 0x00, 0x7F, 0x87, 0xF0,
  0x20, 0x00, 0x3F, 0xC3, 0xF8, 0x30, 0x00, 0x0F, 0xE1, 0xFC, 0x18, 0x00,
  0x07, 0xF0, 0xFE, 0x0C, 0x00, 0x03, 0xF8, 0x7F, 0x07, 0x00, 0x00, 0xFC,
  0x3F, 0x83, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x7F, 0xC0, 0x1F, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xFC,
  0x0F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xC0,
  0x7F, 0x00, 0x07, 0x83, 0xC0, 0x3F, 0x80, 0x01, 0xC1, 0xC0, 0x1F, 0xC0,
  0x00, 0xC1, 0xC0, 0x0F, 0xE0, 0x00, 0x41, 0xC0, 0x07, 0xF0, 0x00, 0x01,
  0xC0, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFF,
  0xF8, 0x1F, 0xF8, 0x80, 0x0F, 0xFF, 0x39, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x30, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x81, 0xFE, 0x01, 0xF8, 0x1F, 0xFE,
  0x03, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0xC0,
  0x3F, 0xC1, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x07, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x18, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x60, 0x00, 0x0F, 0xC0, 0x0F,
  0xF1, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x70,
  0x18, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0xC0, 0x00, 0x1F, 0x07, 0xFE, 0x03, 0x80, 0x00, 0x78, 0x7F, 0xFE, 0x07,
  0x00, 0x41, 0xE7, 0xFF, 0xFC, 0x0F, 0x06, 0x0F, 0x33, 0xFF, 0xF0, 0x0F,
  0xF0, 0x38, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x33, 0xFF, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0xE0, 0x00, 0x3C, 0x30, 0x7E, 0x00, 0x1E, 0x02, 0x3F,
  0xE4, 0x0F, 0x00, 0xDF, 0xFF, 0x07, 0x80, 0x1F, 0xFF, 0x83, 0xE0, 0x0C,
  0x3F, 0x80, 0xF0, 0x0E, 0x03, 0xC0, 0x7C, 0x07, 0x00, 0x20, 0x1F, 0x07,
  0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x07,
  0xE0, 0xFF, 0x00, 0x01, 0xF8, 0x3F, 0xF0, 0x00, 0x7E, 0x07, 0xFE, 0x00,
  0x1F, 0xC1, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xF0, 0x01, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x01, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x0F,
  0xF0, 0x07, 0x00, 0x03, 0xFE, 0x03, 0x80, 0x00, 0x7F, 0xC1, 0x80, 0x00,
  0x0F, 0xF8, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x70, 0x0F, 0xFF, 0xE1, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x30, 0x7F, 0xF0, 0x1F, 0x00, 0x70, 0x0F,
  0xFC, 0x1E, 0x00, 0x70, 0x03, 0xFE, 0x0E, 0x00, 0x78, 0x00, 0x7F, 0x8F,
  0x00, 0x7C, 0x00, 0x1F, 0xC7, 0x00, 0x3E, 0x00, 0x07, 0xF3, 0x80, 0x3F,
  0x80, 0x01, 0xF9, 0xC0, 0x1F, 0xE0, 0x00, 0xFC, 0xC0, 0x0F, 0xF8, 0x00,
  0x3F, 0x60, 0x03, 0xFF, 0x00, 0x0F, 0x90, 0x01, 0xFF, 0x80, 0x07, 0xCC,
  0x00, 0x7F, 0xE0, 0x01, 0xE6, 0x00, 0x1F, 0xF8, 0x00, 0xF1, 0x80, 0x07,
  0xFC, 0x00, 0x78, 0xC0, 0x01, 0xFE, 0x00, 0x1C, 0x38, 0x00, 0x7F, 0x00,
  0x0E, 0x07, 0x04, 0x1F, 0x80, 0x07, 0x00, 0xFE, 0x07, 0xC0, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x01, 0xFF, 0xF8, 0x00, 0x10, 0x01,
  0xFF, 0xFF, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xE0, 0x18, 0x03, 0x81, 0xFF,
  0xFF, 0xF8, 0x01, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x1C, 0x00, 0x03, 0xC3, 0x07, 0xE0, 0x00, 0xF0, 0x11, 0xFF, 0x20, 0x3C,
  0x03, 0x7F, 0xFC, 0x0F, 0x00, 0x3F, 0xFF, 0x03, 0xE0, 0x0C, 0x3F, 0x80,
  0x78, 0x07, 0x01, 0xE0, 0x1F, 0x01, 0xC0, 0x08, 0x03, 0xE0, 0xF0, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF8, 0x1F, 0x03, 0xF0,
  0x7F, 0x87, 0xF0, 0x7E, 0x0F, 0xFC, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xF9,
  0xF8, 0x1F, 0xFC, 0xFF, 0x3F, 0x81, 0xFF, 0xCF, 0xC7, 0xF0, 0x1F, 0xF8,
  0x70, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x78, 0x00,
  0x1F, 0xE0, 0x0E, 0x00, 0x03, 0xFE, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0xC0,
  0x00, 0x03, 0xFE, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0x00, 0x7F, 0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xFF, 0x87, 0x80, 0x01,
  0xFF, 0xF8, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x11, 0xFE, 0x07,
  0x00, 0x00, 0xC1, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x18,
  0x00, 0x3F, 0x80, 0x20, 0x60, 0x00, 0xFF, 0x00, 0xC1, 0x80, 0x03, 0xFC,
  0x07, 0xC6, 0x00, 0x07, 0xF8, 0x3F, 0x8C, 0x00, 0x1F, 0xF1, 0xFF, 0x30,
  0x00, 0x3F, 0xE7, 0xF8, 0x60, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xFF,
  0x9F, 0x01, 0xC0, 0xE3, 0xFE, 0x38, 0x01, 0xFE, 0x0F, 0xF8, 0x40, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1C, 0x00,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x18, 0x00, 0x00, 0xF1, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0x87, 0xC0, 0x00, 0x78, 0x02, 0x7F, 0x80, 0x03, 0xC0,
  0x06, 0xFF, 0x00, 0x1F, 0x00, 0x31, 0xFF, 0x00, 0xF8, 0x01, 0x83, 0xFE,
  0x03, 0xE0, 0x18, 0x07, 0xFC, 0x1F, 0x00, 0xE0, 0x0F, 0xF8, 0x7C, 0x0F,
  0x00, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x3C, 0x0F, 0xC3, 0xF0, 0x00, 0xC0,
  0x7E, 0x0F, 0xC0, 0x0E, 0x01, 0xF8, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0xFE,
  0x03, 0xF8, 0x1F, 0x83, 0xFC, 0x3F, 0xF8, 0x7E, 0x07, 0xF1, 0xFF, 0xE1,
  0xF8, 0x1F, 0xE8, 0xFF, 0xC7, 0xE0, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0xFF,
  0x80, 0xFE, 0x7F, 0x01, 0xFF, 0x03, 0xFD, 0xFC, 0x03, 0xFC, 0x07, 0xF7,
  0xF0, 0x07, 0xF8, 0x1F, 0xDF, 0xC0, 0x0F, 0xE0, 0x3F, 0x7F, 0x80, 0x3F,
  0x80, 0xFD, 0xFE, 0x00, 0x7E, 0x03, 0xF3, 0xF8, 0x01, 0xF8, 0x0F, 0xCF,
  0xF0, 0x03, 0xC0, 0x3F, 0x1F, 0xC0, 0x0E, 0x00, 0xF8, 0x7F, 0x80, 0x70,
  0x03, 0xE0, 0xFE, 0x03, 0x80, 0x0F, 0x81, 0xFC, 0x1C, 0x00, 0x7C, 0x03,
  0xF8, 0x40, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x1C, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x0F, 0xFA, 0x00, 0x00, 0x30,
  0x3F, 0xF8, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x03, 0xF0, 0x00,
  0x03, 0x80, 0x04, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x03, 0xFF,
  0xC0, 0x07, 0xFC, 0x7F, 0xFF, 0x00, 0x1F, 0xE7, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x7E, 0x07, 0x00, 0xF0, 0x03, 0xF0, 0xFC, 0x07, 0x80, 0x1F, 0x8F, 0xF0,
  0x18, 0x00, 0xFC, 0xFF, 0xC1, 0x80, 0x07, 0xCF, 0xFF, 0x08, 0x00, 0x3E,
  0x07, 0xFF, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x7F, 0x80,
  0x00, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x7F, 0xF8, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x78, 0x00, 0x7F,
  0xFE, 0x1C, 0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x01, 0xFF, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x07, 0xC0, 0x07, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x39, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x40, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0xF8, 0xFF, 0xE0, 0x00, 0x3C,
  0x7F, 0xFC, 0x00, 0x0F, 0x39, 0xFF, 0x80, 0x03, 0x80, 0x3F, 0xF0, 0x00,
  0xE0, 0x07, 0xFE, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x38, 0x00, 0x1F, 0xFE,
  0x18, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0x83, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0xE0, 0x00,
  0xFF, 0xFC, 0x1C, 0x00, 0x0F, 0xFF, 0x07, 0x00, 0x00, 0xFF, 0x80, 0xE0,
  0x00, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1F,
  0x00, 0x18, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x00,
  0x1F, 0xC0, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x03,
  0x81, 0xCF, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x07, 0x83, 0xFE, 0x00, 0x00, 0xF0, 0xFF, 0xF0, 0x00, 0x1C, 0x3F,
  0xFF, 0x00, 0x03, 0x8C, 0x7F, 0xF0, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0x18,
  0x00, 0x3F, 0xF0, 0x06, 0x00, 0x03, 0xFF, 0x01, 0x80, 0x00, 0x3F, 0xFC,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x1F, 0x00, 0x70, 0x00, 0xF8, 0x3F, 0xF0, 0x18, 0x00, 0x78, 0x3F, 0xFC,
  0x0E, 0x00, 0x7C, 0x3F, 0xFF, 0x03, 0x00, 0x3E, 0x38, 0x7F, 0xC1, 0xC0,
  0x3F, 0x18, 0x1F, 0xE0, 0xE0, 0x1F, 0x88, 0x07, 0xF8, 0x70, 0x0F, 0xCC,
  0x01, 0xFC, 0x18, 0x07, 0xF4, 0x00, 0xFF, 0x0C, 0x03, 0xFA, 0x00, 0x3F,
  0x86, 0x01, 0xFF, 0x00, 0x1F, 0xF7, 0x00, 0x7F, 0xC0, 0x07, 0xE3, 0x80,
  0x3F, 0xE0, 0x01, 0xC1, 0x80, 0x1F, 0xF0, 0x00, 0xC1, 0xC0, 0x07, 0xFC,
  0x01, 0x80, 0xC0, 0x01, 0xFF, 0x03, 0xE1, 0xC0, 0x00, 0xFF, 0x87, 0xF9,
  0x80, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x10, 0x07, 0xC0, 0xFE,
  0x00, 0x3E, 0x03, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xE0, 0x1F, 0xC0, 0x7F,
  0xE0, 0x60, 0x0F, 0xF0, 0x7F, 0xF8, 0x60, 0x03, 0xFC, 0x03, 0xFE, 0x60,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x1F, 0x3F, 0x80, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x3F, 0x80,
  0x01, 0xF3, 0xFC, 0x00, 0x1F, 0x3F, 0xE0, 0x01, 0xF1, 0xFE, 0x00, 0x3E,
  0x1F, 0xF0, 0x03, 0xE1, 0xFF, 0x00, 0x7C, 0x0F, 0xF3, 0x1F, 0x80, 0x7F,
  0x9F, 0xF0, 0x07, 0xF8, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x02, 0x03, 0xFF, 0xE0, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0xF9,
  0xFF, 0xF1, 0x8F, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFA, 0x07, 0xF0, 0x3E,
  0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x38, 0x03, 0xFF, 0x03, 0xFC, 0x03,
  0xF8, 0x60, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x60, 0x00, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0x40, 0x00, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0xC0, 0x00,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x40, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x70, 0x60, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0xC0, 0x60, 0x00, 0x07, 0xE0, 0x3F, 0x01, 0x80, 0x3F,
  0xFC, 0x07, 0xE0, 0x1F, 0x03, 0x80, 0x3F, 0xFE, 0x07, 0xE0, 0x1F, 0x07,
  0x00, 0x1F, 0xFE, 0x07, 0xC0, 0x1E, 0x07, 0x00, 0x07, 0xFE, 0x03, 0xC0,
  0x1E, 0x0F, 0x00, 0x00, 0x06, 0x03, 0xC0, 0x1E, 0x1F, 0x00, 0x00, 0x02,
  0x03, 0xC0, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x1C, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x18, 0x3F, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x38, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x30, 0x3F, 0x80, 0x01,
  0xF0, 0x0C, 0x60, 0x30, 0x3F, 0x80, 0x07, 0xF8, 0x0C, 0xF8, 0x20, 0x1F,
  0xC0, 0x0F, 0xFC, 0x1B, 0xFC, 0x60, 0x1F, 0xE3, 0x1F, 0xFE, 0x33, 0xFF,
  0xC0, 0x0F, 0xFE, 0x31, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xCF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x88, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xC6, 0x07, 0xF0, 0x1E, 0x03, 0xFF, 0x20,
  0x3F, 0x81, 0xC0, 0x07, 0xFF, 0x00, 0xFC, 0x0C, 0x00, 0x1F, 0xF0, 0x07,
  0xF0, 0x40, 0x00, 0x7F, 0x80, 0x3F, 0x82, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x30, 0x00, 0x0F, 0xF0, 0x07, 0xF1, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xEC,
  0x00, 0x00, 0xFC, 0x01, 0xFE, 0x60, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0x00,
  0x00, 0x3F, 0x80, 0x18, 0x0C, 0x00, 0x00, 0xFC, 0x01, 0x80, 0x70, 0x30,
  0x07, 0xE0, 0x18, 0x01, 0xFF, 0xE0, 0x3F, 0x01, 0xC0, 0x07, 0xFF, 0x81,
  0xF8, 0x1C, 0x00, 0x1F, 0xFC, 0x07, 0x80, 0xE0, 0x00, 0x7F, 0xE0, 0x3C,
  0x0F, 0x00, 0x00, 0x01, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x08, 0x0F, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x00, 0x03, 0x83, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x3F, 0x80, 0x00,
  0xFC, 0x06, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x30, 0x07, 0xF8, 0x01, 0xFF,
  0x83, 0x00, 0x3F, 0xE6, 0x1F, 0xFE, 0x30, 0x00, 0xFF, 0xE1, 0x8F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x70, 0x07, 0xFF, 0xC0, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x38, 0x00, 0x03,
  0xFF, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x7C,
  0x00, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xF9, 0xFF,
  0xE0, 0x00, 0x07, 0xE3, 0xFF, 0xE0, 0x00, 0x0F, 0x8F, 0xFF, 0xC0, 0x00,
  0x3E, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x1F,
  0xFC, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x21,
  0x00, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x00, 0x60, 0x3F, 0xE0, 0x00, 0x03,
  0x03, 0xFF, 0xC0, 0x00, 0x08, 0x1F, 0xFF, 0xC0, 0x00, 0x60, 0x87, 0xFF,
  0x80, 0x03, 0x00, 0x0F, 0xFF, 0x80, 0x18, 0x00, 0x0F, 0xFF, 0x81, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xC3, 0xFC, 0x00,
  0x3C, 0x03, 0xFE, 0x6F, 0xF0, 0x01, 0xC0, 0x0F, 0xFE, 0x7F, 0xC0, 0x1C,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0xC0, 0x00, 0xFF, 0x0F, 0xFC, 0x06, 0x00,
  0x07, 0xF8, 0x3F, 0xF0, 0x30, 0x00, 0x1F, 0xC0, 0xFF, 0xC1, 0x80, 0x00,
  0xFE, 0x03, 0xFF, 0x0C, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x60, 0x00, 0x1F,
  0x80, 0x3F, 0xF3, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x8C, 0x00, 0x07, 0xE0,
  0x03, 0xFE, 0x60, 0x00, 0x3F, 0x00, 0x0F, 0xF1, 0x80, 0x11, 0xF8, 0x00,
  0x3F, 0xC7, 0x83, 0x8F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x1F, 0xFF,
  0x80, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFE,
  0x0E, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x3C, 0x00,
  0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0xC0, 0x00, 0x01, 0xF8, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0xFE, 0x00,
  0x00, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0xF8,
  0x07, 0xFF, 0x80, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x84, 0x00, 0x10, 0x60, 0x07,
  0xE0, 0x00, 0x7C, 0x60, 0x0F, 0xF8, 0x00, 0xFE, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0x81, 0x87, 0xFF, 0x84, 0x3F, 0xC3,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xC3, 0xF0, 0x00, 0x07, 0xFF, 0x01,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xC1,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC6, 0x0F, 0xF0, 0x0F, 0xC3, 0xFF, 0xC8,
  0x0F, 0xE0, 0x1E, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x78, 0x00, 0x7F, 0xC0,
  0x1F, 0xC0, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC1, 0x80, 0x00, 0x7F, 0x00,
  0x7F, 0x87, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xCE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x98, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x30, 0x00, 0x01, 0xF8, 0x00,
  0xF0, 0x70, 0x00, 0x03, 0xF0, 0x03, 0x80, 0x60, 0x00, 0x03, 0xE0, 0x0C,
  0x00, 0xC0, 0x00, 0x07, 0xC0, 0x60, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xC0,
  0x01, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xC0, 0x10, 0x3E, 0x7F, 0xC0,
  0x01, 0xE0, 0x60, 0x7D, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xF8, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x07, 0xF8, 0x00,
  0x04, 0x00, 0x60, 0x0F, 0xF0, 0x00, 0x3E, 0x01, 0xC0, 0x0F, 0xE0, 0x01,
  0xFE, 0x03, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x0C, 0x00, 0x3F, 0xC0, 0x1F,
  0xFE, 0x30, 0x00, 0x3F, 0xEC, 0x23, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xC7, 0xFF, 0xFF, 0x00, 0x0C, 0x01, 0xFF, 0xF8, 0x00, 0x60, 0x01, 0xFF,
  0xC0, 0x03, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x1E, 0x00,
  0x01, 0xFF, 0xE0, 0x70, 0x00, 0x1F, 0xFF, 0xC1, 0xC0, 0xC1, 0xFF, 0xFF,
  0x87, 0x81, 0x9F, 0xFF, 0xEF, 0x3E, 0x03, 0xFF, 0xF8, 0x04, 0xF8, 0x07,
  0xFF, 0x80, 0x1B, 0xE0, 0x0F, 0xFC, 0x00, 0x27, 0xC0, 0x1F, 0xC0, 0x00,
  0x9F, 0x00, 0x3C, 0x00, 0x02, 0x7E, 0x00, 0x00, 0x00, 0x0D, 0xF8, 0x00,
  0x00, 0x00, 0x27, 0xF0, 0x00, 0x00, 0x00, 0x8F, 0xE0, 0x00, 0x00, 0x06,
  0x3F, 0xC0, 0x00, 0x00, 0x30, 0x7F, 0xC0, 0x00, 0x01, 0xC1, 0xFF, 0xC0,
  0x00, 0x1E, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1E, 0x03, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x01,
  0xFF, 0xE0, 0x98, 0x00, 0x03, 0xFF, 0xE6, 0x60, 0x00, 0x33, 0xFF, 0xF3,
  0x00, 0x01, 0x83, 0xFF, 0x8C, 0x00, 0x1C, 0x07, 0xFC, 0x30, 0x00, 0xF0,
  0x07, 0xC0, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x00, 0x04,
  0x00, 0x7F, 0x00, 0x00, 0x18, 0x01, 0xFE, 0x00, 0x00, 0x20, 0x07, 0xFC,
  0x00, 0x00, 0x60, 0x0F, 0xFC, 0x00, 0x00, 0xE1, 0x9F, 0xF8, 0x00, 0x00,
  0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x78,
  0x00, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x1C, 0x00, 0x00, 0x0F,
  0xFE, 0x40, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x00,
  0xFF, 0xF0, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x40, 0x1E,
  0x38, 0x00, 0x1C, 0x03, 0xC0, 0x80, 0x07, 0x00, 0x78, 0x0C, 0x01, 0xF0,
  0x0F, 0x80, 0xC0, 0x7E, 0x00, 0xF8, 0x0C, 0x1F, 0xE0, 0x1F, 0x81, 0x83,
  0xFE, 0x01, 0xF8, 0x10, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x38, 0x00,
  0xFC, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x0C,
  0x00, 0x0F, 0xC0, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xFC, 0x02,
  0xFE, 0x06, 0xFF, 0xE0, 0xCF, 0xE0, 0x83, 0xFF, 0xFC, 0xFF, 0xE0, 0x0F,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xC6, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFF, 0x60, 0xFF, 0x00, 0xFC, 0x1F, 0xFA, 0x03, 0xF8, 0x0F, 0x80, 0x3F,
  0xF0, 0x1F, 0xE0, 0x70, 0x00, 0xFF, 0x80, 0x7F, 0x03, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x38, 0x00, 0x0F, 0xE0, 0x0F, 0xF1, 0x80, 0x00, 0x3F, 0x00,
  0x7E, 0x0C, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x60, 0x00, 0x07, 0xC0, 0x06,
  0x03, 0x00, 0x00, 0x3E, 0x00, 0x60, 0x08, 0x00, 0x01, 0xF0, 0x07, 0x00,
  0x60, 0x00, 0x0F, 0x80, 0x78, 0x03, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x0C,
  0x00, 0x03, 0xC0, 0x3F, 0x00, 0x30, 0x06, 0x1E, 0x01, 0xFC, 0x00, 0xE1,
  0xC0, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x70, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x63, 0xFF, 0xC0, 0x00, 0x70, 0x02, 0x07, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC3, 0xF0, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC6, 0x32, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xD8, 0x38, 0x07,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x30, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0xC0,
  0xC0, 0x0F, 0xF0, 0x3C, 0x00, 0x7F, 0x83, 0x80, 0x0F, 0xE0, 0x70, 0x00,
  0x7F, 0x87, 0x00, 0x1F, 0xE1, 0xC0, 0x00, 0x7F, 0x1E, 0x00, 0x1F, 0xC3,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0xC6, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x3F, 0xCC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x30, 0x10, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0xC0, 0x30, 0x00,
  0x07, 0xC7, 0xF8, 0x03, 0x80, 0x60, 0x00, 0x0F, 0x8F, 0xF0, 0x0F, 0x00,
  0x60, 0x00, 0x1F, 0x0F, 0xF0, 0x3E, 0x00, 0x60, 0x0C, 0x3C, 0x1F, 0xE0,
  0xFE, 0x00, 0x60, 0x30, 0x78, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x80, 0xE0,
  0x1F, 0xC3, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x3F, 0x83, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x7E, 0x07, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x07, 0xF8, 0x00, 0x33, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x03, 0x80, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x7F,
  0xFC, 0x00, 0x0F, 0x80, 0x07, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x0E,
  0x06, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x18, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0x80, 0x20, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x80, 0x80, 0x00, 0x0F, 0xFF,
  0xF1, 0xFF, 0xC2, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x3E, 0x10, 0x7F, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xC7, 0xC0, 0x3F, 0x8D, 0xFC, 0x78, 0x01, 0xFD, 0x87,
  0x87, 0x00, 0x0F, 0xD0, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x06, 0x00, 0x07,
  0xF0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x60,
  0x00, 0x3E, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x7F, 0xFF,
  0x03, 0x00, 0x0F, 0xFF, 0xE0, 0x1C, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x9F,
  0xFF, 0xC0, 0x00, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x9F, 0xC0, 0x00, 0x3C, 0x09, 0xFE, 0x00, 0x07, 0xE1, 0x9F, 0xF0,
  0x00, 0xFF, 0xB0, 0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x02, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xC6, 0x3F, 0xC0, 0x3F,
  0xFF, 0xFD, 0x83, 0xFC, 0x0F, 0xC1, 0xFF, 0xA0, 0x3F, 0x83, 0xC0, 0x0F,
  0xFC, 0x07, 0xF8, 0x70, 0x00, 0xFF, 0x80, 0x7F, 0x0C, 0x00, 0x0F, 0xF0,
  0x0F, 0xE3, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x60, 0x00, 0x0F, 0xC0, 0x1F,
  0xEC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x30,
  0x00, 0x03, 0xE0, 0x03, 0x82, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x60, 0x00,
  0x0F, 0x80, 0x38, 0x0C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0xC0, 0x00, 0x3C,
  0x03, 0xE0, 0x0C, 0x01, 0x87, 0x80, 0xFC, 0x00, 0xF1, 0xC0, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3C, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x81, 0xFE,
  0x00, 0x07, 0xF8, 0x30, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x11, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00,
  0x07, 0xC0, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x3E,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xFF, 0xC0, 0x0F, 0x00,
  0x0F, 0xF0, 0x0F, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x00, 0xFC, 0x03, 0x80,
  0x00, 0x3E, 0x01, 0x80, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x60,
  0x00, 0x07, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x03, 0xE0, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x07, 0x87, 0xFC, 0x00, 0x03, 0xCF, 0xFF, 0x00,
  0x01, 0xCF, 0xFF, 0xC0, 0x00, 0xE4, 0x3F, 0xF0, 0x00, 0xE0, 0x0F, 0xFC,
  0x00, 0x60, 0x03, 0xFF, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x60, 0x00, 0x3F,
  0xF8, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x7C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xF9,
  0xF0, 0x1E, 0x0F, 0x83, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0xE0,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0xE7, 0xC7, 0xC7, 0x87, 0x07,
  0x06, 0x04, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x0D, 0xFF, 0x80, 0x63, 0xFF, 0x03, 0x83, 0xF8,
  0x1C, 0x07, 0xE0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0x78,
  0x07, 0xE1, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0x93, 0xF8, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F,
  0x0F, 0xC0, 0x78, 0x1E, 0x00, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xF0, 0x08, 0x1C, 0x00, 0x10, 0xE0, 0x00, 0x67, 0x80, 0x00,
  0xBE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x10, 0x07, 0xC0, 0x60, 0x1F, 0x07, 0x80, 0x7E, 0x3F,
  0x01, 0xFB, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8,
  0x0F, 0x87, 0xE0, 0x1E, 0x1F, 0x80, 0x78, 0x7E, 0x01, 0xE1, 0xF8, 0x0F,
  0x87, 0xE0, 0x3C, 0x1F, 0x80, 0xF0, 0x7E, 0x03, 0x81, 0xF8, 0x1C, 0x0F,
  0xF8, 0x60, 0x7F, 0xFA, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0xCF, 0x80, 0xC7, 0xE0, 0xE1, 0xF0, 0xF0,
  0xFC, 0x70, 0x3E, 0x78, 0x1C, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x05, 0xFF, 0x00, 0x21, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8,
  0x07, 0xC7, 0xE0, 0x0F, 0x1F, 0x80, 0x3C, 0x7E, 0x00, 0xE1, 0xF8, 0x03,
  0x87, 0xE0, 0x0E, 0x1F, 0x80, 0x70, 0x7E, 0x01, 0xC1, 0xFC, 0x06, 0x1F,
  0xFC, 0x18, 0x1F, 0xFC, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x7C, 0x00,
  0xFF, 0x00, 0xCF, 0x80, 0xC7, 0xE0, 0xE1, 0xF0, 0xF0, 0xFC, 0x70, 0x7E,
  0x78, 0x1F, 0x3C, 0x0F, 0xDE, 0x03, 0xEF, 0x03, 0x87, 0x8E, 0x07, 0xFC,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07,
  0xF2, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x08, 0x78, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0xFF,
  0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x67, 0xFE,
  0x01, 0x87, 0xFE, 0x07, 0x07, 0xF8, 0x1C, 0x03, 0xE0, 0x78, 0x01, 0xC1,
  0xF0, 0x03, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x1C, 0x1F, 0x80, 0x78, 0x3F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE3, 0xFC, 0x0F, 0xF9, 0xF8, 0x1F, 0x83, 0xF0, 0x1C, 0x03,
  0xE0, 0x20, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x0C, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x7C, 0x03, 0x80, 0xF8, 0x06, 0x00,
  0xF8, 0x38, 0x00, 0xFD, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x08, 0x1C, 0x00, 0x11, 0xE0, 0x00, 0x67, 0x80, 0x00, 0xBE,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x30, 0x07, 0xC1, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x07, 0xE0,
  0x3C, 0x3F, 0x91, 0xE1, 0xFF, 0x87, 0x81, 0xFC, 0x1C, 0x03, 0xE0, 0xE0,
  0x07, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x03,
  0xF8, 0x7F, 0xCD, 0xFE, 0x9F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF9, 0x1F, 0xD0, 0xFE, 0x0F, 0xE0, 0x7C, 0x03, 0xC0,
  0x08, 0x00, 0x70, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x13, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xA0, 0x1E, 0x20,
  0x38, 0x60, 0xE0, 0x4F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0xE2, 0x07,
  0x02, 0x1E, 0x02, 0x78, 0x65, 0xF1, 0xC7, 0xE7, 0x8F, 0xDF, 0x1F, 0xBE,
  0x3F, 0xF4, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xDF, 0xFF, 0xCF,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC2, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x1E, 0x00, 0xE2, 0x07,
  0x02, 0x1C, 0x02, 0x78, 0x05, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC6, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F,
  0x80, 0x1E, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x0C, 0x00, 0x78, 0x0F, 0x03, 0xC0, 0x1F, 0x83, 0xF0, 0xFC,
  0x03, 0xF9, 0xFF, 0x3F, 0xE0, 0xFF, 0x6F, 0xED, 0xFF, 0x17, 0xF8, 0xFF,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x3E, 0x01, 0xF0,
  0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xFC, 0x1F, 0x00,
  0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x0F,
  0x80, 0x7C, 0x0F, 0xC1, 0xF0, 0x0F, 0x81, 0xF8, 0x3E, 0x01, 0xF0, 0x3F,
  0x07, 0xC0, 0x3E, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xFC,
  0x1F, 0x83, 0xE0, 0x1F, 0x83, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x0F, 0xC9,
  0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xE7, 0xFC, 0x1F, 0xC1, 0xF8, 0x3E, 0x03,
  0xF8, 0x1E, 0x03, 0xC0, 0x3E, 0x01, 0x80, 0x30, 0x03, 0x80, 0x20, 0x04,
  0x00, 0x10, 0x08, 0x01, 0x00, 0x1C, 0x03, 0x80, 0x3F, 0x07, 0xC0, 0x3F,
  0x0F, 0xE0, 0x7F, 0x9F, 0xFC, 0x7F, 0xA7, 0xFE, 0x8F, 0xC1, 0xF8, 0x0F,
  0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F,
  0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F,
  0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F,
  0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0x3F, 0xE1, 0xFD, 0x1F,
  0xC0, 0xFF, 0x0F, 0x80, 0xFE, 0x07, 0x80, 0x7C, 0x03, 0x00, 0x3C, 0x02,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xFE,
  0x03, 0xE3, 0xF8, 0x1F, 0x1F, 0xE0, 0xF8, 0x7F, 0x07, 0xC1, 0xFC, 0x3E,
  0x0F, 0xE1, 0xF0, 0x3F, 0x8F, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0,
  0x07, 0x8F, 0x80, 0x78, 0x7C, 0x03, 0x87, 0xF8, 0x18, 0x7F, 0xE1, 0xC1,
  0xFF, 0xD8, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x1F, 0xC0, 0x60,
  0x3F, 0xC1, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0x7F, 0xE0, 0x7F, 0x9F, 0xC0,
  0x7C, 0x1F, 0xC0, 0xF8, 0x1F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07,
  0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x3C,
  0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x07, 0xE0,
  0x3C, 0x3F, 0xC0, 0x78, 0xFF, 0x80, 0xE3, 0xFF, 0xC3, 0x87, 0xFF, 0xE6,
  0x08, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xCE, 0x00,
  0x07, 0x88, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0x3F, 0xE0,
  0x38, 0xFF, 0xC3, 0x81, 0xFC, 0x3C, 0x07, 0xC1, 0xC0, 0x3E, 0x1E, 0x01,
  0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xFC, 0x0F,
  0x87, 0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0xFE, 0x3F, 0x07, 0xFE, 0xF8, 0x1F,
  0xE7, 0xC0, 0x7C, 0x3E, 0x01, 0xC0, 0xF0, 0x04, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x18, 0x04, 0x0F, 0x03, 0x0F, 0xC3, 0x87, 0xE3, 0xE7, 0xFB, 0xFE, 0xFF,
  0xFC, 0x3F, 0x7E, 0x1F, 0x1E, 0x0F, 0x86, 0x07, 0xC2, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x20, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0xC0, 0x30, 0x1E, 0x03, 0x03, 0xF8, 0x70, 0x7F,
  0xFE, 0x19, 0xFF, 0xE3, 0x07, 0xFC, 0x30, 0x1F, 0x87, 0x00, 0x30, 0x70,
  0x06, 0x0F, 0x80, 0xC0, 0xFC, 0x1E, 0x07, 0xE3, 0xF0, 0x7F, 0x7F, 0x83,
  0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xF0, 0x7E, 0x0E, 0x03, 0xE0, 0xC0, 0x1E,
  0x08, 0x01, 0xC1, 0xC0, 0x1C, 0x7F, 0x81, 0x8F, 0xFE, 0x30, 0x7F, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x84, 0x7F, 0xA3, 0xFF, 0x03, 0xF8, 0x03, 0xE0, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x60, 0x1E, 0x00, 0x60,
  0x3F, 0x00, 0xF0, 0x3F, 0x01, 0xF8, 0x7F, 0x83, 0xFC, 0x5F, 0x83, 0xFC,
  0x8F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC3, 0xF9,
  0x1F, 0xE7, 0xFF, 0x3F, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xE0, 0x7C,
  0x00, 0xC0, 0x3C, 0x00, 0x40, 0x08, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x40, 0x38, 0x00, 0xC0, 0x38, 0x03, 0xE0, 0x7C, 0x07, 0xE0,
  0x7E, 0x0F, 0xF0, 0x7F, 0x3F, 0xF8, 0x7F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3E,
  0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x3C, 0x01, 0x80, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x70, 0x07, 0xF0, 0x60, 0x07, 0xFC, 0xC0,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x08,
  0x1F, 0x80, 0x70, 0x06, 0x07, 0xF8, 0x3E, 0x03, 0xC1, 0xFE, 0x1F, 0xC3,
  0xF8, 0x3F, 0x8F, 0xFB, 0xFF, 0x07, 0xF6, 0x7F, 0x1F, 0xC0, 0xFE, 0x1F,
  0x83, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0x80, 0x7C, 0x3F, 0x03, 0xE0, 0x1F, 0x0F,
  0xC0, 0xF8, 0x07, 0xC3, 0xF0, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0x80, 0x7C,
  0x3F, 0x03, 0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x07, 0x83, 0xF0, 0x3E, 0x01,
  0xE0, 0xFC, 0x0F, 0x80, 0x70, 0x3F, 0x03, 0xE0, 0x38, 0x0F, 0xC1, 0xFC,
  0x0C, 0x03, 0xF0, 0xFF, 0xC6, 0x01, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0x81,
  0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x20,
  0x3E, 0x0E, 0x0F, 0xE3, 0xC1, 0xFC, 0xFC, 0x7F, 0xFF, 0x89, 0xFD, 0xF8,
  0x3F, 0x3E, 0x07, 0xE3, 0x80, 0x7C, 0x60, 0x0F, 0x88, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC2, 0x01,
  0xFE, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xC7, 0xC0, 0x30,
  0x70, 0x04, 0x04, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0xC0, 0xC0, 0x3C, 0x0E, 0x1F, 0x80, 0x7F, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x30, 0x3F, 0xC0, 0xE0,
  0x3F, 0xC3, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07,
  0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C,
  0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3F, 0x01, 0xE0, 0xFE, 0xC3,
  0x83, 0xFF, 0x0F, 0x01, 0xFC, 0x1C, 0x00, 0xF0, 0x30, 0x00, 0xC0, 0xE0,
  0x01, 0x83, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x84,
  0x3F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x61, 0xE3, 0x07, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x17, 0xF0, 0x47, 0xE1, 0x87, 0xE2, 0x0F, 0xCC, 0x0F, 0x90, 0x1F, 0x60,
  0x3E, 0xC0, 0x7D, 0x80, 0xFB, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xD8, 0x07,
  0x30, 0x1E, 0x60, 0x38, 0x60, 0x60, 0xC1, 0xC0, 0xC6, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF8,
  0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7C, 0x01, 0xF0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 10, 39, 12, 1, -38 },
  { 50, 19, 15, 21, 1, -38 },
  { 86, 23, 30, 27, 2, -34 },
  { 173, 18, 42, 22, 2, -40 },
  { 268, 35, 38, 38, 1, -38 },
  { 435, 27, 33, 30, 2, -32 },
  { 547, 8, 15, 11, 1, -38 },
  { 562, 12, 43, 13, 1, -42 },
  { 627, 12, 44, 13, 1, -42 },
  { 693, 18, 20, 19, 0, -39 },
  { 738, 17, 19, 21, 2, -27 },
  { 779, 9, 14, 10, 0, -8 },
  { 795, 15, 10, 16, 1, -21 },
  { 814, 9, 9, 11, 1, -8 },
  { 825, 26, 42, 28, 1, -40 },
  { 962, 23, 37, 25, 1, -37 },
  { 1069, 15, 36, 17, 1, -36 },
  { 1137, 22, 36, 24, 1, -36 },
  { 1236, 23, 37, 25, 1, -37 },
  { 1343, 23, 36, 24, 1, -36 },
  { 1447, 23, 37, 25, 1, -37 },
  { 1554, 22, 37, 24, 1, -37 },
  { 1656, 21, 36, 23, 1, -36 },
  { 1751, 23, 37, 25, 1, -37 },
  { 1858, 22, 37, 24, 1, -37 },
  { 1960, 9, 26, 11, 1, -25 },
  { 1990, 10, 31, 9, 0, -25 },
  { 2029, 15, 20, 15, 0, -25 },
  { 2067, 18, 12, 21, 1, -22 },
  { 2094, 15, 20, 15, 0, -25 },
  { 2132, 20, 39, 24, 2, -38 },
  { 2230, 31, 32, 32, 1, -25 },
  { 2354, 41, 39, 43, 1, -38 },
  { 2554, 46, 40, 47, 0, -39 },
  { 2784, 34, 39, 36, 1, -38 },
  { 2950, 41, 41, 43, 1, -39 },
  { 3161, 35, 40, 37, 1, -39 },
  { 3336, 38, 46, 40, 1, -39 },
  { 3555, 38, 39, 41, 1, -38 },
  { 3741, 37, 48, 39, 1, -41 },
  { 3963, 34, 45, 36, 1, -39 },
  { 4155, 35, 52, 38, 1, -39 },
  { 4383, 41, 39, 43, 1, -38 },
  { 4583, 28, 38, 30, 1, -37 },
  { 4716, 56, 40, 59, 1, -37 },
  { 4996, 45, 38, 47, 1, -37 },
  { 5210, 38, 39, 40, 1, -38 },
  { 5396, 45, 46, 47, 1, -37 },
  { 5655, 40, 42, 42, 1, -38 },
  { 5865, 47, 39, 49, 1, -38 },
  { 6095, 38, 39, 40, 1, -38 },
  { 6281, 38, 38, 40, 1, -38 },
  { 6462, 36, 40, 38, 1, -37 },
  { 6642, 45, 40, 47, 1, -39 },
  { 6867, 55, 39, 57, 1, -38 },
  { 7136, 36, 40, 38, 1, -39 },
  { 7316, 43, 47, 45, 1, -39 },
  { 7569, 33, 46, 35, 1, -39 },
  { 7759, 7, 42, 10, 1, -39 },
  { 7796, 32, 38, 6, -10, -35 },
  { 7948, 7, 42, 10, 1, -39 },
  { 7985, 20, 14, 22, 1, -37 },
  { 8020, 25, 4, 24, 0, 6 },
  { 8033, 7, 10, 27, 9, -37 },
  { 8042, 22, 29, 24, 1, -27 },
  { 8122, 22, 39, 24, 1, -37 },
  { 8230, 17, 28, 19, 1, -27 },
  { 8290, 22, 38, 24, 1, -37 },
  { 8395, 17, 28, 19, 1, -27 },
  { 8455, 16, 48, 13, 0, -39 },
  { 8551, 23, 38, 25, 1, -27 },
  { 8661, 22, 46, 24, 1, -37 },
  { 8788, 12, 38, 14, 1, -37 },
  { 8845, 15, 48, 13, -3, -38 },
  { 8935, 15, 38, 17, 1, -37 },
  { 9007, 15, 38, 14, 1, -37 },
  { 9079, 35, 29, 38, 1, -28 },
  { 9206, 24, 28, 27, 1, -27 },
  { 9290, 21, 28, 22, 0, -27 },
  { 9364, 23, 43, 24, 0, -32 },
  { 9488, 21, 38, 23, 1, -27 },
  { 9588, 17, 28, 19, 1, -27 },
  { 9648, 20, 34, 22, 1, -33 },
  { 9733, 14, 35, 16, 1, -34 },
  { 9795, 24, 29, 27, 1, -28 },
  { 9882, 24, 31, 24, -1, -30 },
  { 9975, 34, 32, 37, 1, -31 },
  { 10111, 19, 39, 21, 1, -28 },
  { 10204, 23, 41, 25, 1, -32 },
  { 10322, 15, 37, 18, 1, -27 },
  { 10392, 14, 42, 18, 1, -41 },
  { 10466, 3, 43, 8, 3, -41 },
  { 10483, 14, 42, 18, 1, -41 },
  { 10557, 17, 4, 19, 1, -18 },
};

const GFXfont UnifrakturMaguntia_Regular53pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular53pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular53pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR53PT7B_H_
