#ifndef _UNIFRAKTURMAGUNTIA_REGULAR62PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x1F, 0xC7, 0xFE, 0x7F, 0xF3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x60, 0x0F, 0x01,
  0xFC, 0x3F, 0xE5, 0xFC, 0x0F, 0x00, 0x70, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x40, 0x18, 0x03, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x7F, 0xC7, 0xFC,
  0xFF, 0x3F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0x78, 0x0E,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x04, 0x01, 0x00, 0x20, 0x08, 0x00, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x78,
  0x0F, 0x00, 0xE0, 0xF0, 0x07, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xF3,
  0xF8, 0x03, 0x9F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xB8, 0x07, 0xFD, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xF7, 0x00, 0x0F, 0xB8, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x00, 0x3C,
  0x1C, 0x03, 0xE0, 0x7C, 0x3E, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x0F, 0xF8, 0x00, 0x00, 0x0E, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x3C,
  0x3E, 0x00, 0x00, 0x38, 0x7C, 0x1E, 0x00, 0x00, 0x38, 0x7C, 0x1F, 0x00,
  0x00, 0x70, 0xFC, 0x1F, 0x00, 0x00, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0xC0,
  0xFC, 0x1F, 0x80, 0x03, 0x80, 0xFC, 0x1F, 0x80, 0x07, 0x00, 0xFC, 0x1F,
  0x80, 0x0E, 0x00, 0xFC, 0x1F, 0x80, 0x0C, 0x00, 0xFC, 0x1F, 0x80, 0x1C,
  0x00, 0xFC, 0x1F, 0x80, 0x38, 0x00, 0xFC, 0x1F, 0x80, 0x70, 0x00, 0xFC,
  0x1F, 0x00, 0xE0, 0x00, 0x7C, 0x1F, 0x01, 0xC0, 0x00, 0x7C, 0x1E, 0x03,
  0x80, 0x00, 0x3C, 0x3E, 0x07, 0x00, 0x00, 0x1E, 0x3C, 0x07, 0x00, 0x00,
  0x0F, 0xF8, 0x0E, 0x07, 0xC0, 0x03, 0xE0, 0x1C, 0x1F, 0xF0, 0x00, 0x00,
  0x38, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x7C, 0x3C, 0x00, 0x00, 0xE0, 0x78,
  0x3E, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x00, 0x01, 0x80, 0xF8, 0x3F, 0x00,
  0x03, 0x81, 0xF8, 0x3F, 0x00, 0x07, 0x01, 0xF8, 0x3F, 0x00, 0x0E, 0x01,
  0xF8, 0x3F, 0x00, 0x1C, 0x01, 0xF8, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x3F,
  0x00, 0x70, 0x01, 0xF8, 0x3F, 0x00, 0x60, 0x01, 0xF8, 0x3F, 0x00, 0xE0,
  0x01, 0xF8, 0x3F, 0x01, 0xC0, 0x00, 0xF8, 0x3F, 0x03, 0x80, 0x00, 0xF8,
  0x3E, 0x07, 0x00, 0x00, 0x78, 0x3E, 0x0E, 0x00, 0x00, 0x7C, 0x3C, 0x1C,
  0x00, 0x00, 0x3C, 0x78, 0x38, 0x00, 0x00, 0x1F, 0xF0, 0x18, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF8,
  0x3C, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x01, 0xF8,
  0x78, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0x7F, 0x80, 0x78, 0x0E, 0x3F,
  0x80, 0x70, 0x1E, 0x3F, 0xC0, 0x70, 0x3C, 0x3F, 0xC0, 0x60, 0x7C, 0x1F,
  0xE0, 0x60, 0x7C, 0x1F, 0xE0, 0x60, 0xFC, 0x0F, 0xF0, 0x40, 0xFC, 0x0F,
  0xF0, 0xC0, 0xFC, 0x07, 0xF8, 0x80, 0xFC, 0x07, 0xF9, 0x80, 0xFE, 0x03,
  0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0x7F, 0xC0, 0x7F, 0xC6, 0x3F, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x8F, 0xF8, 0x03, 0xFC,
  0x03, 0xE0, 0x04, 0x03, 0x01, 0xE0, 0xFC, 0x7F, 0xFF, 0xF1, 0xFC, 0x3E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x40, 0x20, 0x08, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xE0, 0x00, 0x80, 0x40, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x06, 0x7D, 0xC3, 0xF3, 0xC7, 0xEF, 0x8E, 0x7E, 0x7E, 0x73, 0xF3,
  0xF9, 0x3F, 0x0F, 0xEB, 0xF8, 0x41, 0xF0, 0x44, 0x0F, 0x02, 0x3F, 0xFF,
  0xF1, 0xFC, 0x9F, 0x8F, 0xCC, 0xFE, 0x7E, 0x73, 0xF7, 0xE3, 0x9F, 0x83,
  0x3E, 0x62, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x00, 0xE0, 0x7C, 0x3F, 0x9F, 0xF3, 0xFC, 0x7F, 0x0F,
  0xC1, 0xE0, 0x78, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x10, 0x08, 0x00, 0x00,
  0x01, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x78, 0x3F, 0x3F, 0xF7, 0xF8, 0x78,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xFC,
  0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0C, 0x7F, 0x82, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xFC, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xC1,
  0xFF, 0xC3, 0xC0, 0x1F, 0xF0, 0xE0, 0x03, 0xFE, 0x70, 0x00, 0x7F, 0x98,
  0x00, 0x1F, 0xE6, 0x00, 0x07, 0xF9, 0x80, 0x00, 0xFE, 0x40, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x08, 0x03,
  0xC0, 0x03, 0x01, 0xE0, 0x00, 0xC0, 0xF0, 0x00, 0x20, 0x78, 0x00, 0x08,
  0x1C, 0x00, 0x02, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0x03, 0xFF,
  0x01, 0xC0, 0x1F, 0xF0, 0x70, 0x01, 0xFE, 0x08, 0x00, 0x1F, 0xE2, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x07,
  0xC7, 0xF0, 0x01, 0xF0, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x81, 0xFC,
  0x03, 0xE0, 0x0F, 0xC0, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x33, 0xF0, 0x00, 0x0E, 0x7E, 0x00, 0x01,
  0x8F, 0xC0, 0x00, 0x61, 0xF8, 0x00, 0x0C, 0x3F, 0x00, 0x03, 0x07, 0xE0,
  0x00, 0xE0, 0xFC, 0x00, 0x18, 0x1F, 0x80, 0x06, 0x03, 0xF0, 0x01, 0xC0,
  0x7E, 0x00, 0x30, 0x0F, 0xC0, 0x0C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00,
  0x60, 0x07, 0xE0, 0x18, 0x00, 0xFC, 0x07, 0x00, 0x1F, 0x80, 0xC0, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0C,
  0x00, 0x03, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x1F,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x3C, 0x00,
  0xFF, 0x0E, 0x00, 0x0F, 0xF1, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x80, 0x07,
  0xC7, 0xF0, 0x01, 0xF0, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x03, 0xE0, 0x0F, 0xC0, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0x81, 0xF8, 0x03, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0xC0, 0x78, 0x03, 0xF0,
  0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x01,
  0xF0, 0xFE, 0x00, 0x38, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xFE, 0x07,
  0xF1, 0x9F, 0xC1, 0xFC, 0x81, 0xF8, 0x7F, 0x60, 0x7F, 0x1F, 0xD0, 0x0F,
  0xE7, 0xFC, 0x03, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x07, 0xF7, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F,
  0x9F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7C, 0x3F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x07,
  0xC0, 0x78, 0x00, 0xFC, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xE0, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xC1,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0xF1, 0xF8, 0x00,
  0x1E, 0x3F, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0xF0, 0x7F, 0x80, 0x1E, 0x0F,
  0xF8, 0x07, 0x81, 0xFF, 0xC0, 0xE0, 0x1F, 0xFE, 0x38, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x6F, 0xFF, 0x80, 0x38, 0x3F, 0xF8, 0x0E, 0x03, 0xFF,
  0x03, 0x80, 0x1F, 0xF0, 0xF0, 0x01, 0xFE, 0x3C, 0x00, 0x1F, 0xE7, 0x80,
  0x01, 0xFC, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3C, 0x3F, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x1F,
  0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3E, 0x00, 0x7F, 0x1F, 0x80,
  0x1F, 0xC7, 0xE0, 0x07, 0xF9, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x00,
  0x7F, 0xDF, 0xC0, 0x1F, 0xF7, 0xF8, 0x0B, 0xF8, 0xFE, 0x02, 0xFE, 0x1F,
  0xC1, 0x3F, 0x83, 0xFF, 0x8F, 0xE0, 0x7F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x1C, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC,
  0x01, 0xF0, 0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x1E, 0x03, 0xF8, 0x0F, 0x80,
  0x7E, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x0C, 0x03, 0x01, 0xE0, 0xFC, 0xFF, 0xDF, 0xE3,
  0xE0, 0x70, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x01, 0xE0, 0xFC, 0xFF, 0xDF,
  0xE1, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x3C, 0x0F, 0xC7,
  0xFE, 0x7F, 0x87, 0xC0, 0x70, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1C,
  0x07, 0xC1, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x07, 0xE0, 0x78, 0x0F, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7C, 0x0F, 0xE1, 0xE0, 0x0F, 0xC7, 0x80,
  0x0F, 0xCE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xE3, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x60, 0x3C, 0x00, 0xC0, 0x7C, 0x01, 0x00, 0x7C, 0x06, 0x00, 0x7C,
  0x38, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x40, 0x00, 0x7C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x1F, 0x00, 0x00,
  0x03, 0x81, 0xE0, 0x07, 0xDF, 0x3C, 0x3C, 0x01, 0xFF, 0xE1, 0xC3, 0xC0,
  0x3E, 0x7E, 0x1C, 0x7C, 0x07, 0xC7, 0xE1, 0xC7, 0x80, 0xF8, 0x7E, 0x1C,
  0x78, 0x1F, 0x07, 0xC1, 0xCF, 0x83, 0xF0, 0x7C, 0x1C, 0xF0, 0x3E, 0x0F,
  0xC1, 0xCF, 0x07, 0xE0, 0xF8, 0x3C, 0xF0, 0x7C, 0x0F, 0x83, 0xCF, 0x0F,
  0xC1, 0xF8, 0x38, 0xF0, 0xF8, 0x1F, 0x07, 0x8F, 0x0F, 0x83, 0xF0, 0x78,
  0xF0, 0xF8, 0x3F, 0x0F, 0x0F, 0x0F, 0x87, 0xF1, 0xE0, 0x78, 0xFD, 0xFF,
  0x3E, 0x07, 0x8F, 0xFD, 0xFF, 0xC7, 0x78, 0x7F, 0x9F, 0xF0, 0xF3, 0xC3,
  0xE0, 0xFC, 0x1E, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x0C, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x18, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x30, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x30, 0x00, 0x1F, 0xF8,
  0x3F, 0xC0, 0x60, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x60, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x60, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0xE0, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0xE0, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x78, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x3F, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x1F, 0xFC, 0x03, 0xF0,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0xC0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xC0, 0x3F, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x3F, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x1E, 0x00,
  0x3F, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x38, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0x00, 0x07, 0xFF, 0xC3,
  0x9F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0x87, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xCC, 0x0F, 0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0x20, 0x1F,
  0xF0, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0x80, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x70,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xC7, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x1C, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0xF8, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x0E, 0x00,
  0x00, 0x1F, 0x01, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x7C, 0x1F, 0xFF, 0x80,
  0x70, 0x00, 0x83, 0xE1, 0xFF, 0xFF, 0x00, 0xF0, 0x06, 0x0F, 0x9F, 0xFF,
  0xFE, 0x01, 0xF0, 0x70, 0x3C, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x21, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x03,
  0xE0, 0x60, 0xFF, 0x00, 0x0F, 0x80, 0x63, 0xFF, 0x90, 0x3E, 0x00, 0xCF,
  0xFF, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0x83, 0xF0, 0x01, 0xFF, 0xFE, 0x07,
  0xC0, 0x0E, 0x07, 0xF0, 0x1F, 0x80, 0x38, 0x03, 0xC0, 0x3F, 0x01, 0xE0,
  0x01, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x00, 0x3F,
  0xF0, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0xE0,
  0x00, 0x00, 0x7F, 0xF1, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0x00, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x80, 0x06, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0x1C, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x7C, 0x00,
  0x78, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x70, 0x00,
  0xF8, 0x00, 0x07, 0xF8, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0xE0, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0xFE, 0x60, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x60, 0x00,
  0xFF, 0xE0, 0x00, 0x7E, 0x60, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x60, 0x00,
  0x7F, 0xF8, 0x00, 0x3E, 0x30, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x30, 0x00,
  0x1F, 0xF8, 0x00, 0x1E, 0x18, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0x0C, 0x00,
  0x07, 0xFC, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0x03, 0xFF,
  0x81, 0xF8, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03,
  0xC2, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x07, 0x07,
  0xFF, 0xFF, 0x0F, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x18, 0x3F, 0xC0, 0x01, 0xF0, 0x0C, 0x7F, 0xF6,
  0x03, 0xE0, 0x04, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x0F, 0x80,
  0x07, 0x7F, 0xF8, 0x0F, 0x80, 0x1C, 0x0F, 0xE0, 0x1F, 0x80, 0x38, 0x01,
  0xC0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x03, 0x00,
  0xFF, 0x0F, 0xFC, 0x07, 0xC0, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xFF, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0xFF, 0x01, 0xFF, 0xE3, 0xFC, 0xFF, 0x00, 0xFF, 0xF0, 0xF8, 0xFF,
  0x00, 0x7F, 0xF8, 0x70, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0x00, 0x0F,
  0xFE, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x88,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x78, 0x00, 0x00, 0x87,
  0xF8, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x10,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x06, 0x07, 0x00,
  0x01, 0xFF, 0x00, 0x78, 0x18, 0x00, 0x0F, 0xFC, 0x07, 0xE0, 0xC0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC7, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x1C, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x60, 0x00, 0x3F, 0xFB, 0xFF, 0x01, 0xC0, 0x00, 0xFF,
  0xF3, 0xF0, 0x07, 0x81, 0xE3, 0xFF, 0x87, 0x00, 0x0F, 0xFC, 0x1F, 0xFC,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x3E, 0x0C,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x20, 0xFE, 0x00, 0x01, 0xF0, 0x01, 0x1F,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xCF, 0xFC,
  0x00, 0x7C, 0x00, 0x30, 0xFF, 0xE0, 0x0F, 0xC0, 0x06, 0x07, 0xFF, 0x01,
  0xF8, 0x01, 0xC0, 0x3F, 0xFC, 0x1F, 0x80, 0x78, 0x01, 0xFF, 0xC3, 0xF8,
  0x0F, 0x00, 0x07, 0xF8, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xF0, 0x3F,
  0x00, 0x01, 0xC0, 0x7F, 0x03, 0xF0, 0x00, 0x70, 0x07, 0xF0, 0x7F, 0x00,
  0x0E, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xF0, 0x3F, 0xE3, 0xFF, 0xF0,
  0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0x8F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x7F, 0xC0, 0x07, 0xF8, 0x07,
  0xF7, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xE3,
  0xFE, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0xE0, 0x03, 0xC0, 0x07, 0xE1, 0xFF,
  0x00, 0x78, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0x7F, 0x81,
  0xC0, 0x00, 0xF8, 0x03, 0xFC, 0x10, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x00,
  0x60, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC1, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0xFF,
  0x00, 0xF0, 0x00, 0x7E, 0x3F, 0xF0, 0x0E, 0x00, 0x0F, 0xCF, 0xFF, 0x03,
  0x80, 0x03, 0xF3, 0xFF, 0xF0, 0x60, 0x00, 0x7E, 0x07, 0xFF, 0xB8, 0x00,
  0x0F, 0x80, 0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0x00,
  0x03, 0xFF, 0xE6, 0x0F, 0x00, 0x01, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0xFF,
  0xF8, 0x1C, 0x00, 0x00, 0x3F, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00,
  0x1C, 0x00, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x0E, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x04, 0x7F, 0x80, 0x00,
  0xFE, 0x3E, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x02, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xE0, 0x00,
  0x00, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x00, 0x7C,
  0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x7F, 0xFF, 0xC0, 0x00, 0x78, 0xC3, 0xFF,
  0xE0, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x00,
  0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x03, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0x00, 0x07, 0xFF, 0xEE, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x80, 0x1C, 0x00,
  0x00, 0x07, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xC0, 0x04, 0x7F, 0xC0, 0x00, 0x1E, 0x0F, 0x9F, 0xF0, 0x00,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x07, 0xFC, 0x00, 0x00, 0x1C,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x81, 0xFF,
  0xFF, 0x00, 0x00, 0xE0, 0xC1, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFC,
  0x00, 0x18, 0x00, 0x07, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x1F, 0xFF, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0xFF, 0x00, 0x78, 0x00, 0x1F, 0x03, 0xFF, 0xC0, 0x38, 0x00, 0x3F,
  0x07, 0xFF, 0xE0, 0x3C, 0x00, 0x3F, 0x0F, 0xFF, 0xF0, 0x1C, 0x00, 0x7E,
  0x1F, 0x3F, 0xF8, 0x1E, 0x00, 0x7E, 0x1C, 0x0F, 0xFC, 0x0E, 0x00, 0x7E,
  0x18, 0x07, 0xFC, 0x0E, 0x00, 0xFF, 0x30, 0x03, 0xFE, 0x0E, 0x00, 0xFF,
  0x30, 0x03, 0xFE, 0x0E, 0x00, 0xFF, 0x20, 0x01, 0xFE, 0x0F, 0x00, 0x7F,
  0xA0, 0x01, 0xFF, 0x0E, 0x00, 0x7F, 0xA0, 0x00, 0xFF, 0xCE, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x8E, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x0E, 0x00, 0x3F,
  0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x3F, 0xF8, 0x00, 0x70, 0x18, 0x00, 0x1F,
  0xF8, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0xFC, 0x03, 0xE0, 0x60, 0x00, 0x0F,
  0xFE, 0x0F, 0xF1, 0xC0, 0x00, 0x07, 0xFE, 0x3F, 0xF9, 0x00, 0x00, 0x07,
  0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x1F, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x1F, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0E, 0x00, 0x7F, 0x80, 0x7F, 0xF8,
  0x0C, 0x00, 0x7F, 0xC0, 0xFF, 0xFC, 0x18, 0x00, 0x3F, 0xE0, 0x8F, 0xFE,
  0x30, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x0F,
  0xE0, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF1,
  0xFE, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0xFC, 0x7F, 0xC0, 0x00, 0x7E,
  0x3F, 0xF0, 0x00, 0x3E, 0x1F, 0xF8, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x1F,
  0x83, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x1F, 0x80, 0x7F, 0xE7, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x18, 0x07,
  0xFF, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xF8, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFE, 0x60, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xC0, 0x78, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x70, 0x00, 0xFF,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x30, 0x00, 0x3F, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x30, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x18, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC4, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE2, 0x00, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFD, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x60, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x30, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x30, 0x07, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x38, 0x03, 0xFF, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x38, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x3F,
  0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0xFC, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0xE0, 0xC0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x00, 0x60, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0x20, 0x1F, 0x00,
  0x1E, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x07, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC1, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60, 0x3F, 0xE0,
  0x00, 0x3F, 0x80, 0x31, 0xC0, 0x30, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x31,
  0xF8, 0x30, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x19, 0xFE, 0x18, 0x03, 0xFF,
  0x0C, 0x7F, 0xFE, 0x19, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x63, 0xFF, 0x99,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x20, 0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF9, 0xDF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x83, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x0E, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF3, 0x80, 0xFF, 0x03, 0xC0,
  0x0F, 0xFE, 0x60, 0x1F, 0xE0, 0x70, 0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x1C,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xC3, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x60, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF1, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x20, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x7E, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x03, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x07, 0x8F, 0xE0,
  0x0F, 0xC0, 0x0C, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x03, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0x3C, 0x00, 0x07,
  0xFF, 0x80, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x30, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x06, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x80, 0x7C, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x81,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x07, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x38, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x0E, 0x00, 0x1F, 0xF9, 0xC7, 0xFF, 0xE1, 0x80, 0x03, 0xFF, 0xF1, 0x8F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xFF,
  0x83, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC7,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE3, 0xFF, 0xFC, 0x00,
  0x00, 0x3E, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0x00, 0x00,
  0x3E, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x18, 0x01, 0xF9, 0x00,
  0x00, 0x03, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x7F, 0xFF, 0xE0, 0x00, 0x0C,
  0x04, 0x7F, 0xFF, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0x07, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x9F,
  0xF8, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x07, 0x00, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x01, 0x80, 0x00,
  0x3F, 0xE0, 0x7F, 0xF0, 0x0C, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xE0, 0x60,
  0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x83, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFE,
  0x18, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0xC2, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x18, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF8, 0x60, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE3, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x0E, 0x00, 0x63, 0xF8, 0x00, 0x07, 0xF8, 0x3C,
  0x0E, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x04,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC7, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0xF2, 0x00,
  0x07, 0xC7, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xCC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xF1, 0xFF, 0xFC, 0x30, 0x7F, 0xC3, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x60, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x80,
  0xFF, 0x80, 0x1F, 0x81, 0xFF, 0xF3, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x7F,
  0xF4, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x03, 0xC0,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x18, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFE, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0x01, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x03, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x1E, 0x00, 0x20, 0x3F, 0x1F, 0xF0, 0x00, 0x0E,
  0x00, 0xC0, 0x7E, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x3F, 0xE0,
  0x00, 0x01, 0xE0, 0x01, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0x80,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x06, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x1C, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x30, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xF0, 0xC0, 0x00, 0x3F, 0xF3, 0x04, 0x7F, 0xFB, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFE, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x07, 0xFF,
  0xFF, 0x80, 0x06, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x60, 0x00, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xFF,
  0x83, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x78, 0x08, 0x03, 0xFF, 0xFF, 0x8F,
  0x00, 0x81, 0xFF, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF, 0xFF, 0x87, 0x3E, 0x01,
  0xFF, 0xFF, 0x80, 0x37, 0xC0, 0x1F, 0xFF, 0xC0, 0x02, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0xFE,
  0x00, 0x00, 0x00, 0x06, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xC7, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFC, 0x37, 0x00, 0x00, 0x27, 0xFF, 0xFE, 0x60, 0x00, 0x0E,
  0x3F, 0xFF, 0xC6, 0x00, 0x01, 0xC0, 0xFF, 0xF8, 0x40, 0x00, 0x78, 0x03,
  0xFF, 0x0C, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0xC0, 0x00, 0xFC, 0x00, 0x30,
  0x04, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x37,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0xFF,
  0xC1, 0xE0, 0x00, 0x06, 0x1F, 0xFE, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x7C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x80, 0x1F, 0x03, 0x00,
  0x03, 0xC0, 0x0F, 0x80, 0x60, 0x03, 0xF0, 0x07, 0xC0, 0x18, 0x03, 0xF8,
  0x01, 0xF0, 0x06, 0x03, 0xFE, 0x00, 0xFC, 0x01, 0x83, 0xFF, 0x00, 0x3F,
  0x00, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x60, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xC0,
  0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xDF, 0xC0, 0x7F, 0xFF, 0xC0, 0xE7, 0xF0,
  0x30, 0x7F, 0xFC, 0xF1, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x71,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE2, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xB0, 0x1F, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x3C, 0x00,
  0x3F, 0xF8, 0x03, 0xFE, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x1C,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x8E, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x70, 0x00, 0x01, 0xFE, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x3F,
  0x80, 0x06, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x60,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x0C, 0x00, 0x20, 0x78, 0x03, 0xFC, 0x00, 0x30, 0x03, 0x07, 0xC0, 0x1F,
  0xF0, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x18, 0x7F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x80,
  0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x83, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x07, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x8E, 0x71, 0x83,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xD8, 0x1B, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0xF0, 0x0C, 0x00,
  0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x3F, 0xE0, 0x7C, 0x00,
  0x1F, 0xF8, 0x3C, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x0F, 0xF8, 0x3C, 0x00,
  0x1F, 0xE0, 0x70, 0x00, 0x07, 0xF8, 0x7C, 0x00, 0x1F, 0xF0, 0x60, 0x00,
  0x03, 0xFC, 0x7C, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x03, 0xFC, 0x7E, 0x00,
  0x0F, 0xFC, 0x60, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF0, 0x60, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x00, 0xFC, 0xFF, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x03, 0x00, 0x60, 0x00,
  0x00, 0xFC, 0x7F, 0xC0, 0x07, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x7F, 0xC0,
  0x0F, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x18, 0x00,
  0x00, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x0C, 0x00, 0x60, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x07, 0x01, 0x81, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xF8,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x03, 0x8F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1C, 0x04, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x20, 0x00, 0x00, 0x7F, 0xFC, 0xF7, 0xFF,
  0xE0, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x84, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0x81,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0xFE, 0x07, 0xFE, 0x3F, 0xFC,
  0x3E, 0x00, 0x7F, 0x8C, 0x7E, 0x1F, 0x00, 0x0F, 0xF2, 0x0F, 0x07, 0x80,
  0x01, 0xFD, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x60, 0x00,
  0x3F, 0xFF, 0xE0, 0x0C, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xC0, 0x8F, 0xFF,
  0xFC, 0x00, 0x3F, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x02, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xBF, 0xC0, 0x00, 0x00, 0x00,
  0x4F, 0xF8, 0x00, 0x01, 0xF0, 0x31, 0xFF, 0x00, 0x00, 0xFE, 0x0C, 0x7F,
  0xE0, 0x40, 0x7F, 0xE6, 0x1F, 0xFF, 0x78, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x43, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x71, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC8, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFB, 0x01, 0xFF, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x3C,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC1,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x30, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x8E, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF1, 0xC0, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xB8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF7, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x18, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x30, 0x00,
  0x81, 0xE0, 0x0F, 0xC0, 0x03, 0x80, 0x30, 0x7C, 0x03, 0xFC, 0x00, 0x3F,
  0x78, 0x0F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x40, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x18, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x0C, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0xE0,
  0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x38, 0x00,
  0x00, 0x7F, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x01, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0x80,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x1F, 0x03, 0xF8, 0x00,
  0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x7F, 0xFC, 0x00, 0x00, 0xF1,
  0xFF, 0xFC, 0x00, 0x01, 0xC6, 0x3F, 0xFC, 0x00, 0x03, 0x80, 0x1F, 0xFC,
  0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x1F, 0xFC, 0x00, 0x60,
  0x00, 0x1F, 0xFC, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x0C, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x8F, 0xC0, 0x3E, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x9E, 0x00, 0x07, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78,
  0x7E, 0x3F, 0x1F, 0xC7, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x01, 0xC0, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x09, 0xFF, 0x80, 0x06,
  0x3F, 0xFC, 0x07, 0x07, 0xFE, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x0F, 0xC0,
  0x78, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07,
  0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F,
  0x03, 0xFE, 0x1F, 0xEC, 0x7F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFE,
  0x3F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x00, 0xF8, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x20, 0x1C, 0x00,
  0x08, 0x3C, 0x00, 0x06, 0x3E, 0x00, 0x01, 0x3E, 0x00, 0x00, 0xDF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x7E, 0x03, 0x80, 0x3F,
  0x03, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xCF, 0xFC, 0x07, 0xFD, 0xFF, 0x03,
  0xF8, 0x7F, 0x81, 0xF8, 0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC,
  0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1E, 0x07, 0xE0,
  0x0F, 0x03, 0xF0, 0x0F, 0x03, 0xFC, 0x07, 0x01, 0xFF, 0x87, 0x01, 0xFF,
  0xF3, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x33, 0xF8, 0x07, 0x1F,
  0xC0, 0xE1, 0xFC, 0x1E, 0x0F, 0xC1, 0xE0, 0xFE, 0x3E, 0x07, 0xE3, 0xC0,
  0x70, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x30, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x23, 0xFF, 0x00, 0x60, 0x7F, 0x83, 0xF0, 0x1F, 0xE1, 0xF8,
  0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1,
  0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x78, 0x7E, 0x00, 0x3C, 0x3F, 0x00, 0x1E,
  0x1F, 0x80, 0x0E, 0x0F, 0xC0, 0x07, 0x07, 0xF0, 0x07, 0x07, 0xFC, 0x03,
  0x87, 0xFF, 0x81, 0x81, 0xFF, 0xF1, 0x80, 0x1F, 0xFD, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x03, 0x3F, 0x80, 0x71, 0xF8, 0x0E, 0x1F, 0xC1, 0xE0, 0xFC, 0x1E, 0x0F,
  0xE3, 0xE0, 0xFE, 0x3C, 0x07, 0xE7, 0xC0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0,
  0x38, 0x7C, 0x1E, 0x07, 0xC7, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC3,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x81, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x30, 0xF8, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x09, 0xFF,
  0xC0, 0x0E, 0x3F, 0xFC, 0x07, 0x03, 0xFF, 0x03, 0xC0, 0x7F, 0x81, 0xE0,
  0x07, 0xE0, 0x78, 0x00, 0x70, 0x3E, 0x00, 0x1C, 0x1F, 0x80, 0x0F, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xFF, 0xBF,
  0x81, 0xFF, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0x00, 0x7E, 0x03, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x07, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xFC, 0x00, 0xF0,
  0x1F, 0x00, 0x38, 0x07, 0xE0, 0x18, 0x00, 0xFC, 0x1C, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x10,
  0x3C, 0x00, 0x18, 0x3C, 0x00, 0x02, 0x3E, 0x00, 0x01, 0xBE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x08, 0x00, 0xFC, 0x0E, 0x00, 0x7E, 0x0F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x9F, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xE1,
  0xFE, 0x03, 0xF0, 0x7F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87,
  0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xE0, 0xFE, 0x31, 0xF0, 0xFF, 0xF0, 0xF0, 0x7F, 0xF0, 0x78, 0x0F, 0xF0,
  0x78, 0x03, 0xF0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xE0,
  0x7F, 0xF0, 0xFF, 0xF3, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xE0, 0x07, 0x80, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x86, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xF9, 0x00, 0xF8, 0xC0, 0x78, 0x30, 0x78, 0x08, 0x70, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x08, 0x07, 0x81, 0x03, 0xC0, 0x21,
  0xE0, 0x0C, 0xF8, 0x71, 0x7E, 0x3C, 0x7F, 0x9F, 0x0F, 0xCF, 0xC3, 0xF7,
  0xF0, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE1, 0x07, 0xFE, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0x08, 0x07, 0x01, 0x07, 0xC0, 0x23, 0xE0, 0x0C, 0xF8, 0x01, 0x7C, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE1, 0x07, 0xFE, 0x83, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x3F, 0x01, 0xF8,
  0x1F, 0x00, 0x3F, 0x83, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xFC, 0x7F, 0xF0,
  0x7F, 0xDD, 0xFE, 0xFF, 0xFC, 0x9F, 0xF0, 0xFF, 0x8F, 0xF8, 0x8F, 0xE0,
  0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xF1, 0x3F, 0xF1, 0xFF,
  0x83, 0xF9, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0x80, 0x3C, 0x00, 0xFC, 0x03, 0x00,
  0x18, 0x00, 0x78, 0x01, 0x00, 0x18, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xF3, 0xFF, 0xC1, 0xFF, 0xB7, 0xFF, 0x09, 0xFF, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x7F, 0x81, 0xFC, 0x07, 0xFE, 0x0F, 0xE6, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x3F,
  0x00, 0x30, 0x00, 0xF8, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xDF, 0xE0, 0x3F,
  0x0F, 0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0x07, 0xFC, 0x3F,
  0x03, 0xFC, 0x3F, 0x01, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3E, 0x3F,
  0x80, 0x3E, 0x3F, 0x80, 0x3C, 0x3F, 0x80, 0x38, 0x7F, 0xE0, 0x70, 0xFF,
  0xF0, 0x60, 0x7F, 0xFC, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0C, 0x03, 0xFC,
  0x03, 0xC0, 0x7F, 0xC0, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x9F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8,
  0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8,
  0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0,
  0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xF0, 0x07, 0xC3, 0xFE, 0x00,
  0xF0, 0xFF, 0xE0, 0x1C, 0x3F, 0xFF, 0x07, 0x07, 0xFF, 0xF8, 0xC0, 0xC7,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3E, 0x70, 0x00, 0x07, 0xC4, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xE0, 0x01, 0xBF, 0xF8, 0x03, 0x1F, 0xFF, 0x07, 0x07, 0xFE,
  0x0E, 0x03, 0xFC, 0x1E, 0x01, 0xFC, 0x3C, 0x01, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFE, 0x00, 0xF8, 0xFE, 0x00, 0xF8,
  0xFE, 0x00, 0xF8, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x80, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0xE3, 0xFC, 0x1F, 0xFE, 0xFC, 0x1F, 0xF8, 0xFC,
  0x0F, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0xFC, 0x01, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x08, 0x00, 0x00, 0xE0, 0x08, 0x1F, 0x01, 0xC1, 0xF8, 0x3C, 0x3F, 0xC7,
  0xE7, 0xFE, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0x7F, 0x07, 0xE3, 0xE0, 0x7E,
  0x3E, 0x07, 0xE1, 0xC0, 0x7E, 0x08, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x18, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x78, 0x02, 0x00, 0xFC, 0x06, 0x01, 0xFF, 0x0E, 0x07, 0xFF, 0xFE, 0x0C,
  0x7F, 0xFC, 0x18, 0x3F, 0xFC, 0x30, 0x0F, 0xF0, 0x30, 0x03, 0xE0, 0x70,
  0x00, 0x40, 0x78, 0x00, 0x80, 0x7C, 0x01, 0x80, 0x7E, 0x03, 0xC0, 0x7F,
  0x07, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xC3, 0xFC, 0x0F, 0x81, 0xFC, 0x07, 0x00, 0xFC, 0x06, 0x00, 0x7C, 0x04,
  0x00, 0x3C, 0x0C, 0x00, 0x38, 0x1F, 0x00, 0x38, 0x3F, 0xE0, 0x30, 0x7F,
  0xF8, 0x60, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x83,
  0xFE, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00, 0x70, 0x00, 0x60,
  0x07, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x09, 0xFC, 0x07, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x83, 0xFC, 0x83, 0xFE, 0x3F, 0xF6, 0x3F, 0xFF, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x3C, 0x00, 0x38, 0x03, 0xC0,
  0x0F, 0xC0, 0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x7F, 0x8F, 0xFF,
  0x07, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0,
  0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0xE0, 0x03, 0xFC, 0x1C, 0x00, 0x7F,
  0xE1, 0x80, 0x07, 0xFF, 0xB0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x0C, 0x00, 0x10, 0x3F, 0xC0, 0x1E, 0x00, 0x70, 0x7F, 0xC0, 0x7E,
  0x03, 0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0,
  0xFF, 0x33, 0xFF, 0x1F, 0xE0, 0xFF, 0xC3, 0xF8, 0x1F, 0xC0, 0xFF, 0x07,
  0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0x3F,
  0x87, 0xE0, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0x80, 0xFE, 0x07, 0xFC, 0x0C, 0x01, 0xFC, 0x1F, 0xFC,
  0x30, 0x07, 0xFC, 0x3F, 0xFE, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x7C,
  0x07, 0x01, 0xF8, 0x3C, 0x0F, 0xF1, 0xF8, 0x7F, 0xCF, 0xE1, 0xFF, 0xFF,
  0xC8, 0xFF, 0xFF, 0x03, 0xFC, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x87, 0x00,
  0x7E, 0x18, 0x01, 0xF8, 0x40, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE1, 0x00, 0x3F, 0xEC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0C, 0x1F, 0x00, 0x60, 0x38, 0x01,
  0x80, 0x40, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x18, 0x03, 0xE0, 0x38, 0x1F,
  0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x1F, 0xE0, 0x0C, 0x03,
  0xFE, 0x07, 0xC0, 0x7F, 0xC1, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7F, 0x98, 0x78,
  0x1F, 0xFE, 0x1F, 0x03, 0xFF, 0x83, 0xC0, 0x1F, 0xE0, 0x70, 0x00, 0xF8,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x83, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x04, 0x0C, 0x06, 0x07, 0x86, 0x07, 0xFB, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x19, 0xFE,
  0x0C, 0x3F, 0x83, 0x0F, 0xF1, 0x81, 0xFC, 0xE0, 0x7F, 0x30, 0x0F, 0xCC,
  0x03, 0xF7, 0x00, 0xFD, 0xC0, 0x3F, 0x60, 0x0F, 0xD8, 0x03, 0xF6, 0x00,
  0x7D, 0x80, 0x1E, 0x60, 0x07, 0x98, 0x03, 0xC7, 0x00, 0xF0, 0xC0, 0x38,
  0x30, 0x0C, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 12, 46, 14, 1, -45 },
  { 70, 22, 17, 25, 1, -44 },
  { 117, 28, 36, 32, 2, -40 },
  { 243, 21, 50, 26, 2, -47 },
  { 375, 40, 43, 44, 2, -44 },
  { 590, 32, 39, 36, 2, -38 },
  { 746, 10, 17, 12, 1, -44 },
  { 768, 14, 51, 15, 1, -49 },
  { 858, 14, 51, 15, 1, -49 },
  { 948, 21, 24, 22, 0, -46 },
  { 1011, 21, 22, 25, 2, -31 },
  { 1069, 10, 18, 11, 0, -10 },
  { 1092, 17, 12, 18, 2, -24 },
  { 1118, 10, 11, 12, 1, -10 },
  { 1132, 29, 49, 32, 2, -46 },
  { 1310, 27, 44, 29, 1, -43 },
  { 1459, 18, 42, 20, 1, -42 },
  { 1554, 26, 42, 28, 1, -42 },
  { 1691, 27, 43, 29, 1, -43 },
  { 1837, 27, 42, 28, 1, -42 },
  { 1979, 27, 43, 29, 1, -43 },
  { 2125, 26, 44, 28, 1, -44 },
  { 2268, 25, 42, 27, 1, -42 },
  { 2400, 27, 44, 29, 1, -44 },
  { 2549, 26, 44, 28, 1, -44 },
  { 2692, 10, 30, 12, 1, -29 },
  { 2730, 11, 37, 11, 0, -29 },
  { 2781, 17, 23, 18, 0, -29 },
  { 2830, 22, 13, 24, 1, -25 },
  { 2866, 17, 23, 18, 0, -29 },
  { 2915, 23, 45, 28, 2, -44 },
  { 3045, 36, 37, 38, 1, -29 },
  { 3212, 48, 45, 50, 1, -44 },
  { 3482, 54, 46, 55, 0, -45 },
  { 3793, 39, 46, 43, 2, -45 },
  { 4018, 48, 47, 50, 1, -45 },
  { 4300, 40, 46, 44, 2, -45 },
  { 4530, 45, 54, 47, 1, -46 },
  { 4834, 44, 47, 48, 2, -45 },
  { 5093, 43, 56, 46, 1, -48 },
  { 5394, 40, 53, 42, 1, -45 },
  { 5659, 42, 61, 44, 1, -45 },
  { 5980, 48, 45, 50, 1, -44 },
  { 6250, 33, 45, 35, 1, -44 },
  { 6436, 65, 47, 69, 2, -44 },
  { 6818, 51, 45, 55, 2, -44 },
  { 7105, 44, 45, 47, 1, -44 },
  { 7353, 53, 54, 55, 1, -44 },
  { 7711, 47, 49, 49, 1, -45 },
  { 7999, 55, 46, 58, 1, -45 },
  { 8316, 43, 45, 47, 2, -44 },
  { 8558, 44, 45, 46, 1, -44 },
  { 8806, 42, 47, 44, 1, -43 },
  { 9053, 53, 46, 55, 1, -45 },
  { 9358, 64, 46, 67, 1, -45 },
  { 9726, 42, 46, 45, 1, -45 },
  { 9968, 51, 55, 53, 1, -45 },
  { 10319, 39, 54, 41, 1, -45 },
  { 10583, 9, 49, 11, 1, -46 },
  { 10639, 38, 43, 7, -12, -40 },
  { 10844, 9, 49, 11, 1, -46 },
  { 10900, 23, 18, 26, 1, -44 },
  { 10952, 30, 4, 28, -1, 7 },
  { 10967, 9, 11, 31, 10, -43 },
  { 10980, 26, 34, 29, 1, -32 },
  { 11091, 25, 45, 28, 1, -43 },
  { 11232, 20, 32, 22, 1, -31 },
  { 11312, 25, 44, 28, 2, -43 },
  { 11450, 20, 33, 22, 1, -32 },
  { 11533, 19, 56, 15, -1, -46 },
  { 11666, 26, 45, 29, 1, -32 },
  { 11813, 25, 54, 27, 1, -43 },
  { 11982, 15, 44, 17, 1, -43 },
  { 12065, 17, 55, 15, -3, -44 },
  { 12182, 18, 45, 20, 1, -43 },
  { 12284, 18, 44, 17, 1, -43 },
  { 12383, 40, 33, 44, 2, -32 },
  { 12548, 29, 33, 31, 1, -32 },
  { 12668, 24, 33, 26, 0, -32 },
  { 12767, 27, 49, 28, 0, -37 },
  { 12933, 24, 45, 27, 1, -32 },
  { 13068, 20, 33, 23, 1, -32 },
  { 13151, 24, 40, 26, 1, -39 },
  { 13271, 17, 42, 19, 1, -40 },
  { 13361, 29, 33, 31, 1, -32 },
  { 13481, 28, 36, 28, -1, -35 },
  { 13607, 39, 38, 43, 2, -36 },
  { 13793, 22, 46, 24, 1, -33 },
  { 13920, 27, 48, 29, 1, -37 },
  { 14082, 18, 44, 21, 1, -33 },
  { 14181, 17, 49, 21, 1, -48 },
  { 14286, 4, 51, 10, 3, -48 },
  { 14312, 17, 49, 21, 1, -48 },
  { 14417, 20, 4, 23, 1, -20 },
};

const GFXfont UnifrakturMaguntia_Regular62pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular62pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular62pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR62PT7B_H_
