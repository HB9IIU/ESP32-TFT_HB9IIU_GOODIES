#ifndef _UNIFRAKTURMAGUNTIA_REGULAR33PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0x20, 0xC7, 0xBF, 0x79, 0xE7, 0x1C, 0x30, 0xC3, 0x0C, 0x20, 0x82,
  0x08, 0x00, 0x00, 0x08, 0x33, 0xE7, 0x08, 0x00, 0x04, 0x11, 0xC7, 0x7D,
  0xF3, 0x8E, 0x70, 0xC4, 0x11, 0x02, 0x20, 0x88, 0x20, 0x06, 0x30, 0x0C,
  0x60, 0x38, 0xC0, 0x71, 0x80, 0xE3, 0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x38,
  0x0C, 0x70, 0x18, 0xC0, 0x71, 0x87, 0xFF, 0xEF, 0xFF, 0xC3, 0x1C, 0x06,
  0x38, 0x0C, 0x70, 0x18, 0xC0, 0x31, 0x80, 0xE3, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x83, 0x0C, 0x40, 0x98, 0x1B, 0x07, 0x70, 0xEE, 0x0D, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0x81, 0xE0,
  0x34, 0x06, 0xC1, 0x8E, 0xE0, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x1C,
  0x00, 0x09, 0xDC, 0x00, 0x46, 0x30, 0x03, 0x38, 0xE0, 0x18, 0xE3, 0x80,
  0xC3, 0x8E, 0x06, 0x0E, 0x38, 0x30, 0x38, 0xE0, 0x80, 0xE3, 0x84, 0x01,
  0x8C, 0x20, 0x07, 0x71, 0x80, 0x07, 0x0C, 0x78, 0x00, 0x63, 0x30, 0x03,
  0x1C, 0xE0, 0x08, 0x73, 0x80, 0x43, 0xCE, 0x02, 0x0F, 0x3C, 0x18, 0x3C,
  0xF0, 0xC0, 0xF3, 0x86, 0x01, 0xCE, 0x30, 0x07, 0x38, 0x80, 0x0C, 0xC4,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0x30, 0x03, 0x8C, 0x01, 0xC6, 0x00,
  0xE3, 0x00, 0x73, 0x00, 0x39, 0x80, 0x1F, 0x00, 0x0F, 0x0F, 0x8F, 0xC3,
  0x8D, 0xE1, 0x8E, 0xF8, 0xC6, 0x3C, 0x47, 0x1F, 0x23, 0x87, 0xA1, 0xE3,
  0xF0, 0xF0, 0xF8, 0x3C, 0x3C, 0x5E, 0x1F, 0xC3, 0xF3, 0xC0, 0x01, 0x1D,
  0xF7, 0x98, 0xC4, 0x22, 0x00, 0x03, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x02, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x18, 0x10, 0x60, 0x04,
  0x01, 0xC0, 0xFE, 0x73, 0x77, 0x5C, 0xFF, 0x97, 0xD3, 0xAE, 0xE4, 0xE5,
  0xE0, 0x78, 0x02, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF,
  0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x21, 0x9F, 0x71,
  0x8C, 0x42, 0x20, 0x0F, 0x9F, 0x9E, 0x00, 0xE7, 0xE7, 0xE0, 0x10, 0xC7,
  0xCE, 0x10, 0x00, 0x02, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x07, 0x80, 0x73, 0x03, 0x86, 0x0E,
  0x1C, 0x78, 0x79, 0xC1, 0xEF, 0x07, 0xBC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x79,
  0xC1, 0xE7, 0x07, 0x8E, 0x1C, 0x38, 0x60, 0x63, 0x00, 0x78, 0x00, 0x02,
  0x00, 0x80, 0x60, 0x38, 0x1E, 0x0F, 0x85, 0xE2, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1F, 0x07, 0xC7, 0xFC, 0x07, 0xE0, 0x7F, 0xC3, 0x0F, 0x98, 0x1F, 0x40,
  0x3D, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x81, 0x0C, 0x04, 0x20, 0x11,
  0xFF, 0xCF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xE0, 0x61, 0xF0, 0x81,
  0xE2, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0xE0, 0x1F, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x70, 0x1E, 0xE0, 0x39, 0xE0, 0x73, 0xC1, 0xC3, 0x83, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x2E, 0x00, 0x9C,
  0x03, 0x38, 0x04, 0x70, 0x10, 0xE0, 0x61, 0xC0, 0x83, 0x82, 0x07, 0x04,
  0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF3, 0xC3, 0xFE,
  0x0F, 0xF0, 0x3F, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x2F, 0x81, 0xFF,
  0x87, 0xFF, 0x1F, 0xFE, 0x70, 0xF9, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFE, 0x03, 0xB8, 0x0E, 0xF0, 0x33, 0xC1, 0xC7, 0x0E, 0x07,
  0xE0, 0x07, 0xC0, 0x47, 0x06, 0x1C, 0x70, 0xF7, 0x07, 0xB8, 0x1D, 0xC0,
  0x1E, 0x00, 0xF1, 0x87, 0xBF, 0x3E, 0x1D, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x1E, 0xE0, 0xE3, 0x86, 0x0C,
  0x60, 0x3E, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0x80, 0x28, 0x02, 0x40,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0xC0, 0x86, 0x03, 0x18, 0x06, 0xE0, 0x1B,
  0x80, 0x6F, 0x03, 0x1F, 0x0C, 0x7F, 0x60, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x21, 0xF1, 0x83, 0xEC, 0x07, 0xB0, 0x0E, 0xC0, 0x1F, 0x00, 0x6C, 0x01,
  0xB0, 0x0E, 0x60, 0x30, 0xC1, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0xC6, 0x0C,
  0x38, 0xE1, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE1, 0xF7, 0x17, 0x9F, 0xBC, 0x31, 0xE0, 0x0F, 0x00, 0x77,
  0x03, 0xBC, 0x1D, 0xE1, 0xC7, 0x0C, 0x1C, 0x40, 0x7C, 0x00, 0x00, 0xC7,
  0x9F, 0x30, 0x80, 0x00, 0x00, 0x00, 0x04, 0x31, 0xF3, 0x84, 0x00, 0xC7,
  0x9F, 0x30, 0x80, 0x00, 0x00, 0x00, 0x08, 0x31, 0xEB, 0x86, 0x18, 0x41,
  0x08, 0x01, 0x81, 0x81, 0x83, 0x83, 0x83, 0xC3, 0xE0, 0x70, 0x1C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x1E, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x00, 0x1F, 0xC3, 0x87, 0x18, 0x1D, 0x80, 0xEE, 0x07, 0x78,
  0x3D, 0xC1, 0xE0, 0x1E, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0,
  0x1C, 0x00, 0xC0, 0x87, 0x08, 0x1C, 0x40, 0x7C, 0x00, 0x00, 0x04, 0x00,
  0x30, 0x03, 0xC0, 0x1C, 0x00, 0x40, 0x01, 0xF8, 0x01, 0xC1, 0xC0, 0x60,
  0x0C, 0x18, 0x00, 0xC7, 0x00, 0x08, 0xC1, 0xF9, 0xB0, 0xE7, 0x36, 0x38,
  0xE6, 0xC7, 0x38, 0xD9, 0xC7, 0x13, 0x38, 0xE6, 0x67, 0x39, 0x8C, 0xEF,
  0x31, 0x8E, 0xF8, 0xD8, 0x00, 0x33, 0x00, 0x0C, 0x38, 0x03, 0x01, 0x81,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF8, 0x01, 0x8F, 0xFE,
  0x03, 0x8C, 0x1F, 0x87, 0x84, 0x07, 0xEF, 0xC4, 0x01, 0xF1, 0xE2, 0x00,
  0x78, 0xF1, 0x00, 0x3C, 0x78, 0x80, 0x1E, 0x3C, 0x70, 0x0F, 0x1E, 0x3F,
  0x07, 0x8F, 0x0F, 0xC3, 0x87, 0x83, 0xE1, 0xC3, 0xC0, 0x71, 0xC1, 0xE0,
  0x18, 0xC0, 0xF0, 0x08, 0xC0, 0x78, 0x00, 0xC0, 0x3C, 0x00, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xFE, 0x0F, 0x81, 0xFF, 0x8F, 0xC8, 0x0F, 0xFD,
  0xF8, 0x03, 0xFC, 0x78, 0x00, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x1C, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xFF, 0x33, 0xE0, 0x7D, 0xFD,
  0x0F, 0x07, 0x01, 0xF0, 0x7C, 0x30, 0x0F, 0x81, 0xE1, 0x00, 0x3C, 0x0F,
  0x18, 0x00, 0xE0, 0x7C, 0xC0, 0x07, 0x01, 0xC2, 0x00, 0x38, 0x18, 0x18,
  0x01, 0xC3, 0xF0, 0xC0, 0x8E, 0xFF, 0xC3, 0x8C, 0x69, 0xFF, 0x03, 0x86,
  0x00, 0xF8, 0x00, 0x20, 0x03, 0xC0, 0x02, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x78, 0x07, 0xC0, 0x03, 0x80, 0xFF, 0x00, 0x1C, 0x09, 0xFC, 0x00, 0xC0,
  0x07, 0xF0, 0x04, 0x00, 0x1F, 0xE0, 0x40, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0x00, 0x71, 0x1E, 0x07,
  0x05, 0xFE, 0x70, 0x3F, 0xE3, 0x82, 0x0C, 0x3C, 0x60, 0x01, 0xC7, 0x00,
  0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0xC0, 0x3C, 0x7F, 0x01, 0xE1,
  0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xF0,
  0x7C, 0x07, 0x01, 0xF0, 0x30, 0x0F, 0xC3, 0x00, 0x3F, 0x20, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x1C, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x3F,
  0xC3, 0x81, 0x87, 0xE3, 0x81, 0x80, 0xF9, 0x81, 0xC0, 0x3E, 0x81, 0xE0,
  0x0F, 0x40, 0xF8, 0x03, 0xA0, 0x3F, 0x01, 0xD0, 0x1F, 0x80, 0x78, 0x07,
  0xE0, 0x3A, 0x01, 0xF0, 0x1C, 0xC0, 0x78, 0x06, 0x1F, 0x1C, 0x02, 0x00,
  0x0C, 0x01, 0x00, 0x04, 0x01, 0x80, 0x74, 0x00, 0x80, 0xFE, 0x00, 0x41,
  0xFF, 0xC0, 0x41, 0x9F, 0xF8, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0x00, 0x38, 0x8F, 0x01, 0xC1, 0x7F,
  0x8E, 0x07, 0xFC, 0x38, 0x20, 0xC1, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x78, 0x00, 0xF1, 0xE0, 0xC3, 0xC7, 0xE7, 0xAF, 0x1F, 0xFF, 0xBC, 0x3F,
  0xBC, 0xF0, 0x7E, 0x23, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x1E, 0x03, 0xE0,
  0x7C, 0x07, 0x00, 0xF8, 0x18, 0x03, 0xF0, 0xC0, 0x07, 0xE4, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x97, 0x81, 0xFF,
  0xCC, 0x01, 0xFF, 0x30, 0x02, 0x38, 0x60, 0x0C, 0x20, 0x80, 0x38, 0x01,
  0x00, 0x78, 0x12, 0x00, 0xF8, 0x76, 0x01, 0xF9, 0xF4, 0x01, 0xF7, 0xEC,
  0x03, 0xFB, 0x8C, 0x13, 0xF2, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xE0, 0x38,
  0x07, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1C, 0x07, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x1E, 0x07,
  0x00, 0x1C, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x80, 0x07, 0x31,
  0xC0, 0x0C, 0x0B, 0xE0, 0x1C, 0x0D, 0xF0, 0x38, 0x10, 0xF8, 0x38, 0x20,
  0x7C, 0x70, 0xE0, 0x38, 0x71, 0xE0, 0x30, 0xF1, 0xE0, 0x40, 0xF1, 0xF1,
  0xF8, 0xF1, 0xF3, 0xFC, 0xF0, 0xF8, 0x7C, 0xF0, 0x7C, 0x3E, 0xF0, 0x7E,
  0x1E, 0xF8, 0x3E, 0x1E, 0xF8, 0x1E, 0x0E, 0x78, 0x0E, 0x0E, 0x7C, 0x0E,
  0x0E, 0x3C, 0x0C, 0x0E, 0x3E, 0x10, 0x1C, 0x1F, 0x20, 0x1C, 0x0F, 0x80,
  0x38, 0x07, 0xC0, 0x60, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0x0F, 0xC0, 0x02, 0x07, 0x80, 0x06, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x40, 0x0F, 0x01, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xCF,
  0xF8, 0x07, 0xD8, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8,
  0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x08, 0x38,
  0x0E, 0x3C, 0x18, 0x1E, 0x7E, 0x10, 0x1E, 0x9F, 0xA0, 0x1C, 0x0F, 0xC0,
  0x18, 0x07, 0x80, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x70, 0x7F, 0x03, 0x01, 0xFF, 0x30, 0x07, 0xF1, 0x80,
  0x07, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0xC0,
  0x60, 0x1F, 0x01, 0x80, 0xF8, 0x07, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x1F, 0x00, 0x39, 0xFC, 0x01, 0xD3, 0xF0, 0x0C, 0x0F, 0xC0,
  0x40, 0x3F, 0x84, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0E, 0x0F, 0xE0, 0x70, 0x1F, 0xF1, 0x80,
  0x3F, 0x86, 0x00, 0x1C, 0x10, 0x00, 0x60, 0x40, 0x03, 0x01, 0x00, 0x1C,
  0x06, 0x00, 0x78, 0x08, 0x01, 0xE0, 0x10, 0x07, 0x80, 0x3B, 0xDF, 0x00,
  0x10, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xF8, 0x00, 0xC7, 0xF0, 0x03, 0x27,
  0xE0, 0x18, 0x0F, 0xC0, 0x40, 0x1F, 0xC2, 0x00, 0x3F, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x01, 0xC3, 0x83, 0x00, 0xE3, 0xF8, 0x60, 0x39, 0xFF, 0x18,
  0x1E, 0x43, 0xE3, 0x07, 0xA0, 0x78, 0xC1, 0xE8, 0x1F, 0x30, 0x7E, 0x07,
  0xEC, 0x1F, 0x80, 0xE2, 0x03, 0xE0, 0x31, 0x80, 0xFC, 0x18, 0xC0, 0x1F,
  0x9F, 0x40, 0x03, 0xFB, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xC7, 0xC0, 0x70, 0x60, 0xF0, 0x7E, 0x10, 0x3E, 0x27, 0xCC, 0x07,
  0xD0, 0xFC, 0x01, 0xF8, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xFC, 0x06, 0x07, 0x06, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0x3B, 0xC0, 0x1D,
  0xE0, 0x0E, 0xF8, 0x07, 0x7E, 0x07, 0x9F, 0x03, 0x8F, 0xBF, 0x83, 0xE2,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0F,
  0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x10, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0xF0, 0x7C, 0x03, 0xFE, 0x7F, 0x9F, 0xC0, 0xFF,
  0xEF, 0xF4, 0x7C, 0x38, 0xFE, 0x1F, 0x87, 0x8C, 0x07, 0xE1, 0xF0, 0xF1,
  0x00, 0x7C, 0x1E, 0x1F, 0x20, 0x07, 0xC3, 0xC1, 0xE4, 0x00, 0x78, 0x78,
  0x3E, 0x80, 0x0F, 0x07, 0x83, 0x90, 0x01, 0xE0, 0xF0, 0x43, 0x18, 0x1C,
  0x1C, 0x10, 0x3F, 0xC3, 0x83, 0x86, 0x03, 0xF8, 0x70, 0x71, 0x80, 0x01,
  0x0E, 0x0E, 0x70, 0x00, 0x01, 0x81, 0xCE, 0x00, 0x00, 0x30, 0x31, 0xC0,
  0x00, 0x06, 0x06, 0x3C, 0x00, 0x00, 0x80, 0x87, 0x80, 0x3C, 0x26, 0x10,
  0xF0, 0x1F, 0x85, 0xE4, 0x1F, 0x37, 0xF9, 0x7F, 0x81, 0xFC, 0x0F, 0xDF,
  0xE0, 0x1F, 0x01, 0xF0, 0x78, 0x01, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x07, 0xFE, 0x1F, 0xE1, 0xFF,
  0xE2, 0x7C, 0x30, 0x7E, 0x87, 0xCC, 0x07, 0xE0, 0x79, 0x00, 0x7C, 0x0F,
  0x20, 0x07, 0xC1, 0xF4, 0x00, 0x78, 0x1F, 0x80, 0x0F, 0x03, 0x90, 0x00,
  0xE0, 0x41, 0xBC, 0x1C, 0x18, 0x3F, 0xC3, 0x86, 0x03, 0xF8, 0x70, 0xC0,
  0x01, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x06,
  0x3C, 0x00, 0x01, 0x87, 0xC0, 0x3C, 0x30, 0x78, 0x1F, 0xCC, 0x0F, 0x94,
  0xFF, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x63, 0xFE, 0x03, 0x00, 0xFE, 0x0C, 0x00, 0x7E, 0x30, 0x00, 0x7C,
  0xE0, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xF0, 0x00, 0x77, 0xF8, 0x00, 0xF7,
  0xFC, 0x00, 0xE7, 0xF8, 0x01, 0xC3, 0xF8, 0x03, 0x00, 0xE0, 0x06, 0x00,
  0xC0, 0x0C, 0x11, 0x00, 0x18, 0xFC, 0x00, 0x23, 0xFC, 0x00, 0x8B, 0xFC,
  0x02, 0x01, 0xFE, 0x08, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x06, 0x00, 0xFF, 0xC0, 0xE0, 0x0F, 0xFF, 0x1F, 0x00,
  0xE0, 0xFF, 0x7C, 0x04, 0x03, 0xE3, 0xE0, 0x20, 0x0F, 0x1F, 0x83, 0x00,
  0x7C, 0x7F, 0x08, 0x03, 0xE1, 0xFC, 0x40, 0x0F, 0x07, 0xE2, 0x00, 0x78,
  0x1F, 0x88, 0x03, 0xC0, 0x7C, 0x31, 0x9E, 0x01, 0xF0, 0x70, 0xF0, 0x07,
  0x80, 0x07, 0x80, 0x18, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00,
  0x0E, 0x00, 0x20, 0x00, 0xF0, 0x01, 0x00, 0x1F, 0xE0, 0x10, 0x01, 0xFF,
  0x81, 0x00, 0x18, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1B, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x63, 0xFE, 0x00, 0xC0, 0x3F, 0x80, 0xC0, 0x07, 0xE0, 0xC0, 0x01, 0xF0,
  0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x3F, 0x00, 0x07, 0x1F, 0xE0, 0x03,
  0xC7, 0xFC, 0x00, 0xE1, 0xFE, 0x00, 0x70, 0x3F, 0x80, 0x30, 0x03, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x04, 0x40, 0x46, 0x0F, 0xC0, 0x7A, 0x0F, 0xF0,
  0xFE, 0x0B, 0xFC, 0x8F, 0x90, 0x7F, 0x83, 0xF8, 0x0F, 0xFE, 0xF8, 0x01,
  0xFC, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x07, 0xFE, 0x1F, 0xC0, 0x7F, 0xF9, 0x1F, 0x07,
  0x1F, 0xF0, 0x7C, 0x70, 0x1F, 0x83, 0xE3, 0x00, 0x7C, 0x1F, 0x10, 0x01,
  0xE0, 0x7E, 0x80, 0x0F, 0x01, 0xE4, 0x00, 0x38, 0x04, 0x20, 0x01, 0xE0,
  0xC1, 0x80, 0x0F, 0x18, 0x04, 0x00, 0x79, 0xE0, 0x18, 0x21, 0xFF, 0x00,
  0x3E, 0x0C, 0x7C, 0x00, 0x00, 0x61, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x30, 0x7C, 0x00, 0x01, 0x83, 0xE0, 0x1E, 0x08, 0x0F, 0x01, 0xF8, 0x80,
  0x7C, 0x17, 0xEC, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x10, 0x1F, 0xFF, 0xC0, 0xC0, 0xFF, 0x03, 0x00, 0x7C, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x07, 0xC3, 0x00, 0x3F, 0xE6,
  0x11, 0xFF, 0xEE, 0x1F, 0xF8, 0x5C, 0x1F, 0xC0, 0x78, 0x1E, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x02, 0xF0, 0x00, 0x0D, 0xF8, 0x00, 0x31, 0xFC,
  0x00, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x01, 0xC1, 0xFF, 0x02, 0x00, 0xFF,
  0x08, 0x01, 0x7F, 0xF0, 0x04, 0x3F, 0x20, 0x38, 0x3C, 0x40, 0x70, 0x00,
  0x80, 0xF0, 0x00, 0x81, 0xF0, 0x01, 0x83, 0xF8, 0x00, 0xFB, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0x83, 0xC0, 0x1F, 0x83, 0x80, 0x7F,
  0x8C, 0x01, 0x3F, 0xA0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x40, 0x1F,
  0xC1, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x08, 0x71,
  0x00, 0xC3, 0x82, 0x0E, 0x0E, 0x10, 0xF8, 0x78, 0x47, 0xE1, 0xF0, 0x07,
  0x87, 0xE0, 0x1E, 0x0F, 0xC0, 0x78, 0x3F, 0x01, 0xE0, 0x7E, 0x07, 0x80,
  0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x0C, 0x07, 0x80, 0x60,
  0x1E, 0x01, 0x00, 0x78, 0x08, 0x01, 0xE0, 0x78, 0x07, 0x87, 0xF0, 0x3E,
  0x3F, 0xE3, 0x78, 0x0F, 0xF9, 0xFC, 0x1F, 0xC7, 0xC0, 0x3E, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x03, 0xFE, 0x1F, 0x80,
  0xFF, 0xE4, 0xF8, 0x3F, 0xFF, 0x0F, 0x8E, 0x07, 0xE0, 0xF1, 0x80, 0x7C,
  0x1F, 0x20, 0x07, 0x81, 0xF4, 0x00, 0x70, 0x18, 0x80, 0x0E, 0x02, 0x10,
  0x01, 0xC0, 0x83, 0x00, 0x38, 0x38, 0x20, 0x47, 0x07, 0x03, 0x10, 0xC1,
  0xF0, 0x1C, 0x10, 0x1F, 0x00, 0x06, 0x03, 0xF0, 0x01, 0x80, 0x3F, 0x00,
  0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x38, 0x3F, 0xE0, 0x07, 0x0C, 0xFE, 0x00,
  0xC0, 0x0F, 0xE0, 0x10, 0x00, 0xFF, 0x04, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x71, 0xFC, 0x03, 0xFF, 0xB6, 0x8F, 0xC1, 0xFF, 0xF8, 0x41, 0xF0, 0x70,
  0x7E, 0x30, 0x3E, 0x30, 0x0F, 0x8C, 0x0F, 0x88, 0x01, 0xE7, 0x01, 0xF2,
  0x00, 0x39, 0xC0, 0x3E, 0x80, 0x0E, 0x78, 0x04, 0x20, 0x03, 0x9F, 0x02,
  0x08, 0x00, 0xE7, 0xC1, 0x81, 0x00, 0x38, 0xF8, 0xF0, 0x30, 0x8C, 0x3E,
  0x3E, 0x03, 0xC3, 0x07, 0x8F, 0xC0, 0x01, 0x81, 0xE1, 0xF8, 0x00, 0x40,
  0x38, 0x3E, 0x00, 0x20, 0x0E, 0x07, 0x81, 0xF0, 0x03, 0x00, 0xE0, 0xFE,
  0x00, 0xE0, 0x18, 0x4F, 0xC0, 0x3C, 0x04, 0x21, 0xF8, 0x1F, 0x81, 0x00,
  0x3F, 0x9F, 0xF0, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0x93, 0xFF,
  0x1F, 0xDF, 0xFC, 0x7E, 0xE0, 0xFB, 0x73, 0x01, 0xE8, 0x0C, 0x03, 0xC0,
  0x20, 0x0F, 0x00, 0x80, 0x1C, 0x01, 0x00, 0x70, 0x04, 0x03, 0xFF, 0x0C,
  0x5F, 0xF8, 0x0E, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x05, 0xF0, 0x07, 0x13, 0xC0,
  0x3E, 0xCF, 0xC8, 0xFE, 0x1F, 0xC7, 0xF8, 0x7E, 0x03, 0xC0, 0x70, 0x03,
  0x80, 0x38, 0x07, 0xFC, 0x3F, 0x83, 0xFF, 0x93, 0xF1, 0xFF, 0xF8, 0x7C,
  0xE0, 0x7E, 0x0F, 0x30, 0x0F, 0x83, 0xE8, 0x01, 0xE0, 0xFA, 0x00, 0x38,
  0x1F, 0x80, 0x0E, 0x03, 0xA0, 0x03, 0x80, 0x8C, 0x00, 0xE0, 0xE1, 0x02,
  0x38, 0x78, 0x3B, 0x0C, 0x1E, 0x01, 0x03, 0x0F, 0x80, 0x01, 0x81, 0xF0,
  0x00, 0x60, 0x7C, 0x00, 0x30, 0x1F, 0x80, 0x08, 0x03, 0xE0, 0x06, 0x00,
  0x7C, 0x03, 0xC2, 0x1F, 0x01, 0xFF, 0x07, 0xC0, 0xFF, 0xC1, 0xF0, 0x07,
  0xE0, 0x78, 0x00, 0x70, 0x1E, 0x04, 0x00, 0x07, 0x00, 0x80, 0x03, 0x80,
  0x10, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xC0, 0xFC, 0x18, 0x03, 0xC1, 0x00,
  0x1E, 0x10, 0x01, 0xE1, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xC0, 0x38, 0x07,
  0x02, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x18, 0x00, 0x77, 0xE0, 0x06, 0xFF, 0x00, 0x61, 0xF8, 0x04, 0x0F, 0xC0,
  0x80, 0x7F, 0x30, 0x01, 0xFC, 0x00, 0x06, 0x00, 0xFE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0xFF, 0x04, 0x00,
  0xE0, 0x0F, 0x01, 0xF8, 0x3B, 0x87, 0x0C, 0x60, 0x6C, 0x03, 0x80, 0x10,
  0xFF, 0xFF, 0xFF, 0xFC, 0x67, 0x9C, 0x61, 0x84, 0x02, 0x00, 0x0C, 0x00,
  0x78, 0x07, 0xF8, 0x33, 0xF1, 0x83, 0x86, 0x0E, 0x38, 0x38, 0xE0, 0xE3,
  0x83, 0x8E, 0x0E, 0x3C, 0x38, 0xF0, 0xE1, 0xE3, 0x87, 0xDF, 0x8F, 0xBC,
  0x18, 0x70, 0x40, 0x80, 0x01, 0x04, 0x70, 0x26, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xE1, 0x07, 0x18, 0x39, 0xE1, 0xFF, 0x8E, 0x3C, 0x70, 0xF3,
  0x87, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x31, 0xC1, 0x8E, 0x18, 0xF8,
  0x8F, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x40, 0x01, 0x03, 0xC1, 0x78, 0x8E,
  0x63, 0xF8, 0x4E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0xE4, 0xFE, 0x1E, 0x02, 0x00, 0x20, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x0F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x4F, 0x8E, 0x1E,
  0x70, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x03, 0x38, 0x19, 0xC0, 0x9E,
  0x0C, 0xFC, 0x4B, 0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0x03, 0xC1,
  0x78, 0x8E, 0x63, 0xB8, 0xFE, 0x1F, 0x8C, 0xFC, 0x38, 0x0E, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0xE4, 0xFE, 0x1E, 0x02, 0x00, 0x00, 0x07, 0x91, 0xF8,
  0xFE, 0x20, 0x08, 0x02, 0x00, 0xE0, 0x7F, 0x2F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x78, 0x07, 0xFC, 0x31, 0xF9, 0xC3, 0xC6, 0x02, 0x38, 0x18, 0xE0,
  0xE3, 0x83, 0x8E, 0x0E, 0x3C, 0x3C, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x0F,
  0xDE, 0x38, 0x78, 0x80, 0xE0, 0x03, 0x80, 0x0C, 0x60, 0x71, 0xC1, 0x83,
  0x88, 0x03, 0xC0, 0x03, 0x84, 0x60, 0x26, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE2, 0x07, 0x38, 0x3B, 0xE1, 0xEF, 0x0E, 0x3C, 0x70, 0xE3, 0x87,
  0x9C, 0x3C, 0xE1, 0xE7, 0x0F, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0xF0, 0xE7,
  0xE6, 0x7E, 0x30, 0x63, 0x02, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x0C, 0x1E, 0x1C, 0x1C, 0x00, 0x00, 0x10, 0x38, 0x3C,
  0x7E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F,
  0x1E, 0x0E, 0x04, 0x07, 0x03, 0xC0, 0xF0, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x38, 0x1F, 0x8B, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xC8, 0x61, 0xE0, 0x00, 0x03, 0xC6, 0x26, 0x0F, 0x37, 0xB9, 0xFC, 0xF0,
  0x70, 0x7F, 0xFF, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x27, 0xE0, 0xF0, 0x30, 0x10, 0x03, 0xC6, 0x26, 0x0F, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x27, 0xE0, 0xF0, 0x30, 0x10, 0x20, 0x41,
  0x01, 0xE3, 0x8F, 0x07, 0x9F, 0x7F, 0x2F, 0x9E, 0x7C, 0x3C, 0x70, 0xE0,
  0xF1, 0xC3, 0x83, 0xC7, 0x0E, 0x0F, 0x1C, 0x38, 0x3C, 0x70, 0xE0, 0xF1,
  0xC3, 0x83, 0xC7, 0x0E, 0x0F, 0x1C, 0x38, 0x3C, 0x70, 0xE0, 0xF1, 0xE3,
  0x87, 0xEF, 0x8F, 0x8E, 0x1C, 0x1E, 0x18, 0x30, 0x70, 0x40, 0x80, 0x00,
  0x20, 0x80, 0xE1, 0x81, 0xE7, 0xC7, 0xD7, 0xE3, 0xC7, 0x87, 0x0E, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0xC7,
  0x07, 0x8F, 0x1F, 0x9F, 0x9C, 0x1E, 0x18, 0x18, 0x20, 0x10, 0x00, 0x80,
  0x1E, 0x1F, 0xF0, 0xF7, 0xC7, 0x9F, 0x3C, 0x79, 0xE1, 0xCF, 0x0F, 0x78,
  0x7B, 0xC1, 0xDE, 0x0E, 0xF0, 0x67, 0x86, 0x7E, 0x20, 0xFE, 0x01, 0xE0,
  0x06, 0x00, 0x20, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x3C, 0x08, 0xF8,
  0x61, 0xF7, 0xC3, 0xFF, 0x87, 0x1E, 0x1C, 0x3C, 0x70, 0xF1, 0xC1, 0xC7,
  0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0x9F, 0x06, 0xFE, 0x32, 0xFE, 0x81,
  0xFC, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x02, 0x00, 0x70, 0x0F, 0x81, 0x7E, 0x33, 0xF6,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF0, 0xEF,
  0x8E, 0x7F, 0xE3, 0xCE, 0x18, 0xE2, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x20, 0x9C, 0x67, 0xBF, 0xFF, 0x3D, 0xCE, 0x63,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x47, 0xF0, 0x78,
  0x0C, 0x02, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x01, 0x04, 0x10, 0xE1,
  0x3F, 0xF4, 0x7E, 0xC1, 0xCC, 0x08, 0xE1, 0x8F, 0x3C, 0x7F, 0xE7, 0x9E,
  0x30, 0xE2, 0x06, 0x70, 0x4F, 0xC4, 0x7F, 0x80, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x07, 0x07, 0xFF, 0xFE, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x23, 0xF0,
  0x7C, 0x06, 0x01, 0x00, 0x20, 0x20, 0xE0, 0x61, 0xE1, 0xE7, 0xC7, 0xE3,
  0x87, 0x87, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE1,
  0xC1, 0xC3, 0x83, 0x87, 0x07, 0x8F, 0x5F, 0xFF, 0x0F, 0x1E, 0x0C, 0x18,
  0x00, 0x00, 0x20, 0x01, 0x00, 0x04, 0x06, 0x38, 0x38, 0xF3, 0xF3, 0xF3,
  0xE7, 0x87, 0x9F, 0x0F, 0x3C, 0x3C, 0x70, 0x70, 0xC1, 0xC3, 0x07, 0x0C,
  0x18, 0x20, 0x61, 0x83, 0x07, 0x88, 0x3F, 0x40, 0x3E, 0x00, 0x30, 0x00,
  0x40, 0x60, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x11, 0xF0, 0xC1, 0x8F,
  0x8F, 0x3E, 0x3F, 0xFE, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x78,
  0x79, 0xE3, 0xC1, 0xCF, 0x1E, 0x0E, 0x78, 0x70, 0x73, 0xC3, 0x83, 0x1E,
  0x1C, 0x18, 0xF1, 0xE1, 0x87, 0x8F, 0xC8, 0x7E, 0xBF, 0x81, 0xE0, 0x78,
  0x06, 0x01, 0x80, 0x20, 0x04, 0x00, 0x30, 0x47, 0x19, 0xF7, 0xCF, 0x71,
  0xCE, 0x38, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3D, 0x0F, 0xC3, 0xF0, 0x8E, 0x10, 0x82, 0x00, 0x40, 0x04, 0x08, 0x47,
  0x87, 0xE0, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x10, 0xF8, 0xE3,
  0xEF, 0xC7, 0xCF, 0x0E, 0x1E, 0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x0F,
  0x38, 0x3C, 0xE0, 0xF3, 0xC3, 0x8F, 0x0E, 0x3C, 0x39, 0xFC, 0xC3, 0xC3,
  0x03, 0x18, 0x08, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x00, 0x08, 0x0F, 0x0F, 0x99, 0xE0, 0xE0, 0x70, 0x30, 0x21, 0x3A, 0x7F,
  0x0F, 0xC3, 0xE2, 0x7A, 0x3D, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x6C,
  0x32, 0x30, 0xF0, 0x01, 0x06, 0x0C, 0x18, 0x38, 0x38, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1C, 0x18, 0x30, 0xC0, 0x70, 0x38, 0x18, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x18, 0x0C, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x60, 0x30, 0x18, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x18,
  0x1C, 0x0E, 0x03, 0x0E, 0x1C, 0x18, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C,
  0x18, 0x38, 0x60, 0x80, 0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 24, 8, 1, -24 },
  { 19, 11, 10, 13, 1, -24 },
  { 33, 15, 19, 17, 1, -21 },
  { 69, 11, 27, 14, 1, -25 },
  { 107, 22, 23, 24, 1, -23 },
  { 171, 17, 20, 19, 1, -20 },
  { 214, 5, 10, 7, 1, -24 },
  { 221, 8, 27, 8, 0, -26 },
  { 248, 8, 27, 8, 0, -26 },
  { 275, 11, 12, 12, 0, -24 },
  { 292, 11, 12, 13, 1, -17 },
  { 309, 5, 9, 6, 0, -5 },
  { 315, 9, 6, 10, 1, -13 },
  { 322, 6, 5, 7, 0, -5 },
  { 326, 16, 26, 17, 1, -25 },
  { 378, 14, 23, 16, 1, -23 },
  { 419, 10, 23, 11, 0, -23 },
  { 448, 14, 22, 15, 0, -22 },
  { 487, 15, 22, 15, 0, -22 },
  { 529, 15, 22, 15, 0, -22 },
  { 571, 14, 24, 15, 1, -24 },
  { 613, 13, 23, 15, 1, -23 },
  { 651, 13, 22, 14, 1, -22 },
  { 687, 14, 23, 15, 1, -23 },
  { 728, 13, 23, 15, 1, -23 },
  { 766, 6, 16, 7, 0, -16 },
  { 778, 6, 20, 6, 0, -16 },
  { 793, 9, 12, 10, 0, -15 },
  { 807, 11, 7, 13, 1, -13 },
  { 817, 9, 12, 10, 0, -15 },
  { 831, 13, 24, 15, 1, -24 },
  { 870, 19, 19, 20, 1, -15 },
  { 916, 25, 25, 27, 1, -24 },
  { 995, 29, 25, 29, 0, -24 },
  { 1086, 21, 24, 23, 1, -24 },
  { 1149, 25, 25, 27, 1, -24 },
  { 1228, 22, 24, 23, 1, -24 },
  { 1294, 23, 28, 25, 1, -24 },
  { 1375, 24, 25, 25, 1, -24 },
  { 1450, 24, 31, 24, 0, -26 },
  { 1543, 21, 28, 23, 1, -24 },
  { 1617, 22, 32, 23, 1, -24 },
  { 1705, 26, 25, 27, 0, -24 },
  { 1787, 17, 24, 19, 1, -23 },
  { 1838, 35, 25, 37, 1, -23 },
  { 1948, 27, 24, 29, 1, -23 },
  { 2029, 23, 25, 25, 1, -24 },
  { 2101, 29, 29, 29, 0, -23 },
  { 2207, 25, 26, 26, 1, -24 },
  { 2289, 29, 25, 31, 1, -24 },
  { 2380, 23, 24, 25, 1, -24 },
  { 2449, 23, 23, 25, 1, -23 },
  { 2516, 22, 25, 24, 1, -23 },
  { 2585, 27, 25, 29, 1, -24 },
  { 2670, 34, 25, 36, 1, -24 },
  { 2777, 22, 24, 24, 1, -24 },
  { 2843, 26, 29, 28, 1, -24 },
  { 2938, 20, 28, 22, 1, -24 },
  { 3008, 4, 26, 6, 1, -24 },
  { 3021, 20, 24, 4, -6, -22 },
  { 3081, 4, 26, 6, 1, -24 },
  { 3094, 12, 9, 14, 1, -23 },
  { 3108, 15, 2, 15, 0, 4 },
  { 3112, 5, 6, 17, 5, -23 },
  { 3116, 14, 18, 15, 1, -17 },
  { 3148, 13, 24, 15, 1, -23 },
  { 3187, 10, 18, 12, 1, -17 },
  { 3210, 13, 24, 15, 1, -23 },
  { 3249, 10, 18, 12, 1, -17 },
  { 3272, 10, 29, 8, 0, -24 },
  { 3309, 14, 24, 15, 1, -17 },
  { 3351, 13, 29, 15, 1, -23 },
  { 3399, 8, 24, 9, 0, -23 },
  { 3423, 10, 29, 8, -2, -23 },
  { 3460, 9, 24, 11, 1, -23 },
  { 3487, 9, 24, 9, 1, -23 },
  { 3514, 22, 18, 23, 1, -17 },
  { 3564, 15, 18, 17, 1, -17 },
  { 3598, 13, 18, 14, 0, -17 },
  { 3628, 14, 27, 15, 0, -20 },
  { 3676, 12, 24, 14, 1, -17 },
  { 3712, 10, 18, 12, 1, -17 },
  { 3735, 12, 22, 14, 1, -21 },
  { 3768, 10, 22, 10, 0, -21 },
  { 3796, 15, 18, 17, 1, -17 },
  { 3830, 14, 20, 15, 0, -19 },
  { 3865, 21, 20, 23, 1, -19 },
  { 3918, 11, 24, 13, 1, -17 },
  { 3951, 14, 26, 15, 1, -20 },
  { 3997, 9, 23, 11, 1, -17 },
  { 4023, 8, 27, 11, 1, -26 },
  { 4050, 2, 28, 5, 2, -26 },
  { 4057, 8, 27, 11, 1, -26 },
  { 4084, 10, 2, 12, 1, -11 },
};

const GFXfont UnifrakturMaguntia_Regular33pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular33pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular33pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR33PT7B_H_
