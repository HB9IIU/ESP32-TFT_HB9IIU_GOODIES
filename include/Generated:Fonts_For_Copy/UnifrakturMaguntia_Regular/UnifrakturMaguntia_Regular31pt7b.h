#ifndef _UNIFRAKTURMAGUNTIA_REGULAR31PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0x21, 0xCF, 0xBE, 0x71, 0xC7, 0x1C, 0x30, 0x82, 0x08, 0x20, 0x82,
  0x00, 0x00, 0x82, 0x1E, 0xF0, 0x80, 0x20, 0x98, 0x6F, 0xBD, 0xE7, 0x30,
  0xCC, 0x32, 0x08, 0x84, 0x0E, 0x70, 0x39, 0xC0, 0xC6, 0x03, 0x18, 0x0C,
  0x61, 0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0x8C, 0x3F,
  0xFE, 0xFF, 0xF8, 0x63, 0x01, 0x8C, 0x0E, 0x30, 0x39, 0xC0, 0xE7, 0x00,
  0x04, 0x00, 0x80, 0x10, 0x0F, 0x83, 0x18, 0xC1, 0x98, 0x33, 0x06, 0x70,
  0xCF, 0x01, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF6, 0x0F, 0xE0, 0xF8,
  0x1F, 0x03, 0x20, 0x62, 0x18, 0x3E, 0x01, 0x00, 0x20, 0x04, 0x00, 0x3C,
  0x00, 0x16, 0x60, 0x02, 0x67, 0x00, 0x4E, 0x70, 0x0C, 0xE7, 0x01, 0x8E,
  0x38, 0x30, 0xE3, 0x82, 0x0E, 0x70, 0x40, 0xE7, 0x08, 0x06, 0x71, 0x00,
  0x66, 0x30, 0x03, 0xC6, 0x3C, 0x00, 0xC6, 0x60, 0x18, 0xE7, 0x01, 0x0E,
  0x70, 0x20, 0xE7, 0x04, 0x1E, 0x70, 0xC0, 0xE7, 0x18, 0x0E, 0x73, 0x00,
  0xE7, 0x60, 0x06, 0x64, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x60, 0x0C, 0x60,
  0x1C, 0x60, 0x1C, 0x60, 0x1E, 0x40, 0x0E, 0x80, 0x0F, 0x00, 0x0F, 0x1F,
  0x3F, 0x0C, 0x77, 0x84, 0x67, 0x88, 0xE3, 0xC8, 0xE3, 0xC8, 0xE1, 0xF0,
  0xF1, 0xF0, 0x70, 0xF1, 0x78, 0xFE, 0x1F, 0x3C, 0x21, 0x9E, 0x71, 0x8C,
  0x44, 0x0E, 0x30, 0x41, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x8F,
  0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0x83, 0x02, 0x06, 0x04, 0x06, 0x60,
  0x20, 0x60, 0xE0, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x60, 0x08, 0x03, 0x03,
  0xF3, 0xB7, 0x75, 0xDF, 0xF5, 0xED, 0xD7, 0xED, 0xCB, 0xC1, 0xC0, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x21, 0x9F, 0xF3, 0x88, 0x44, 0x20, 0x3F, 0x3F, 0xC0, 0x02,
  0x7E, 0xFC, 0x20, 0xC7, 0x9C, 0x20, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x0F, 0x00, 0xCE, 0x0E, 0x38, 0xE1, 0xC7, 0x07, 0x78,
  0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x73, 0x83, 0x9C, 0x38, 0x61, 0xC1,
  0x8C, 0x07, 0x80, 0x06, 0x03, 0x80, 0xE0, 0x78, 0x7E, 0x27, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x7C, 0x7F, 0xC0, 0x0F, 0xC0, 0xFF, 0x8C, 0x3C, 0xC0,
  0xF4, 0x07, 0xA0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x21, 0x81, 0x08, 0x08, 0xFF, 0xCF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0xC3, 0xC6, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1F, 0xC0, 0x9F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xDC, 0x0F, 0x70, 0x39, 0xC0,
  0xE7, 0x03, 0x0E, 0x18, 0x0F, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x07, 0xC0, 0x17, 0x00, 0xDC, 0x02, 0x70, 0x11, 0xC0, 0xC7, 0x02,
  0x1C, 0x10, 0x70, 0xC1, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0xF8, 0x07, 0xF8, 0x10, 0x10, 0x7F, 0xC1, 0xFE,
  0x07, 0xE0, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0B, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x8C, 0x1E, 0x20, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x70,
  0x1D, 0xC0, 0x67, 0x03, 0x9C, 0x0C, 0x38, 0x60, 0x3E, 0x00, 0x03, 0xC0,
  0x31, 0x81, 0x87, 0x06, 0x1E, 0x38, 0x38, 0xE0, 0xE7, 0x80, 0x1E, 0x00,
  0x79, 0xE1, 0xEB, 0xC7, 0xC7, 0x9E, 0x1E, 0x78, 0x39, 0xE0, 0xE7, 0x83,
  0x9E, 0x0E, 0x78, 0x39, 0xE0, 0xE3, 0x83, 0x0E, 0x1C, 0x1C, 0x60, 0x1E,
  0x00, 0x3F, 0xFB, 0xFF, 0xD0, 0x04, 0x80, 0x68, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01,
  0x86, 0x18, 0x18, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0xC0, 0x8F, 0x8C, 0x7E,
  0xC1, 0xFC, 0x07, 0xF0, 0x6F, 0xC6, 0x1F, 0x60, 0x7B, 0x01, 0xD8, 0x07,
  0xC0, 0x3E, 0x01, 0xB0, 0x0D, 0xC0, 0xE7, 0x0E, 0x0F, 0xC0, 0x0F, 0x01,
  0x8E, 0x1C, 0x38, 0xC1, 0xCE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0,
  0xF7, 0x07, 0xBC, 0x3D, 0xE3, 0xE7, 0xAF, 0x1E, 0x78, 0x03, 0xC0, 0x1E,
  0x60, 0xE7, 0x87, 0x3C, 0x30, 0xE1, 0x87, 0x18, 0x0F, 0x80, 0x20, 0xC7,
  0x9E, 0x30, 0x00, 0x00, 0x00, 0x02, 0x0C, 0x79, 0xC2, 0x00, 0x20, 0xC7,
  0x9E, 0x30, 0x00, 0x00, 0x00, 0x02, 0x0C, 0x7B, 0xE3, 0x84, 0x10, 0x82,
  0x00, 0x01, 0x03, 0x03, 0x83, 0x87, 0x87, 0x81, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0x40, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x38, 0x38, 0x38, 0x30, 0x30, 0x00,
  0x1F, 0x87, 0x1E, 0xC0, 0xEC, 0x0F, 0xE0, 0x7F, 0x07, 0x60, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF8, 0x3C, 0x03, 0x00, 0x30, 0x43, 0x04, 0x18, 0x80, 0xF0,
  0x00, 0x00, 0x40, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x20, 0x01, 0xFC, 0x00,
  0xE0, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x0F, 0xC8, 0xE3, 0xB9, 0x98,
  0xE7, 0x33, 0x38, 0xC6, 0x67, 0x18, 0x9D, 0xC7, 0x31, 0xB9, 0xE4, 0x33,
  0x39, 0x86, 0x7B, 0xC6, 0xC0, 0x01, 0x8C, 0x00, 0x60, 0xC0, 0x18, 0x0E,
  0x0E, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x04, 0x1F, 0xF0, 0x18, 0x73, 0xF8,
  0x78, 0x40, 0xF9, 0xF8, 0x80, 0x7C, 0x78, 0x80, 0x3C, 0x78, 0x80, 0x3C,
  0x78, 0x80, 0x3C, 0x78, 0xE0, 0x1C, 0x78, 0xF8, 0x1C, 0x78, 0x7C, 0x38,
  0x78, 0x3E, 0x38, 0x78, 0x06, 0x30, 0x78, 0x04, 0x60, 0x78, 0x00, 0xC0,
  0x78, 0x01, 0x00, 0x78, 0x03, 0x80, 0x78, 0x07, 0xE0, 0x78, 0x1F, 0xF0,
  0xF8, 0x03, 0xFB, 0x7E, 0x00, 0xFE, 0x7C, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x80, 0x7F, 0xE2, 0xF8, 0x1F,
  0xFE, 0x8F, 0x87, 0x03, 0xE0, 0xF0, 0xC0, 0x3C, 0x1E, 0x10, 0x07, 0x83,
  0xE6, 0x00, 0x70, 0x3E, 0xC0, 0x0E, 0x03, 0x08, 0x01, 0xC1, 0x81, 0x80,
  0x38, 0xFC, 0x10, 0x27, 0x7F, 0xC1, 0xF8, 0xC0, 0xFC, 0x00, 0x30, 0x07,
  0xC0, 0x04, 0x00, 0x78, 0x03, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x7F,
  0x00, 0x18, 0x1F, 0xF0, 0x03, 0x00, 0x3F, 0x00, 0xC0, 0x07, 0xF0, 0x30,
  0x00, 0x3F, 0xD8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xFC, 0x70, 0x1C, 0x2F, 0xF3, 0x81, 0xFE, 0x38, 0x61, 0x87, 0x0C,
  0x00, 0x71, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xE0, 0x0F, 0x3F, 0x00, 0xF1,
  0xF8, 0x0F, 0x0F, 0xC0, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07,
  0x80, 0xE0, 0x7C, 0x0E, 0x03, 0xE0, 0x80, 0x3F, 0x10, 0x01, 0xFA, 0x00,
  0x0F, 0xE0, 0x20, 0x7F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xC0, 0xFF, 0x0E, 0x0C,
  0x3F, 0x38, 0x30, 0x3E, 0x60, 0xE0, 0x1E, 0x81, 0xE0, 0x1D, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x78, 0x07, 0xC0, 0x68, 0x07, 0x80,
  0xCC, 0x47, 0x01, 0x87, 0x06, 0x03, 0x00, 0x18, 0x04, 0x00, 0x60, 0x08,
  0x1F, 0x80, 0x20, 0xFF, 0x80, 0x43, 0xFF, 0xC3, 0x08, 0x1F, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xEC, 0x70, 0x1C, 0x2F,
  0xF3, 0x81, 0xFE, 0x30, 0x61, 0x87, 0x0C, 0x00, 0x71, 0xC0, 0x0F, 0x3C,
  0x00, 0xF3, 0xE1, 0x8F, 0x3F, 0x3D, 0xF1, 0xFF, 0xFF, 0x0F, 0xDE, 0xF0,
  0x7E, 0x0F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xE0, 0x7C, 0x0E, 0x03,
  0xE0, 0xC0, 0x3F, 0x10, 0x01, 0xFA, 0x00, 0x0F, 0xE0, 0x30, 0x7F, 0xFC,
  0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFB, 0x78, 0x1F, 0xF9, 0x80, 0x5F, 0x8C, 0x01, 0x9C, 0x30, 0x0C,
  0x00, 0x80, 0x70, 0x02, 0x01, 0xE0, 0x88, 0x07, 0xC3, 0x20, 0x1F, 0x9F,
  0x40, 0x3E, 0xF8, 0x80, 0x7C, 0xC1, 0xFD, 0xF9, 0x00, 0x03, 0xE0, 0x10,
  0x07, 0xC0, 0xB0, 0x1F, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xC0, 0x0E, 0x07, 0x00,
  0x1C, 0x30, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0x80, 0x30, 0x4F, 0x01,
  0xC0, 0xFE, 0x0E, 0x04, 0xFC, 0x78, 0x61, 0xF9, 0xC3, 0x01, 0xC7, 0x1C,
  0x06, 0x3C, 0x70, 0x20, 0xF1, 0xE3, 0xE3, 0xC7, 0xDF, 0xCF, 0x0F, 0x0F,
  0xBC, 0x3E, 0x1E, 0xF0, 0x7C, 0x3F, 0xC0, 0xF0, 0xFF, 0x83, 0xC3, 0xDE,
  0x07, 0x0F, 0x7C, 0x18, 0x38, 0xF0, 0xC0, 0xE1, 0xE2, 0x03, 0x03, 0xC0,
  0x18, 0x07, 0x80, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0x1F, 0x80,
  0x08, 0x3C, 0x00, 0x60, 0x60, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x80, 0x3C,
  0x0F, 0x00, 0xF0, 0x7E, 0x03, 0xE7, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xCF, 0x0C, 0x0F, 0x7E, 0x30, 0x3A, 0xFC, 0x80, 0xE1, 0xFC,
  0x03, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0x87,
  0xF0, 0x60, 0x1F, 0xE6, 0x00, 0xF8, 0x60, 0x01, 0x04, 0x00, 0x20, 0x40,
  0x06, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x03, 0x00, 0xF0, 0x1C, 0x6F, 0x00,
  0x78, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0xEF, 0xF0, 0x0C, 0x9F, 0x80,
  0xC0, 0xFC, 0x18, 0x07, 0xF2, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0x87, 0xF0, 0x60, 0x1F, 0xE6,
  0x00, 0xF8, 0x40, 0x01, 0x04, 0x00, 0x30, 0x40, 0x06, 0x04, 0x00, 0xE0,
  0x60, 0x0F, 0x03, 0x00, 0xF0, 0x18, 0x6F, 0x00, 0x78, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x7E,
  0x00, 0x6F, 0xF0, 0x0C, 0x1F, 0x80, 0x80, 0xFC, 0x10, 0x07, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x60, 0xC0, 0x39, 0xFC, 0x20, 0x39, 0xFF, 0x18, 0x1C, 0x87, 0x8C,
  0x0E, 0x81, 0xE2, 0x07, 0xC0, 0xF1, 0x03, 0xE0, 0x3D, 0x81, 0xF0, 0x1C,
  0xC0, 0x7C, 0x08, 0x40, 0x3F, 0x1C, 0xC0, 0x0F, 0xBF, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x0E, 0x18, 0x3C, 0x0F, 0x8C,
  0x1E, 0x0F, 0xE4, 0x07, 0xA1, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0xE0, 0x00,
  0x00, 0x40, 0x03, 0xE0, 0x0C, 0x1C, 0x18, 0x0E, 0x38, 0x06, 0x78, 0x07,
  0x78, 0x07, 0x78, 0x07, 0x7C, 0x07, 0x7C, 0x06, 0x3E, 0x0E, 0x3E, 0xFC,
  0x1E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0xFF, 0x81, 0x1F, 0xE6, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0xC0, 0x40, 0x0F, 0xF1, 0xF8, 0xFC, 0x0F, 0xFD, 0xFE, 0x9F,
  0x0E, 0x7F, 0x0F, 0x87, 0x8C, 0x0F, 0xC3, 0xC3, 0xC4, 0x03, 0xE1, 0xE0,
  0xF2, 0x00, 0xF8, 0x78, 0x79, 0x00, 0x3C, 0x3C, 0x3E, 0x80, 0x1E, 0x1E,
  0x0C, 0x40, 0x07, 0x07, 0x04, 0x3F, 0xC3, 0x83, 0x84, 0x0F, 0xE1, 0xC1,
  0xC6, 0x01, 0xF0, 0xE0, 0xC6, 0x00, 0x08, 0x70, 0x63, 0x00, 0x00, 0x30,
  0x33, 0x80, 0x00, 0x18, 0x19, 0xE0, 0x00, 0x08, 0x08, 0xF0, 0x07, 0x0C,
  0x0C, 0x78, 0x0F, 0xC5, 0xE4, 0x1E, 0x4F, 0xF5, 0xFC, 0x0F, 0xE0, 0xFD,
  0xFE, 0x03, 0xE0, 0x3C, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x0F, 0xF8, 0x3F, 0x07, 0xFF, 0x1F,
  0xE1, 0x87, 0xE8, 0x78, 0xC0, 0x7C, 0x1E, 0x20, 0x0F, 0x03, 0xC8, 0x03,
  0xE0, 0xF2, 0x00, 0x78, 0x3E, 0x80, 0x1E, 0x06, 0x20, 0x03, 0x81, 0x07,
  0xF0, 0xE0, 0x81, 0xFC, 0x38, 0x60, 0x1D, 0x0E, 0x30, 0x00, 0x43, 0x8C,
  0x00, 0x00, 0xC7, 0x80, 0x00, 0x31, 0xE0, 0x00, 0x08, 0x78, 0x03, 0x86,
  0x1F, 0x03, 0xF1, 0x03, 0xE9, 0xFE, 0x80, 0xFF, 0x0F, 0xC0, 0x1F, 0x01,
  0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x18, 0x0F, 0xE0, 0x80, 0x0F, 0x86, 0x00,
  0x1F, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xF0, 0x00, 0xEF, 0xF0, 0x03,
  0x9F, 0xE0, 0x06, 0x1F, 0xC0, 0x18, 0x1F, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x40, 0x04, 0x1C, 0x00, 0x11, 0xFC, 0x00, 0x8F, 0xF8, 0x04, 0x03, 0xF8,
  0x20, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x08, 0x03, 0xFE, 0x07, 0x00, 0xFF, 0xE3, 0xE0, 0x38, 0x7E, 0xFC, 0x04,
  0x07, 0xE7, 0xC0, 0x80, 0x78, 0xFC, 0x30, 0x0F, 0x8F, 0xC2, 0x00, 0xF0,
  0xFC, 0x40, 0x1E, 0x0F, 0xC8, 0x03, 0xC0, 0xF8, 0x82, 0x78, 0x0F, 0x8F,
  0xCF, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80,
  0x10, 0x00, 0x70, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x0F, 0xC0, 0x10, 0x03,
  0xFE, 0x04, 0x00, 0xDF, 0xFB, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1B, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0x80, 0xFE, 0x0C, 0x00, 0x7C, 0x18,
  0x00, 0x7C, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xF8, 0x00, 0x73, 0xFC,
  0x00, 0xE3, 0xFC, 0x01, 0xC1, 0xFC, 0x01, 0x80, 0xF8, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x80, 0x08, 0x1C, 0x03, 0x90, 0xFE, 0x0F, 0xC3, 0xFE, 0x27,
  0x88, 0x7F, 0x07, 0xE0, 0x7F, 0xF7, 0x80, 0x3F, 0x86, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x30, 0x03, 0xFE, 0x1F, 0x80, 0xFF, 0xE6,
  0xF8, 0x3D, 0xFF, 0x0F, 0x8E, 0x07, 0xE0, 0xF1, 0x80, 0x7C, 0x1F, 0x20,
  0x07, 0x81, 0xF4, 0x00, 0x70, 0x3C, 0x80, 0x0E, 0x02, 0x10, 0x01, 0xC1,
  0x83, 0x00, 0x1C, 0x40, 0x20, 0x03, 0x3C, 0x03, 0x98, 0x6F, 0xC0, 0x0C,
  0x0C, 0x7C, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x30, 0xF0, 0x00, 0x0C, 0x1E,
  0x01, 0xC1, 0x03, 0xE0, 0x7C, 0x20, 0x3C, 0x1F, 0xC8, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xF8, 0x20, 0x3F, 0xFF, 0x03, 0x0F, 0xF8, 0x10, 0x07, 0xC0, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x07, 0xC3, 0x10, 0x7F,
  0xCC, 0x27, 0xFF, 0xB0, 0x7F, 0x82, 0xE0, 0xF8, 0x0B, 0x81, 0x80, 0x1F,
  0x00, 0x00, 0xBE, 0x00, 0x02, 0x7C, 0x00, 0x19, 0xFC, 0x00, 0xC3, 0xFE,
  0x3F, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0xF0, 0x06, 0x0F, 0xF0, 0x30, 0x07, 0xF2, 0x80, 0x0F, 0xFA,
  0x01, 0x8F, 0xC8, 0x0C, 0x1C, 0x20, 0x78, 0x00, 0x81, 0xF0, 0x01, 0x07,
  0xE0, 0x03, 0x2F, 0xC0, 0x03, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0xE0, 0x1F, 0xC3, 0x00, 0xFF, 0x90, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x0C, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xC8, 0x06, 0x38, 0x41, 0xC3, 0x84, 0x7C, 0x78, 0x8F, 0x87,
  0x80, 0x38, 0x7C, 0x03, 0x83, 0xE0, 0x38, 0x3F, 0x03, 0x81, 0xF0, 0x38,
  0x0F, 0x83, 0x80, 0x78, 0x38, 0x07, 0x03, 0x80, 0x60, 0x38, 0x04, 0x03,
  0x80, 0x80, 0x38, 0x1C, 0x03, 0x83, 0xE0, 0x78, 0xFF, 0x0B, 0xC8, 0xFF,
  0x3F, 0x07, 0xE3, 0xE0, 0x3C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x3C, 0x03, 0xFF, 0x3F, 0xC1, 0xFF, 0xE8, 0xF0,
  0xE0, 0xFC, 0x3E, 0x30, 0x1F, 0x07, 0x88, 0x03, 0xC1, 0xF2, 0x00, 0x70,
  0x30, 0x80, 0x1C, 0x08, 0x20, 0x07, 0x06, 0x08, 0x01, 0xC1, 0x81, 0x02,
  0x70, 0xF0, 0x1F, 0x18, 0x3E, 0x00, 0x04, 0x07, 0xC0, 0x02, 0x01, 0xF8,
  0x01, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0x83, 0xFC, 0x00, 0xC1, 0xFF, 0x80,
  0x30, 0x07, 0xF0, 0x08, 0x00, 0x7F, 0x04, 0x00, 0x0F, 0xF6, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0x87, 0xC0, 0x3F, 0xF3, 0xDB,
  0xE0, 0x7F, 0xFC, 0x61, 0xF0, 0x70, 0xF8, 0x60, 0xF8, 0xC0, 0x7C, 0x40,
  0x78, 0x80, 0x3C, 0xE0, 0x7C, 0x80, 0x1C, 0xE0, 0x3C, 0x80, 0x1C, 0xF0,
  0x10, 0x80, 0x1C, 0xF0, 0x30, 0x80, 0x1C, 0xF8, 0x70, 0x40, 0x9C, 0x78,
  0xF0, 0x3B, 0x18, 0x7C, 0xF8, 0x04, 0x10, 0x3C, 0x7E, 0x00, 0x30, 0x3C,
  0x7E, 0x00, 0x20, 0x1C, 0x1E, 0x03, 0xC0, 0x18, 0x0E, 0x0F, 0xC0, 0x18,
  0x0E, 0x1F, 0xE0, 0x3C, 0x06, 0x21, 0xF0, 0x3E, 0x04, 0x00, 0xFC, 0xFF,
  0x08, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x0C, 0x0F, 0xF8, 0xFE, 0xFF, 0xC7, 0xEE,
  0x0F, 0x7E, 0x60, 0x3A, 0x22, 0x01, 0xF0, 0x10, 0x07, 0x00, 0x80, 0x38,
  0x02, 0x01, 0xC0, 0x10, 0x1F, 0xF0, 0x6D, 0xFF, 0x00, 0x83, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x06, 0x17, 0x80, 0x79, 0x3F, 0x23, 0xF8, 0xFE, 0x3F, 0x87, 0xE0, 0x3C,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xFC, 0xFF, 0x0F,
  0xFF, 0x47, 0x8E, 0x0F, 0xC3, 0xE6, 0x01, 0xE0, 0xF2, 0x00, 0xF0, 0x7D,
  0x00, 0x38, 0x1F, 0x80, 0x1C, 0x0E, 0x40, 0x0E, 0x06, 0x30, 0x07, 0x06,
  0x08, 0x13, 0x87, 0x03, 0xF1, 0x87, 0xC0, 0x00, 0xC3, 0xE0, 0x00, 0xC0,
  0xF8, 0x00, 0x40, 0x7C, 0x00, 0x40, 0x1F, 0x00, 0x20, 0x0F, 0x80, 0x38,
  0x43, 0xC0, 0x3F, 0x61, 0xE0, 0x3F, 0xE0, 0xF0, 0x23, 0xE0, 0x78, 0x00,
  0xE0, 0x38, 0x08, 0x00, 0x1C, 0x02, 0x00, 0x1C, 0x00, 0x80, 0x18, 0x00,
  0x38, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0xE0, 0x7C, 0x0C, 0x03, 0xC0, 0x80, 0x1C, 0x18, 0x01, 0xC0,
  0x80, 0x1C, 0x08, 0x01, 0x80, 0xC0, 0x30, 0x03, 0x06, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0xC0, 0x06, 0x3F, 0x00, 0x67, 0xF8,
  0x06, 0x0F, 0xC0, 0xC0, 0x7E, 0x08, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCF, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x7F, 0x04, 0x01, 0xC0, 0x78, 0x0F, 0x83, 0x38, 0xC3,
  0xB0, 0x14, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x1C, 0x61, 0x0C, 0x04,
  0x00, 0x30, 0x03, 0xE0, 0x2F, 0xC2, 0x3E, 0x30, 0xE3, 0x87, 0x1C, 0x38,
  0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xE3, 0x8F, 0x1C, 0x3C, 0xFC, 0xFB, 0xC3,
  0x1C, 0x10, 0x20, 0x0F, 0x09, 0x80, 0xB8, 0x07, 0x80, 0x78, 0x07, 0x88,
  0x78, 0x87, 0xBC, 0x7D, 0xE7, 0x8F, 0x78, 0xF7, 0x87, 0x78, 0x77, 0x87,
  0x78, 0x77, 0x86, 0x78, 0x67, 0xCC, 0xFF, 0x81, 0xE0, 0x06, 0x00, 0x40,
  0x02, 0x07, 0x8D, 0xCC, 0xF6, 0x3F, 0x13, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1E, 0x07, 0x03, 0xE0, 0xFE, 0x38, 0x08, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x4F,
  0x9E, 0x3C, 0xF0, 0xE7, 0x87, 0x3C, 0x1D, 0xE0, 0xCF, 0x06, 0x78, 0x33,
  0xC1, 0x1F, 0x19, 0x7E, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x02, 0x03,
  0xC3, 0x71, 0x9C, 0x63, 0xB8, 0xEE, 0x3B, 0x90, 0xF8, 0x38, 0x0E, 0x03,
  0xC0, 0x70, 0x1F, 0x03, 0xF8, 0x70, 0x08, 0x00, 0x1C, 0x8F, 0xCF, 0xC4,
  0x42, 0x01, 0x00, 0xC0, 0xFE, 0xBC, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x02, 0x00, 0x38, 0x03, 0xE0, 0x2F, 0xC2, 0x1F, 0x30,
  0x73, 0x81, 0x1C, 0x18, 0xE0, 0xC7, 0x0F, 0x38, 0x79, 0xE3, 0xC7, 0x0E,
  0x3C, 0x78, 0xFF, 0xC7, 0x0E, 0x20, 0x70, 0x03, 0x80, 0x18, 0xC0, 0xC7,
  0x0C, 0x1D, 0x80, 0x10, 0x00, 0x01, 0x80, 0xE0, 0x98, 0x0B, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x87, 0x98, 0x7F, 0xC7, 0x9E, 0x78, 0xE7, 0x8F, 0x78,
  0xF7, 0x87, 0x78, 0x77, 0x87, 0x78, 0x77, 0x87, 0x78, 0x67, 0xA6, 0xFC,
  0xC3, 0x88, 0x11, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x00, 0x08, 0x1C,
  0x1C, 0x18, 0x10, 0x00, 0x10, 0x38, 0x7C, 0x7E, 0xBC, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1F, 0x1E, 0x0C, 0x04, 0x07, 0x07, 0x83,
  0xC0, 0xC0, 0x00, 0x00, 0x30, 0x3C, 0x1F, 0x17, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E,
  0x0F, 0x06, 0x46, 0x1C, 0x00, 0x01, 0x0E, 0x98, 0x79, 0x7B, 0x7F, 0x3C,
  0x78, 0x7F, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78,
  0x7F, 0xBC, 0x0C, 0x08, 0x01, 0x0E, 0x98, 0xF8, 0x78, 0x78, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3A, 0x7F,
  0xBC, 0x08, 0x08, 0x20, 0x82, 0x07, 0x1E, 0x70, 0xFB, 0xEF, 0xEB, 0xCF,
  0x3C, 0x38, 0xF1, 0xC3, 0x87, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x1C, 0x38, 0x71, 0xC3, 0x8F, 0x1C, 0x38, 0xF1, 0xC7,
  0xDF, 0x9F, 0x38, 0xF1, 0xE1, 0x06, 0x0E, 0x10, 0x40, 0x00, 0x40, 0x81,
  0xC3, 0x07, 0xBE, 0x3F, 0x3E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xF1, 0xF3, 0x87,
  0x84, 0x0C, 0x10, 0x10, 0x00, 0x80, 0x38, 0x7F, 0xC7, 0x3C, 0x71, 0xE7,
  0x0E, 0x70, 0xF7, 0x07, 0x70, 0x77, 0x07, 0x70, 0x67, 0x06, 0xFC, 0xC7,
  0xE8, 0x1F, 0x00, 0x40, 0x00, 0x00, 0x60, 0x01, 0x00, 0x0E, 0x04, 0x3E,
  0x30, 0x79, 0xE0, 0xFB, 0xC3, 0x87, 0x86, 0x1E, 0x18, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xF0, 0xCF, 0xE2, 0x3F, 0xD0, 0x1F, 0x80,
  0x7C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00,
  0x02, 0x00, 0x18, 0x01, 0xF0, 0x17, 0xE1, 0x1F, 0x98, 0x71, 0xC3, 0x8E,
  0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x8E, 0x1E, 0xF0, 0xFB,
  0x83, 0x9C, 0x10, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x61, 0x1C, 0x6F, 0xBB, 0xFF, 0x39, 0x8E, 0x43, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x39, 0x1F, 0x81, 0xC0, 0x30, 0x00, 0x00, 0x0F, 0x80,
  0x08, 0x00, 0x84, 0x11, 0xE2, 0x7F, 0xD1, 0xF6, 0x0C, 0xC1, 0x1C, 0x73,
  0xDF, 0x3D, 0xE3, 0x1E, 0x41, 0xD8, 0x17, 0xC4, 0xFF, 0x03, 0xC0, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x80, 0x80, 0x80, 0xC1, 0xE1, 0xFF, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1F, 0xC7, 0x80,
  0xC0, 0x40, 0x20, 0x21, 0xC1, 0x8F, 0x8F, 0x3E, 0x3E, 0x38, 0xF0, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0xF1, 0xF5, 0xF1, 0xE7, 0x83, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x10,
  0x11, 0xC3, 0xCF, 0x3E, 0x7E, 0x79, 0xE1, 0xE7, 0x0F, 0x1C, 0x38, 0xE1,
  0xC7, 0x0E, 0x10, 0x71, 0x83, 0x0C, 0x18, 0x71, 0x87, 0xE8, 0x0F, 0x80,
  0x38, 0x00, 0x80, 0x40, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x8F, 0x0E,
  0x18, 0xF9, 0xF7, 0xC7, 0xAF, 0x9C, 0x3C, 0x71, 0xE3, 0x87, 0x0E, 0x38,
  0x70, 0xF3, 0x87, 0x07, 0x38, 0x70, 0x63, 0x87, 0x06, 0x38, 0x70, 0xE3,
  0x87, 0x0C, 0x38, 0xF8, 0x87, 0xC7, 0xF0, 0x38, 0x1E, 0x01, 0x80, 0xC0,
  0x10, 0x04, 0x00, 0x30, 0x87, 0x39, 0xFF, 0x4E, 0xF1, 0xCC, 0x39, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC8, 0x7E, 0x1F, 0x84,
  0x60, 0x88, 0x10, 0x02, 0x00, 0x20, 0xC3, 0x78, 0x1E, 0x00, 0x00, 0x02,
  0x00, 0x30, 0x01, 0xC1, 0x0F, 0x9C, 0x7D, 0xF1, 0xF3, 0xC7, 0x1E, 0x38,
  0x71, 0xC3, 0xCE, 0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xC7, 0x0E,
  0x7E, 0x61, 0xE3, 0x06, 0x30, 0x21, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x10, 0x0E, 0x0F, 0x8B, 0xC0, 0xE0, 0x60, 0x20, 0x22, 0x3A, 0x7E,
  0x07, 0x85, 0xE4, 0x72, 0x3A, 0x0F, 0x07, 0x83, 0x41, 0xA0, 0xD8, 0xC4,
  0x41, 0xC0, 0x07, 0x0C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x18, 0x18,
  0x38, 0x60, 0xC0, 0x30, 0x38, 0x18, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x18, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x30,
  0x38, 0x18, 0x38, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x18, 0x0C, 0x07, 0x0C,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x18, 0x18, 0x30, 0x60, 0x80, 0xFF,
  0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 10, 8, 12, 1, -22 },
  { 28, 14, 18, 16, 1, -20 },
  { 60, 11, 25, 13, 1, -24 },
  { 95, 20, 22, 22, 1, -22 },
  { 150, 16, 19, 18, 1, -19 },
  { 188, 5, 8, 6, 0, -22 },
  { 193, 7, 25, 8, 0, -24 },
  { 215, 7, 25, 8, 0, -24 },
  { 237, 10, 12, 11, 0, -23 },
  { 252, 10, 11, 12, 1, -16 },
  { 266, 5, 9, 6, 0, -5 },
  { 272, 8, 6, 9, 1, -12 },
  { 278, 6, 5, 6, 0, -5 },
  { 282, 15, 24, 16, 1, -23 },
  { 327, 13, 22, 15, 1, -22 },
  { 363, 10, 21, 10, 0, -21 },
  { 390, 13, 21, 14, 0, -21 },
  { 425, 14, 21, 14, 0, -21 },
  { 462, 14, 21, 14, 0, -21 },
  { 499, 14, 22, 14, 0, -22 },
  { 538, 14, 22, 14, 0, -22 },
  { 577, 13, 20, 13, 0, -20 },
  { 610, 13, 22, 14, 1, -22 },
  { 646, 13, 22, 14, 1, -22 },
  { 682, 6, 15, 6, 0, -15 },
  { 694, 6, 19, 5, 0, -15 },
  { 709, 9, 11, 9, 0, -14 },
  { 722, 10, 7, 12, 1, -13 },
  { 731, 9, 11, 9, 0, -14 },
  { 744, 12, 22, 14, 1, -22 },
  { 777, 19, 18, 19, 0, -14 },
  { 820, 24, 23, 25, 1, -22 },
  { 889, 27, 24, 28, 0, -23 },
  { 970, 20, 23, 21, 1, -23 },
  { 1028, 23, 24, 25, 1, -23 },
  { 1097, 20, 23, 22, 1, -23 },
  { 1155, 22, 27, 23, 1, -23 },
  { 1230, 22, 23, 24, 1, -22 },
  { 1294, 22, 28, 23, 0, -24 },
  { 1371, 20, 27, 21, 1, -23 },
  { 1439, 20, 30, 22, 1, -23 },
  { 1514, 25, 23, 25, 0, -22 },
  { 1586, 16, 23, 18, 1, -22 },
  { 1632, 33, 24, 34, 1, -22 },
  { 1731, 26, 23, 27, 1, -22 },
  { 1806, 22, 23, 23, 1, -22 },
  { 1870, 27, 27, 28, 0, -22 },
  { 1962, 23, 24, 25, 1, -22 },
  { 2031, 27, 23, 29, 1, -22 },
  { 2109, 22, 22, 24, 1, -22 },
  { 2170, 22, 22, 23, 1, -22 },
  { 2231, 20, 24, 22, 1, -22 },
  { 2291, 26, 24, 28, 1, -23 },
  { 2369, 32, 23, 33, 1, -22 },
  { 2461, 21, 23, 22, 1, -23 },
  { 2522, 25, 28, 27, 1, -23 },
  { 2610, 20, 27, 21, 0, -23 },
  { 2678, 4, 24, 6, 1, -23 },
  { 2690, 19, 21, 3, -6, -20 },
  { 2740, 4, 24, 6, 1, -23 },
  { 2752, 11, 8, 13, 1, -22 },
  { 2763, 14, 2, 14, 0, 4 },
  { 2767, 5, 6, 16, 5, -22 },
  { 2771, 13, 17, 14, 1, -16 },
  { 2799, 12, 22, 14, 1, -21 },
  { 2832, 9, 17, 11, 1, -16 },
  { 2852, 13, 23, 14, 1, -22 },
  { 2890, 10, 17, 11, 1, -16 },
  { 2912, 9, 27, 8, 0, -22 },
  { 2943, 13, 23, 14, 1, -16 },
  { 2981, 12, 27, 14, 1, -22 },
  { 3022, 8, 23, 8, 0, -22 },
  { 3045, 9, 28, 8, -2, -22 },
  { 3077, 8, 23, 10, 1, -22 },
  { 3100, 8, 23, 8, 1, -22 },
  { 3123, 20, 17, 22, 1, -16 },
  { 3166, 14, 17, 16, 1, -16 },
  { 3196, 12, 17, 13, 0, -16 },
  { 3222, 14, 24, 14, 0, -18 },
  { 3264, 13, 22, 13, 0, -16 },
  { 3300, 10, 17, 11, 1, -16 },
  { 3322, 11, 20, 13, 1, -19 },
  { 3350, 9, 21, 10, 0, -20 },
  { 3374, 14, 17, 16, 1, -16 },
  { 3404, 13, 19, 14, 0, -18 },
  { 3435, 20, 19, 21, 1, -18 },
  { 3483, 11, 22, 12, 1, -16 },
  { 3514, 13, 24, 15, 1, -19 },
  { 3553, 9, 22, 10, 1, -16 },
  { 3578, 8, 25, 10, 1, -24 },
  { 3603, 2, 25, 5, 1, -24 },
  { 3610, 8, 25, 10, 1, -24 },
  { 3635, 10, 2, 11, 1, -10 },
};

const GFXfont UnifrakturMaguntia_Regular31pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular31pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular31pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR31PT7B_H_
