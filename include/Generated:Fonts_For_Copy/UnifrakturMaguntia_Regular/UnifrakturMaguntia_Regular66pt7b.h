#ifndef _UNIFRAKTURMAGUNTIA_REGULAR66PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x00, 0x40, 0x0E, 0x01, 0xF0, 0x3F, 0x87, 0xFC, 0xFF, 0xE7,
  0xFE, 0x7F, 0xC7, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x60, 0x0E, 0x01, 0xF0, 0x3F, 0xC7, 0xFE, 0x3F, 0x81, 0xF0, 0x0E, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x40, 0x30, 0x03, 0x01, 0xE0, 0x0E, 0x0F,
  0xC0, 0x7C, 0x7F, 0x87, 0xFB, 0xFF, 0x3F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF0,
  0x7F, 0x0F, 0xC0, 0xFC, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xC0, 0x0E,
  0x07, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x00, 0x10, 0x08,
  0x00, 0xC0, 0x60, 0x02, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00,
  0x07, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0xC1, 0xE0, 0x1E, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0,
  0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x7E, 0x00,
  0x7C, 0xFC, 0x00, 0xF9, 0xFE, 0x00, 0xF1, 0xFE, 0x00, 0xC3, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x18, 0x03, 0xFF, 0x78, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xEF, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x7C, 0x70, 0x00,
  0xF0, 0x70, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x18, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0x8F, 0x9F, 0x00, 0x00, 0x01, 0xC3, 0xE1, 0xF0, 0x00, 0x00, 0x70,
  0x7C, 0x3E, 0x00, 0x00, 0x1C, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0x83, 0xE0,
  0x7C, 0x00, 0x00, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x38, 0x1F, 0x81, 0xF8,
  0x00, 0x0E, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0x80, 0x7E, 0x07, 0xE0, 0x00,
  0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x38, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x70, 0x00, 0xFC,
  0x0F, 0xC0, 0x1C, 0x00, 0x1F, 0x81, 0xF8, 0x07, 0x00, 0x01, 0xF0, 0x3E,
  0x01, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x70, 0x00, 0x03, 0xE1, 0xF0, 0x1C,
  0x00, 0x00, 0x7C, 0x3E, 0x03, 0x80, 0x00, 0x07, 0xCF, 0x80, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x38, 0x0F, 0xC0, 0x03, 0xF0, 0x0E, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0x81, 0xE3, 0xE0, 0x00, 0x00, 0xE0, 0x7C, 0x3E, 0x00, 0x00,
  0x38, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xC0,
  0x7C, 0x0F, 0x80, 0x00, 0x70, 0x1F, 0x81, 0xF8, 0x00, 0x1C, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0x70, 0x01, 0xF8, 0x1F, 0x80, 0x1C, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x38, 0x00,
  0x1F, 0x81, 0xF8, 0x0E, 0x00, 0x03, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x3E,
  0x0F, 0xC0, 0xE0, 0x00, 0x07, 0xE1, 0xF0, 0x38, 0x00, 0x00, 0x7C, 0x3E,
  0x0F, 0x00, 0x00, 0x07, 0x8F, 0x81, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x70,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07,
  0xE0, 0x3C, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00,
  0x1F, 0xC1, 0xE0, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x01, 0xFE, 0x3C, 0x00,
  0x00, 0x7F, 0x9E, 0x00, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0x07, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x1E, 0x01, 0xEF,
  0xF0, 0x07, 0x00, 0xF3, 0xFE, 0x01, 0xC0, 0x78, 0x7F, 0x80, 0x60, 0x3E,
  0x1F, 0xF0, 0x18, 0x1F, 0x83, 0xFC, 0x06, 0x07, 0xE0, 0xFF, 0x83, 0x01,
  0xF8, 0x1F, 0xE0, 0xC0, 0xFE, 0x07, 0xFC, 0x30, 0x3F, 0x80, 0xFF, 0x18,
  0x0F, 0xE0, 0x3F, 0xEE, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x03, 0x7F, 0xC0, 0x3F, 0xE1, 0xCF, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC3, 0xFC, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x04, 0x00, 0xC0, 0x38, 0x0F, 0x83, 0xFD, 0xFF,
  0xCF, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x07, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x33, 0xF3, 0x0F, 0xC7, 0x8F,
  0xDF, 0x8E, 0x7E, 0x7E, 0x31, 0xF9, 0xFC, 0xCF, 0xE3, 0xFB, 0x7F, 0x0E,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x83, 0xF0, 0x47, 0xFB, 0x7F, 0x9F, 0xCC,
  0xFE, 0x7F, 0x33, 0xF9, 0xF8, 0xE7, 0xEF, 0xE7, 0x9F, 0xC3, 0xBF, 0x70,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x3C, 0x0F, 0xC3,
  0xFC, 0xFF, 0xCF, 0xF8, 0x7F, 0x07, 0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x00, 0x07, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x0F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFC, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x78, 0x1F, 0x87, 0xF9, 0xFF, 0xCF, 0xE0, 0xF8,
  0x0E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F, 0xE0, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFE, 0x00,
  0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x61, 0xFC, 0x08, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0x0F, 0x80, 0x3F, 0xF1, 0xC0,
  0x03, 0xFE, 0x38, 0x00, 0x3F, 0xCE, 0x00, 0x07, 0xFD, 0x80, 0x00, 0xFF,
  0xB0, 0x00, 0x0F, 0xF6, 0x00, 0x01, 0xFE, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x20, 0x1E, 0x00, 0x04, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00,
  0x30, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1E, 0x07, 0xFF, 0x01, 0xC0, 0x0F,
  0xF8, 0x1C, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0xFF, 0x04, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x3C, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03,
  0xE1, 0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xBF, 0x80, 0x00, 0x3B, 0xF8, 0x00, 0x07, 0x3F, 0x80, 0x00, 0x63, 0xF8,
  0x00, 0x0E, 0x3F, 0x80, 0x00, 0xC3, 0xF8, 0x00, 0x18, 0x3F, 0x80, 0x03,
  0x83, 0xF8, 0x00, 0x30, 0x3F, 0x80, 0x06, 0x03, 0xF8, 0x00, 0xE0, 0x3F,
  0x80, 0x0C, 0x03, 0xF8, 0x01, 0x80, 0x3F, 0x80, 0x18, 0x03, 0xF8, 0x03,
  0x00, 0x3F, 0x80, 0x70, 0x03, 0xF8, 0x06, 0x00, 0x3F, 0x80, 0xC0, 0x03,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x80, 0x7C, 0x00, 0x7C,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x06, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x87, 0xF8, 0x00, 0x0D, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7E, 0x03, 0xFF, 0x83, 0xC0, 0x07, 0xFC, 0x1C, 0x00, 0x1F, 0xF0,
  0xC0, 0x00, 0x7F, 0x88, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x3F, 0x7F, 0x80, 0x03, 0xF1, 0xFC,
  0x00, 0x1F, 0x0F, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xFC, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x78, 0x7E, 0x00, 0x0F, 0x03, 0xF0, 0x01, 0xE0, 0x3F, 0x80, 0x3C, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0,
  0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x03, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0x87, 0xFC, 0x07, 0xF8,
  0xFF, 0xF0, 0x7F, 0x98, 0x7F, 0x87, 0xFB, 0x03, 0xF8, 0x7F, 0xA0, 0x1F,
  0xC7, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F,
  0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xF8,
  0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1E, 0x00, 0x3E,
  0x03, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3,
  0xF0, 0x00, 0x3C, 0x3F, 0x80, 0x03, 0xC3, 0xFC, 0x00, 0x78, 0x3F, 0xF0,
  0x07, 0x83, 0xFF, 0xC0, 0xF0, 0x1F, 0xFE, 0x1E, 0x01, 0xFF, 0xFB, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x38, 0xFF, 0xF8, 0x07, 0x03, 0xFF,
  0xC0, 0xE0, 0x0F, 0xFC, 0x1C, 0x00, 0x7F, 0xE3, 0xC0, 0x03, 0xFE, 0x3C,
  0x00, 0x1F, 0xE7, 0x80, 0x00, 0xFF, 0x78, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xE1, 0xF8,
  0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03,
  0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE7,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xF8,
  0x07, 0xFE, 0x3F, 0xC0, 0x5F, 0xE3, 0xFC, 0x0D, 0xFE, 0x1F, 0xE1, 0x9F,
  0xE0, 0xFF, 0xF1, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x0C, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x87,
  0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x80,
  0x3E, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x78, 0x00, 0xFC, 0x0F, 0x00,
  0x07, 0xE1, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x04,
  0x01, 0xC0, 0x78, 0x1F, 0x87, 0xFD, 0xFF, 0xCF, 0xE0, 0xF0, 0x0E, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xF3, 0xFF,
  0x9F, 0xC1, 0xF0, 0x1C, 0x01, 0x00, 0x00, 0x02, 0x00, 0x70, 0x0F, 0x01,
  0xF8, 0x3F, 0xE7, 0xFF, 0x1F, 0xC0, 0xF0, 0x07, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xE3,
  0xFE, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF8,
  0x03, 0xE0, 0x7F, 0x07, 0xC0, 0x1F, 0xC3, 0xC0, 0x07, 0xF3, 0xC0, 0x01,
  0xF9, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xF8,
  0x03, 0xFC, 0x30, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x02, 0x01, 0xF0, 0x01, 0x00, 0xF8, 0x01,
  0x80, 0x3E, 0x00, 0xC0, 0x1F, 0x00, 0xC0, 0x07, 0xE1, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x7E, 0xF9,
  0xE0, 0x78, 0x03, 0xFF, 0xE1, 0xC1, 0xF0, 0x0F, 0x9F, 0xC3, 0x83, 0xC0,
  0x3E, 0x3F, 0x87, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0x1F, 0x03, 0xE0, 0xFC,
  0x1E, 0x3C, 0x0F, 0xC1, 0xF8, 0x3C, 0xF8, 0x1F, 0x03, 0xE0, 0x79, 0xF0,
  0x7E, 0x07, 0xC0, 0xE3, 0xE1, 0xF8, 0x1F, 0x83, 0xC7, 0xC3, 0xF0, 0x3F,
  0x07, 0x8F, 0x87, 0xE0, 0x7C, 0x0F, 0x1F, 0x1F, 0x81, 0xF8, 0x3C, 0x3E,
  0x3F, 0x07, 0xF0, 0xF8, 0x7C, 0x7E, 0x0F, 0xC1, 0xE0, 0xF8, 0xFC, 0x3F,
  0x87, 0x80, 0xF0, 0xF9, 0xFF, 0x3F, 0x01, 0xE1, 0xFF, 0xFF, 0xFC, 0x73,
  0xC1, 0xFE, 0x7F, 0xE1, 0xE3, 0xC1, 0xF0, 0x7F, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x1E, 0x03, 0xFF, 0xE0, 0x0F,
  0xF8, 0x07, 0x00, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x30, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x06, 0x00, 0x00, 0xFF,
  0xC1, 0xFF, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x30, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0xC0, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x38, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x70, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x3F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x7F,
  0x80, 0x7F, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x01,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xC0,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x06,
  0x07, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xC7, 0xFF, 0xE0, 0x77, 0xFE, 0x60, 0x00, 0x3F, 0xFF,
  0x3C, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x07, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF3, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xFD, 0x00,
  0x7F, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x0F,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x83, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x70,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x01, 0xC0,
  0x00, 0x01, 0xF8, 0x1F, 0xFF, 0x80, 0x70, 0x00, 0x00, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3C, 0x00, 0x30, 0x7C, 0x7F, 0xFF, 0xF8, 0x0F, 0x80, 0x30, 0x3C,
  0x7F, 0xFF, 0xFE, 0x01, 0xF9, 0xE0, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x00,
  0x00, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xE1, 0xC0, 0xFE, 0x00, 0x03,
  0xE0, 0x18, 0x7F, 0xE2, 0x01, 0xF0, 0x02, 0x3F, 0xFF, 0xC0, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0x00, 0x0C, 0x3F,
  0xF0, 0x0F, 0xC0, 0x0E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x1C, 0x01,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xC1, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x7F,
  0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xC0,
  0x38, 0x00, 0x00, 0x7F, 0xF8, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0x1C, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x20,
  0x0F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xC1, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x70, 0x1F, 0xFF, 0x01, 0xF8, 0x00,
  0x70, 0x01, 0xFF, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x3E, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE3, 0xC0,
  0x03, 0xF0, 0x00, 0x0F, 0xF8, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x38,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xCE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF3,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xB0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFB, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0x98, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE7, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0x83, 0xC0, 0x20, 0x7F, 0x80, 0x01, 0xE0, 0x3F, 0xF8, 0x0F,
  0xC0, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xBE, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x70, 0x3F, 0x80,
  0x00, 0x7C, 0x03, 0x0F, 0xFC, 0x20, 0x1F, 0x00, 0x23, 0xFF, 0xFC, 0x07,
  0xC0, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x7E, 0x00,
  0x18, 0x3F, 0xE0, 0x0F, 0xC0, 0x0E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x80,
  0x0E, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x07,
  0xFC, 0x00, 0xC0, 0x0F, 0xE0, 0xFF, 0xC0, 0x3E, 0x01, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFE, 0x7F, 0xE7,
  0xFC, 0x03, 0xFF, 0xE3, 0xF8, 0xFF, 0x80, 0x3F, 0xFE, 0x3E, 0x1F, 0xF0,
  0x03, 0xFF, 0xC1, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0x0F, 0xFE, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x70,
  0x00, 0x00, 0x1F, 0xFE, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x10, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x13,
  0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x3E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF8,
  0x00, 0x40, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0xFC,
  0x01, 0xF0, 0x70, 0x00, 0x07, 0xFE, 0x03, 0xF8, 0x30, 0x00, 0x07, 0xFF,
  0x03, 0xFC, 0x38, 0x00, 0x07, 0xFF, 0x87, 0xFE, 0x18, 0x00, 0x03, 0xFF,
  0x8F, 0xFE, 0x1C, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x0E, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0xF0, 0x03, 0xC0, 0x1C, 0x7F,
  0xF0, 0x70, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x20, 0x00, 0x1F, 0xC0, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x3C, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x0C, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x08, 0x7F,
  0xC0, 0x00, 0x3F, 0x00, 0x09, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1D, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x71, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0x81, 0xFF,
  0xC0, 0x1F, 0x80, 0x06, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x38, 0x01, 0xFF,
  0xE0, 0xFC, 0x01, 0xE0, 0x01, 0xFF, 0xC3, 0xF8, 0x07, 0xC0, 0x01, 0xFE,
  0x07, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xC0,
  0x3F, 0xC0, 0xFC, 0x00, 0x07, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x38, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xE0, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFE, 0x1F,
  0xE0, 0x3F, 0xF3, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xF4, 0x3F, 0xFC, 0x7F,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xBF, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0xFF, 0xC0,
  0x03, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xF1, 0xFF, 0x80,
  0x07, 0xC0, 0x0F, 0xE1, 0xFF, 0x00, 0x0F, 0x00, 0x1F, 0xC3, 0xFF, 0x00,
  0x3C, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x7E, 0x03, 0xFE, 0x03,
  0x80, 0x01, 0xF8, 0x03, 0xFE, 0x0E, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0x8F, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x9E, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x3E, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x70, 0x00, 0x3F, 0x8F, 0xFE, 0x01,
  0xC0, 0x00, 0xFC, 0x7F, 0xFC, 0x06, 0x00, 0x03, 0xF3, 0x3F, 0xF8, 0x30,
  0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x3F, 0xFF, 0x30, 0x3C, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0x80,
  0x00, 0x3F, 0xFF, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x3C, 0x00, 0x00,
  0x0F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x3E, 0x07, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xC3,
  0x9F, 0xFF, 0x00, 0x00, 0xF0, 0xC0, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x38, 0x00, 0x00, 0xFF, 0xFC, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFF,
  0x98, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x38, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0x80, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0xC0, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x81, 0xFF, 0xF8,
  0x00, 0x00, 0x70, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xE0, 0x41, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0xE0,
  0x0F, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x7E, 0x0F, 0xFF,
  0xF0, 0x1E, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0x01, 0xC0, 0x03, 0xF0, 0x78,
  0xFF, 0xF0, 0x3C, 0x00, 0x7E, 0x1C, 0x07, 0xFE, 0x07, 0x80, 0x1F, 0xC3,
  0x00, 0x7F, 0xE0, 0x70, 0x03, 0xFC, 0x40, 0x07, 0xFC, 0x0E, 0x00, 0x7F,
  0x88, 0x00, 0xFF, 0xC1, 0xE0, 0x0F, 0xF3, 0x00, 0x0F, 0xF8, 0x3C, 0x01,
  0xFF, 0x60, 0x01, 0xFF, 0x07, 0x80, 0x3F, 0xEC, 0x00, 0x1F, 0xFC, 0xE0,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC3,
  0x80, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x30,
  0x1C, 0x00, 0x1F, 0xFC, 0x00, 0x18, 0x07, 0x00, 0x01, 0xFF, 0xC0, 0x0E,
  0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x07, 0xE0, 0x70, 0x00, 0x03, 0xFF, 0x83,
  0xFE, 0x18, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE4, 0x00, 0x00, 0x07, 0xFF,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x38, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x06, 0x00, 0x0F,
  0xF8, 0x1F, 0xFF, 0xC1, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x70, 0x00,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x00,
  0xFC, 0x7F, 0x80, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x03, 0xF1, 0xFF, 0x00,
  0x00, 0x7E, 0x3F, 0xE0, 0x00, 0x0F, 0xC7, 0xFE, 0x00, 0x01, 0xF8, 0xFF,
  0xC0, 0x00, 0x7F, 0x1F, 0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0x01, 0xF8,
  0x3F, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xF3, 0x0F,
  0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0xFC, 0x00, 0x1E, 0x1F, 0xFF, 0xC0, 0x06,
  0x00, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x98,
  0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFD, 0x80, 0xFF, 0x80, 0xFE,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFC, 0x07, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xF0, 0x70, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x83, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x30, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE1, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x88, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x40,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF2, 0x00, 0x00, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC6, 0x00, 0x00,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x78, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0x80, 0x3E, 0xFF, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x38, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x03,
  0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x0C, 0x03,
  0xE0, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x07, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x3C, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x0E, 0x10, 0x03, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x63, 0xF0, 0x30, 0x07, 0xFC, 0x00, 0x1F,
  0xFC, 0x07, 0x3F, 0xC1, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x33, 0xFF,
  0x18, 0x00, 0xFF, 0xE7, 0x1F, 0xFF, 0xC3, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF1, 0x87, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF9, 0x9F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x3C, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x60, 0x3F, 0xE0, 0x1F, 0x81,
  0xFF, 0xF9, 0x80, 0x7F, 0xC0, 0x78, 0x00, 0x7F, 0xFB, 0x00, 0x7F, 0x80,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x0C, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x10, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x20, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF9, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0x83, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xC0, 0x0E, 0x03,
  0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x0E, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x38, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0x00,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x7E, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x00, 0x06, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0x0C, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xC0, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x38, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xE0, 0x01, 0xFF, 0x82, 0x0F, 0xFF, 0xC1,
  0x80, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0x86, 0x00, 0x03, 0xFF, 0xF0, 0xC3,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE3, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE7, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x8F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x03, 0xE3, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x3F, 0xF8, 0x00,
  0x70, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x07,
  0xFC, 0x0F, 0xFF, 0x80, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0xC0,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xF0, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x60, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE,
  0x30, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x18, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x0E, 0x00, 0x61, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFF, 0xC1,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0x8C, 0x00, 0x07, 0x87, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF9, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x09, 0xFF,
  0xFF, 0xE0, 0xC3, 0xFF, 0x03, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF1, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC7, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC3, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0x80, 0x7F,
  0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0x40, 0x0F, 0xF8, 0x07, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x01, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xFC, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x30,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x1E, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xE1, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0x01, 0xF9, 0xFF, 0xC0, 0x00,
  0x3E, 0x03, 0x80, 0x7E, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x83,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0x80,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x60, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x30, 0x00, 0x0F, 0xFC,
  0x20, 0x7F, 0xFF, 0x1C, 0x00, 0x03, 0xFF, 0xDC, 0x21, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x04, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x07,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0xF8,
  0x08, 0x01, 0xFF, 0xFF, 0xC3, 0xE0, 0x30, 0x1F, 0xFF, 0xFF, 0x8F, 0x80,
  0x61, 0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1B, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x2F, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xDF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0D, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x63, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0xEE, 0x00, 0x00, 0x31, 0xFF, 0xFF, 0x30, 0x00, 0x03, 0x83, 0xFF,
  0xF8, 0xC0, 0x00, 0x1C, 0x03, 0xFF, 0xC3, 0x00, 0x01, 0xF0, 0x07, 0xFE,
  0x0C, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0,
  0x37, 0xFF, 0xC0, 0x00, 0x01, 0xF3, 0x8F, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0x00,
  0x00, 0x19, 0xFF, 0xF8, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xF1, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x70, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x40, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x3E, 0x06, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x18,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x40, 0x07, 0xF0, 0x03, 0xF0, 0x02, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x10, 0x1F, 0xF8, 0x01, 0xFC, 0x01, 0x81, 0xFF,
  0xC0, 0x0F, 0xE0, 0x18, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x67, 0xF8, 0x0C, 0x3F, 0xFE, 0x0E, 0x3F,
  0xC0, 0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xE7, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF1, 0x83, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0xFF, 0xFB, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0x80, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x70, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x70, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x7C, 0x00, 0xFF, 0x00, 0x07, 0x00,
  0xC0, 0x7C, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x78, 0x00, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0xE7, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0x81, 0xFF, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xE3,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE7, 0x06, 0x60, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x38, 0x00, 0xFF,
  0xC0, 0x3F, 0x00, 0x0F, 0xFC, 0x07, 0x00, 0x07, 0xFE, 0x07, 0xC0, 0x00,
  0x7F, 0xE0, 0x70, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x03, 0xFE, 0x0F, 0x00,
  0x03, 0xFE, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x1F, 0xF0, 0x70,
  0x00, 0x01, 0xFF, 0x1F, 0x80, 0x01, 0xFF, 0x86, 0x00, 0x00, 0x0F, 0xF1,
  0xF8, 0x00, 0x0F, 0xFC, 0x60, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF,
  0x06, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x00, 0x07, 0xF1, 0xFF, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0xF0, 0x03, 0x00,
  0x00, 0x03, 0xE1, 0xFF, 0x80, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x0F,
  0xFC, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0xC0, 0x3F, 0x00,
  0x1C, 0x00, 0x10, 0x7C, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xE0, 0x06, 0x07,
  0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xC3, 0xC0, 0x78, 0x03, 0xFE, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1C, 0x03, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFC, 0x0C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x82, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0x70, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0x80, 0x7F, 0xE3, 0xFF, 0xC1, 0xF0, 0x00, 0xFF, 0x18,
  0x7E, 0x1F, 0x00, 0x03, 0xF9, 0x81, 0xC0, 0xF0, 0x00, 0x1F, 0xE8, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x78, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x00, 0x06,
  0x7F, 0x80, 0x00, 0x03, 0xC0, 0x23, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x18, 0x7F, 0xF0, 0x30, 0x1F, 0xFF, 0x83, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x41, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE1,
  0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC6, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xB0, 0x1F, 0xF8, 0x07, 0xF0, 0x3F, 0xFE, 0xC0, 0x3F, 0xE0, 0x3E,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x07, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x1C, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x70, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE3, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xCE, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE1,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x70, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x30, 0x00, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x03, 0x00, 0x0C, 0x1F, 0x00, 0x7F, 0x00, 0x07,
  0x00, 0xC0, 0x7C, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xF0, 0x0F, 0xF8,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x18, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF1, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0x9F, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0x80, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0x00, 0x0F,
  0xE0, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x38, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x1E, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x07, 0xC1, 0xFF, 0xC0, 0x00, 0x03, 0xE1, 0xFF,
  0xF0, 0x00, 0x01, 0xF3, 0xFF, 0xFC, 0x00, 0x00, 0xF3, 0xBF, 0xFF, 0x00,
  0x00, 0x71, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x38,
  0x00, 0x3F, 0xFC, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x00, 0x38, 0x00, 0x03,
  0xFF, 0xC0, 0x38, 0x00, 0x00, 0xFF, 0xFC, 0x70, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x3F, 0x0F, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0C, 0xFF,
  0xF0, 0x07, 0x0F, 0xFF, 0x01, 0xC0, 0xFF, 0xC0, 0x78, 0x03, 0xF8, 0x1F,
  0x00, 0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xFC, 0x1F, 0xE0,
  0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0xE0, 0x7F, 0x13, 0xFE, 0x1F, 0xFE,
  0x7F, 0xFD, 0xFF, 0x87, 0xFF, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xE0,
  0x7F, 0x00, 0x78, 0x07, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x20, 0x78,
  0x00, 0x06, 0x1F, 0x00, 0x00, 0x47, 0xC0, 0x00, 0x0C, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x30, 0x03,
  0xF8, 0x0E, 0x00, 0x7F, 0x03, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F,
  0xC0, 0x3F, 0xBF, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3E,
  0x0F, 0xE0, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x3F, 0x80, 0x3E, 0x07, 0xF0,
  0x07, 0xC0, 0xFE, 0x00, 0xF0, 0x1F, 0xC0, 0x3C, 0x07, 0xFE, 0x07, 0x01,
  0xFF, 0xF1, 0xC0, 0x3F, 0xFF, 0x60, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x80, 0x33, 0xF8, 0x06, 0x3F, 0xC0, 0xE1, 0xFC, 0x1E, 0x1F, 0xE3,
  0xC0, 0xFE, 0x3C, 0x0F, 0xE7, 0xC0, 0x78, 0x7C, 0x06, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x70, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xCF, 0xFC, 0x00,
  0x60, 0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F,
  0x87, 0xF0, 0x01, 0xF0, 0xFE, 0x00, 0x3E, 0x1F, 0xC0, 0x07, 0xC3, 0xF8,
  0x00, 0xF0, 0x7F, 0x00, 0x1E, 0x0F, 0xE0, 0x03, 0xC1, 0xFC, 0x00, 0x70,
  0x3F, 0xC0, 0x0E, 0x0F, 0xFE, 0x03, 0x83, 0xFF, 0xF0, 0x60, 0x1F, 0xFF,
  0x18, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x33, 0xF8, 0x07,
  0x1F, 0xC0, 0x38, 0x7F, 0x03, 0xC3, 0xF8, 0x3C, 0x0F, 0xE1, 0xE0, 0x7F,
  0x1F, 0x03, 0xF8, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFB, 0xF0,
  0x0E, 0x1F, 0x83, 0xC0, 0xFC, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xFC, 0x10, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x31, 0xFC, 0x06, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x67, 0xFF, 0x00,
  0x1C, 0xFF, 0xFC, 0x07, 0x07, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x03,
  0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3F,
  0x00, 0x0F, 0x07, 0xE0, 0x01, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF,
  0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0x03, 0xFF, 0xCF, 0xE0, 0x7F, 0xE1, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xF0, 0x03, 0xF0, 0x18, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xFC, 0x00,
  0xF0, 0x1F, 0x80, 0x3C, 0x01, 0xF8, 0x0E, 0x00, 0x1F, 0x87, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x20, 0x7C, 0x00, 0x06, 0x1F, 0x00, 0x00, 0x47,
  0xC0, 0x00, 0x0D, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x01, 0x00, 0x1F, 0xC0, 0x60, 0x03, 0xF8, 0x3C, 0x00, 0x7F, 0x0F, 0xC0,
  0x0F, 0xE7, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F,
  0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0x7C, 0x1F, 0xE3, 0x1F,
  0x07, 0xFF, 0x83, 0xE0, 0x7F, 0xF0, 0x78, 0x07, 0xF8, 0x1E, 0x00, 0x3E,
  0x03, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0xCF, 0xF0, 0x8F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE2, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF8,
  0x37, 0xF8, 0x19, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFB, 0x00, 0x7C, 0x40, 0x3E, 0x08, 0x0F, 0x03, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x20, 0x3C, 0x02, 0x0F, 0x00, 0x63, 0xE0, 0xC4, 0xFC, 0x78, 0xFF,
  0x1F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0xBF, 0x87, 0xFF, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x84, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x60, 0x7C, 0x06, 0x1F, 0x00,
  0x63, 0xE0, 0x04, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x20, 0x7F, 0x8C, 0x1F,
  0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xFE,
  0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0x3F,
  0xF8, 0x8F, 0xF0, 0x7F, 0xC1, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xE2, 0x7F, 0xF1, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xC0,
  0x1F, 0x00, 0x7F, 0x80, 0x78, 0x01, 0xC0, 0x07, 0xE0, 0x0E, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x80, 0x02, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x01, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x3F,
  0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0xFF, 0xFE, 0x37, 0xFE,
  0x3F, 0xF0, 0x8F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xFC, 0x0F, 0xE2, 0x3F, 0xF8, 0x1F, 0xCC, 0x7F, 0xC0, 0x7F,
  0xE0, 0xFE, 0x01, 0xFF, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xF0, 0x0F, 0xE3, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xF0, 0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0xFE,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0x8F, 0xE0, 0x03, 0xE3, 0xF8,
  0x01, 0xF0, 0xFE, 0x00, 0x7C, 0x3F, 0x80, 0x1E, 0x0F, 0xF0, 0x07, 0x07,
  0xFF, 0x03, 0x83, 0xFF, 0xF1, 0xC0, 0x3F, 0xFE, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x30, 0x0F, 0xF8, 0x07, 0x80, 0x7F, 0xE0,
  0x7C, 0x03, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0x87, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0x3C, 0x1F, 0xF8, 0x03, 0xE1, 0xFF, 0xC0, 0x1E, 0x0F, 0xFF, 0x80,
  0xE0, 0xFF, 0xFF, 0x0E, 0x07, 0xFF, 0xFE, 0x60, 0x20, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xCE, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0D, 0xFF,
  0x80, 0x06, 0x3F, 0xFC, 0x07, 0x07, 0xFF, 0xC3, 0xC0, 0xFF, 0xC1, 0xE0,
  0x0F, 0xE0, 0x78, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0x8F, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F,
  0xE0, 0x1F, 0x87, 0xFC, 0x07, 0xE0, 0xFF, 0x83, 0xF8, 0x3F, 0xF1, 0xFE,
  0x07, 0xFF, 0x9F, 0x80, 0xFF, 0xC7, 0xE0, 0x1F, 0xE1, 0xF8, 0x03, 0xE0,
  0x7E, 0x00, 0x70, 0x1F, 0x80, 0x18, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x38, 0x01, 0x01, 0xF8, 0x0E, 0x07, 0xF0,
  0x7C, 0x3F, 0xE3, 0xF0, 0xFF, 0x9F, 0xE7, 0xFF, 0xFF, 0x93, 0xFF, 0xFF,
  0x07, 0xF9, 0xF8, 0x1F, 0xC7, 0xC0, 0x7F, 0x0E, 0x01, 0xFC, 0x38, 0x07,
  0xF0, 0x40, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x04, 0x01, 0xFE, 0x20, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x38, 0x01, 0x80, 0x3F, 0x00, 0xC0, 0x7F,
  0xE0, 0xE0, 0x7F, 0xFF, 0xF0, 0x67, 0xFF, 0xF0, 0x61, 0xFF, 0xF0, 0x60,
  0x3F, 0xF0, 0x70, 0x07, 0xF0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x30, 0x1F,
  0x00, 0x30, 0x0F, 0xC0, 0x38, 0x07, 0xF0, 0x3E, 0x03, 0xFC, 0x3F, 0x81,
  0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF,
  0x03, 0xF0, 0x3F, 0xC0, 0xF0, 0x0F, 0xE0, 0x30, 0x03, 0xF0, 0x30, 0x00,
  0xF8, 0x10, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1F, 0xC0, 0x18, 0x1F, 0xF8,
  0x0C, 0x1F, 0xFF, 0x8C, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC2,
  0x0F, 0xFD, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00, 0x78, 0x00,
  0x38, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x3F,
  0x81, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x27, 0xF8, 0x1F, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xFC, 0x1F, 0xF2, 0x3F, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F,
  0xE1, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xC0,
  0x0F, 0x00, 0x03, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x18, 0x03, 0xC0, 0x01, 0xE0,
  0x1F, 0x00, 0x3F, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0xF0, 0x7F,
  0x87, 0xFF, 0x83, 0xFE, 0xE3, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7E, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x03,
  0xF0, 0x07, 0x80, 0x1F, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xFC, 0x03, 0x80, 0x0F, 0xF8, 0x38, 0x00, 0xFF,
  0xF1, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x6F, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0x00, 0x03,
  0x03, 0xFE, 0x00, 0xF0, 0x01, 0xC0, 0xFF, 0xC0, 0x7E, 0x01, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F,
  0xFE, 0xFF, 0xF8, 0x1F, 0xEC, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xFE,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x7E,
  0x01, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0x81,
  0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x1F, 0x80,
  0x7F, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0xC0, 0x1E, 0x01, 0xF8, 0x07, 0xF0,
  0x07, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0xC0,
  0x0F, 0xF0, 0x7F, 0xFC, 0x60, 0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x10, 0x03, 0xC0, 0x38, 0x07, 0xF0, 0x78,
  0x0F, 0xF0, 0xFC, 0x0F, 0xF8, 0xFC, 0x1F, 0xF9, 0xFE, 0x13, 0xFF, 0xFE,
  0x21, 0xFE, 0xFF, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7C, 0x01, 0xFC, 0x38,
  0x01, 0xFC, 0x10, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x30,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x38, 0x7E, 0x00, 0x70, 0x1C, 0x00, 0x60, 0x08, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x0C, 0x01, 0xF8,
  0x07, 0x87, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x20, 0x0F, 0xF0, 0x03, 0x00, 0x7F, 0xC0, 0x3C, 0x03,
  0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xEF, 0xFE, 0x01, 0xFF,
  0x8F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80,
  0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F,
  0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x84, 0x3E, 0x03, 0xFE, 0xC1, 0xF0, 0x3F, 0xFC,
  0x0F, 0x00, 0xFF, 0xC0, 0xF0, 0x01, 0xFC, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0C, 0x7F,
  0x82, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x10, 0x18, 0x06, 0x0F, 0x03,
  0x03, 0xF9, 0x80, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x37, 0xFC, 0x0C, 0x7F, 0x83, 0x87, 0xF8, 0x60, 0xFF,
  0x18, 0x0F, 0xE3, 0x01, 0xFC, 0xE0, 0x1F, 0x98, 0x03, 0xF7, 0x00, 0x7E,
  0xE0, 0x0F, 0xDC, 0x01, 0xFB, 0x80, 0x3F, 0x70, 0x07, 0xEE, 0x00, 0xFD,
  0xC0, 0x1F, 0x38, 0x03, 0xE7, 0x00, 0x78, 0x60, 0x0F, 0x0C, 0x01, 0xC0,
  0xC0, 0x70, 0x08, 0x0C, 0x00, 0xC7, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
};

const GFXglyph UnifrakturMaguntia_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 12, 49, 15, 2, -48 },
  { 75, 22, 18, 27, 2, -47 },
  { 125, 30, 37, 34, 2, -42 },
  { 264, 23, 53, 28, 2, -50 },
  { 417, 43, 46, 47, 2, -47 },
  { 665, 34, 42, 38, 2, -41 },
  { 844, 11, 18, 13, 1, -47 },
  { 869, 15, 54, 16, 1, -52 },
  { 971, 15, 54, 16, 1, -52 },
  { 1073, 22, 25, 23, 0, -49 },
  { 1142, 22, 23, 26, 2, -33 },
  { 1206, 11, 18, 12, 0, -10 },
  { 1231, 18, 13, 20, 2, -26 },
  { 1261, 11, 11, 13, 1, -10 },
  { 1277, 32, 52, 34, 2, -49 },
  { 1485, 29, 47, 31, 1, -46 },
  { 1656, 19, 45, 21, 1, -45 },
  { 1763, 27, 45, 30, 1, -45 },
  { 1915, 29, 45, 31, 1, -45 },
  { 2079, 28, 45, 30, 1, -45 },
  { 2237, 29, 46, 31, 1, -46 },
  { 2404, 28, 47, 30, 1, -47 },
  { 2569, 27, 45, 28, 1, -45 },
  { 2721, 28, 46, 31, 1, -46 },
  { 2882, 28, 47, 30, 1, -47 },
  { 3047, 11, 32, 13, 1, -31 },
  { 3091, 12, 39, 11, 0, -31 },
  { 3150, 18, 25, 19, 0, -31 },
  { 3207, 22, 15, 26, 2, -27 },
  { 3249, 18, 25, 19, 0, -31 },
  { 3306, 25, 48, 30, 2, -47 },
  { 3456, 39, 39, 40, 1, -30 },
  { 3647, 51, 48, 54, 1, -47 },
  { 3953, 57, 49, 59, 0, -48 },
  { 4303, 42, 49, 45, 2, -48 },
  { 4561, 50, 51, 54, 2, -48 },
  { 4880, 43, 49, 46, 2, -48 },
  { 5144, 48, 56, 50, 1, -48 },
  { 5480, 47, 50, 51, 2, -48 },
  { 5774, 46, 60, 48, 1, -51 },
  { 6119, 43, 57, 45, 1, -49 },
  { 6426, 44, 65, 47, 1, -49 },
  { 6784, 51, 49, 54, 1, -47 },
  { 7097, 35, 47, 38, 1, -46 },
  { 7303, 69, 49, 73, 2, -46 },
  { 7726, 55, 48, 58, 2, -47 },
  { 8056, 47, 49, 50, 1, -47 },
  { 8344, 56, 57, 59, 1, -46 },
  { 8743, 50, 52, 53, 1, -47 },
  { 9068, 58, 49, 61, 2, -48 },
  { 9424, 46, 48, 50, 2, -47 },
  { 9700, 46, 48, 49, 2, -47 },
  { 9976, 45, 50, 47, 1, -46 },
  { 10258, 56, 49, 59, 1, -48 },
  { 10601, 68, 48, 71, 1, -47 },
  { 11009, 45, 49, 48, 1, -48 },
  { 11285, 54, 58, 57, 1, -48 },
  { 11677, 41, 58, 44, 1, -48 },
  { 11975, 9, 52, 12, 1, -49 },
  { 12034, 40, 46, 7, -12, -43 },
  { 12264, 9, 52, 12, 1, -49 },
  { 12323, 25, 19, 28, 1, -47 },
  { 12383, 32, 5, 30, -1, 7 },
  { 12403, 10, 12, 33, 11, -46 },
  { 12418, 27, 36, 30, 2, -34 },
  { 12540, 27, 48, 29, 1, -46 },
  { 12702, 20, 34, 23, 2, -33 },
  { 12787, 27, 47, 30, 2, -46 },
  { 12946, 21, 35, 24, 2, -34 },
  { 13038, 20, 60, 16, -1, -49 },
  { 13188, 27, 48, 31, 2, -34 },
  { 13350, 27, 57, 29, 1, -46 },
  { 13543, 16, 47, 18, 1, -46 },
  { 13637, 18, 59, 16, -3, -47 },
  { 13770, 19, 48, 21, 1, -46 },
  { 13884, 19, 48, 18, 1, -46 },
  { 13998, 43, 36, 47, 2, -35 },
  { 14192, 30, 36, 33, 2, -34 },
  { 14327, 26, 35, 27, 0, -34 },
  { 14441, 29, 52, 30, 0, -39 },
  { 14630, 26, 48, 28, 1, -34 },
  { 14786, 22, 35, 24, 1, -34 },
  { 14883, 25, 42, 28, 1, -41 },
  { 15015, 18, 44, 20, 1, -42 },
  { 15114, 30, 35, 33, 2, -34 },
  { 15246, 29, 38, 30, -1, -37 },
  { 15384, 42, 41, 45, 2, -39 },
  { 15600, 24, 49, 26, 1, -35 },
  { 15747, 29, 51, 31, 1, -40 },
  { 15932, 19, 46, 22, 2, -34 },
  { 16042, 18, 52, 22, 1, -51 },
  { 16159, 4, 54, 10, 3, -51 },
  { 16186, 18, 52, 22, 1, -51 },
  { 16303, 21, 5, 24, 2, -22 },
};

const GFXfont UnifrakturMaguntia_Regular66pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular66pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular66pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR66PT7B_H_
