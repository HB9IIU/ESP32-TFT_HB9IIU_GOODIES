#ifndef _UNIFRAKTURMAGUNTIA_REGULAR14PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0x5D, 0x24, 0x90, 0x4C, 0x57, 0x52, 0xA0, 0x24, 0xFC, 0xA1, 0x4F,
  0xC5, 0x1A, 0x00, 0x21, 0x92, 0x94, 0x38, 0x69, 0x8A, 0x4C, 0x40, 0x60,
  0x94, 0x2D, 0x13, 0x48, 0x54, 0x1A, 0xE1, 0x28, 0x8B, 0x42, 0x90, 0xE0,
  0x18, 0x24, 0x28, 0x30, 0x57, 0x5A, 0xCC, 0x4C, 0x7F, 0x76, 0x29, 0x6D,
  0xB6, 0x49, 0x80, 0xC8, 0x92, 0x49, 0x27, 0x00, 0x27, 0xFC, 0x50, 0x44,
  0xF4, 0x40, 0x76, 0x16, 0xF0, 0x58, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08,
  0x10, 0x41, 0x02, 0x00, 0x39, 0xA4, 0xF3, 0xCF, 0x3C, 0xD3, 0x4C, 0xE0,
  0x26, 0xA2, 0x22, 0x22, 0x6F, 0x7A, 0x38, 0xC3, 0x08, 0x46, 0x5F, 0xFC,
  0x3B, 0x30, 0xC2, 0x38, 0x30, 0x71, 0x4D, 0xE0, 0x08, 0x61, 0x9E, 0x5A,
  0x6F, 0xC6, 0x18, 0xF0, 0x7D, 0xC4, 0x1E, 0x7E, 0x30, 0x71, 0x4D, 0xE0,
  0x39, 0xA4, 0xD0, 0xFB, 0x3C, 0x53, 0x4C, 0xE0, 0x7E, 0x20, 0x82, 0x10,
  0x43, 0x08, 0x60, 0x39, 0x14, 0x5A, 0x79, 0x38, 0x61, 0xC5, 0xE0, 0x39,
  0x2C, 0xF3, 0xCD, 0x33, 0xD3, 0x48, 0xC0, 0x9A, 0x00, 0xB0, 0x9A, 0x00,
  0xB2, 0x80, 0x12, 0x6C, 0x23, 0xF8, 0x3E, 0x8C, 0x63, 0x48, 0x79, 0x3C,
  0xD3, 0x31, 0x04, 0x8C, 0x10, 0xC0, 0x1E, 0x62, 0x4D, 0x95, 0xA5, 0xAF,
  0x7F, 0x63, 0x3C, 0x3C, 0x79, 0xBA, 0x1B, 0x43, 0x66, 0x6C, 0x69, 0x8A,
  0x30, 0x86, 0x3D, 0xE1, 0xD8, 0x3D, 0xC4, 0xE6, 0x86, 0x68, 0x63, 0x82,
  0xE7, 0x53, 0x08, 0x31, 0xC1, 0x2E, 0x20, 0x7C, 0x3B, 0x36, 0xD2, 0x0B,
  0x0C, 0xC2, 0x31, 0x88, 0xC4, 0x3C, 0x0F, 0xC0, 0x3F, 0x0E, 0x71, 0x23,
  0x44, 0x38, 0xC3, 0x0C, 0x5C, 0x88, 0x22, 0x3C, 0x49, 0xF0, 0x00, 0x00,
  0x3B, 0x1B, 0x64, 0x81, 0x64, 0xCF, 0xD1, 0x86, 0x21, 0x88, 0x3C, 0x07,
  0xE0, 0x1E, 0x1F, 0xE4, 0x3E, 0x10, 0x84, 0xA1, 0xB4, 0xF4, 0xCC, 0x71,
  0x8C, 0x63, 0x10, 0xC8, 0x1C, 0x00, 0x1D, 0x09, 0xE4, 0x8D, 0x64, 0xCF,
  0xF3, 0xB6, 0x65, 0x91, 0x38, 0xC7, 0xC0, 0x00, 0x03, 0x03, 0x70, 0x80,
  0x33, 0x0D, 0xE1, 0x8C, 0x73, 0x0C, 0xFA, 0x33, 0x08, 0x04, 0x06, 0x00,
  0x3C, 0x23, 0xD0, 0x48, 0x44, 0x21, 0xD8, 0x0E, 0x03, 0x01, 0xF8, 0x46,
  0x41, 0xC0, 0x3C, 0x11, 0xE8, 0x12, 0x08, 0x43, 0x0E, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x26, 0x0A, 0xC4, 0x1E, 0x00, 0x07, 0x83, 0x08, 0xDC, 0x9C,
  0xD3, 0x8E, 0x32, 0x87, 0xE0, 0x6C, 0x68, 0xD6, 0x1C, 0x1C, 0x62, 0x63,
  0x63, 0x72, 0x3C, 0x20, 0x20, 0xF9, 0x1E, 0x39, 0x98, 0xFD, 0xDA, 0x19,
  0xB4, 0x33, 0x38, 0x26, 0x8E, 0x4D, 0x00, 0x96, 0x02, 0x2C, 0x77, 0x8E,
  0x7B, 0x18, 0x00, 0x00, 0x38, 0xC7, 0xF6, 0x86, 0x68, 0x63, 0x82, 0x47,
  0x24, 0x02, 0xC0, 0x2C, 0x74, 0xF1, 0x86, 0x0E, 0x07, 0xC6, 0x19, 0x03,
  0xE0, 0x5E, 0x11, 0x84, 0x82, 0xF8, 0x87, 0xC0, 0x38, 0xC5, 0xD8, 0x8E,
  0xC8, 0x66, 0x86, 0x37, 0x61, 0x06, 0x10, 0x62, 0x0F, 0x21, 0x7C, 0x04,
  0x00, 0x40, 0x0E, 0x03, 0xE1, 0x86, 0x20, 0x6E, 0x04, 0xF0, 0x86, 0x11,
  0x0C, 0xFF, 0xA3, 0xD8, 0x00, 0x00, 0x38, 0xC3, 0xEB, 0x21, 0x9D, 0x04,
  0x68, 0x24, 0x25, 0x60, 0xC9, 0x80, 0x4C, 0x34, 0x62, 0xC1, 0xC0, 0x0E,
  0x0D, 0xF4, 0x11, 0x04, 0xA7, 0xB7, 0x94, 0x05, 0x81, 0x3F, 0x87, 0xC0,
  0x3C, 0x11, 0xC8, 0x9E, 0x20, 0x8C, 0x1D, 0x82, 0x21, 0xD0, 0x1C, 0x83,
  0xC0, 0x38, 0x9A, 0x46, 0x31, 0xC4, 0x31, 0x04, 0x42, 0x10, 0x84, 0x77,
  0x26, 0x70, 0x00, 0x39, 0xC4, 0xE6, 0x86, 0x68, 0x24, 0x82, 0x47, 0x46,
  0x08, 0x33, 0xC3, 0x0E, 0x20, 0x7C, 0x39, 0x78, 0xDD, 0x32, 0x1A, 0x34,
  0x14, 0x48, 0x2C, 0x8E, 0x9B, 0x82, 0x13, 0x9C, 0x22, 0x4C, 0xE4, 0x1E,
  0xF0, 0x39, 0xD3, 0x68, 0x62, 0x10, 0x4F, 0x8D, 0x00, 0x60, 0x18, 0x7B,
  0xAC, 0xE0, 0x3D, 0xC4, 0xE6, 0x86, 0x68, 0x23, 0x82, 0x47, 0x4C, 0x04,
  0x60, 0x86, 0x1F, 0x60, 0x66, 0x20, 0x41, 0xF8, 0x1E, 0x11, 0x90, 0x48,
  0x23, 0x20, 0xF8, 0x06, 0x03, 0x60, 0xF8, 0x86, 0x80, 0x80, 0xEA, 0xAA,
  0xAC, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x00, 0xD5, 0x55, 0x5C, 0x21, 0x93, 0x10, 0xFE, 0xD4, 0x11, 0xF4, 0xB2,
  0xC9, 0x27, 0xC0, 0x13, 0x86, 0x1A, 0x79, 0xB6, 0x59, 0x68, 0xC0, 0x32,
  0x93, 0x8C, 0x30, 0xE0, 0x42, 0x06, 0x0E, 0x2D, 0x96, 0x59, 0x68, 0xC0,
  0x32, 0x97, 0xCC, 0x30, 0xE0, 0x78, 0x8F, 0x44, 0x44, 0x44, 0x44, 0x40,
  0x11, 0xF4, 0xB2, 0xC9, 0x37, 0xC3, 0x49, 0xC0, 0x13, 0x84, 0x16, 0x69,
  0xB6, 0xDB, 0x6D, 0xE1, 0x08, 0x66, 0x04, 0xE6, 0x66, 0x66, 0x32, 0x02,
  0x72, 0x22, 0x22, 0x23, 0xC0, 0x1B, 0x76, 0xF6, 0x66, 0x72, 0x1A, 0x66,
  0x66, 0x66, 0x72, 0x4B, 0x3F, 0x66, 0xD9, 0xB6, 0x6D, 0x9B, 0x62, 0xCC,
  0x49, 0xF9, 0xB3, 0x66, 0xCD, 0x99, 0x80, 0x36, 0xF3, 0x9C, 0xF8, 0x80,
  0x83, 0x27, 0xD3, 0x65, 0x9E, 0x9C, 0x41, 0x04, 0x00, 0x11, 0xF4, 0xB2,
  0xC9, 0x27, 0x82, 0x08, 0x20, 0x57, 0xDC, 0xC6, 0x38, 0x80, 0x10, 0xA3,
  0xB6, 0xD1, 0xE4, 0xBC, 0x30, 0x32, 0x6F, 0x66, 0x67, 0x20, 0x4D, 0xD9,
  0xB3, 0x66, 0xCD, 0xCD, 0x00, 0x82, 0x6E, 0xDB, 0x25, 0x16, 0x8C, 0xC0,
  0x64, 0x9F, 0xED, 0x96, 0xCB, 0x65, 0xBC, 0x44, 0x69, 0xC8, 0x42, 0x19,
  0x90, 0x93, 0xC0, 0xC3, 0xA7, 0xD9, 0x65, 0x96, 0x4E, 0x10, 0x80, 0x27,
  0x25, 0xE9, 0x99, 0x96, 0x12, 0x66, 0x2C, 0x42, 0x66, 0x30, 0xFF, 0xF0,
  0xC2, 0x26, 0x21, 0x26, 0x62, 0xC0, 0xF8,
};

const GFXglyph UnifrakturMaguntia_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 5, 4, 6, 0, -10 },
  { 8, 7, 7, 7, 0, -8 },
  { 15, 5, 12, 6, 0, -11 },
  { 23, 10, 10, 10, 0, -10 },
  { 36, 8, 9, 8, 0, -9 },
  { 45, 2, 4, 3, 0, -10 },
  { 46, 3, 11, 3, 0, -11 },
  { 51, 3, 11, 3, 0, -11 },
  { 56, 5, 4, 5, 0, -10 },
  { 59, 4, 5, 6, 1, -7 },
  { 62, 2, 4, 3, 0, -2 },
  { 63, 4, 3, 4, 0, -6 },
  { 65, 3, 2, 3, 0, -2 },
  { 66, 7, 11, 7, 0, -10 },
  { 76, 6, 10, 7, 0, -10 },
  { 84, 4, 10, 4, 0, -10 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 10, 7, 0, -10 },
  { 104, 6, 10, 6, 0, -10 },
  { 112, 6, 10, 7, 0, -10 },
  { 120, 6, 10, 6, 0, -10 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 6, 10, 7, 0, -10 },
  { 143, 6, 10, 6, 0, -10 },
  { 151, 3, 7, 3, 0, -7 },
  { 154, 3, 9, 2, 0, -7 },
  { 158, 4, 6, 4, 0, -7 },
  { 161, 5, 3, 5, 0, -6 },
  { 163, 4, 6, 4, 0, -7 },
  { 166, 6, 10, 6, 0, -10 },
  { 174, 8, 9, 9, 0, -7 },
  { 183, 11, 10, 11, 0, -10 },
  { 197, 12, 10, 13, 0, -10 },
  { 212, 9, 10, 10, 0, -10 },
  { 224, 11, 11, 11, 0, -10 },
  { 240, 10, 10, 10, 0, -10 },
  { 253, 10, 13, 11, 0, -11 },
  { 270, 10, 10, 11, 0, -10 },
  { 283, 10, 13, 10, 0, -11 },
  { 300, 9, 12, 10, 0, -10 },
  { 314, 10, 13, 10, 0, -10 },
  { 331, 11, 10, 11, 0, -10 },
  { 345, 8, 10, 8, 0, -10 },
  { 355, 15, 11, 15, 0, -10 },
  { 376, 12, 10, 12, 0, -10 },
  { 391, 10, 10, 11, 0, -10 },
  { 404, 12, 12, 12, 0, -10 },
  { 422, 11, 11, 11, 0, -10 },
  { 438, 13, 10, 13, 0, -10 },
  { 455, 10, 10, 11, 0, -10 },
  { 468, 10, 10, 10, 0, -10 },
  { 481, 10, 11, 10, 0, -10 },
  { 495, 12, 10, 12, 0, -10 },
  { 510, 15, 10, 15, 0, -10 },
  { 529, 10, 10, 10, 0, -10 },
  { 542, 12, 12, 12, 0, -10 },
  { 560, 9, 12, 9, 0, -10 },
  { 574, 2, 11, 3, 0, -10 },
  { 577, 9, 10, 2, -3, -9 },
  { 589, 2, 11, 3, 0, -10 },
  { 592, 5, 4, 6, 0, -10 },
  { 595, 7, 1, 6, 0, 2 },
  { 596, 2, 3, 7, 2, -10 },
  { 597, 6, 7, 6, 0, -7 },
  { 603, 6, 10, 6, 0, -10 },
  { 611, 5, 7, 5, 0, -7 },
  { 616, 6, 10, 6, 0, -10 },
  { 624, 5, 7, 5, 0, -7 },
  { 629, 4, 13, 3, 0, -10 },
  { 636, 6, 10, 7, 0, -7 },
  { 644, 6, 12, 6, 0, -10 },
  { 653, 4, 10, 4, 0, -10 },
  { 658, 4, 13, 3, -1, -10 },
  { 665, 4, 10, 5, 0, -10 },
  { 670, 4, 10, 4, 0, -10 },
  { 675, 10, 7, 10, 0, -7 },
  { 684, 7, 7, 7, 0, -7 },
  { 691, 5, 7, 6, 0, -7 },
  { 696, 6, 11, 6, 0, -8 },
  { 705, 6, 10, 6, 0, -7 },
  { 713, 5, 7, 5, 0, -7 },
  { 718, 6, 9, 6, 0, -9 },
  { 725, 4, 9, 4, 0, -9 },
  { 730, 7, 7, 7, 0, -7 },
  { 737, 6, 8, 6, 0, -8 },
  { 743, 9, 8, 10, 0, -8 },
  { 752, 5, 10, 6, 0, -7 },
  { 759, 6, 10, 7, 0, -8 },
  { 767, 4, 10, 5, 0, -7 },
  { 772, 4, 11, 5, 0, -11 },
  { 778, 1, 12, 2, 1, -11 },
  { 780, 4, 11, 5, 0, -11 },
  { 786, 5, 1, 5, 0, -5 },
};

const GFXfont UnifrakturMaguntia_Regular14pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular14pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular14pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR14PT7B_H_
