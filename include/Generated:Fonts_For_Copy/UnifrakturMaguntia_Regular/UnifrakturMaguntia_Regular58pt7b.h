#ifndef _UNIFRAKTURMAGUNTIA_REGULAR58PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x00, 0xC0, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0xDF, 0xF1, 0xFE,
  0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x18, 0x07, 0x01, 0xF0, 0x7F, 0x9F, 0xF0, 0xF8, 0x0E, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x80, 0xC0, 0x18, 0x1E, 0x03, 0xC3, 0xF0, 0x7E, 0x7F,
  0xCF, 0xF3, 0xFC, 0x7F, 0x0F, 0x83, 0xF0, 0x78, 0x1F, 0x07, 0x80, 0xF0,
  0x70, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00, 0x80, 0x40, 0x18,
  0x08, 0x01, 0x01, 0x00, 0x20, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0xF0,
  0x70, 0x1E, 0x01, 0x83, 0xC0, 0x1C, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x7E, 0x01, 0xE7,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE2, 0x01, 0xFF, 0x70, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0x30,
  0x01, 0xC3, 0x80, 0x3C, 0x1E, 0x07, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x10, 0x7F, 0xC0, 0x00, 0x00,
  0xE3, 0xC7, 0x80, 0x00, 0x07, 0x0F, 0x0F, 0x00, 0x00, 0x18, 0x7C, 0x3C,
  0x00, 0x00, 0xC1, 0xE0, 0xF8, 0x00, 0x07, 0x0F, 0x83, 0xE0, 0x00, 0x38,
  0x3E, 0x0F, 0xC0, 0x01, 0xC0, 0xF8, 0x3F, 0x00, 0x0E, 0x03, 0xE0, 0xFC,
  0x00, 0x70, 0x0F, 0x83, 0xF0, 0x01, 0x80, 0x3E, 0x0F, 0xC0, 0x0C, 0x00,
  0xF8, 0x3F, 0x00, 0x70, 0x03, 0xE0, 0xFC, 0x03, 0x80, 0x0F, 0x83, 0xE0,
  0x1C, 0x00, 0x1E, 0x0F, 0x80, 0xE0, 0x00, 0x7C, 0x3C, 0x07, 0x00, 0x00,
  0xF0, 0xF0, 0x38, 0x00, 0x03, 0xC7, 0x80, 0xC0, 0x00, 0x07, 0xFC, 0x06,
  0x07, 0xC0, 0x07, 0xC0, 0x38, 0x7F, 0xC0, 0x00, 0x01, 0xC3, 0xC7, 0x80,
  0x00, 0x0E, 0x1F, 0x1F, 0x00, 0x00, 0x70, 0x78, 0x3C, 0x00, 0x03, 0x83,
  0xE0, 0xF8, 0x00, 0x0C, 0x0F, 0x83, 0xE0, 0x00, 0x60, 0x3E, 0x0F, 0x80,
  0x03, 0x80, 0xF8, 0x3F, 0x00, 0x1C, 0x07, 0xE0, 0xFC, 0x00, 0xE0, 0x1F,
  0x83, 0xF0, 0x07, 0x00, 0x7E, 0x0F, 0xC0, 0x38, 0x01, 0xF8, 0x3F, 0x01,
  0xC0, 0x03, 0xE0, 0xF8, 0x06, 0x00, 0x0F, 0x83, 0xE0, 0x30, 0x00, 0x3E,
  0x0F, 0x81, 0xC0, 0x00, 0x78, 0x3C, 0x0E, 0x00, 0x01, 0xF1, 0xF0, 0x70,
  0x00, 0x03, 0xC7, 0x83, 0x80, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3F, 0x07, 0x80, 0x00, 0xFC, 0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x0F,
  0xC3, 0xC0, 0x00, 0x3F, 0x9E, 0x00, 0x00, 0xFE, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x83,
  0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x07, 0x80, 0xE7, 0xF0, 0x1C,
  0x07, 0x1F, 0xC0, 0x70, 0x3C, 0x3F, 0x81, 0x81, 0xF0, 0xFE, 0x06, 0x07,
  0xC1, 0xFC, 0x18, 0x3F, 0x07, 0xF0, 0x40, 0xFC, 0x0F, 0xE3, 0x03, 0xF0,
  0x3F, 0x8C, 0x0F, 0xC0, 0x7F, 0x60, 0x3F, 0x01, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x9F, 0xE0, 0x3F,
  0xC7, 0x3F, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF3, 0xFE,
  0x00, 0xFF, 0x03, 0xE0, 0x08, 0x06, 0x07, 0x8F, 0xEF, 0xF9, 0xFC, 0x7E,
  0x1F, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x00, 0x10,
  0x07, 0x80, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x33, 0xFE,
  0x3F, 0x3C, 0xFB, 0xE7, 0x3F, 0x7E, 0x67, 0xCF, 0xC9, 0xF8, 0xFF, 0xFF,
  0x00, 0x70, 0x06, 0x3F, 0x8C, 0xFE, 0x9F, 0x9F, 0x9B, 0xF3, 0xE3, 0x3F,
  0xFC, 0xE7, 0xE1, 0xBE, 0x60, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x08, 0x06, 0x07, 0x87, 0xE7, 0xFB, 0xFC,
  0x7E, 0x1F, 0x07, 0x83, 0x81, 0xC0, 0xC0, 0x60, 0x20, 0x20, 0x10, 0x00,
  0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0xFC, 0x00, 0x08, 0x02, 0x01,
  0xC0, 0xF8, 0xFF, 0x9F, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xFD, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07,
  0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00,
  0x7E, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x03, 0xC7, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1B, 0xFC, 0x10, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1E, 0x07, 0xFC, 0x38, 0x03,
  0xFE, 0x70, 0x01, 0xFE, 0x70, 0x00, 0xFE, 0x60, 0x00, 0xFE, 0x60, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0x01, 0xC0,
  0x03, 0x03, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x03, 0xC1, 0xFF, 0x81, 0x80, 0x3F, 0xC1, 0x80, 0x0F, 0xF1, 0x80,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0xC0,
  0x01, 0xFD, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x3F, 0x7F,
  0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x0F, 0xC0, 0x07, 0x07, 0xE0, 0x07, 0x01,
  0xF8, 0x07, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x6F, 0xC0, 0x00, 0x67,
  0xE0, 0x00, 0x63, 0xF0, 0x00, 0x31, 0xF8, 0x00, 0x30, 0xFC, 0x00, 0x30,
  0x7E, 0x00, 0x18, 0x3F, 0x00, 0x18, 0x1F, 0x80, 0x18, 0x0F, 0xC0, 0x0C,
  0x07, 0xE0, 0x0C, 0x03, 0xF0, 0x0C, 0x01, 0xF8, 0x06, 0x00, 0xFC, 0x06,
  0x00, 0x7E, 0x03, 0x00, 0x3F, 0x03, 0x00, 0x1F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x0C,
  0x00, 0x0C, 0x07, 0xE0, 0x7C, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC7, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xE0,
  0x7F, 0xC3, 0xC0, 0x0F, 0xF1, 0xC0, 0x03, 0xF8, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x7D,
  0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x1F, 0x7F, 0x00, 0x0F, 0x1F, 0x80, 0x0F,
  0x0F, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0x80, 0xF8, 0x07, 0x00, 0x3E, 0x07,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE1, 0xF0, 0x01, 0xC0,
  0xF8, 0x03, 0x80, 0xFC, 0x07, 0x80, 0xFC, 0x07, 0x80, 0xFE, 0x0F, 0x80,
  0xFE, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x3C, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x3F, 0xF0, 0x7E, 0x7F, 0xFC, 0x7E, 0x61,
  0xFC, 0xFE, 0xC0, 0xFE, 0xFE, 0xC0, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x3F, 0x00,
  0x7C, 0x1F, 0x80, 0x78, 0x0F, 0x80, 0x70, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0xE0, 0x01, 0xE1, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x62,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x01, 0xE0, 0x1C, 0x01,
  0xE0, 0x07, 0x01, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x80, 0x07,
  0x8F, 0xE0, 0x03, 0xC3, 0xF8, 0x03, 0xC1, 0xFF, 0x01, 0xC0, 0xFF, 0xC1,
  0xE0, 0x3F, 0xF9, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3B, 0xFF, 0xE0, 0x38,
  0x7F, 0xF8, 0x38, 0x0F, 0xFC, 0x3C, 0x01, 0xFF, 0x3C, 0x00, 0x7F, 0x9E,
  0x00, 0x1F, 0xDE, 0x00, 0x07, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC3, 0x80, 0x03, 0xC0, 0xE0, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0x83, 0x80, 0x03, 0x01, 0xE0, 0x07, 0x01, 0xF0, 0x0E,
  0x01, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x7F,
  0x01, 0xFF, 0x7F, 0x83, 0x7F, 0x3F, 0xC7, 0x7F, 0x1F, 0xFE, 0x7F, 0x0F,
  0xFC, 0x7E, 0x07, 0xF8, 0x7E, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x7E,
  0x00, 0xF8, 0x7F, 0x00, 0xF8, 0x7F, 0x00, 0xF0, 0x7F, 0x00, 0xF0, 0x3F,
  0x01, 0xE0, 0x3F, 0x01, 0xC0, 0x1F, 0x83, 0x80, 0x0F, 0xC7, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x02, 0x01, 0xC0, 0xF8, 0x7F, 0x3F, 0xE3, 0xE0, 0x70,
  0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x08, 0x07, 0x03, 0xE3, 0xFE, 0x7F, 0x0F, 0x81, 0xC0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0xFF, 0x87,
  0xC0, 0x70, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x3C, 0x0F, 0xC3, 0xFC,
  0x7F, 0x83, 0xF0, 0x3E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x3C, 0x1F, 0x03, 0xC0, 0x3E, 0x1C, 0x00, 0x7C,
  0x70, 0x01, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x10, 0x0F, 0x00, 0x40, 0x3C, 0x03,
  0x00, 0x78, 0x08, 0x00, 0xF0, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0xFF, 0xCE, 0x0F,
  0x00, 0xFF, 0xF1, 0xC3, 0xC0, 0x79, 0xF8, 0x71, 0xE0, 0x3C, 0x3E, 0x1C,
  0x78, 0x1E, 0x0F, 0x87, 0x1E, 0x0F, 0x87, 0xC1, 0xCF, 0x07, 0xC1, 0xF0,
  0x73, 0xC1, 0xF0, 0x7C, 0x1C, 0xF0, 0xF8, 0x1E, 0x0F, 0x3C, 0x3E, 0x0F,
  0x83, 0x8F, 0x1F, 0x83, 0xE1, 0xE3, 0xC7, 0xC1, 0xF8, 0x78, 0xF1, 0xF0,
  0xFC, 0x3C, 0x3C, 0x7C, 0x3F, 0x1F, 0x0F, 0x1F, 0xBF, 0xCF, 0x81, 0xC3,
  0xFF, 0xFF, 0xCF, 0x78, 0xFF, 0x7F, 0xE3, 0x9E, 0x1F, 0x0F, 0xC1, 0xE3,
  0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0xE0, 0x7F, 0xF8, 0x07, 0xF0, 0x0C, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x06, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x60,
  0x00, 0x3F, 0xE0, 0xFE, 0x03, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x18, 0x00,
  0x07, 0xF8, 0x3F, 0x81, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x0E, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x70, 0x00, 0x07, 0xF0, 0x7F, 0x03, 0xC0, 0x00, 0x1F,
  0x83, 0xF8, 0x0F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xE0,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0xFF, 0x80, 0xF8, 0x0F, 0xE0,
  0x01, 0xFE, 0x07, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x78, 0x03, 0xF8, 0x00,
  0x07, 0x03, 0x80, 0x1F, 0xC0, 0x00, 0x38, 0x38, 0x00, 0xFE, 0x00, 0x01,
  0x83, 0x80, 0x07, 0xF0, 0x00, 0x08, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0x80, 0x01, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xC0, 0x06, 0x1F, 0xFE, 0x0D, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x86, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF3, 0x03, 0xFC,
  0x01, 0xFC, 0x0F, 0xFE, 0x80, 0x7F, 0x80, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xE0, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x1E, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xC0, 0x00, 0x1F, 0xE0,
  0x0F, 0xF8, 0x70, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x98, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xC6, 0x00, 0x00, 0x1F, 0x80, 0x07, 0x81, 0xC0, 0x00, 0x07,
  0xE0, 0x03, 0x80, 0x70, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0x00,
  0x7C, 0x03, 0xF8, 0x03, 0x80, 0x00, 0x1F, 0x03, 0xFF, 0x80, 0xE0, 0x00,
  0x07, 0xC3, 0xFF, 0xF8, 0x1C, 0x00, 0x41, 0xE3, 0xFF, 0xFF, 0x03, 0xC0,
  0x60, 0xF1, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x3C, 0x00, 0x3F, 0xF8, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x18, 0x00, 0x01, 0xFF, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0x87, 0xF8, 0x00, 0x78, 0x02, 0x3F, 0xFF, 0x03,
  0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x7C, 0x00, 0xC3,
  0xFC, 0x03, 0xE0, 0x0E, 0x01, 0xE0, 0x1F, 0x80, 0xF0, 0x01, 0x00, 0x7E,
  0x07, 0x80, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x00,
  0x07, 0xFC, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x18, 0x00, 0x00, 0x3F, 0xF0,
  0xC0, 0x00, 0x00, 0x7F, 0xF4, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x08,
  0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0x80, 0x0C, 0x1F, 0xFE, 0x01, 0xF8, 0x01, 0xC0, 0x3F,
  0xF8, 0x1F, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x01, 0xFF,
  0x07, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x78, 0x01, 0xF8, 0x00, 0x1F, 0xE3,
  0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x9C, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0xE0,
  0x03, 0xFE, 0x00, 0x07, 0xE7, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xB8, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xE6, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x30, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xC7, 0x00, 0x03, 0xFE, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0x70, 0x00, 0x3F, 0x80, 0x07, 0x80, 0xFF, 0xC0, 0xF8, 0x00,
  0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0xC8, 0x00, 0x01, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x8F, 0xFF,
  0xF8, 0x0E, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x18, 0x00, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x61, 0xFE, 0x00, 0x0F, 0x00, 0x47, 0xFF, 0xE0, 0x3E, 0x00, 0xFF,
  0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x03, 0x0F, 0xF0, 0x07,
  0xC0, 0x1C, 0x03, 0xC0, 0x1F, 0x80, 0xF0, 0x01, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xFE,
  0x01, 0x80, 0x3F, 0x83, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xFE, 0x1F, 0xE4,
  0xFE, 0x0F, 0xFE, 0x7F, 0xF9, 0xFC, 0x0F, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F,
  0xFF, 0x7F, 0xC7, 0xF0, 0x0F, 0xFE, 0x3F, 0x0F, 0xE0, 0x0F, 0xFE, 0x3C,
  0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0xE0,
  0x00, 0x07, 0xFC, 0x03, 0x80, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0x00, 0x0F,
  0xFC, 0x30, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x07, 0xFF,
  0xF8, 0x3E, 0x00, 0x01, 0x7F, 0xFC, 0x0F, 0x00, 0x00, 0xE7, 0xFC, 0x03,
  0x80, 0x00, 0x70, 0x7E, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x18,
  0x18, 0x00, 0x0F, 0xF0, 0x0F, 0x86, 0x00, 0x03, 0xFE, 0x03, 0xF1, 0x80,
  0x00, 0xFF, 0xC1, 0xFE, 0x30, 0x00, 0x1F, 0xF8, 0xFF, 0xCC, 0x00, 0x07,
  0xFF, 0x7F, 0xE1, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x1F, 0xF8,
  0xF8, 0x07, 0x00, 0x67, 0xFF, 0x0C, 0x00, 0xF9, 0xF8, 0xFF, 0xC2, 0x00,
  0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x08, 0x7F, 0x00, 0x01, 0xF0,
  0x03, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x6F, 0xFC, 0x00, 0x3E, 0x00, 0x31,
  0xFF, 0x80, 0x1F, 0x00, 0x18, 0x3F, 0xF0, 0x0F, 0xC0, 0x1C, 0x07, 0xFE,
  0x03, 0xE0, 0x0E, 0x00, 0xFF, 0xC1, 0xF8, 0x0F, 0x00, 0x1F, 0xE0, 0x7E,
  0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x70, 0x0F, 0xC0, 0xFC,
  0x00, 0x38, 0x03, 0xF0, 0x7F, 0x00, 0x18, 0x01, 0xFC, 0x1F, 0xC0, 0x1F,
  0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0x07,
  0xF0, 0x3F, 0xE7, 0xFF, 0xE1, 0xFC, 0x0F, 0xF9, 0x3F, 0xFC, 0x7F, 0x01,
  0xFF, 0x01, 0xFF, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE7, 0xF0, 0x0F, 0xFC,
  0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xDF, 0xE0, 0x07, 0xF8, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0x01, 0xFD, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xCF, 0xF0, 0x01,
  0xF8, 0x07, 0xF1, 0xFE, 0x00, 0x3E, 0x01, 0xF8, 0x7F, 0x80, 0x0F, 0x00,
  0x7E, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0x83, 0xFC, 0x03, 0xC0, 0x07, 0xC0,
  0x7F, 0x81, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x60, 0x00, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x7F, 0xF0, 0x00, 0x00, 0x0C, 0x1F, 0xFA,
  0x00, 0x00, 0x18, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x07, 0xFC, 0x00, 0x00,
  0x70, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x00,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x9C, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x07,
  0x00, 0x7C, 0x00, 0x7F, 0x0F, 0xC0, 0x3C, 0x00, 0x7F, 0x3F, 0xE0, 0x38,
  0x00, 0x7E, 0x7F, 0xF0, 0x38, 0x00, 0x7E, 0xFF, 0xF8, 0x30, 0x00, 0x7C,
  0x8F, 0xFC, 0x60, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x81, 0xFF,
  0xE0, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0xF0,
  0x00, 0x1F, 0xFF, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0x00, 0xFE,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x03,
  0xF0, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x0E,
  0x00, 0x07, 0xF8, 0x00, 0x3C, 0x03, 0x3F, 0xC0, 0x00, 0xFF, 0xF1, 0xFF,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xC3, 0xFF, 0xC0, 0x00, 0x3E, 0x7F, 0xFF,
  0x00, 0x01, 0xE7, 0xBF, 0xFC, 0x00, 0x0E, 0x20, 0x7F, 0xF0, 0x00, 0x70,
  0x01, 0xFF, 0xC0, 0x07, 0x00, 0x07, 0xFF, 0x00, 0x70, 0x00, 0x1F, 0xFE,
  0x07, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0x38, 0x00, 0x0F, 0xFF, 0xC0, 0x70, 0x00,
  0x07, 0xFF, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x30, 0x00, 0x01, 0xF0,
  0x00, 0x60, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xE0, 0x0C, 0xFF, 0x00, 0x00, 0xFD, 0xF0, 0xFF, 0x00, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x0F,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0x07, 0xFF, 0x00, 0x00, 0x3C, 0x1F, 0xFF,
  0x80, 0x00, 0x70, 0x7F, 0xFF, 0x80, 0x01, 0xC1, 0x87, 0xFF, 0x80, 0x03,
  0x80, 0x07, 0xFF, 0x80, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x18, 0x00, 0x03,
  0xFF, 0x80, 0x60, 0x00, 0x03, 0xFF, 0xE7, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x03,
  0xE0, 0x0E, 0x00, 0x07, 0xC0, 0xFF, 0xC0, 0x38, 0x00, 0x3E, 0x0F, 0xFF,
  0x81, 0xE0, 0x03, 0xF0, 0xFF, 0xFE, 0x07, 0x00, 0x1F, 0x0F, 0xFF, 0xF0,
  0x3C, 0x01, 0xF8, 0x60, 0x7F, 0xC0, 0xE0, 0x0F, 0xC6, 0x01, 0xFF, 0x07,
  0x00, 0x7F, 0x30, 0x07, 0xF8, 0x38, 0x03, 0xF9, 0x00, 0x3F, 0xC1, 0xC0,
  0x1F, 0xC8, 0x00, 0xFF, 0x0E, 0x00, 0xFF, 0x40, 0x07, 0xFC, 0x70, 0x07,
  0xFE, 0x00, 0x1F, 0xF3, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0x1C, 0x00, 0xFF,
  0xC0, 0x01, 0xE0, 0xC0, 0x07, 0xFE, 0x00, 0x0C, 0x0E, 0x00, 0x1F, 0xF8,
  0x01, 0x80, 0xE0, 0x00, 0xFF, 0xC0, 0x3C, 0x0E, 0x00, 0x03, 0xFF, 0x07,
  0xF0, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xCC, 0x00, 0x00, 0x7F, 0xEF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x0F,
  0x80, 0x3C, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x0E, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x60, 0x03, 0xFE, 0x0D, 0xFF, 0x86,
  0x00, 0x0F, 0xF9, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0xFF,
  0x00, 0x01, 0xF1, 0xFE, 0x00, 0x03, 0xF3, 0xFE, 0x00, 0x07, 0xC7, 0xFC,
  0x00, 0x0F, 0x87, 0xFC, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x7E, 0x1F, 0xF8,
  0x00, 0xF8, 0x1F, 0xF0, 0x03, 0xF0, 0x1F, 0xF2, 0x1F, 0xC0, 0x3F, 0xE7,
  0xFE, 0x00, 0x3F, 0xC1, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x14,
  0x1F, 0xFF, 0x00, 0x60, 0x0F, 0xFF, 0xC7, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x7F, 0xFF, 0x30, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFE, 0x81,
  0xFE, 0x01, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xF8, 0x0E, 0x00, 0x7F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x70, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC1, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x04, 0x00, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x10, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE3, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xEC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x10,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x40, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x03, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x18, 0x07, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0xC0, 0x0F, 0xFF, 0x80, 0x7E, 0x00, 0xFC,
  0x07, 0x00, 0x3F, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x38, 0x00, 0x7F, 0xFC,
  0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x0F,
  0x00, 0x00, 0xF8, 0xE0, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x01, 0x00,
  0xF0, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x04, 0x03, 0xC0, 0x0F, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x83, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0E, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0xFE, 0x00, 0x00,
  0xF8, 0x03, 0x80, 0x06, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0C, 0xF8, 0x18,
  0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x67, 0xF0, 0x40, 0x1F, 0xF0, 0x83, 0xFF,
  0xC1, 0xBF, 0xF3, 0x00, 0x7F, 0xFF, 0x1D, 0xFF, 0x8D, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x43, 0xFF, 0xE7, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF9, 0x07, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x60, 0x7F, 0x80, 0xF8, 0x0F, 0xFE,
  0x60, 0x3F, 0xC0, 0x70, 0x01, 0xFF, 0xA0, 0x0F, 0xE0, 0x70, 0x00, 0x7F,
  0xF0, 0x07, 0xF8, 0x30, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x10, 0x00, 0x07,
  0xFC, 0x00, 0xFE, 0x08, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x8C, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xC6, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF9, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x60, 0x00,
  0x01, 0xF8, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x1C, 0x06,
  0x00, 0x7E, 0x00, 0x60, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x60, 0x01, 0xFF,
  0xF0, 0x0F, 0x80, 0x70, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x70, 0x00, 0x1F,
  0xFE, 0x03, 0xE0, 0x78, 0x00, 0x03, 0x83, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0x01, 0x80, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x78, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFF, 0x00,
  0x00, 0xFC, 0x03, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0x80, 0x1F, 0xE0,
  0x01, 0xFF, 0xC1, 0xC0, 0x0F, 0xF8, 0x61, 0xFF, 0xE0, 0xC0, 0x03, 0xFF,
  0xE1, 0x9F, 0xF9, 0xC0, 0x01, 0xFF, 0xE0, 0x87, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x07, 0xFF, 0xE0,
  0x01, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x03, 0xC0,
  0x00, 0x03, 0xFF, 0x81, 0xE0, 0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x00, 0x00,
  0x1F, 0xF1, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0xFC,
  0x00, 0x00, 0x0F, 0xCF, 0xFF, 0x80, 0x00, 0x07, 0xE3, 0xFF, 0xF0, 0x00,
  0x01, 0xF1, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0x00, 0x00, 0x3E,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x02, 0x0C, 0x00, 0x00, 0x38, 0x07, 0xE4, 0x00, 0x00, 0x18, 0x0F, 0xFC,
  0x00, 0x00, 0x1C, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x0F, 0xFF, 0xE0, 0x00,
  0x0C, 0x0F, 0xFF, 0xF8, 0x00, 0x0C, 0x08, 0x3F, 0xFF, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0xE0, 0x0C, 0x00, 0x01, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0xF3,
  0xBF, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0xE0, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x0C, 0x00, 0x03,
  0xFC, 0x1F, 0xFC, 0x03, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0xC0, 0x00,
  0x1F, 0xC0, 0x7F, 0xF8, 0x30, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x0C, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0xC3, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x40,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x18, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC3,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0xE0, 0x04, 0x3F, 0x80, 0x01, 0xFE,
  0x0E, 0x03, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFF, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0x0E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0x80, 0x00, 0x0E, 0x1F, 0xFF, 0xFB, 0xC0, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0xF8, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F,
  0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x7F, 0xFE, 0x00,
  0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x83, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x20, 0x00, 0xF8, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0xDC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x18, 0xFF, 0x83, 0x03, 0xFF, 0xF0, 0x03,
  0xFE, 0x60, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x8F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0x00,
  0x00, 0x1F, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x73, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC4, 0x0F, 0xF8,
  0x01, 0xFC, 0xFF, 0xFC, 0xC0, 0x7F, 0x80, 0x3E, 0x00, 0xFF, 0xE8, 0x03,
  0xFC, 0x03, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x70, 0x00, 0x1F, 0xF8,
  0x03, 0xFE, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x60, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x8E, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x00,
  0x60, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x30,
  0x00, 0x70, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x7F, 0x80, 0x00, 0xE0, 0x0C, 0x07,
  0xDF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7C, 0x7F, 0xC0, 0x00, 0x0F, 0xC0,
  0x07, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0xF8, 0x00, 0x07, 0xC0, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x18, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x83,
  0x00, 0x03, 0xFE, 0x20, 0x7F, 0xFC, 0x60, 0x00, 0x3F, 0xFE, 0x08, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x08, 0x00, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x87, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x1F, 0xFF,
  0xE0, 0x01, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x70, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0,
  0x1E, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xC1, 0xE0,
  0x60, 0x7F, 0xFF, 0xF8, 0x78, 0x0C, 0x7F, 0xFF, 0xFE, 0x1E, 0x01, 0xFF,
  0xFF, 0x80, 0xC7, 0x80, 0x3F, 0xFF, 0x00, 0x11, 0xF0, 0x0F, 0xFF, 0x80,
  0x06, 0x7C, 0x01, 0xFF, 0x80, 0x01, 0x9F, 0x00, 0x1F, 0x80, 0x00, 0x27,
  0xE0, 0x01, 0x00, 0x00, 0x09, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0x8F, 0xE0, 0x00, 0x00, 0x00, 0x63, 0xFC, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xE3, 0x60, 0x00,
  0x08, 0xFF, 0xFF, 0x30, 0x00, 0x0E, 0x3F, 0xFF, 0x10, 0x00, 0x1C, 0x07,
  0xFF, 0x18, 0x00, 0x1E, 0x01, 0xFE, 0x0C, 0x00, 0x1F, 0x00, 0x3E, 0x06,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x07,
  0xF8, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0xDF, 0xFC, 0x00, 0x00,
  0x3F, 0xC7, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xFF, 0xF8,
  0x1E, 0x00, 0x01, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x88, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x7F,
  0xF8, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x87, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x30, 0x03, 0xC3, 0x80, 0x01, 0xC0, 0x1F, 0x03, 0x00, 0x0F,
  0x00, 0x7C, 0x02, 0x00, 0x7E, 0x00, 0xF8, 0x04, 0x03, 0xF8, 0x03, 0xE0,
  0x08, 0x1F, 0xF0, 0x07, 0xE0, 0x30, 0x7F, 0xE0, 0x1F, 0xC0, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x7E, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xFC, 0x06, 0x7F, 0x06, 0x1F, 0xFC, 0x38, 0xFF,
  0x10, 0x0F, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03,
  0xC0, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF1, 0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x81, 0xFE, 0x00, 0xFC, 0x0F,
  0xFF, 0xC0, 0x7F, 0x80, 0x78, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x78, 0x00,
  0x3F, 0xE0, 0x0F, 0xF0, 0x38, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x18, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0x9C, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x0E, 0x00,
  0x00, 0x7F, 0x00, 0x3E, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x03, 0x00,
  0x00, 0x0F, 0xC0, 0x06, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x06, 0x00, 0x60,
  0x00, 0x03, 0xF0, 0x07, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x0C,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x01,
  0x80, 0x18, 0x3C, 0x01, 0xFC, 0x00, 0x70, 0x18, 0x1E, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x1E, 0x00, 0x7F, 0xC0, 0x00, 0x40, 0x0E, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1B, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0xC1, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x1F, 0x83, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC3, 0xFC,
  0x67, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x30, 0xC8, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x30, 0x07,
  0xFC, 0x03, 0xF0, 0x0F, 0xFC, 0x07, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x3F,
  0xE0, 0xE0, 0x01, 0xFE, 0x07, 0x80, 0x01, 0xFE, 0x0E, 0x00, 0x1F, 0xE0,
  0x70, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0xFF, 0x0E, 0x00, 0x00, 0xFF, 0x1F,
  0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0x7F, 0xCE, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF0, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x3F, 0x3F, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x03,
  0xF3, 0xFE, 0x00, 0x38, 0x06, 0x00, 0x00, 0x3F, 0x1F, 0xE0, 0x07, 0x00,
  0x20, 0x00, 0x03, 0xE1, 0xFF, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x3E, 0x0F,
  0xF0, 0x1F, 0x80, 0x18, 0x00, 0x83, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0xC0,
  0x18, 0x3C, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0x80, 0x7F, 0x83,
  0xFF, 0x00, 0x1F, 0x80, 0x78, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x01, 0xFC, 0x0F, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00,
  0x32, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00,
  0x07, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1C,
  0x06, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0x1F, 0xFE, 0x1F, 0xFF, 0xE0, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0x9C, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0x88, 0x3F,
  0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xFF, 0x83,
  0xFF, 0x8F, 0xFB, 0xFF, 0x8F, 0xFF, 0x1F, 0x00, 0xFF, 0x1D, 0xFC, 0x78,
  0x00, 0x7F, 0x30, 0xF0, 0xE0, 0x00, 0xFE, 0xC0, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0x00, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x00, 0x0C,
  0x00, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x07,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xC0,
  0x60, 0x00, 0xFF, 0xFF, 0x00, 0x60, 0x03, 0xFF, 0xFE, 0x00, 0x79, 0xCF,
  0xFF, 0xF8, 0x00, 0x3E, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x17, 0xF8, 0x00, 0x00, 0x00, 0x27, 0xF0,
  0x00, 0x01, 0x80, 0xCF, 0xF0, 0x00, 0x0F, 0xC1, 0x1F, 0xF0, 0x00, 0x3F,
  0xC6, 0x1F, 0xF8, 0x60, 0x7F, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x11,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE3, 0x07,
  0xF8, 0x07, 0xFF, 0xFF, 0xE4, 0x07, 0xF8, 0x1F, 0x80, 0xFF, 0xF8, 0x0F,
  0xF0, 0x3C, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0xF0, 0x00, 0x7F, 0xC0, 0x1F,
  0xE1, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC7, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xCE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x9C, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x60, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0x01,
  0x80, 0x00, 0x0F, 0x80, 0x1E, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x03,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0x00, 0x30, 0x78, 0x07, 0xF0, 0x03,
  0xC1, 0xC0, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0x08, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x30, 0x1F, 0xE0, 0x00, 0x7F,
  0xF1, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x08, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0x7F,
  0x80, 0x38, 0x00, 0x03, 0xF8, 0x03, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00,
  0x01, 0xF8, 0x03, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x01, 0xF8, 0x03,
  0x00, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x01, 0x80, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x1E, 0x1F,
  0xF8, 0x00, 0x01, 0xE7, 0xFF, 0xC0, 0x00, 0x1C, 0xFF, 0xFE, 0x00, 0x01,
  0xC8, 0x7F, 0xF0, 0x00, 0x38, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0xFC,
  0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0C, 0x00, 0x03, 0xFF, 0x83, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x1E,
  0x0F, 0x00, 0x3C, 0x70, 0x00, 0x7B, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0x7C,
  0x1E, 0x07, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x04, 0xFF, 0xC0, 0x06, 0x3F, 0xF8, 0x0E, 0x07, 0xF8, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00,
  0xF8, 0x3F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xFC, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x3F, 0xC3, 0xF9, 0x0F,
  0xF3, 0xFF, 0x87, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x1E, 0x03, 0xC0, 0x04, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0xC1, 0xE0, 0x00, 0x43, 0xC0, 0x00, 0x27, 0xC0, 0x00,
  0x27, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x40, 0x0F, 0x80, 0xC0,
  0x0F, 0x83, 0xE0, 0x0F, 0x87, 0xF0, 0x0F, 0x9F, 0xF8, 0x0F, 0xE3, 0xF8,
  0x0F, 0x81, 0xFC, 0x0F, 0x81, 0xFC, 0x0F, 0x80, 0xFE, 0x0F, 0x80, 0x7E,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0xC0, 0x3C, 0x0F, 0xC0, 0x3C, 0x0F, 0xC0, 0x78, 0x1F, 0xC0, 0x70,
  0x1F, 0xE0, 0x60, 0x3F, 0xF8, 0xC0, 0x5F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1C, 0xFC,
  0x0E, 0x3F, 0x07, 0x87, 0xE1, 0xC1, 0xF8, 0xF0, 0x3F, 0x3C, 0x0F, 0x1F,
  0x01, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x43,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x18, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x2F, 0xFC, 0x00,
  0x43, 0xFC, 0x0F, 0x81, 0xFE, 0x0F, 0x80, 0xFE, 0x0F, 0x80, 0x7F, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x1E, 0x0F, 0xC0, 0x1E, 0x0F, 0xC0, 0x1E, 0x1F, 0xC0, 0x1C, 0x1F,
  0xE0, 0x18, 0x3F, 0xF0, 0x38, 0x3F, 0xFC, 0x30, 0x0F, 0xFF, 0x60, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0x9F, 0x80,
  0xE3, 0xF0, 0x3C, 0x3F, 0x07, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x0F, 0xCF,
  0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x03, 0xC7, 0xC1, 0xC0, 0xF9, 0xE0, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x41, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xC4, 0x0F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x63, 0xF0, 0x10, 0x30, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x04, 0x7F, 0xF0,
  0x0E, 0x1F, 0xFC, 0x0E, 0x07, 0xFC, 0x0F, 0x00, 0xFC, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x07, 0x07, 0xC0, 0x07, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03,
  0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x03,
  0xF9, 0xFF, 0x81, 0xFF, 0x8F, 0xC0, 0x7E, 0x07, 0xE0, 0x3C, 0x03, 0xF0,
  0x18, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF8, 0x03,
  0x80, 0x7C, 0x03, 0x80, 0x1F, 0x03, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xC1,
  0xE0, 0x00, 0x43, 0xC0, 0x00, 0x27, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x80, 0x1F, 0x81, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x8F, 0xE0, 0x0F,
  0x9F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0x83, 0xF8, 0x0F, 0x83, 0xF8, 0x0F,
  0x81, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xFE, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7F, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F,
  0xC8, 0x78, 0x3F, 0xFC, 0x78, 0x7F, 0xF0, 0x70, 0x1F, 0xE0, 0xF0, 0x07,
  0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0xFE, 0x03,
  0xFC, 0x1F, 0xFC, 0xDF, 0xE2, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x19, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF4, 0x03, 0xE6, 0x03, 0xC2, 0x07,
  0x81, 0x0F, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x80, 0x3C, 0x30,
  0x38, 0x08, 0x3C, 0x02, 0x3C, 0x11, 0xBE, 0x38, 0x7F, 0x3C, 0x3F, 0xBE,
  0x1F, 0xDF, 0x07, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xFD, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF9, 0x87, 0xFF, 0x83,
  0xFF, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x70, 0xC1, 0xE0, 0x43, 0xC0, 0x23, 0xC0, 0x37,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC2, 0x1F, 0xE4, 0x3F,
  0xFC, 0x1F, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x7C, 0x07, 0xE0,
  0xF8, 0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0xFF, 0xCF, 0xFE, 0x0F,
  0xFB, 0x3F, 0xF7, 0xFF, 0x13, 0xFC, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x0F, 0x80,
  0x1F, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07,
  0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x0F, 0x80,
  0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x3E,
  0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0xF8, 0x03, 0xF8,
  0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFF, 0x07,
  0xE4, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0x3E,
  0x03, 0xE0, 0x1F, 0xC0, 0x38, 0x03, 0x80, 0x1F, 0x00, 0x70, 0x07, 0x00,
  0x1E, 0x00, 0x40, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x7F, 0x9F, 0xFE, 0x1F, 0xF6, 0x7F, 0xC4, 0x7F, 0x07, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00,
  0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03,
  0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x23, 0xFE, 0x0F, 0xF8, 0x3F,
  0x81, 0xFF, 0x03, 0xE0, 0x1F, 0xC0, 0x78, 0x01, 0xF8, 0x07, 0x00, 0x1E,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xE3, 0xFC, 0x0F, 0xC7, 0xF8,
  0x1F, 0x87, 0xF8, 0x3F, 0x07, 0xF8, 0x7E, 0x0F, 0xF0, 0xFC, 0x0F, 0xF1,
  0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8,
  0x03, 0xE3, 0xF0, 0x07, 0x87, 0xE0, 0x0E, 0x0F, 0xE0, 0x38, 0x3F, 0xF0,
  0x70, 0xFF, 0xF1, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0x80, 0xFF, 0x01, 0xC0, 0x7F,
  0xC3, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF7, 0xFF, 0x03, 0xFE, 0x7F, 0x80,
  0xFC, 0x0F, 0xE0, 0x3E, 0x07, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0xFE,
  0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x1F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x0F, 0xF8, 0x07, 0x8F, 0xFC,
  0x03, 0x87, 0xFF, 0x83, 0x87, 0xFF, 0xE1, 0x83, 0x7F, 0xFD, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xF3, 0x80, 0x00,
  0x78, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xCF, 0xFC, 0x03, 0x0F, 0xFE,
  0x0E, 0x07, 0xF8, 0x38, 0x07, 0xE0, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87,
  0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xE0,
  0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0xC0, 0x7C, 0x3F, 0x80, 0xF8, 0x3F, 0x83,
  0xF0, 0x7F, 0xCF, 0xE0, 0x7F, 0xE7, 0xC0, 0x7F, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x70, 0x3E, 0x00, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x08, 0x00, 0x03, 0x80, 0x20, 0x7C, 0x0E, 0x1F, 0xC3, 0xC3,
  0xF8, 0xFC, 0xFF, 0xBF, 0x97, 0xFF, 0xFC, 0x7F, 0x3F, 0x0F, 0xC7, 0xC1,
  0xF8, 0x70, 0x3F, 0x0C, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x10, 0x0F,
  0xF2, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x3C, 0x03, 0x01, 0xF8, 0x0C, 0x0F, 0xF8, 0x70, 0x7F, 0xFF, 0x82, 0x3F,
  0xFE, 0x10, 0x3F, 0xF0, 0xC0, 0x3F, 0x87, 0x00, 0x18, 0x1C, 0x00, 0x40,
  0x78, 0x03, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x7F, 0x03, 0xC0, 0xFE, 0x06, 0x01,
  0xF8, 0x10, 0x03, 0xE0, 0x80, 0x07, 0x07, 0x80, 0x1C, 0x3F, 0x80, 0x61,
  0xFF, 0x83, 0x0F, 0xFF, 0x98, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE2, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0x60, 0x08, 0x00, 0x10, 0x01, 0xC0, 0x03, 0x00, 0x7C, 0x00, 0xF0,
  0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0xF0, 0xFF, 0x83, 0xFF, 0x17, 0xF0,
  0x3F, 0xC0, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80,
  0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00,
  0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F,
  0xF1, 0xFE, 0x67, 0xFF, 0x6F, 0xF8, 0x3F, 0xF9, 0xFE, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0x01, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x38, 0x00, 0x70, 0x0F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x3F,
  0xF0, 0x7F, 0xBF, 0xFE, 0x1F, 0xF8, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF,
  0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3E, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x1C,
  0x00, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x3F, 0x03, 0x80, 0x1F, 0xF0, 0xC0, 0x07, 0xFE, 0x60, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x60, 0x01, 0x03, 0xFC, 0x07, 0x80, 0x38, 0x1F, 0xF0,
  0x7F, 0x03, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE,
  0x0F, 0xF6, 0x7F, 0x87, 0xF0, 0x3F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x0F, 0xC1,
  0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0xFC,
  0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x07,
  0x81, 0xF8, 0x1F, 0x80, 0x3C, 0x0F, 0xC0, 0xFC, 0x01, 0xC0, 0x7E, 0x07,
  0xE0, 0x1E, 0x03, 0xF0, 0x3F, 0x80, 0xE0, 0x1F, 0x81, 0xFF, 0x0E, 0x01,
  0xFE, 0x3F, 0xFC, 0x40, 0x1F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x02, 0x01, 0xE0, 0x30, 0x1F, 0x83, 0xC0,
  0xFE, 0x3E, 0x0F, 0xF3, 0xF8, 0xFF, 0xFF, 0xC4, 0x7F, 0x7F, 0x03, 0xF1,
  0xF0, 0x1F, 0x8F, 0x00, 0xFC, 0x30, 0x07, 0xE1, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x38, 0x7C, 0x01, 0x81, 0xC0, 0x08, 0x06,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x70, 0x1F, 0x01, 0xE7, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x02,
  0x01, 0xFC, 0x03, 0x80, 0xFF, 0x03, 0xC0, 0x7F, 0xC3, 0xF0, 0x1F, 0xE7,
  0xFC, 0x0F, 0xFC, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03,
  0xE0, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8,
  0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01,
  0xE0, 0x7F, 0x31, 0xF0, 0x7F, 0xF0, 0xF0, 0x7F, 0xF0, 0x78, 0x07, 0xF0,
  0x38, 0x01, 0xF0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0xC7, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x04, 0x1C, 0x0C, 0x1F,
  0x18, 0x1F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x2F, 0xE0,
  0x23, 0xF8, 0x31, 0xFC, 0x30, 0x7E, 0x18, 0x3F, 0x98, 0x0F, 0xCC, 0x07,
  0xEE, 0x03, 0xF6, 0x01, 0xFB, 0x00, 0x7D, 0x80, 0x3E, 0xC0, 0x1F, 0x60,
  0x0F, 0x30, 0x07, 0x98, 0x03, 0x8C, 0x03, 0xC7, 0x01, 0xC1, 0x80, 0xC0,
  0x60, 0xE0, 0x1D, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 11, 43, 13, 1, -42 },
  { 61, 20, 16, 23, 1, -41 },
  { 101, 26, 33, 30, 2, -37 },
  { 209, 20, 47, 24, 2, -44 },
  { 327, 38, 40, 41, 2, -41 },
  { 517, 30, 36, 33, 2, -35 },
  { 652, 9, 16, 12, 1, -41 },
  { 670, 13, 48, 14, 1, -46 },
  { 748, 13, 48, 14, 1, -46 },
  { 826, 19, 23, 20, 0, -44 },
  { 881, 19, 20, 23, 2, -29 },
  { 929, 9, 16, 11, 0, -9 },
  { 947, 16, 11, 17, 2, -23 },
  { 969, 10, 10, 12, 1, -9 },
  { 982, 27, 45, 30, 2, -43 },
  { 1134, 25, 42, 27, 1, -41 },
  { 1266, 17, 40, 19, 1, -40 },
  { 1351, 24, 39, 26, 1, -39 },
  { 1468, 25, 40, 27, 1, -40 },
  { 1593, 25, 39, 27, 1, -39 },
  { 1715, 25, 40, 27, 1, -40 },
  { 1840, 24, 41, 26, 1, -41 },
  { 1963, 23, 40, 25, 1, -40 },
  { 2078, 25, 41, 27, 1, -41 },
  { 2207, 24, 41, 26, 1, -41 },
  { 2330, 10, 29, 12, 1, -28 },
  { 2367, 11, 35, 10, 0, -28 },
  { 2416, 16, 21, 17, 0, -27 },
  { 2458, 20, 13, 22, 1, -24 },
  { 2491, 16, 21, 17, 0, -27 },
  { 2533, 22, 42, 26, 2, -41 },
  { 2649, 34, 35, 35, 1, -27 },
  { 2798, 45, 42, 47, 1, -41 },
  { 3035, 50, 43, 52, 0, -42 },
  { 3304, 38, 43, 40, 1, -42 },
  { 3509, 45, 44, 47, 1, -42 },
  { 3757, 39, 43, 41, 1, -42 },
  { 3967, 42, 49, 44, 1, -42 },
  { 4225, 42, 44, 45, 1, -42 },
  { 4456, 40, 53, 43, 1, -45 },
  { 4721, 37, 50, 40, 1, -43 },
  { 4953, 39, 57, 41, 1, -43 },
  { 5231, 45, 42, 47, 1, -41 },
  { 5468, 31, 42, 33, 1, -41 },
  { 5631, 62, 44, 64, 1, -41 },
  { 5972, 49, 42, 51, 1, -41 },
  { 6230, 41, 43, 44, 1, -42 },
  { 6451, 50, 51, 52, 1, -41 },
  { 6770, 44, 46, 46, 1, -42 },
  { 7023, 52, 43, 54, 1, -42 },
  { 7303, 42, 43, 44, 1, -42 },
  { 7529, 41, 42, 43, 1, -41 },
  { 7745, 39, 45, 41, 1, -41 },
  { 7965, 49, 43, 51, 1, -42 },
  { 8229, 60, 43, 63, 1, -42 },
  { 8552, 39, 43, 42, 1, -42 },
  { 8762, 47, 52, 50, 1, -43 },
  { 9068, 36, 50, 39, 1, -43 },
  { 9293, 8, 46, 11, 1, -43 },
  { 9339, 36, 41, 6, -11, -38 },
  { 9524, 8, 46, 11, 1, -43 },
  { 9570, 22, 16, 24, 1, -41 },
  { 9614, 28, 4, 26, -1, 7 },
  { 9628, 9, 11, 29, 9, -41 },
  { 9641, 25, 32, 27, 1, -30 },
  { 9741, 24, 42, 26, 1, -40 },
  { 9867, 18, 30, 21, 1, -29 },
  { 9935, 24, 41, 26, 1, -40 },
  { 10058, 19, 30, 21, 1, -29 },
  { 10130, 18, 53, 14, -1, -43 },
  { 10250, 25, 42, 27, 1, -30 },
  { 10382, 24, 51, 26, 1, -41 },
  { 10535, 14, 41, 16, 1, -40 },
  { 10607, 16, 52, 14, -3, -41 },
  { 10711, 17, 41, 19, 1, -40 },
  { 10799, 16, 42, 16, 1, -41 },
  { 10883, 39, 31, 41, 1, -30 },
  { 11035, 27, 31, 29, 1, -30 },
  { 11140, 23, 31, 24, 0, -30 },
  { 11230, 25, 47, 26, 0, -35 },
  { 11377, 23, 42, 25, 1, -30 },
  { 11498, 19, 31, 21, 1, -30 },
  { 11572, 22, 37, 24, 1, -36 },
  { 11674, 16, 38, 18, 1, -37 },
  { 11750, 27, 31, 29, 1, -30 },
  { 11855, 26, 34, 26, -1, -33 },
  { 11966, 37, 36, 40, 2, -34 },
  { 12133, 21, 43, 23, 1, -31 },
  { 12246, 25, 45, 27, 1, -35 },
  { 12387, 17, 41, 19, 1, -30 },
  { 12475, 16, 46, 19, 1, -45 },
  { 12567, 3, 48, 9, 3, -45 },
  { 12585, 16, 46, 19, 1, -45 },
  { 12677, 19, 4, 21, 1, -19 },
};

const GFXfont UnifrakturMaguntia_Regular58pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular58pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular58pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR58PT7B_H_
