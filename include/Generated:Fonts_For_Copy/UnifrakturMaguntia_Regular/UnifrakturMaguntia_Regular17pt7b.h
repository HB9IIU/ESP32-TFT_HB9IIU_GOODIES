#ifndef _UNIFRAKTURMAGUNTIA_REGULAR17PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0x46, 0x66, 0x44, 0x44, 0x04, 0x64, 0x49, 0xB2, 0x52, 0x48, 0x24,
  0x48, 0xB7, 0xF6, 0x8D, 0x3F, 0xA4, 0x48, 0x90, 0x23, 0xB3, 0x18, 0xF1,
  0xC7, 0x9C, 0x62, 0xA2, 0x10, 0x30, 0x25, 0x82, 0xC8, 0x4C, 0x88, 0x59,
  0x03, 0x2C, 0x05, 0xA0, 0x9B, 0x11, 0xB1, 0x1B, 0x21, 0xA4, 0x0C, 0x38,
  0x2C, 0x64, 0x68, 0x30, 0x77, 0xBA, 0x9A, 0x9C, 0xCC, 0x77, 0x5C, 0xA8,
  0x34, 0x44, 0xCC, 0xCC, 0xC4, 0x44, 0x30, 0xC2, 0x23, 0x33, 0x33, 0x33,
  0x22, 0xC0, 0x20, 0xCE, 0xCC, 0xF8, 0xD2, 0x00, 0x21, 0x09, 0xF2, 0x10,
  0x4B, 0xA4, 0x1B, 0x81, 0xE0, 0x4F, 0x00, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x00, 0x3C,
  0x24, 0x66, 0x66, 0xE7, 0xE7, 0xE7, 0xE7, 0x66, 0x66, 0x24, 0x3C, 0x11,
  0x9D, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xF0, 0x3C, 0x8E, 0x18, 0x30, 0x61,
  0x82, 0x09, 0x22, 0xFF, 0xF8, 0x3C, 0x46, 0x06, 0x06, 0x0C, 0x1E, 0x26,
  0x03, 0x43, 0xC2, 0x46, 0x3C, 0x0C, 0x0C, 0x1C, 0x2C, 0x4C, 0x4C, 0x8C,
  0xFF, 0x0C, 0x0C, 0x0C, 0x1E, 0x62, 0x7C, 0x40, 0x40, 0x7C, 0x7E, 0x46,
  0x03, 0x43, 0xC2, 0x66, 0x3C, 0x1C, 0x4D, 0x9B, 0x16, 0x1F, 0xF9, 0xF3,
  0x66, 0xCD, 0x91, 0xE0, 0x7F, 0x04, 0x10, 0x20, 0xC1, 0x06, 0x0C, 0x30,
  0x61, 0xC0, 0x3C, 0x42, 0x42, 0x62, 0x74, 0x3C, 0x4E, 0x42, 0xC2, 0xC2,
  0x46, 0x3C, 0x38, 0xC9, 0x1E, 0x3C, 0x78, 0xD9, 0x8F, 0x46, 0xCD, 0x91,
  0xC0, 0x5D, 0x00, 0x9E, 0x5D, 0x00, 0x97, 0x48, 0x19, 0x19, 0xC2, 0x0C,
  0xFC, 0x00, 0x3F, 0x83, 0x0C, 0x76, 0x40, 0x7A, 0x38, 0xF3, 0x19, 0x84,
  0x32, 0x70, 0x83, 0x08, 0x1F, 0x0C, 0x66, 0xF9, 0x6D, 0xD2, 0x6C, 0xAB,
  0x69, 0x7D, 0x40, 0xC8, 0x61, 0xE0, 0x3E, 0x0A, 0x3B, 0xA0, 0xCD, 0x06,
  0x6C, 0x33, 0x39, 0x98, 0x48, 0xC2, 0x86, 0x08, 0x30, 0xE1, 0x8B, 0xBE,
  0x0E, 0x60, 0x3E, 0x70, 0xDF, 0x32, 0x0C, 0x64, 0x18, 0x68, 0x11, 0x08,
  0x2F, 0x8E, 0x83, 0x02, 0x03, 0x0C, 0x06, 0x3C, 0x08, 0x1E, 0x20, 0x1F,
  0x80, 0x1C, 0xC4, 0x7D, 0x90, 0x36, 0x06, 0xE0, 0xCE, 0x18, 0xE3, 0x0C,
  0x71, 0x87, 0x40, 0x70, 0x87, 0xE0, 0x1F, 0xC1, 0xFF, 0x11, 0x1D, 0x08,
  0x78, 0xE1, 0xC3, 0x85, 0x0C, 0x27, 0x21, 0x01, 0x08, 0xF0, 0x8F, 0xC4,
  0x8F, 0xC0, 0x00, 0x00, 0x1C, 0xE2, 0x3C, 0x64, 0x06, 0xC0, 0x6E, 0xC6,
  0x77, 0x63, 0x86, 0x18, 0x71, 0x83, 0xA0, 0x1C, 0x20, 0xFC, 0x1F, 0x01,
  0xFE, 0x18, 0x7C, 0x84, 0x88, 0x20, 0x41, 0x99, 0x0F, 0xC4, 0xBC, 0x19,
  0xC1, 0x86, 0x06, 0x30, 0x60, 0x83, 0x0C, 0x0C, 0x40, 0x3C, 0x00, 0x1E,
  0xC1, 0x1F, 0x19, 0x1C, 0xD8, 0x46, 0xCE, 0x33, 0xBB, 0x9C, 0xCC, 0x63,
  0x61, 0x11, 0x90, 0x8E, 0x08, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x1B, 0x81,
  0x10, 0x30, 0x83, 0x9C, 0x1A, 0xE1, 0xC7, 0x0E, 0x30, 0x63, 0x66, 0x3F,
  0x42, 0x38, 0x60, 0x04, 0x03, 0x80, 0x1F, 0x04, 0x71, 0x07, 0xA0, 0x44,
  0x18, 0x43, 0x07, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0xC1, 0xFC, 0x21, 0xC8,
  0x0E, 0x00, 0x1F, 0x06, 0x38, 0x41, 0xE4, 0x08, 0x41, 0x84, 0x18, 0x3D,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x02, 0x30, 0x2F, 0x84, 0x1C,
  0x40, 0xF8, 0x07, 0xE0, 0x40, 0x86, 0xF2, 0x29, 0xD1, 0xC6, 0x8E, 0x3C,
  0x71, 0x41, 0xFC, 0x06, 0x61, 0x33, 0x3D, 0x0C, 0x70, 0x70, 0x1F, 0x10,
  0xD8, 0x2C, 0x17, 0x19, 0xB8, 0xC0, 0x20, 0x20, 0x3C, 0x2F, 0x21, 0xE0,
  0x1C, 0xE7, 0x1F, 0xDE, 0x68, 0x73, 0x9A, 0x0E, 0x67, 0x81, 0x98, 0xA4,
  0x66, 0x47, 0x99, 0x90, 0x26, 0x6C, 0x01, 0x13, 0x04, 0x44, 0xC7, 0xBE,
  0x3C, 0x7B, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x70, 0xFD, 0x32, 0x1C, 0x64,
  0x1C, 0xE8, 0x18, 0x8B, 0x32, 0x0E, 0x64, 0x04, 0xD8, 0x01, 0x30, 0x22,
  0x61, 0xE8, 0xF8, 0xE0, 0xC0, 0x07, 0x00, 0xFC, 0x31, 0xE4, 0x07, 0x60,
  0x37, 0x83, 0x3C, 0x10, 0xC1, 0x08, 0x17, 0x82, 0xBC, 0x40, 0xF8, 0x3C,
  0x30, 0xFC, 0xC2, 0x1F, 0xC4, 0x19, 0xC8, 0x31, 0xD0, 0x61, 0xDE, 0xC1,
  0x81, 0x83, 0x03, 0x04, 0x0E, 0x08, 0x3F, 0x20, 0x0F, 0x80, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x07, 0x00, 0x7E, 0x0C, 0x78, 0x80, 0xE6, 0x03,
  0x3C, 0x18, 0xF0, 0x41, 0x82, 0x08, 0x13, 0xC7, 0x2F, 0x5E, 0x1F, 0x60,
  0x00, 0x00, 0x1C, 0x30, 0xFF, 0xB1, 0x0E, 0x74, 0x0C, 0x78, 0x18, 0x50,
  0x33, 0x11, 0x2C, 0x1C, 0x6C, 0x01, 0x98, 0x22, 0x38, 0xE8, 0x78, 0xE0,
  0x60, 0x07, 0x01, 0xFF, 0x20, 0xC4, 0x00, 0x40, 0xC5, 0x3F, 0xCF, 0x14,
  0x01, 0x60, 0x17, 0x83, 0x3F, 0xE0, 0xFC, 0x3F, 0x04, 0x3C, 0x82, 0xF8,
  0x46, 0x8E, 0x04, 0xF0, 0x33, 0x81, 0x18, 0x79, 0x01, 0xE0, 0x0E, 0x20,
  0x7C, 0x1C, 0x22, 0x4C, 0x65, 0xC7, 0x0C, 0x38, 0xC1, 0x8C, 0x18, 0xC1,
  0x0C, 0x20, 0xC7, 0x0C, 0xBF, 0xF1, 0xC6, 0x00, 0x00, 0x3E, 0x70, 0xDF,
  0x72, 0x0C, 0x64, 0x18, 0x68, 0x11, 0x09, 0x22, 0x0C, 0x87, 0x01, 0x0E,
  0x0C, 0x0C, 0x7E, 0x08, 0x1E, 0x20, 0x0F, 0x80, 0x3E, 0xDE, 0x1F, 0xC8,
  0xC4, 0x32, 0x3A, 0x0D, 0x86, 0x81, 0x71, 0x10, 0x4C, 0xC3, 0x93, 0x38,
  0x08, 0x67, 0x0C, 0x10, 0xCF, 0x86, 0x20, 0x73, 0xC8, 0x0F, 0x7C, 0x3C,
  0x77, 0xEE, 0x47, 0x08, 0x30, 0x83, 0x05, 0x7E, 0x23, 0x00, 0x30, 0x03,
  0x02, 0x78, 0x39, 0xEF, 0x8C, 0x3E, 0x71, 0xBE, 0x68, 0x31, 0xA0, 0xC7,
  0x81, 0x11, 0x24, 0xC3, 0x13, 0x80, 0x8E, 0x04, 0x1C, 0x12, 0x70, 0xF8,
  0xC0, 0xC6, 0x10, 0x18, 0x20, 0xC0, 0x7C, 0x00, 0x0F, 0x86, 0x38, 0x83,
  0x10, 0x62, 0x08, 0x33, 0x03, 0xF0, 0x07, 0x00, 0x60, 0x0D, 0xC1, 0xDC,
  0x21, 0xC8, 0x0E, 0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xC0, 0x00, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02,
  0x00, 0xED, 0xB6, 0xDB, 0x6D, 0xB7, 0xC0, 0x10, 0x71, 0xA2, 0x28, 0x20,
  0xFF, 0xB4, 0x10, 0x18, 0x2E, 0x44, 0x44, 0xC4, 0x44, 0x6E, 0x36, 0x09,
  0x61, 0x83, 0x26, 0xCE, 0xD9, 0xB1, 0x62, 0xC9, 0xE0, 0x80, 0x00, 0x10,
  0xE4, 0x91, 0xC1, 0x06, 0x18, 0x3C, 0x40, 0x83, 0x83, 0xC1, 0xCC, 0xD8,
  0xB1, 0x62, 0xC5, 0xF0, 0xC0, 0x10, 0xE4, 0x93, 0xD1, 0x86, 0x18, 0x3C,
  0x2B, 0xE0, 0x8F, 0x31, 0x8C, 0x63, 0x18, 0x44, 0x21, 0x00, 0x10, 0x18,
  0x2E, 0x44, 0xC4, 0x44, 0x46, 0x66, 0x3E, 0x06, 0x46, 0x64, 0x18, 0x19,
  0x41, 0x83, 0x47, 0xCC, 0xD9, 0xB3, 0x66, 0xCD, 0xD9, 0x20, 0x82, 0x08,
  0x00, 0x26, 0x04, 0x6F, 0x66, 0x66, 0x73, 0x31, 0x80, 0x47, 0x1C, 0xC6,
  0x31, 0x8C, 0x63, 0x1B, 0x20, 0x1D, 0x5A, 0xE7, 0xF1, 0x8C, 0x63, 0x1E,
  0x60, 0x1D, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1E, 0x60, 0x44, 0x86, 0xFC,
  0xB6, 0x62, 0x64, 0x26, 0x42, 0x64, 0x26, 0x47, 0x67, 0x26, 0x60, 0x48,
  0x6C, 0xB7, 0x26, 0x26, 0x26, 0x26, 0x77, 0x23, 0x08, 0xF1, 0x32, 0x64,
  0x68, 0xD1, 0x7C, 0x30, 0xC1, 0x8B, 0xB3, 0xB6, 0x6C, 0x58, 0xB1, 0xF4,
  0x70, 0x81, 0x02, 0x00, 0x10, 0x31, 0xBA, 0x2C, 0x58, 0xB1, 0x36, 0x34,
  0x08, 0x10, 0x20, 0x00, 0x49, 0xAB, 0xCA, 0x20, 0x82, 0x1E, 0x30, 0x00,
  0x38, 0x49, 0xFC, 0xD9, 0x1F, 0x12, 0x45, 0xF0, 0x40, 0x10, 0x88, 0xFE,
  0x31, 0x8C, 0x63, 0xCC, 0x44, 0x66, 0xA7, 0x26, 0x26, 0x26, 0x26, 0x77,
  0x1A, 0x41, 0x13, 0x77, 0x36, 0x64, 0x48, 0xA2, 0x78, 0x20, 0x40, 0x08,
  0x09, 0xBB, 0x1B, 0xB2, 0x66, 0x4C, 0x49, 0x89, 0x32, 0x77, 0x84, 0x20,
  0x25, 0xF3, 0x4C, 0x30, 0xC3, 0x0E, 0x72, 0x08, 0x1F, 0x00, 0x40, 0x44,
  0xEC, 0x36, 0x22, 0x23, 0x23, 0x22, 0x6A, 0x34, 0x08, 0x10, 0x20, 0x23,
  0x84, 0x43, 0xB9, 0x6B, 0x8C, 0x62, 0xE0, 0x19, 0x08, 0x63, 0x13, 0x04,
  0x21, 0x88, 0x41, 0x80, 0xFF, 0xFC, 0xC1, 0x0C, 0x42, 0x10, 0x66, 0x21,
  0x0C, 0x4E, 0x00, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 6, 5, 7, 0, -12 },
  { 11, 7, 10, 9, 1, -11 },
  { 20, 5, 14, 7, 1, -13 },
  { 29, 12, 12, 12, 0, -12 },
  { 47, 8, 11, 10, 1, -11 },
  { 58, 3, 5, 3, 0, -12 },
  { 60, 4, 13, 4, 0, -13 },
  { 67, 4, 13, 4, 0, -13 },
  { 74, 6, 7, 6, 0, -13 },
  { 80, 5, 6, 7, 1, -9 },
  { 84, 3, 5, 3, 0, -3 },
  { 86, 5, 4, 5, 0, -7 },
  { 89, 3, 3, 3, 0, -3 },
  { 91, 9, 14, 9, 0, -13 },
  { 107, 8, 12, 8, 0, -12 },
  { 119, 5, 12, 5, 0, -12 },
  { 127, 7, 11, 8, 0, -11 },
  { 137, 8, 12, 8, 0, -12 },
  { 149, 8, 12, 8, 0, -12 },
  { 161, 8, 12, 8, 0, -12 },
  { 173, 7, 12, 8, 0, -12 },
  { 184, 7, 11, 7, 0, -11 },
  { 194, 8, 12, 8, 0, -12 },
  { 206, 7, 12, 8, 0, -12 },
  { 217, 3, 8, 3, 0, -8 },
  { 220, 3, 10, 3, 0, -8 },
  { 224, 5, 6, 5, 0, -8 },
  { 228, 6, 4, 7, 0, -7 },
  { 231, 5, 6, 5, 0, -8 },
  { 235, 6, 12, 8, 1, -12 },
  { 244, 10, 11, 10, 0, -8 },
  { 258, 13, 12, 14, 0, -12 },
  { 278, 15, 12, 15, 0, -12 },
  { 301, 11, 12, 12, 0, -12 },
  { 318, 13, 13, 14, 0, -12 },
  { 340, 12, 12, 12, 0, -12 },
  { 358, 13, 15, 13, 0, -13 },
  { 383, 13, 12, 13, 0, -12 },
  { 403, 12, 15, 12, 0, -13 },
  { 426, 11, 14, 12, 0, -12 },
  { 446, 12, 16, 12, 0, -12 },
  { 470, 13, 12, 14, 0, -12 },
  { 490, 9, 12, 10, 0, -12 },
  { 504, 18, 13, 19, 0, -12 },
  { 534, 15, 12, 15, 0, -12 },
  { 557, 12, 12, 13, 0, -12 },
  { 575, 15, 15, 15, 0, -12 },
  { 604, 13, 13, 14, 0, -12 },
  { 626, 15, 12, 16, 0, -12 },
  { 649, 12, 12, 13, 0, -12 },
  { 667, 12, 12, 13, 0, -12 },
  { 685, 12, 13, 12, 0, -12 },
  { 705, 15, 12, 15, 0, -12 },
  { 728, 18, 12, 18, 0, -12 },
  { 755, 12, 12, 12, 0, -12 },
  { 773, 14, 15, 15, 0, -12 },
  { 800, 11, 14, 11, 0, -12 },
  { 820, 3, 14, 3, 0, -13 },
  { 826, 10, 12, 2, -3, -11 },
  { 841, 3, 14, 3, 0, -13 },
  { 847, 7, 5, 7, 0, -12 },
  { 852, 8, 1, 8, 0, 2 },
  { 853, 2, 3, 9, 3, -12 },
  { 854, 8, 9, 8, 0, -9 },
  { 863, 7, 13, 8, 0, -12 },
  { 875, 6, 9, 6, 0, -9 },
  { 882, 7, 12, 8, 0, -12 },
  { 893, 6, 9, 6, 0, -9 },
  { 900, 5, 15, 4, 0, -12 },
  { 910, 8, 13, 8, 0, -9 },
  { 923, 7, 15, 8, 0, -12 },
  { 937, 4, 12, 5, 0, -12 },
  { 943, 5, 15, 4, -1, -12 },
  { 953, 5, 12, 6, 0, -12 },
  { 961, 5, 12, 5, 0, -12 },
  { 969, 12, 9, 12, 0, -9 },
  { 983, 8, 9, 9, 0, -9 },
  { 992, 7, 9, 7, 0, -9 },
  { 1000, 7, 13, 8, 0, -10 },
  { 1012, 7, 13, 7, 0, -9 },
  { 1024, 6, 9, 6, 0, -9 },
  { 1031, 7, 11, 7, 0, -11 },
  { 1041, 5, 11, 5, 0, -11 },
  { 1048, 8, 9, 9, 0, -9 },
  { 1057, 7, 10, 8, 0, -10 },
  { 1066, 11, 10, 12, 0, -10 },
  { 1080, 6, 13, 7, 0, -9 },
  { 1090, 8, 13, 8, 0, -10 },
  { 1103, 5, 12, 6, 0, -9 },
  { 1111, 5, 13, 6, 0, -13 },
  { 1120, 1, 14, 3, 1, -13 },
  { 1122, 5, 13, 6, 0, -13 },
  { 1131, 6, 1, 6, 0, -6 },
};

const GFXfont UnifrakturMaguntia_Regular17pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular17pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular17pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR17PT7B_H_
