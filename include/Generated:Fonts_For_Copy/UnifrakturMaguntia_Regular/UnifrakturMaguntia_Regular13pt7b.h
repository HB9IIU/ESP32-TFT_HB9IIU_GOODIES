#ifndef _UNIFRAKTURMAGUNTIA_REGULAR13PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0x5D, 0x24, 0x82, 0x60, 0x56, 0x54, 0x28, 0xA7, 0xCA, 0xFC, 0xA5,
  0x00, 0x23, 0x94, 0x96, 0x1A, 0x79, 0x8B, 0x88, 0x61, 0xE8, 0xB4, 0x9A,
  0x86, 0xB0, 0xB4, 0x9A, 0x8D, 0x43, 0x00, 0x38, 0x50, 0xA1, 0xB5, 0x5B,
  0xB2, 0x3F, 0x74, 0x69, 0x6D, 0xB6, 0x4C, 0xC8, 0x92, 0x49, 0x58, 0x2D,
  0x2D, 0x60, 0x21, 0x3E, 0x42, 0x00, 0x96, 0x7E, 0x70, 0x02, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x41, 0x02, 0x00, 0x31, 0x24, 0xF3, 0xCF, 0x34,
  0xD2, 0x30, 0x26, 0xE2, 0x22, 0x66, 0xF0, 0x7A, 0x28, 0x83, 0x18, 0x42,
  0x11, 0xF8, 0x3B, 0x20, 0x84, 0x38, 0x3C, 0xF2, 0x70, 0x10, 0xC5, 0x14,
  0x93, 0xF1, 0x06, 0x3C, 0x79, 0xC8, 0x1E, 0x8C, 0x3C, 0x52, 0x70, 0x31,
  0x24, 0xB4, 0xEB, 0x3C, 0xD2, 0x30, 0x7C, 0x42, 0x21, 0x08, 0x84, 0x60,
  0x79, 0x24, 0x9C, 0x5A, 0x38, 0x73, 0x78, 0x31, 0x2C, 0xB3, 0xCD, 0xF0,
  0xB2, 0x49, 0xC0, 0x70, 0x70, 0x70, 0x96, 0x34, 0xC4, 0x30, 0xF8, 0x3E,
  0x84, 0x34, 0x80, 0x7A, 0x72, 0x13, 0x21, 0x66, 0x20, 0x80, 0x3C, 0x62,
  0x5E, 0xB6, 0xAA, 0xBD, 0x42, 0x3C, 0x7C, 0xE3, 0x68, 0x5B, 0x16, 0x65,
  0x8A, 0x61, 0x18, 0xE6, 0x0E, 0xC0, 0x7F, 0xD1, 0x9A, 0x11, 0xC2, 0x65,
  0x5E, 0x50, 0x46, 0x09, 0x61, 0x07, 0xC0, 0x3F, 0xA5, 0x16, 0x1B, 0x8C,
  0xC3, 0x31, 0x90, 0x70, 0x1F, 0x80, 0x00, 0x0F, 0xC4, 0xBA, 0x23, 0x9C,
  0x63, 0x17, 0x44, 0x11, 0x3C, 0x93, 0xC0, 0x00, 0x3F, 0xA5, 0x16, 0x1B,
  0xFC, 0xF2, 0x31, 0x90, 0x70, 0x1F, 0x80, 0x3E, 0x11, 0xF8, 0x82, 0x32,
  0x87, 0xDD, 0xC6, 0x30, 0xCC, 0x23, 0x08, 0x81, 0xC0, 0x3B, 0x13, 0x65,
  0x93, 0x6E, 0xCC, 0xB1, 0x36, 0x49, 0xA2, 0x1F, 0x00, 0x00, 0x0E, 0x09,
  0x84, 0x43, 0x71, 0xCC, 0x66, 0x11, 0x68, 0xD8, 0x80, 0x81, 0x80, 0x3C,
  0x23, 0xA0, 0x90, 0x44, 0x61, 0xD8, 0x0C, 0x02, 0x71, 0x5C, 0x87, 0x80,
  0x3C, 0x23, 0xA0, 0x90, 0x44, 0x61, 0xD8, 0x0C, 0x02, 0x01, 0x80, 0xBC,
  0x47, 0x40, 0x40, 0x0F, 0x85, 0x92, 0xB4, 0xC7, 0x39, 0x47, 0xE0, 0x99,
  0xA6, 0xB0, 0xC0, 0x3C, 0x85, 0x8B, 0x12, 0xC4, 0x10, 0x79, 0x1C, 0x3B,
  0xBB, 0x33, 0x68, 0x6C, 0xA1, 0x93, 0x76, 0x50, 0x49, 0x40, 0x4B, 0x1E,
  0xA6, 0x3F, 0x1C, 0x00, 0x00, 0x79, 0xD1, 0xDA, 0x19, 0xC3, 0x27, 0x28,
  0x25, 0x01, 0x23, 0xA7, 0x38, 0x40, 0x0E, 0x1B, 0x90, 0x78, 0x17, 0x08,
  0xC4, 0xC3, 0xE2, 0x1E, 0x00, 0x78, 0x91, 0xF2, 0x33, 0x42, 0x35, 0x42,
  0x48, 0x41, 0x08, 0xF2, 0x07, 0x80, 0x80, 0x20, 0x00, 0x0E, 0x0D, 0xC4,
  0x1B, 0x02, 0x70, 0x86, 0x23, 0x2B, 0xDD, 0x1E, 0x80, 0x00, 0x39, 0xC4,
  0xE6, 0x86, 0x68, 0x24, 0x82, 0x87, 0x3C, 0x04, 0xC3, 0x46, 0x78, 0x70,
  0x1E, 0x99, 0xC4, 0x02, 0x1C, 0x9E, 0xB2, 0x26, 0x09, 0xE6, 0x1F, 0x00,
  0x3C, 0x63, 0xA2, 0xF3, 0x05, 0xE1, 0x31, 0xD0, 0x70, 0x0F, 0x80, 0x31,
  0xAD, 0x98, 0xCE, 0x63, 0x31, 0x19, 0x0C, 0xEE, 0xBB, 0x80, 0x00, 0x7F,
  0xD1, 0x9A, 0x11, 0xC2, 0x45, 0x4C, 0x50, 0xC6, 0x19, 0xE2, 0x07, 0x80,
  0x7B, 0xF1, 0x34, 0x68, 0x51, 0xA1, 0x64, 0x54, 0x98, 0xA3, 0x73, 0x88,
  0xD7, 0x32, 0x0F, 0x70, 0x7B, 0xC6, 0xA3, 0x11, 0xE6, 0xE0, 0x20, 0x30,
  0xED, 0x73, 0x00, 0x00, 0x0F, 0xFA, 0x33, 0x42, 0x38, 0x48, 0xA9, 0x0A,
  0x30, 0x46, 0x1E, 0x61, 0x88, 0x83, 0x0F, 0x80, 0x1E, 0x63, 0x43, 0x32,
  0x06, 0x1F, 0x03, 0x01, 0x61, 0xB2, 0x0C, 0xEA, 0xAA, 0xAC, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x80, 0xD5, 0x55, 0x5C, 0x23, 0xB2,
  0xFC, 0x90, 0x20, 0xC4, 0xB2, 0xC9, 0x66, 0xC0, 0xB1, 0x05, 0x16, 0x69,
  0x34, 0x9A, 0x30, 0x25, 0x5C, 0xC4, 0x70, 0xC3, 0x07, 0x0E, 0x4D, 0x14,
  0x9A, 0x30, 0x27, 0x5E, 0xC4, 0x70, 0x7A, 0x8E, 0x44, 0x44, 0x44, 0x44,
  0x20, 0xC4, 0xB2, 0xC9, 0x27, 0x82, 0x48, 0xC0, 0xB1, 0x05, 0x1E, 0x49,
  0x24, 0x92, 0x68, 0x46, 0x00, 0x69, 0x74, 0x92, 0x60, 0x22, 0x27, 0x22,
  0x22, 0x22, 0xF0, 0xB5, 0x6F, 0x44, 0x44, 0x30, 0xB4, 0x44, 0x44, 0x44,
  0x30, 0x52, 0x37, 0xBA, 0x4D, 0x26, 0x93, 0x49, 0x36, 0x91, 0x7E, 0x9A,
  0x69, 0xA4, 0xC0, 0x17, 0xB7, 0x9C, 0xE8, 0x80, 0x82, 0x45, 0x9A, 0x4D,
  0x2E, 0x9C, 0x41, 0x04, 0x00, 0x21, 0x97, 0x3C, 0xE5, 0xE1, 0x10, 0x80,
  0x9D, 0x74, 0x47, 0x20, 0x39, 0x7F, 0x27, 0xA5, 0xD4, 0x26, 0xF4, 0x44,
  0x43, 0x49, 0x3E, 0x9A, 0x69, 0xA3, 0xC0, 0x93, 0xE4, 0x93, 0x49, 0x23,
  0x00, 0x80, 0x41, 0x1E, 0xCD, 0xB6, 0x9B, 0x49, 0xB4, 0xCC, 0x53, 0xCC,
  0x42, 0x19, 0x90, 0x93, 0x00, 0x83, 0x47, 0x9B, 0x6D, 0xB6, 0x9E, 0x10,
  0x80, 0x62, 0x27, 0xFB, 0x99, 0xE0, 0x36, 0x66, 0x4C, 0x66, 0x63, 0xFF,
  0xE0, 0xC6, 0x66, 0x23, 0x46, 0x6C, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 5, 3, 5, 0, -9 },
  { 7, 6, 7, 7, 0, -8 },
  { 13, 5, 11, 5, 0, -10 },
  { 20, 9, 9, 9, 0, -9 },
  { 31, 7, 8, 7, 0, -8 },
  { 38, 2, 3, 3, 0, -9 },
  { 39, 3, 10, 3, 0, -10 },
  { 43, 3, 10, 3, 0, -10 },
  { 47, 4, 5, 5, 0, -10 },
  { 50, 5, 5, 5, 0, -7 },
  { 54, 2, 4, 2, 0, -2 },
  { 55, 4, 2, 4, 0, -5 },
  { 56, 2, 2, 3, 0, -2 },
  { 57, 7, 11, 7, 0, -10 },
  { 67, 6, 9, 6, 0, -9 },
  { 74, 4, 9, 4, 0, -9 },
  { 79, 6, 9, 6, 0, -9 },
  { 86, 6, 9, 6, 0, -9 },
  { 93, 6, 9, 6, 0, -9 },
  { 100, 6, 9, 6, 0, -9 },
  { 107, 6, 9, 6, 0, -9 },
  { 114, 5, 9, 6, 0, -9 },
  { 120, 6, 9, 6, 0, -9 },
  { 127, 6, 10, 6, 0, -10 },
  { 135, 2, 6, 3, 0, -6 },
  { 137, 2, 8, 2, 0, -6 },
  { 139, 4, 5, 4, 0, -6 },
  { 142, 5, 3, 5, 0, -5 },
  { 144, 4, 5, 4, 0, -6 },
  { 147, 5, 10, 6, 0, -10 },
  { 154, 8, 8, 8, 0, -6 },
  { 162, 10, 9, 11, 0, -9 },
  { 174, 11, 9, 12, 0, -9 },
  { 187, 9, 9, 9, 0, -9 },
  { 198, 10, 11, 11, 0, -10 },
  { 212, 9, 9, 9, 0, -9 },
  { 223, 10, 11, 10, 0, -9 },
  { 237, 10, 9, 10, 0, -9 },
  { 249, 9, 12, 10, 0, -10 },
  { 263, 9, 11, 9, 0, -9 },
  { 276, 9, 13, 9, 0, -9 },
  { 291, 10, 9, 11, 0, -9 },
  { 303, 7, 9, 7, 0, -9 },
  { 311, 14, 10, 14, 0, -9 },
  { 329, 11, 9, 11, 0, -9 },
  { 342, 9, 9, 10, 0, -9 },
  { 353, 11, 11, 12, 0, -9 },
  { 369, 10, 10, 10, 0, -9 },
  { 382, 12, 9, 12, 0, -9 },
  { 396, 10, 9, 10, 0, -9 },
  { 408, 9, 9, 10, 0, -9 },
  { 419, 9, 10, 9, 0, -9 },
  { 431, 11, 9, 12, 0, -9 },
  { 444, 14, 9, 14, 0, -9 },
  { 460, 9, 9, 9, 0, -9 },
  { 471, 11, 12, 11, 0, -10 },
  { 488, 8, 11, 9, 0, -9 },
  { 499, 2, 11, 2, 0, -10 },
  { 502, 8, 9, 1, -2, -8 },
  { 511, 2, 11, 2, 0, -10 },
  { 514, 5, 3, 5, 0, -9 },
  { 516, 6, 1, 6, 0, 1 },
  { 517, 2, 2, 7, 2, -9 },
  { 518, 6, 7, 6, 0, -7 },
  { 524, 6, 9, 6, 0, -9 },
  { 531, 4, 7, 5, 0, -7 },
  { 535, 6, 9, 6, 0, -9 },
  { 542, 4, 7, 5, 0, -7 },
  { 546, 4, 12, 3, 0, -10 },
  { 552, 6, 10, 6, 0, -7 },
  { 560, 6, 11, 6, 0, -9 },
  { 569, 3, 9, 4, 0, -9 },
  { 573, 4, 11, 3, -1, -9 },
  { 579, 4, 9, 4, 0, -9 },
  { 584, 4, 9, 4, 0, -9 },
  { 589, 9, 7, 9, 0, -7 },
  { 597, 6, 7, 7, 0, -7 },
  { 603, 5, 7, 5, 0, -7 },
  { 608, 6, 11, 6, 0, -8 },
  { 617, 5, 10, 6, 0, -7 },
  { 624, 4, 7, 5, 0, -7 },
  { 628, 5, 8, 5, 0, -8 },
  { 633, 4, 8, 4, 0, -8 },
  { 637, 6, 7, 7, 0, -7 },
  { 643, 6, 7, 6, 0, -7 },
  { 649, 9, 8, 9, 0, -8 },
  { 658, 5, 10, 5, 0, -7 },
  { 665, 6, 10, 6, 0, -8 },
  { 673, 4, 9, 4, 0, -7 },
  { 678, 4, 10, 4, 0, -10 },
  { 683, 1, 11, 2, 1, -10 },
  { 685, 4, 10, 4, 0, -10 },
  { 690, 4, 1, 5, 0, -4 },
};

const GFXfont UnifrakturMaguntia_Regular13pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular13pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular13pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR13PT7B_H_
