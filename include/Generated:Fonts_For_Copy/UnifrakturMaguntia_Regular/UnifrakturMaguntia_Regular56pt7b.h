#ifndef _UNIFRAKTURMAGUNTIA_REGULAR56PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x01, 0xC0, 0x7C, 0x1F, 0xC7, 0xFC, 0xFF, 0x8F, 0xE1, 0xFC,
  0x3F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0xC0,
  0x7C, 0x1F, 0xC7, 0xFC, 0x3E, 0x03, 0x80, 0x20, 0x00, 0x00, 0x08, 0x01,
  0x00, 0xC0, 0x10, 0x1E, 0x03, 0x83, 0xF0, 0x7C, 0x7F, 0x9F, 0xF3, 0xF8,
  0xFF, 0x1F, 0x83, 0xF0, 0xF8, 0x1E, 0x07, 0x01, 0xE0, 0x70, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x08, 0x04, 0x01, 0x80, 0xC0, 0x10, 0x08, 0x03, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x1F,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x78, 0x38, 0x1C,
  0x03, 0x87, 0x80, 0x70, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1E, 0x7E, 0x01, 0xCF, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xB8, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3D, 0xC0, 0x07, 0x38, 0x01, 0xE3, 0x80, 0x38, 0x38, 0x0E, 0x03, 0xEF,
  0x80, 0x1F, 0xE0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x1F,
  0x00, 0x00, 0x01, 0xC3, 0xFE, 0x00, 0x00, 0x0C, 0x3C, 0x78, 0x00, 0x00,
  0xC3, 0xC3, 0xC0, 0x00, 0x0C, 0x1E, 0x1F, 0x00, 0x00, 0xE1, 0xF0, 0x78,
  0x00, 0x0E, 0x0F, 0x83, 0xE0, 0x00, 0xE0, 0x7C, 0x1F, 0x00, 0x0E, 0x03,
  0xE0, 0xF8, 0x00, 0xE0, 0x3F, 0x07, 0xC0, 0x06, 0x01, 0xF8, 0x3E, 0x00,
  0x60, 0x07, 0xC1, 0xF0, 0x07, 0x00, 0x3E, 0x0F, 0x80, 0x70, 0x01, 0xF0,
  0x7C, 0x07, 0x00, 0x0F, 0x83, 0xC0, 0x70, 0x00, 0x3C, 0x3E, 0x07, 0x00,
  0x01, 0xE1, 0xE0, 0x30, 0x00, 0x07, 0x8F, 0x03, 0x00, 0x00, 0x1F, 0xF0,
  0x30, 0x3E, 0x00, 0x3E, 0x03, 0x87, 0xFC, 0x00, 0x00, 0x38, 0x78, 0xF0,
  0x00, 0x03, 0x87, 0xC7, 0x80, 0x00, 0x38, 0x3C, 0x1E, 0x00, 0x03, 0x83,
  0xE0, 0xF8, 0x00, 0x18, 0x1F, 0x07, 0xC0, 0x01, 0x80, 0xF8, 0x3E, 0x00,
  0x1C, 0x07, 0xC1, 0xF0, 0x01, 0xC0, 0x3E, 0x0F, 0x80, 0x1C, 0x01, 0xF0,
  0x7C, 0x01, 0xC0, 0x0F, 0x83, 0xE0, 0x1C, 0x00, 0x7C, 0x1F, 0x00, 0xC0,
  0x03, 0xE0, 0xF8, 0x0C, 0x00, 0x1F, 0x07, 0xC0, 0xC0, 0x00, 0x78, 0x3C,
  0x0E, 0x00, 0x03, 0xE3, 0xC0, 0xE0, 0x00, 0x0F, 0x1E, 0x0E, 0x00, 0x00,
  0x3F, 0xE0, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x00,
  0xFC, 0x70, 0x00, 0x07, 0xF7, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x83, 0xFE, 0x07, 0xFE, 0x03,
  0xC0, 0x77, 0xF0, 0x1C, 0x07, 0x1F, 0xC0, 0x60, 0x78, 0xFE, 0x03, 0x07,
  0x83, 0xF8, 0x30, 0x3C, 0x1F, 0xC1, 0x83, 0xE0, 0xFF, 0x0C, 0x1F, 0x03,
  0xF8, 0x40, 0xF8, 0x1F, 0xE6, 0x07, 0xE0, 0x7F, 0x60, 0x3F, 0x01, 0xFF,
  0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x09,
  0xFC, 0x07, 0xF8, 0xEF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF1, 0xFE, 0x00, 0xFE, 0x07, 0xC0, 0x08, 0x04, 0x07, 0x07, 0xCF, 0xFB,
  0xFC, 0x7E, 0x1E, 0x0F, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x00,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x70, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0x80, 0x01,
  0xFC, 0x01, 0x9F, 0x61, 0xF1, 0xCF, 0xDF, 0x39, 0xF3, 0xE2, 0x7E, 0x7E,
  0x5F, 0x8F, 0xFF, 0xF0, 0x03, 0x80, 0x31, 0xFC, 0x47, 0xF5, 0xF8, 0xFC,
  0x9F, 0x9F, 0x39, 0xF7, 0xE7, 0x3E, 0x0D, 0xF6, 0x20, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x07, 0x07, 0xC7,
  0xFB, 0xFC, 0x7E, 0x1F, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x40, 0x60, 0x20,
  0x20, 0x00, 0x3F, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7E, 0x00, 0x00,
  0x04, 0x07, 0x07, 0xC7, 0xF7, 0xFC, 0xF8, 0x38, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xE3,
  0xC0, 0x07, 0xC1, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x80,
  0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00,
  0xFE, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0xEF, 0xE0,
  0x87, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xE0, 0xFF, 0x87, 0x00,
  0x7F, 0x9C, 0x00, 0x7F, 0x30, 0x00, 0xFE, 0x60, 0x01, 0xFE, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x10, 0x1C, 0x00, 0x20, 0x70, 0x00, 0xC1, 0xC0,
  0x01, 0x87, 0x00, 0x03, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1E, 0x0F, 0xF8, 0x38, 0x03,
  0xFC, 0x30, 0x01, 0xFC, 0x60, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x78, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFE, 0x00,
  0x3C, 0xFE, 0x00, 0x7C, 0x7E, 0x00, 0x78, 0x7E, 0x00, 0x70, 0x3F, 0x00,
  0xE0, 0x1F, 0x83, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x6F, 0xC0, 0x00, 0xCF,
  0xC0, 0x01, 0xCF, 0xC0, 0x01, 0x8F, 0xC0, 0x03, 0x0F, 0xC0, 0x03, 0x0F,
  0xC0, 0x06, 0x0F, 0xC0, 0x0C, 0x0F, 0xC0, 0x0C, 0x0F, 0xC0, 0x18, 0x0F,
  0xC0, 0x30, 0x0F, 0xC0, 0x30, 0x0F, 0xC0, 0x60, 0x0F, 0xC0, 0xC0, 0x0F,
  0xC0, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x08, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x07,
  0xFE, 0x3C, 0x01, 0xFE, 0x30, 0x00, 0xFE, 0x20, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x3C, 0xFE, 0x00, 0x3C, 0x7E, 0x00,
  0x78, 0x7E, 0x00, 0x70, 0x3F, 0x00, 0xE0, 0x0F, 0x83, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xE3, 0xE0, 0x01, 0x81, 0xF0, 0x03, 0x80,
  0xF8, 0x07, 0x80, 0xFC, 0x0F, 0x00, 0xFC, 0x0F, 0x00, 0xFC, 0x1F, 0x00,
  0xFC, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x38, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F,
  0xE0, 0x7E, 0x7F, 0xF8, 0x7E, 0xE1, 0xF8, 0xFE, 0xC1, 0xFC, 0xFF, 0x80,
  0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7E, 0xFF, 0x00,
  0x7E, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7C, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0xE0, 0x07, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0x00, 0x01, 0xB8, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x01, 0xC8, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x80,
  0xE0, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x00,
  0x1C, 0x3C, 0x00, 0x1C, 0x7C, 0x00, 0x1C, 0x7C, 0x00, 0x1C, 0x7E, 0x00,
  0x1C, 0x7E, 0x00, 0x3C, 0x7F, 0x80, 0x38, 0x3F, 0xC0, 0x78, 0x3F, 0xF0,
  0xF0, 0x1F, 0xFD, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0x7F, 0xF8, 0x1E, 0x1F,
  0xFC, 0x3C, 0x07, 0xFC, 0x38, 0x01, 0xFE, 0x78, 0x00, 0xFE, 0x70, 0x00,
  0x7E, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x07, 0x01,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x87, 0x80, 0x07, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x0E, 0x01, 0xF0, 0x1E, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x3E, 0x01, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFE, 0x7F, 0x03, 0xFE, 0x7F, 0x03, 0xFE, 0x3F, 0x86, 0xFE, 0x1F, 0xFC,
  0xFE, 0x0F, 0xFC, 0xFE, 0x07, 0xF0, 0xFC, 0x00, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7E, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7F, 0x01, 0xE0, 0x3F, 0x01,
  0xC0, 0x3F, 0x01, 0xC0, 0x1F, 0x03, 0x80, 0x0F, 0x86, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x04, 0x07, 0x07, 0xC7, 0xF7, 0xFC, 0xF8, 0x38, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
  0xC1, 0xF1, 0xFD, 0xFF, 0x3E, 0x0E, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0xE0, 0x7C, 0x3F, 0x9F, 0xF1, 0xF0, 0x38, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x0F,
  0x87, 0xF9, 0xFE, 0x1F, 0x83, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xF0, 0x7C, 0x0E,
  0x00, 0xF8, 0xE0, 0x07, 0xCF, 0x00, 0x1F, 0x70, 0x00, 0xFB, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x00, 0x7E, 0x30,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x08, 0x1E, 0x00, 0xC0,
  0x78, 0x04, 0x01, 0xC0, 0x60, 0x07, 0x86, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x38, 0x3C, 0x01, 0xFF, 0x9C, 0x1E, 0x03, 0xFF, 0xC7, 0x1E,
  0x03, 0xE7, 0xC3, 0x8F, 0x03, 0xE3, 0xE1, 0xC7, 0x83, 0xE1, 0xF0, 0xE7,
  0x83, 0xE0, 0xF0, 0x73, 0xC1, 0xF0, 0xF8, 0x39, 0xE1, 0xF0, 0x7C, 0x3C,
  0xF0, 0xF8, 0x3C, 0x1C, 0x78, 0xF8, 0x3E, 0x0E, 0x3C, 0x7C, 0x1F, 0x0F,
  0x1E, 0x3E, 0x1F, 0x8F, 0x0F, 0x1F, 0x1F, 0x8F, 0x87, 0x8F, 0x9F, 0xCF,
  0x83, 0xC7, 0xFD, 0xFF, 0x9C, 0xE1, 0xFC, 0xFF, 0x8E, 0x78, 0x78, 0x3F,
  0x0F, 0x1C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x70, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0xF1, 0xFF, 0xF0, 0x0F, 0xE0, 0x30, 0x07, 0xFF, 0x07, 0xF8, 0x0C,
  0x00, 0x3F, 0xE3, 0xFF, 0x01, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x60, 0x00,
  0x3F, 0xC1, 0xFC, 0x0C, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x60, 0x00, 0x0F, 0xE0, 0xFE, 0x0C, 0x00, 0x01, 0xFE, 0x1F,
  0xC1, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0x7F, 0x03,
  0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x0F, 0xFC,
  0x01, 0xF8, 0x3F, 0x80, 0xFF, 0xC0, 0x3E, 0x07, 0xF0, 0x0F, 0xFC, 0x0F,
  0xC0, 0xFE, 0x00, 0xFF, 0x81, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3C, 0x03,
  0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x7F, 0x00, 0x01, 0xC1, 0xC0, 0x0F, 0xE0,
  0x00, 0x30, 0x70, 0x01, 0xFC, 0x00, 0x04, 0x1C, 0x00, 0x3F, 0x80, 0x01,
  0x03, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x0C, 0x7F, 0xF8, 0x37, 0xF9, 0x80,
  0x07, 0xFF, 0xDC, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0xC3, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xFF,
  0x40, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x3C, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x1C, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x06, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xE3, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE1, 0x80, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0x80, 0x70, 0x00,
  0x03, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x0E, 0x00,
  0x00, 0xF8, 0x3F, 0xFC, 0x07, 0x00, 0x00, 0x7C, 0x7F, 0xFF, 0x01, 0xE0,
  0x08, 0x3C, 0xFF, 0xFF, 0xC0, 0x7C, 0x18, 0x1C, 0x03, 0xFF, 0xF0, 0x0F,
  0xF8, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x21, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0x80, 0x00,
  0xF8, 0x70, 0xFE, 0x00, 0x1E, 0x01, 0x1F, 0xF9, 0x03, 0xE0, 0x1B, 0xFF,
  0xF0, 0x7C, 0x00, 0xFF, 0xFE, 0x07, 0x80, 0x1C, 0xFF, 0xC0, 0xF8, 0x03,
  0x01, 0xF0, 0x1F, 0x80, 0xE0, 0x06, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0x3F,
  0x03, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF,
  0x80, 0x00, 0x7F, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xE0, 0x00, 0x7F,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0xC0,
  0x07, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x00, 0xFF, 0x80,
  0x78, 0x00, 0x07, 0xFC, 0x0E, 0x00, 0x00, 0x3F, 0xE1, 0x80, 0x00, 0x03,
  0xFF, 0x90, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0xFF, 0xF8, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0x80, 0x18, 0x3F, 0xFC, 0x07,
  0xC0, 0x06, 0x01, 0xFF, 0xC1, 0xF0, 0x01, 0x80, 0x0F, 0xF8, 0x3C, 0x00,
  0xF0, 0x00, 0xFF, 0x87, 0x00, 0x1E, 0x00, 0x0F, 0xF1, 0xE0, 0x07, 0xC0,
  0x00, 0xFF, 0x38, 0x01, 0xFC, 0x00, 0x0F, 0xE7, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xDC, 0x00, 0xFF, 0xC0, 0x01, 0xFB,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0x30, 0x01, 0xFF, 0xC0, 0x03, 0xE6, 0x00,
  0x1F, 0xFC, 0x00, 0x3E, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xCC, 0x00, 0x1F,
  0xF8, 0x00, 0x79, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0xE0,
  0x01, 0xE0, 0xE0, 0x41, 0xFC, 0x00, 0x38, 0x07, 0xF8, 0x1F, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0xC0, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xC0, 0x04,
  0x00, 0x77, 0xFF, 0xFE, 0x03, 0x80, 0x18, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xC0,
  0x00, 0x3E, 0x0C, 0x3F, 0x80, 0x03, 0xC0, 0x23, 0xFF, 0x20, 0x3C, 0x01,
  0xBF, 0xFF, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x1E, 0x00, 0x73, 0xFF, 0x01,
  0xF0, 0x06, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x06, 0x00, 0xF8, 0x0E, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x30,
  0x0F, 0xE1, 0xFF, 0x07, 0xE0, 0x7F, 0x0F, 0xFC, 0x7F, 0xCB, 0xF8, 0x3F,
  0xF3, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xBF, 0xC7,
  0xF0, 0x1F, 0xFC, 0x7E, 0x3F, 0x80, 0x7F, 0xF1, 0xC1, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x0F, 0x00, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x0E, 0x00, 0x00,
  0x1F, 0xF8, 0xC0, 0x00, 0x00, 0xFF, 0xE4, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x20, 0x0F, 0xFF, 0x80, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x1F, 0x00,
  0x03, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x38, 0x00, 0x03, 0x3F,
  0xE0, 0x78, 0x00, 0x06, 0x0F, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x30,
  0x60, 0x00, 0x7F, 0x80, 0x78, 0x60, 0x00, 0x7F, 0xC0, 0xFC, 0x60, 0x00,
  0x3F, 0xE0, 0xFE, 0x30, 0x00, 0x3F, 0xF1, 0xFF, 0x38, 0x00, 0x1F, 0xFB,
  0xFE, 0x1C, 0x00, 0x1F, 0xFF, 0xFC, 0x0E, 0x00, 0x0F, 0xFC, 0x7C, 0x07,
  0x81, 0xC7, 0xFE, 0x18, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x06, 0x00, 0x00, 0x1F, 0x0C, 0x0F, 0x00, 0x00, 0x1E, 0x01,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xCF, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xFC,
  0x00, 0x1E, 0x00, 0x19, 0xFF, 0x00, 0x1F, 0x00, 0x30, 0x7F, 0xE0, 0x1F,
  0x00, 0x30, 0x1F, 0xF8, 0x1F, 0x80, 0x70, 0x07, 0xFE, 0x0F, 0xC0, 0x70,
  0x01, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0x1C,
  0x03, 0xF0, 0x7E, 0x00, 0x1C, 0x03, 0xF8, 0x3F, 0x00, 0x18, 0x01, 0xFC,
  0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x07, 0xF8,
  0x7F, 0xF8, 0x3F, 0x81, 0xFE, 0x7F, 0xFE, 0x1F, 0xC0, 0xFF, 0x83, 0xFF,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC7, 0xF0, 0x1F, 0xF0, 0x1F, 0xE3, 0xF8,
  0x07, 0xFC, 0x07, 0xF9, 0xFC, 0x01, 0xFF, 0x01, 0xFC, 0xFF, 0x00, 0x7F,
  0x80, 0xFE, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F,
  0x9F, 0xE0, 0x03, 0xF8, 0x0F, 0xC7, 0xF8, 0x01, 0xFC, 0x07, 0xE3, 0xFC,
  0x00, 0x7C, 0x03, 0xF0, 0xFF, 0x00, 0x3C, 0x01, 0xF8, 0x7F, 0x80, 0x1C,
  0x00, 0xF8, 0x1F, 0xE0, 0x1C, 0x00, 0x7C, 0x07, 0xF0, 0x1C, 0x00, 0x7C,
  0x03, 0xFC, 0x18, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x1F,
  0xFA, 0x00, 0x00, 0x18, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x1F, 0xF0, 0x00,
  0x01, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x00,
  0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xFE,
  0x00, 0x1F, 0xF1, 0xFF, 0xFE, 0x00, 0x3F, 0xE7, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x3E, 0x01, 0xE0,
  0x03, 0xF0, 0xFE, 0x03, 0xC0, 0x07, 0xE7, 0xFE, 0x03, 0x00, 0x0F, 0xDF,
  0xFE, 0x0C, 0x00, 0x1F, 0x27, 0xFE, 0x30, 0x00, 0x7E, 0x07, 0xFF, 0xC0,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xC0, 0xFF, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x1E, 0x00, 0x0F, 0xFF,
  0xE1, 0xC0, 0x00, 0x7F, 0xFC, 0x1C, 0x00, 0x03, 0xFF, 0x03, 0xC0, 0x00,
  0x0F, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xF0,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0x00,
  0x3F, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x03,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x87, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x00, 0x7E, 0x3F,
  0xFC, 0x00, 0x03, 0xC7, 0xFF, 0xF0, 0x00, 0x3C, 0xE7, 0xFF, 0x00, 0x03,
  0x80, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x06, 0x00, 0x07, 0xFF,
  0x00, 0xC0, 0x00, 0x3F, 0xFC, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xC0,
  0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xE0, 0x70, 0x00, 0x1F, 0xFF,
  0x01, 0x80, 0x00, 0x3F, 0xF0, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0x07, 0xC0, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x00, 0xFE, 0x00,
  0x0C, 0x00, 0x03, 0xF8, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x00,
  0x3F, 0xC0, 0x00, 0x78, 0x1C, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0xFF,
  0xF0, 0x00, 0x07, 0x07, 0xFF, 0xF0, 0x00, 0x1C, 0x39, 0xFF, 0xE0, 0x00,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x03, 0xFF, 0x80, 0x18, 0x00, 0x07,
  0xFF, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x78, 0x01, 0xC0, 0x01, 0xF0, 0x3F, 0xE0, 0x3C, 0x00, 0x7C,
  0x1F, 0xFE, 0x03, 0x80, 0x0F, 0x87, 0xFF, 0xE0, 0x38, 0x03, 0xF0, 0xFF,
  0xFE, 0x07, 0x00, 0x7E, 0x38, 0x3F, 0xE0, 0xE0, 0x0F, 0xC4, 0x03, 0xFC,
  0x1E, 0x01, 0xF8, 0x80, 0x3F, 0xC1, 0xC0, 0x7F, 0x30, 0x07, 0xF8, 0x38,
  0x07, 0xF4, 0x00, 0x7F, 0x87, 0x00, 0xFE, 0x80, 0x0F, 0xF8, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x98, 0x03, 0xFF, 0x00, 0x0F, 0xC7, 0x00, 0x3F, 0xE0,
  0x00, 0xE0, 0xE0, 0x07, 0xFC, 0x00, 0x30, 0x18, 0x00, 0xFF, 0xC0, 0x1C,
  0x06, 0x00, 0x0F, 0xFC, 0x07, 0x83, 0x80, 0x00, 0xFF, 0x83, 0xF8, 0xC0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x2F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x3C, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x78, 0x07, 0xF8,
  0x07, 0xFC, 0x06, 0x00, 0x7F, 0x81, 0xFF, 0xC0, 0xC0, 0x0F, 0xF0, 0x6F,
  0xFC, 0x30, 0x00, 0xFF, 0x10, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0xFE, 0x00, 0x03, 0xE3, 0xFC, 0x00,
  0x0F, 0x8F, 0xF0, 0x00, 0x3E, 0x3F, 0xE0, 0x00, 0xF8, 0x7F, 0x80, 0x03,
  0xE1, 0xFF, 0x00, 0x0F, 0x87, 0xFC, 0x00, 0x7C, 0x0F, 0xF8, 0x03, 0xE0,
  0x3F, 0xE6, 0x3F, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x03, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0x1F, 0xFF, 0x00, 0x60, 0x1F, 0xFF, 0x87, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xC6, 0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0xC7,
  0xFE, 0xC1, 0xFE, 0x01, 0xF9, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x38,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x07, 0x00, 0x0F, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x60, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x04, 0x00, 0x03,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x40, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x8C, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0xC0, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0xEC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x03, 0xFC, 0xC0,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x04, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x18, 0x07, 0x01, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0x00, 0x3F, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x70,
  0x03, 0xFF, 0xE0, 0x1F, 0x00, 0x7C, 0x0E, 0x00, 0x1F, 0xFF, 0x01, 0xF0,
  0x07, 0xC1, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x03, 0x01, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x02, 0x01, 0xE0, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x70, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0E, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0xFE, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x63, 0xC0, 0xC0,
  0x7F, 0x80, 0x07, 0xFE, 0x06, 0x7E, 0x18, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0xCF, 0xF1, 0x00, 0x3F, 0xE6, 0x1F, 0xFF, 0x19, 0xFF, 0xF0, 0x03, 0xFF,
  0xC1, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x43, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE3, 0x07, 0xF8, 0x0F, 0x81, 0xFF, 0xCC, 0x07, 0xF0, 0x1C, 0x00,
  0xFF, 0xD0, 0x0F, 0xF0, 0x70, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0xC0, 0x00,
  0x7F, 0x80, 0x1F, 0xC1, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC2, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0x8C, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x98, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xB0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x20, 0x00, 0x03,
  0xF8, 0x00, 0xF0, 0x60, 0x00, 0x03, 0xF0, 0x01, 0x80, 0xC0, 0x00, 0x07,
  0xE0, 0x06, 0x01, 0xC1, 0xF0, 0x0F, 0xC0, 0x18, 0x01, 0xFF, 0xF0, 0x0F,
  0x80, 0x70, 0x01, 0xFF, 0xF0, 0x1F, 0x01, 0xC0, 0x01, 0xFF, 0xE0, 0x3E,
  0x07, 0x80, 0x01, 0xFF, 0xC0, 0x7C, 0x0F, 0x00, 0x00, 0x01, 0x80, 0xF8,
  0x3E, 0x00, 0x00, 0x03, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC1,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0x80, 0x00, 0x7C, 0x01, 0x80, 0x7F,
  0x80, 0x03, 0xFC, 0x06, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0xFF,
  0x04, 0x3F, 0xFC, 0x30, 0x01, 0xFF, 0xF8, 0xCF, 0xF8, 0xC0, 0x01, 0xFF,
  0xE1, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0x80,
  0x03, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x3F,
  0xF0, 0x3C, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x00, 0x07, 0xF8, 0x7E,
  0x00, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x7E,
  0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x00, 0x00, 0x3E, 0x1F, 0xFF,
  0x80, 0x00, 0x3E, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x07, 0xFF, 0xC0, 0x00,
  0x1E, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00,
  0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0xE6, 0x00, 0x00, 0x18,
  0x07, 0xF8, 0x00, 0x00, 0x30, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x3F, 0xFF,
  0x00, 0x00, 0x60, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x83, 0xFF, 0xE0, 0x01,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x7F, 0xFE, 0x0E, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xF0,
  0x00, 0x7C, 0x07, 0xFE, 0x7F, 0xF8, 0x00, 0x70, 0x01, 0xFF, 0xE7, 0xFC,
  0x00, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0xC0, 0x00, 0x7F, 0x83, 0xFF, 0x80, 0xC0, 0x00, 0x3F, 0x81, 0xFF,
  0xC0, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0xF0, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0xC0, 0x00, 0x1F, 0xC0, 0x1F,
  0xFC, 0x40, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x60, 0x00, 0x1F, 0xC0, 0x07,
  0xFE, 0x30, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x18, 0x01, 0x1F, 0xC0, 0x00,
  0xFE, 0x0E, 0x06, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x60, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x0E, 0x3F, 0xFF, 0xE7,
  0x80, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x03,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0xCC, 0x00, 0x3C, 0x30,
  0x01, 0xFE, 0x00, 0x0F, 0xEC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x63, 0xFE, 0x0A, 0x0F, 0xFF,
  0x80, 0x3F, 0xE7, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF3, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x3F,
  0x00, 0x00, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0xC3, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x60, 0x7F, 0xC0, 0x3E, 0x01, 0xFF, 0xD0, 0x0F, 0xF0,
  0x1E, 0x00, 0x1F, 0xFC, 0x01, 0xFE, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0x81, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x60, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x38, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xCE, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xE3, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1F,
  0x80, 0x70, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x30, 0x00, 0x30, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xC0, 0x08,
  0x0F, 0x9F, 0xF0, 0x00, 0x3C, 0x06, 0x03, 0xEF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7F, 0x80,
  0x00, 0x78, 0x01, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x30, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x18, 0x00, 0x3F,
  0xE2, 0x0F, 0xFF, 0x8C, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x0C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3D, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x1F,
  0xFF, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x78,
  0x00, 0x03, 0xFF, 0xE0, 0x78, 0x10, 0x0F, 0xFF, 0xF0, 0x78, 0x18, 0x3F,
  0xFF, 0xF8, 0x78, 0x0D, 0xFF, 0xFF, 0x3C, 0x78, 0x07, 0xFF, 0xF8, 0x06,
  0x78, 0x07, 0xFF, 0xE0, 0x06, 0x78, 0x03, 0xFF, 0x80, 0x02, 0x7C, 0x01,
  0xFE, 0x00, 0x03, 0x7C, 0x00, 0x78, 0x00, 0x03, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0x7F, 0x00, 0x00, 0x00, 0x03, 0x7F, 0x00, 0x00, 0x00, 0x02, 0x3F,
  0x80, 0x00, 0x00, 0x06, 0x3F, 0xE0, 0x00, 0x00, 0x06, 0x1F, 0xF0, 0x00,
  0x00, 0x0C, 0x1F, 0xFC, 0x00, 0x00, 0x3C, 0x0F, 0xFF, 0x00, 0x00, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x01, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x00, 0x30, 0x00,
  0x0F, 0xFF, 0x80, 0x70, 0x00, 0x07, 0xFF, 0xE3, 0x60, 0x00, 0x01, 0xFF,
  0xFC, 0x40, 0x00, 0x38, 0x7F, 0xF8, 0xC0, 0x00, 0x70, 0x3F, 0xF0, 0xC0,
  0x00, 0xE0, 0x0F, 0xE0, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x03, 0xFC, 0x00, 0x00,
  0x20, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0x0D, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xE0, 0x00,
  0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x07, 0x00, 0x00, 0x43, 0xFF,
  0x8C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x18, 0x00,
  0x0F, 0xFF, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xC1, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x10, 0x03, 0xC7,
  0x00, 0x01, 0xC0, 0x3C, 0x0C, 0x00, 0x1C, 0x01, 0xF0, 0x18, 0x01, 0xF0,
  0x07, 0x80, 0x60, 0x1F, 0x80, 0x3E, 0x01, 0x81, 0xFE, 0x01, 0xF8, 0x04,
  0x1F, 0xF8, 0x07, 0xE0, 0x20, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x00,
  0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xFE, 0x01, 0x3F, 0x83, 0x1F, 0xFC, 0x1C, 0xFE, 0x00, 0x1F,
  0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE3, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE4, 0x0F, 0xF0,
  0x0F, 0xE1, 0xFF, 0xF8, 0x1F, 0xE0, 0x1E, 0x00, 0x7F, 0xE0, 0x1F, 0xE0,
  0x78, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC3,
  0x80, 0x00, 0x7F, 0x00, 0x7F, 0xE7, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x8C,
  0x00, 0x00, 0xFE, 0x00, 0x7C, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x30,
  0x00, 0x01, 0xF8, 0x00, 0xC0, 0x60, 0x00, 0x03, 0xF0, 0x03, 0x00, 0x60,
  0x00, 0x07, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x80,
  0x00, 0x1F, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0x80,
  0x18, 0x78, 0x03, 0xF8, 0x01, 0xE1, 0xC0, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x01, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xF0, 0x06, 0x1F, 0xFF, 0x00, 0x01, 0xC0, 0x08, 0x0F, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0x80, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x83, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF9, 0x8E, 0x61, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x18, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xF8, 0x0C, 0x00, 0xFF, 0x81, 0xF0,
  0x01, 0xFF, 0x07, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x3F, 0xC1, 0xC0, 0x07,
  0xF8, 0x1C, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0xFF, 0x0E, 0x00, 0x01, 0xFE,
  0x3C, 0x00, 0x3F, 0xE3, 0x80, 0x00, 0x3F, 0x8F, 0x80, 0x07, 0xFC, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x30, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x1C, 0x04, 0x00, 0x00, 0x7E, 0x7F, 0x80, 0x06, 0x01, 0x80, 0x00, 0x1F,
  0x9F, 0xE0, 0x03, 0x80, 0x60, 0x00, 0x03, 0xE3, 0xFC, 0x01, 0xC0, 0x08,
  0x00, 0x00, 0xF0, 0xFF, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x7C, 0x1F, 0xE0,
  0x7E, 0x00, 0x60, 0x06, 0x1F, 0x07, 0xF8, 0x1F, 0xC0, 0x0E, 0x07, 0x07,
  0x80, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x80,
  0x02, 0x00, 0xF0, 0x07, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x1F, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1C,
  0x06, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x07,
  0xFF, 0x0F, 0xFF, 0xE0, 0x20, 0x00, 0x01, 0xFF, 0xFE, 0x1F, 0xFE, 0x30,
  0x00, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x18, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x41, 0xFF, 0xF8, 0x07,
  0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC3, 0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0xFC, 0x78, 0x00, 0xFE, 0x63,
  0xE1, 0xC0, 0x01, 0xF9, 0x00, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x18, 0x00,
  0x0F, 0xE0, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x00, 0xFE, 0x00,
  0x06, 0x00, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x20, 0x00,
  0x1F, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x07, 0xFF, 0xF8,
  0x03, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x21, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x13,
  0xF8, 0x00, 0x00, 0x00, 0x4F, 0xF0, 0x00, 0x0F, 0x83, 0x3F, 0xE0, 0x00,
  0x7F, 0x0C, 0x7F, 0xC1, 0x81, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x04,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x30, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x81, 0xFE,
  0x03, 0xF8, 0x7F, 0xFE, 0x03, 0xFC, 0x0F, 0x00, 0x3F, 0xF0, 0x0F, 0xF0,
  0x78, 0x00, 0x7F, 0xC0, 0x1F, 0xC1, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x8E,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x38, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0xC0,
  0x00, 0x0F, 0xE0, 0x0F, 0xFB, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x60, 0x00,
  0x07, 0xE0, 0x07, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x0C, 0x00, 0x41, 0xF0, 0x0F, 0x80, 0x1C, 0x03, 0x87,
  0x80, 0x7E, 0x00, 0x1E, 0x78, 0x1E, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x78,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x04, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x30, 0x3F, 0xC0, 0x00, 0x7F, 0xE1, 0x80, 0x7F, 0x00,
  0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x47, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x0F,
  0xF8, 0x03, 0x80, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x1C, 0x00,
  0x00, 0xFC, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x03, 0xF0, 0x06,
  0x00, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x01, 0xF0,
  0x01, 0x80, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x04, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x81,
  0xC0, 0x00, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x3C, 0x7F, 0xF0, 0x00, 0x07,
  0x9F, 0xFF, 0x00, 0x00, 0xE7, 0x7F, 0xF0, 0x00, 0x3C, 0x07, 0xFF, 0x00,
  0x07, 0x00, 0x3F, 0xF0, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x3F,
  0xF0, 0x1C, 0x00, 0x03, 0xFF, 0x86, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF,
  0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0x07, 0x80,
  0xF0, 0x1E, 0x0F, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x00, 0x07, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0xF8, 0xFC, 0x7C, 0x7C, 0x1E,
  0x0E, 0x07, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x3F,
  0xF0, 0x06, 0x1F, 0xF8, 0x0E, 0x07, 0xF0, 0x1E, 0x03, 0xF0, 0x3C, 0x03,
  0xF0, 0x3C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x03,
  0xF0, 0x3F, 0x83, 0xF2, 0x3F, 0xC7, 0xFF, 0x1F, 0xFB, 0xFC, 0x0F, 0xF1,
  0xFC, 0x07, 0xE1, 0xF8, 0x03, 0x80, 0xF8, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x02, 0x03, 0x80, 0x02, 0x1E, 0x00,
  0x06, 0x78, 0x00, 0x04, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x06, 0x01,
  0xF8, 0x1C, 0x03, 0xF0, 0x78, 0x07, 0xE3, 0xF8, 0x0F, 0xDF, 0xF8, 0x1F,
  0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0x78, 0x7E, 0x00, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07,
  0xC3, 0xF0, 0x0F, 0x07, 0xE0, 0x1C, 0x0F, 0xC0, 0x78, 0x1F, 0xE0, 0xC0,
  0x7F, 0xE3, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x37, 0xE0, 0x19, 0xF8, 0x0E, 0x3F, 0x07, 0x0F,
  0xC3, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C, 0x0C, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0x80,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x37, 0xFC, 0x00, 0x83, 0xFC, 0x1F, 0x03, 0xF8, 0x7E, 0x03, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x1F, 0x80, 0x1E, 0x3F, 0x00, 0x3C, 0x7E, 0x00, 0x78, 0xFC,
  0x00, 0xF1, 0xF8, 0x01, 0xC3, 0xF0, 0x03, 0x87, 0xE0, 0x0E, 0x0F, 0xE0,
  0x1C, 0x1F, 0xE0, 0x30, 0xFF, 0xF0, 0xE0, 0x3F, 0xF9, 0x80, 0x1F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x37, 0xE0, 0x19, 0xF8, 0x0E, 0x3F, 0x07,
  0x0F, 0xC3, 0xC1, 0xF0, 0xF0, 0x7E, 0x7C, 0x1F, 0x9F, 0x03, 0xF7, 0xC0,
  0xFD, 0xF0, 0x38, 0x7C, 0x78, 0x1F, 0x70, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0x80, 0x3F,
  0x80, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x81, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x67, 0xE0, 0x20, 0xE0, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0xE1,
  0xFF, 0xF1, 0xFF, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0x3F, 0xFC, 0x06, 0x0F, 0xFC, 0x0E, 0x07, 0xF8, 0x1E, 0x01, 0xF8, 0x3C,
  0x00, 0x70, 0x3C, 0x00, 0x70, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F,
  0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0x80, 0x7C, 0x06, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0xE0, 0x1F, 0x01, 0xC0, 0x0F,
  0x87, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x02, 0x07, 0x80, 0x02, 0x1E, 0x00, 0x06, 0x7C, 0x00, 0x05, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x04, 0x00, 0xFC, 0x0C, 0x01, 0xF8, 0x78, 0x03, 0xF1, 0xF8,
  0x07, 0xEF, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x78, 0x3F, 0x00, 0xF0, 0xFF, 0x63,
  0xC3, 0xFF, 0x87, 0x81, 0xFE, 0x0E, 0x00, 0xF8, 0x38, 0x00, 0xE0, 0x60,
  0x00, 0x81, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x18,
  0x01, 0xE0, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xDF, 0xC4, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x43, 0xFE, 0x1F, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x0B, 0xFA, 0x11, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xEC, 0x03, 0xE4, 0x03, 0xC2, 0x07, 0x81, 0x0E, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x80, 0xE0, 0x41, 0xC0, 0x23, 0xC1,
  0x37, 0xC7, 0x1F, 0x8F, 0x1F, 0x9F, 0x1F, 0xBF, 0x1F, 0xFF, 0x0F, 0xF0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC4, 0x3F, 0xF8,
  0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x1F,
  0x00, 0x78, 0x80, 0xE0, 0x43, 0xC0, 0x27, 0xC0, 0x27, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC4, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xF0,
  0x01, 0xE0, 0x00, 0xC0, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x00, 0xF0,
  0x0F, 0x01, 0xC0, 0x07, 0xC0, 0xFC, 0x1F, 0x00, 0x7F, 0x0F, 0xF1, 0xFC,
  0x03, 0xFC, 0xFF, 0x9F, 0xFC, 0x3F, 0xF8, 0xFF, 0xBF, 0xF1, 0x3F, 0x87,
  0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0x3E, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x0F, 0x81, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x1F,
  0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0x3E, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x0F, 0x81,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xFC, 0x3F, 0xC1, 0xF9, 0x1F, 0xF3, 0xFF,
  0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x81, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0x00, 0xF0, 0x07, 0xC0, 0x30, 0x03, 0x00, 0x1C, 0x00, 0x80, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x01, 0xE0, 0x1C, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x87, 0xF8, 0x1F, 0xF7, 0xFF, 0xC5, 0xFF, 0x3F, 0xE2,
  0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x83, 0xF1, 0x3F, 0xF0, 0xFE, 0x87, 0xF8,
  0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x1E, 0x00, 0xFC, 0x03, 0x00, 0x1E, 0x00,
  0x40, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF1, 0xFE, 0x0F, 0xC3,
  0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x1F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0x7C, 0xFC, 0x01, 0xE3, 0xF0, 0x07, 0x8F, 0xC0, 0x3C, 0x3F, 0x00,
  0xF0, 0xFC, 0x03, 0x87, 0xFC, 0x1C, 0x3F, 0xFC, 0x60, 0x3F, 0xFB, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x7F, 0x81, 0xE0, 0x7F,
  0x83, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xDF, 0xF8, 0x0F, 0xE3, 0xFC, 0x0F,
  0xC1, 0xFC, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x7F, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07,
  0xC0, 0x3E, 0x1F, 0xC0, 0x3C, 0x7F, 0xC0, 0x38, 0x7F, 0xF0, 0x38, 0xFF,
  0xF8, 0x60, 0xFF, 0xFE, 0x40, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xCC, 0x00, 0x03, 0xC4, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x05, 0xFF, 0x00, 0x23, 0xFF, 0x03, 0x87, 0xFF,
  0x1C, 0x0F, 0xF0, 0xF0, 0x0F, 0xC3, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03,
  0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFE, 0x03, 0xE1,
  0xF8, 0x0F, 0x87, 0xF0, 0x3E, 0x1F, 0xE1, 0xF8, 0x3F, 0xCF, 0xE0, 0x7F,
  0xCF, 0x80, 0xFE, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0x03, 0xE0, 0x08, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x10, 0x00, 0x07, 0x00, 0xC1,
  0xF0, 0x70, 0xFE, 0x3E, 0x3F, 0x9F, 0x9F, 0xF7, 0xF9, 0xFF, 0xFC, 0x3F,
  0x3F, 0x0F, 0xC7, 0x83, 0xF1, 0xC0, 0xFC, 0x20, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x20, 0x3F,
  0x90, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x20, 0x1C, 0x01,
  0x01, 0xF8, 0x18, 0x1F, 0xF1, 0xC3, 0xFF, 0xFC, 0x31, 0xFF, 0xE3, 0x03,
  0xFE, 0x18, 0x07, 0xE1, 0xC0, 0x04, 0x0E, 0x00, 0x40, 0xF8, 0x06, 0x07,
  0xE0, 0x78, 0x1F, 0x87, 0xE0, 0xFE, 0x7F, 0x83, 0xFF, 0xFE, 0x1F, 0xC7,
  0xF8, 0x7C, 0x1F, 0xC1, 0xC0, 0x7E, 0x04, 0x01, 0xF0, 0x40, 0x07, 0x87,
  0x00, 0x38, 0x7E, 0x01, 0x87, 0xFC, 0x08, 0x7F, 0xF8, 0xC0, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE1, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF9,
  0x8F, 0xFE, 0x3F, 0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0xF0, 0x07, 0x80, 0xFC, 0x03,
  0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0xC4, 0xFC, 0x0F, 0xE2, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xF1, 0x3F, 0xF3, 0xFF, 0x87, 0xFF, 0x1F,
  0xE0, 0x3F, 0x87, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x60, 0x1E, 0x00, 0x10,
  0x01, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x0C, 0x03, 0x80, 0x0E, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x1F, 0xE0,
  0xFE, 0x1F, 0xF0, 0x7F, 0xB1, 0xFC, 0x3F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80,
  0x7E, 0x07, 0xC0, 0x3F, 0x01, 0xE0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0E, 0x00, 0xF8, 0x07,
  0x00, 0x78, 0x03, 0x00, 0x3C, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x1C, 0x01,
  0xFE, 0x1C, 0x00, 0xFF, 0xCC, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0C, 0x00,
  0x60, 0x7F, 0x00, 0xF0, 0x0E, 0x07, 0xF8, 0x1F, 0x81, 0xF0, 0x7F, 0xC3,
  0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0xDF, 0xFC, 0x1F, 0xD8, 0xFE, 0x1F, 0xC0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0x7F, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x3F, 0x07, 0xC0,
  0x7E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x01, 0xF0,
  0x7C, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x7C, 0x07, 0xE0,
  0x1E, 0x07, 0xC0, 0x7E, 0x01, 0xE0, 0x7C, 0x07, 0xE0, 0x1C, 0x07, 0xC0,
  0x7E, 0x03, 0xC0, 0x7C, 0x07, 0xE0, 0x38, 0x0F, 0xE0, 0xFF, 0x07, 0x00,
  0xFE, 0x1F, 0xFC, 0x60, 0x1F, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x78, 0x1C,
  0x0F, 0xC3, 0xC1, 0xFE, 0x7E, 0x1F, 0xE7, 0xE3, 0xFF, 0xFF, 0x27, 0xF3,
  0xF0, 0x3F, 0x3E, 0x03, 0xE1, 0xC0, 0x3E, 0x18, 0x03, 0xE1, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF1, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0x1F, 0x00, 0x60, 0x70, 0x04, 0x02, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x78, 0x1C, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x40, 0x7F, 0x00, 0xC0, 0x7F,
  0x83, 0xE0, 0x7F, 0x87, 0xE0, 0x3F, 0xDF, 0xF0, 0x3F, 0xE3, 0xF8, 0x0F,
  0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3C, 0x0F, 0xC4, 0x3C, 0x1F, 0xEC, 0x3C, 0x1F, 0xF8, 0x78, 0x0F,
  0xF0, 0x70, 0x03, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x81, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x31, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x01, 0x06, 0x06, 0x0F, 0x88, 0x3F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0C, 0xFE, 0x0C, 0x7F, 0x18, 0x7F,
  0x30, 0x3F, 0x30, 0x3F, 0x70, 0x1F, 0x60, 0x1F, 0x60, 0x1F, 0x60, 0x1F,
  0x60, 0x1F, 0x60, 0x1F, 0x60, 0x1E, 0x60, 0x1E, 0x60, 0x1C, 0x60, 0x1C,
  0x30, 0x18, 0x10, 0x30, 0x08, 0x60, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 41, 13, 1, -40 },
  { 58, 20, 15, 23, 1, -40 },
  { 96, 25, 32, 29, 2, -36 },
  { 196, 19, 46, 23, 2, -43 },
  { 306, 37, 40, 40, 1, -40 },
  { 491, 29, 35, 32, 2, -34 },
  { 618, 9, 15, 11, 1, -40 },
  { 635, 12, 45, 14, 1, -44 },
  { 703, 12, 46, 14, 1, -44 },
  { 772, 19, 22, 20, 0, -41 },
  { 825, 19, 19, 22, 2, -28 },
  { 871, 9, 16, 10, 0, -9 },
  { 889, 16, 11, 17, 1, -22 },
  { 911, 9, 10, 11, 1, -9 },
  { 923, 27, 44, 29, 1, -42 },
  { 1072, 24, 40, 26, 1, -39 },
  { 1192, 16, 38, 18, 1, -38 },
  { 1268, 23, 38, 25, 1, -38 },
  { 1378, 24, 39, 26, 1, -39 },
  { 1495, 24, 38, 26, 1, -38 },
  { 1609, 24, 40, 26, 1, -40 },
  { 1729, 24, 39, 25, 1, -39 },
  { 1846, 22, 38, 24, 1, -38 },
  { 1951, 24, 39, 26, 1, -39 },
  { 2068, 24, 39, 25, 1, -39 },
  { 2185, 9, 28, 11, 1, -27 },
  { 2217, 10, 34, 10, 0, -27 },
  { 2260, 15, 21, 16, 0, -26 },
  { 2300, 20, 12, 22, 1, -23 },
  { 2330, 15, 21, 16, 0, -26 },
  { 2370, 21, 41, 26, 2, -40 },
  { 2478, 33, 34, 34, 1, -26 },
  { 2619, 43, 41, 46, 1, -40 },
  { 2840, 49, 42, 50, 0, -41 },
  { 3098, 36, 42, 38, 1, -41 },
  { 3287, 43, 43, 45, 1, -41 },
  { 3519, 37, 42, 39, 1, -41 },
  { 3714, 40, 49, 42, 1, -42 },
  { 3959, 41, 42, 43, 1, -40 },
  { 4175, 39, 51, 41, 1, -43 },
  { 4424, 36, 49, 38, 1, -41 },
  { 4645, 38, 56, 40, 1, -41 },
  { 4911, 43, 41, 45, 1, -40 },
  { 5132, 30, 40, 32, 1, -39 },
  { 5282, 60, 42, 62, 1, -39 },
  { 5597, 47, 41, 49, 1, -40 },
  { 5838, 40, 41, 42, 1, -40 },
  { 6043, 48, 48, 50, 1, -39 },
  { 6331, 43, 44, 45, 1, -40 },
  { 6568, 50, 42, 52, 1, -41 },
  { 6831, 40, 41, 42, 1, -40 },
  { 7036, 40, 41, 42, 1, -40 },
  { 7241, 38, 42, 40, 1, -39 },
  { 7441, 47, 42, 50, 1, -41 },
  { 7688, 58, 41, 60, 1, -40 },
  { 7986, 38, 42, 40, 1, -41 },
  { 8186, 46, 50, 48, 1, -41 },
  { 8474, 35, 49, 37, 1, -41 },
  { 8689, 8, 44, 10, 1, -41 },
  { 8733, 35, 40, 6, -11, -37 },
  { 8908, 8, 44, 10, 1, -41 },
  { 8952, 21, 15, 23, 1, -39 },
  { 8992, 27, 4, 26, -1, 6 },
  { 9006, 8, 10, 28, 9, -39 },
  { 9016, 24, 31, 26, 1, -29 },
  { 9109, 23, 41, 25, 1, -39 },
  { 9227, 18, 29, 20, 1, -28 },
  { 9293, 23, 40, 25, 1, -39 },
  { 9408, 18, 29, 20, 1, -28 },
  { 9474, 17, 50, 14, 0, -41 },
  { 9581, 24, 41, 26, 1, -29 },
  { 9704, 23, 49, 25, 1, -39 },
  { 9845, 13, 40, 15, 1, -39 },
  { 9910, 16, 50, 14, -3, -40 },
  { 10010, 16, 40, 18, 1, -39 },
  { 10090, 16, 40, 15, 1, -39 },
  { 10170, 37, 30, 40, 1, -29 },
  { 10309, 26, 30, 28, 1, -29 },
  { 10407, 22, 30, 23, 0, -29 },
  { 10490, 24, 44, 25, 0, -33 },
  { 10622, 22, 41, 24, 1, -29 },
  { 10735, 18, 30, 20, 1, -29 },
  { 10803, 21, 36, 23, 1, -35 },
  { 10898, 15, 37, 17, 1, -36 },
  { 10968, 26, 30, 28, 1, -29 },
  { 11066, 25, 33, 25, -1, -32 },
  { 11170, 36, 34, 39, 1, -33 },
  { 11323, 20, 41, 22, 1, -29 },
  { 11426, 24, 44, 26, 1, -34 },
  { 11558, 16, 39, 19, 1, -29 },
  { 11636, 15, 45, 19, 1, -44 },
  { 11721, 3, 47, 9, 3, -44 },
  { 11739, 15, 45, 19, 1, -44 },
  { 11824, 18, 4, 21, 1, -19 },
};

const GFXfont UnifrakturMaguntia_Regular56pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular56pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular56pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR56PT7B_H_
