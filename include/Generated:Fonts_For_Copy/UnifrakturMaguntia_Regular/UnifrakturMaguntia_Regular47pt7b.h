#ifndef _UNIFRAKTURMAGUNTIA_REGULAR47PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x0C, 0x07, 0x0F, 0xCF, 0xFB, 0xF9, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0xC1, 0xF1, 0xFC,
  0x7C, 0x1C, 0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x08, 0x18, 0x1C, 0x3C,
  0x3E, 0xFF, 0x7F, 0x3F, 0x1F, 0x1E, 0x0F, 0x0E, 0x07, 0x0C, 0x06, 0x0C,
  0x06, 0x08, 0x04, 0x08, 0x0C, 0x10, 0x08, 0x03, 0xC3, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x1E,
  0x1E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0xC1, 0xC0,
  0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xE1,
  0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x1C, 0x3C, 0x00,
  0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x07, 0xC0, 0x0F, 0xF0, 0x3C, 0x38, 0x38, 0x0C, 0x70, 0x0C,
  0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x1E, 0xF8, 0x0E, 0x7C, 0x0E, 0x7E, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x40, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x1E, 0x30, 0x1C, 0x1C, 0x78, 0x0F, 0xF0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0x80,
  0x00, 0x06, 0x3F, 0xC0, 0x00, 0x18, 0xF3, 0xC0, 0x00, 0x63, 0xC3, 0x80,
  0x01, 0x87, 0x87, 0x80, 0x07, 0x0F, 0x0F, 0x00, 0x0C, 0x3E, 0x1E, 0x00,
  0x30, 0x7C, 0x3C, 0x00, 0xC0, 0xF8, 0x78, 0x03, 0x01, 0xF0, 0xF0, 0x0C,
  0x03, 0xE1, 0xE0, 0x30, 0x03, 0xC3, 0xC0, 0xE0, 0x07, 0x87, 0x83, 0x80,
  0x0F, 0x0E, 0x06, 0x00, 0x0F, 0x3C, 0x18, 0x00, 0x0F, 0xF0, 0x61, 0xF0,
  0x07, 0x81, 0x87, 0xF0, 0x00, 0x06, 0x1C, 0x70, 0x00, 0x18, 0x78, 0xF0,
  0x00, 0x70, 0xF1, 0xE0, 0x00, 0xC3, 0xE3, 0xE0, 0x03, 0x07, 0xC3, 0xC0,
  0x0C, 0x0F, 0x87, 0x80, 0x30, 0x1F, 0x0F, 0x00, 0xC0, 0x3E, 0x1E, 0x03,
  0x00, 0x7C, 0x3C, 0x0E, 0x00, 0xF8, 0x78, 0x38, 0x01, 0xF1, 0xF0, 0x60,
  0x01, 0xE3, 0xC1, 0x80, 0x03, 0xC7, 0x86, 0x00, 0x03, 0x8E, 0x18, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xCE, 0x00,
  0x03, 0x87, 0x00, 0x07, 0x87, 0x00, 0x07, 0x87, 0x00, 0x07, 0x87, 0x80,
  0x0F, 0x87, 0x00, 0x07, 0x87, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xDC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0xFE, 0x0F, 0xF0, 0x7C,
  0x1D, 0xF0, 0x38, 0x39, 0xF8, 0x18, 0x71, 0xF8, 0x10, 0x70, 0xFC, 0x30,
  0xF0, 0xFC, 0x30, 0xF0, 0x7E, 0x20, 0xF0, 0x7E, 0x60, 0xF0, 0x3F, 0x40,
  0xF8, 0x3F, 0xC0, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC2, 0x7C, 0x0F, 0xE3,
  0x7F, 0x0F, 0xFE, 0x3F, 0xFB, 0xFC, 0x0F, 0xE0, 0xF0, 0x00, 0x20, 0xE3,
  0xEF, 0xE7, 0xC7, 0x8F, 0x0C, 0x18, 0x20, 0x81, 0x00, 0x01, 0xC0, 0xC0,
  0x60, 0x30, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80,
  0xE0, 0x3C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x70, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0E, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x38, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x80, 0x07, 0xC0, 0x13, 0xF8, 0xF9, 0x9F, 0x79, 0x9E, 0x7D,
  0xBE, 0x7F, 0xFC, 0x01, 0x80, 0x7F, 0xFE, 0x7D, 0x3E, 0x79, 0xBE, 0xF9,
  0x9E, 0x1B, 0xD1, 0x07, 0xE0, 0x03, 0x80, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x18, 0x3C, 0x7F, 0x3F,
  0x1E, 0x0E, 0x0E, 0x0C, 0x0C, 0x08, 0x10, 0x10, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x3F, 0xE3, 0x00, 0x00, 0x00, 0x07, 0x8F, 0xFC, 0x7F, 0xC7, 0xF0,
  0x00, 0x10, 0x38, 0x7C, 0xFE, 0x7C, 0x38, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3E,
  0x07, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0,
  0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x80, 0xF0, 0x70, 0x07,
  0x0F, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x47, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1E, 0x1F, 0xE7, 0x00, 0xFC, 0xC0, 0x1F, 0xB0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x08, 0x38, 0x01, 0x0E, 0x00, 0x21, 0x80, 0x04, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x18, 0x3F, 0x83, 0x00, 0xFC, 0x60, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF3, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3C, 0x7C, 0x03, 0x87, 0xC0, 0x70,
  0x3E, 0x0E, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0x7C, 0x00,
  0x13, 0xE0, 0x01, 0x9F, 0x00, 0x18, 0xF8, 0x00, 0xC7, 0xC0, 0x0C, 0x3E,
  0x00, 0xC1, 0xF0, 0x06, 0x0F, 0x80, 0x60, 0x7C, 0x02, 0x03, 0xE0, 0x30,
  0x1F, 0x03, 0x00, 0xF8, 0x10, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x81, 0xE0, 0x7C, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x3F, 0x80, 0x3F,
  0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x1F, 0xE3,
  0x00, 0x7E, 0x20, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x30, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xC7, 0xC0, 0x38, 0x7C, 0x07, 0x01, 0xE0,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x38, 0xF0, 0x07, 0x07, 0x80,
  0xE0, 0x7C, 0x0E, 0x07, 0xC1, 0xE0, 0x7E, 0x3C, 0x07, 0xE3, 0xC0, 0x3C,
  0x3C, 0x01, 0x87, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x7E,
  0x0F, 0xCF, 0xF8, 0xFD, 0x8F, 0xCF, 0xD0, 0x7C, 0xFE, 0x07, 0xEF, 0xE0,
  0x7E, 0xFE, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC3,
  0xE0, 0x3C, 0x3E, 0x03, 0x81, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x70, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xC0, 0x01, 0x30, 0x00, 0x64, 0x00, 0x08, 0x80, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x70,
  0x1C, 0x03, 0x83, 0x80, 0x18, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x00,
  0xC7, 0x80, 0x0C, 0x78, 0x01, 0xC7, 0xE0, 0x1C, 0x7F, 0x03, 0x83, 0xFC,
  0x30, 0x3F, 0xF6, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0xCF, 0xFC, 0x38, 0x3F, 0xC3, 0x00, 0xFE, 0x70, 0x07, 0xEF,
  0x00, 0x3E, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xEE, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x03,
  0x80, 0xE0, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x61, 0xC0, 0x0C,
  0x0E, 0x01, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0x80, 0x7C, 0x78, 0x07, 0xC7,
  0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E,
  0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0x7C, 0x0F,
  0xE7, 0xE1, 0xFE, 0x3F, 0x37, 0xE1, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0x10,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x20, 0x07, 0xC7, 0x80, 0x78, 0x7C,
  0x07, 0x87, 0xC0, 0x70, 0x7C, 0x0F, 0x07, 0xC0, 0xE0, 0x3E, 0x0C, 0x01,
  0xE1, 0x80, 0x07, 0xE0, 0x00, 0x10, 0x38, 0x7C, 0xFE, 0x7C, 0x38, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x38, 0x7C, 0xFE,
  0x7C, 0x38, 0x10, 0x00, 0x08, 0x0E, 0x0F, 0x8F, 0xE3, 0xE0, 0xE0, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x18, 0x1E,
  0x1F, 0xC7, 0xE1, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x04, 0x04, 0x02, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x1E, 0x1F, 0x1C, 0x07, 0xDC, 0x01,
  0xEE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xB8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x41, 0xC0,
  0x40, 0xE0, 0x20, 0x3C, 0x60, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x61, 0xC0, 0x7F, 0xCC, 0x78, 0x1F, 0xF1, 0xCE,
  0x0F, 0xBE, 0x3B, 0xC1, 0xE3, 0xC7, 0x70, 0x78, 0x78, 0xEE, 0x1E, 0x1E,
  0x1D, 0xC3, 0xC3, 0xC3, 0x38, 0xF0, 0x78, 0xE7, 0x1E, 0x1E, 0x1C, 0xE3,
  0xC3, 0xC7, 0x1C, 0x78, 0xF8, 0xE3, 0x8F, 0x3F, 0x78, 0x71, 0xFD, 0xFE,
  0x77, 0x1E, 0x3F, 0x0E, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x1C, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x01, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xC0,
  0x7F, 0xFC, 0x00, 0x38, 0x0F, 0xFF, 0xE0, 0x0F, 0x81, 0x81, 0xFF, 0x03,
  0xF0, 0x30, 0x0F, 0xF8, 0xFF, 0x06, 0x00, 0x3F, 0x8F, 0xF0, 0x40, 0x03,
  0xFC, 0x3F, 0x0C, 0x00, 0x1F, 0xC3, 0xF0, 0xC0, 0x00, 0xFC, 0x3F, 0x0C,
  0x00, 0x0F, 0xC3, 0xF0, 0xC0, 0x00, 0xFC, 0x3F, 0x0E, 0x00, 0x0F, 0xC3,
  0xF0, 0xF0, 0x00, 0x7C, 0x3F, 0x07, 0xF0, 0x0F, 0x83, 0xF0, 0x7F, 0x80,
  0xF8, 0x3F, 0x03, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0xE0, 0xF0, 0x3F, 0x00,
  0x7E, 0x1E, 0x03, 0xF0, 0x00, 0xE1, 0xC0, 0x3F, 0x00, 0x0C, 0x38, 0x03,
  0xF0, 0x00, 0xC3, 0x00, 0x3F, 0x00, 0x10, 0x60, 0x03, 0xF0, 0x00, 0x0C,
  0x00, 0x3F, 0x00, 0x01, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xFC, 0x07,
  0xF0, 0x04, 0x7F, 0xE1, 0xBF, 0xB0, 0x01, 0xFF, 0xF3, 0xFE, 0x00, 0x0F,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0x30, 0xFE,
  0x01, 0xFF, 0xFF, 0x90, 0x7F, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0xE0,
  0x07, 0xF8, 0x0F, 0xE0, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x70, 0x00, 0x7E,
  0x01, 0xF8, 0x30, 0x00, 0x3F, 0x00, 0xFE, 0x18, 0x00, 0x0F, 0x80, 0x3F,
  0x8C, 0x00, 0x07, 0xC0, 0x0F, 0x06, 0x00, 0x03, 0xE0, 0x06, 0x03, 0x00,
  0x00, 0xF0, 0x0E, 0x01, 0x80, 0x00, 0x78, 0x1F, 0xC0, 0x60, 0x00, 0x3C,
  0x7F, 0xF0, 0x38, 0x02, 0x3C, 0xFF, 0xFC, 0x0F, 0x06, 0x1C, 0x7F, 0xFF,
  0x01, 0xFC, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00,
  0x06, 0x00, 0x03, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x7E, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x33,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xE1, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7E, 0x03, 0x00, 0x07, 0x8C, 0x1E, 0x00,
  0x38, 0x09, 0xFE, 0x41, 0xE0, 0x2F, 0xFF, 0x0F, 0x00, 0xFF, 0xF8, 0x7C,
  0x06, 0x0F, 0x81, 0xE0, 0x30, 0x0C, 0x0F, 0x83, 0x80, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x7C, 0x3F, 0x80, 0x01, 0xF0, 0xFF, 0x00, 0x07, 0xC1, 0xFE, 0x00,
  0x1F, 0x83, 0xFC, 0x00, 0x7E, 0x0F, 0xF8, 0x01, 0xF8, 0x1F, 0xF0, 0x07,
  0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x3F, 0xC0,
  0x1C, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0xFE, 0x07, 0x00, 0x03, 0xFE, 0x30,
  0x00, 0x07, 0xFD, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x10, 0x1F, 0xFC, 0x03,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x87, 0xFE, 0x03,
  0xC0, 0x18, 0x1F, 0xF0, 0x78, 0x03, 0x00, 0x7F, 0x87, 0x00, 0x70, 0x03,
  0xF8, 0xE0, 0x0F, 0x00, 0x1F, 0xCE, 0x01, 0xF0, 0x00, 0xFC, 0xC0, 0x1F,
  0x80, 0x07, 0xEC, 0x01, 0xFC, 0x00, 0x3E, 0xC0, 0x1F, 0xE0, 0x03, 0xEC,
  0x00, 0xFF, 0x00, 0x1E, 0x40, 0x0F, 0xF8, 0x01, 0xF4, 0x00, 0x7F, 0xC0,
  0x0F, 0x60, 0x03, 0xFC, 0x00, 0xF3, 0x00, 0x1F, 0xC0, 0x0F, 0x1C, 0x00,
  0xFC, 0x00, 0x60, 0x7F, 0x87, 0xC0, 0x06, 0x00, 0xC0, 0x38, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x00, 0x18, 0x03, 0xFF,
  0xE0, 0x03, 0x00, 0x7F, 0xFF, 0x80, 0x20, 0x1C, 0x7F, 0xFE, 0x1C, 0x01,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x03, 0x00, 0x03, 0xC6, 0x0F, 0x80, 0x0E, 0x02, 0x7F, 0xD0, 0x3C, 0x05,
  0xFF, 0xE0, 0xF0, 0x0F, 0xFF, 0x83, 0xC0, 0x30, 0x7C, 0x07, 0x80, 0xC0,
  0x30, 0x1F, 0x07, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xF8, 0x3E,
  0x0F, 0x87, 0xF8, 0xFE, 0x5F, 0x07, 0xFF, 0xFF, 0xBE, 0x07, 0xFF, 0xFE,
  0x7E, 0x0F, 0xFC, 0xF8, 0xFC, 0x0F, 0xF8, 0xE1, 0xF8, 0x0F, 0xF8, 0x03,
  0xF0, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0x3F,
  0xC0, 0x70, 0x00, 0x3F, 0xC1, 0xC0, 0x00, 0x7F, 0xC6, 0x00, 0x00, 0x7F,
  0xD0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x80, 0x7F, 0xF0, 0x0E, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0xF8,
  0x78, 0x00, 0x37, 0xFC, 0x1C, 0x00, 0x18, 0x7C, 0x06, 0x00, 0x0E, 0x06,
  0x01, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0xFC,
  0x00, 0x0C, 0x00, 0x3F, 0x80, 0xC1, 0x00, 0x0F, 0xF0, 0x78, 0x60, 0x01,
  0xFC, 0x3F, 0x98, 0x00, 0x7F, 0x8F, 0xE2, 0x00, 0x0F, 0xF7, 0xF8, 0xC0,
  0x03, 0xFF, 0xFC, 0x18, 0x00, 0x7F, 0x8E, 0x03, 0x83, 0x8F, 0xF1, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0C, 0x00, 0x0F, 0xE0,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03,
  0xE0, 0x07, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x0F, 0x81, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x1F, 0xE0, 0x70, 0x00, 0x1E, 0x04, 0x3E, 0x00, 0x0F, 0x00,
  0xBF, 0xC0, 0x07, 0x80, 0x37, 0xF8, 0x03, 0xC0, 0x18, 0xFF, 0x01, 0xF0,
  0x0C, 0x1F, 0xE0, 0x78, 0x0E, 0x03, 0xFC, 0x3E, 0x07, 0x00, 0x7E, 0x0F,
  0x83, 0xC0, 0x0F, 0x07, 0xE1, 0xF0, 0x03, 0x81, 0xF0, 0x7C, 0x01, 0x80,
  0x7C, 0x1F, 0x00, 0xE0, 0x1F, 0x07, 0xE0, 0xFF, 0x07, 0xC1, 0xFC, 0x7F,
  0xE3, 0xF0, 0x7F, 0xBF, 0xFC, 0xFC, 0x0F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC,
  0x0F, 0xEF, 0xE0, 0x7F, 0x81, 0xFB, 0xF8, 0x0F, 0xF0, 0x7E, 0x7E, 0x01,
  0xFC, 0x0F, 0xDF, 0x80, 0x3F, 0x03, 0xF7, 0xF0, 0x0F, 0xC0, 0xFD, 0xFC,
  0x01, 0xF0, 0x1F, 0x3F, 0x00, 0x7C, 0x0F, 0x8F, 0xE0, 0x1E, 0x03, 0xE1,
  0xF8, 0x07, 0x00, 0xF8, 0x7F, 0x03, 0x00, 0x3C, 0x0F, 0xE1, 0x80, 0x1E,
  0x01, 0xFC, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x03, 0xC0, 0x07, 0xF0, 0x01,
  0xC0, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0x87, 0xFE, 0x00, 0x01, 0x81, 0xFE, 0x00, 0x01,
  0x80, 0x7E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xF8,
  0x01, 0xFC, 0xF7, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0xE0, 0x3C,
  0x01, 0xF1, 0xF8, 0x1C, 0x00, 0xF9, 0xFE, 0x06, 0x00, 0x79, 0xFF, 0x86,
  0x00, 0x7C, 0x1F, 0xE6, 0x00, 0x3C, 0x07, 0xFE, 0x00, 0x1E, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3C, 0x0F, 0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x87, 0x00,
  0x1F, 0xFE, 0x38, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x3F, 0x03, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38,
  0x03, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x3F, 0x00,
  0x30, 0x00, 0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x6F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x1E, 0x3F, 0xF0, 0x00, 0x73,
  0xFF, 0xE0, 0x01, 0xC8, 0x7F, 0xC0, 0x06, 0x00, 0xFF, 0x80, 0x30, 0x01,
  0xFF, 0x01, 0x80, 0x03, 0xFF, 0x8C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xE0, 0x7F, 0xE0, 0x07, 0x00, 0x7F, 0xE2, 0x1C, 0x00, 0x3F,
  0xFC, 0x38, 0x00, 0x3F, 0xE0, 0x60, 0x00, 0x1F, 0x80, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xE0,
  0x0C, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x3F, 0x00,
  0x38, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C, 0x0C, 0xFC, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0x83, 0xFC, 0x00, 0x07, 0x1F, 0xFC, 0x00,
  0x0C, 0x7F, 0xFC, 0x00, 0x38, 0x87, 0xFC, 0x00, 0x60, 0x07, 0xFC, 0x01,
  0x80, 0x07, 0xFE, 0x06, 0x00, 0x03, 0xFF, 0x38, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0F, 0x03, 0xF0, 0x1C,
  0x00, 0xF0, 0xFF, 0xC0, 0xC0, 0x1F, 0x1F, 0xFE, 0x0E, 0x01, 0xE3, 0x8F,
  0xF0, 0x60, 0x3E, 0x30, 0x3F, 0x06, 0x03, 0xF2, 0x03, 0xF8, 0x70, 0x3F,
  0x20, 0x1F, 0x87, 0x03, 0xF4, 0x01, 0xFC, 0x70, 0x3F, 0xC0, 0x0F, 0xE7,
  0x01, 0xFE, 0x00, 0xFF, 0x60, 0x1F, 0xE0, 0x07, 0x86, 0x01, 0xFE, 0x00,
  0x60, 0xC0, 0x0F, 0xF0, 0x0C, 0x18, 0x00, 0xFF, 0x83, 0xC3, 0x00, 0x07,
  0xF8, 0xFE, 0x60, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x40, 0x3C, 0x0F, 0xC0, 0x1F, 0x03, 0xC0, 0xFE, 0x03, 0xF8,
  0x18, 0x07, 0xE0, 0xFF, 0xC3, 0x00, 0x7F, 0x09, 0xFE, 0x20, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x7C,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3F, 0x00, 0x0F, 0x9F, 0x80,
  0x07, 0xCF, 0xE0, 0x03, 0xC7, 0xF0, 0x01, 0xE3, 0xFC, 0x00, 0xF0, 0xFE,
  0x00, 0xF0, 0x7F, 0x80, 0xF0, 0x1F, 0xCF, 0xF0, 0x07, 0xE0, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x38, 0xFF, 0xE0,
  0x30, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0x80, 0x00,
  0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x80,
  0x7F, 0xFF, 0xBF, 0xFC, 0xC7, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xE0, 0xFC,
  0x0E, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0x06, 0x00, 0x7F, 0x81, 0xFC, 0x07,
  0xE1, 0x00, 0x0F, 0xF0, 0x3F, 0x01, 0xF8, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x7E, 0x20, 0x00, 0x3F, 0x81, 0xF8, 0x1F, 0xC8, 0x00, 0x07, 0xE0, 0x7E,
  0x03, 0xFA, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x1C, 0x30, 0x00, 0x0F, 0x80, 0xF8, 0x06, 0x06, 0x00, 0x03, 0xE0,
  0x3E, 0x03, 0x01, 0xCF, 0xC0, 0x78, 0x0F, 0x81, 0x80, 0x3F, 0xF8, 0x1E,
  0x01, 0xE0, 0xE0, 0x07, 0xFE, 0x07, 0x80, 0x78, 0x70, 0x00, 0xFF, 0x81,
  0xE0, 0x1E, 0x1C, 0x00, 0x00, 0x20, 0x78, 0x07, 0x0F, 0x00, 0x00, 0x08,
  0x1E, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x71, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x1C, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x06, 0x1F, 0x80, 0x00,
  0x00, 0x38, 0x03, 0x87, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xC1, 0xF8, 0x00,
  0x3E, 0x03, 0x30, 0x30, 0x7F, 0x00, 0x3F, 0xC1, 0xBF, 0x08, 0x0F, 0xE0,
  0x1F, 0xF8, 0x5F, 0xE4, 0x03, 0xFF, 0xCC, 0xFF, 0x27, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF3, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF9, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0x0C, 0xFF, 0x03, 0xFF, 0xFF, 0x30, 0x7E, 0x0E, 0x01, 0xFF, 0x40,
  0x7E, 0x18, 0x00, 0xFF, 0x00, 0xFC, 0x20, 0x00, 0xFE, 0x01, 0xF8, 0xC0,
  0x01, 0xFC, 0x03, 0xF1, 0x00, 0x01, 0xFC, 0x03, 0xF2, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xCC, 0x00, 0x03, 0xE0, 0x0E, 0x08,
  0x00, 0x07, 0xC0, 0x18, 0x18, 0x00, 0x0F, 0xC0, 0x60, 0x3F, 0xF8, 0x0F,
  0x81, 0xC0, 0x3F, 0xF8, 0x1E, 0x03, 0x00, 0x3F, 0xF0, 0x3C, 0x0E, 0x00,
  0x1F, 0x60, 0x78, 0x38, 0x00, 0x00, 0x40, 0xF0, 0xF0, 0x00, 0x00, 0x81,
  0xE1, 0xE0, 0x00, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x00, 0x07, 0x0F, 0xC0,
  0x00, 0x00, 0x0C, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x3F, 0x00, 0x01, 0x00,
  0x60, 0x3F, 0x00, 0x0F, 0x80, 0xC0, 0x7E, 0x00, 0x7F, 0x83, 0x00, 0xFE,
  0x11, 0xFF, 0x8C, 0x00, 0xFF, 0xE6, 0x7F, 0xB0, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0x07, 0xFF, 0xC0, 0x0C,
  0x00, 0x7F, 0xF0, 0x1C, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x01, 0xFE, 0x0E,
  0x00, 0x00, 0x7F, 0x8F, 0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x07, 0xF3,
  0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7C, 0xFF, 0xC0, 0x00, 0x1E,
  0x7F, 0xF8, 0x00, 0x0F, 0x9F, 0xFE, 0x00, 0x07, 0xC7, 0xFF, 0x80, 0x01,
  0xE1, 0xFF, 0xC0, 0x00, 0xF0, 0x1F, 0xE0, 0x00, 0x70, 0x03, 0xF0, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x08, 0x00,
  0x06, 0x03, 0xE8, 0x00, 0x03, 0x07, 0xF8, 0x00, 0x03, 0x07, 0xFF, 0x00,
  0x01, 0x0F, 0xFF, 0xC0, 0x01, 0x80, 0x3F, 0xF8, 0x01, 0x80, 0x0F, 0xFF,
  0x01, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x02, 0x00,
  0x07, 0xFF, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0x80, 0x3C, 0x00, 0x3F, 0xFF,
  0xC0, 0xFC, 0x00, 0x7C, 0x3F, 0xE3, 0xFE, 0x00, 0x70, 0x0F, 0xFE, 0xFE,
  0x00, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0xC0,
  0x03, 0xF8, 0x7F, 0xC0, 0x80, 0x01, 0xF8, 0x3F, 0xF0, 0x80, 0x01, 0xF8,
  0x1F, 0xF8, 0x80, 0x01, 0xF8, 0x0F, 0xF8, 0xC0, 0x00, 0xF8, 0x07, 0xFC,
  0xC0, 0x00, 0xF8, 0x03, 0xFE, 0x60, 0x00, 0xF8, 0x00, 0xFE, 0x30, 0x00,
  0xF8, 0x00, 0x7E, 0x18, 0x18, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x1F,
  0xFF, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0xFF, 0xFF,
  0xC0, 0x00, 0x40, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x73, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0xFF, 0xF0, 0x00, 0x60, 0x03, 0xFF, 0x80, 0x1C, 0x00, 0x0F, 0xFC,
  0x03, 0x80, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x01, 0xFE, 0x07, 0x80, 0x00,
  0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0xFF,
  0x00, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x7F, 0xF8, 0x00, 0x0F,
  0x83, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0x80, 0xFF, 0xE0,
  0x00, 0x78, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x7D, 0x00, 0x3E, 0x60, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xFC, 0x33, 0xFC, 0x20, 0x7F, 0xF0, 0x0F, 0xE6, 0x03,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x3F,
  0x00, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0xCF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x41, 0xFC, 0x03, 0xC0, 0xFF, 0x90, 0x3F, 0x81, 0xC0, 0x0F, 0xF8, 0x0F,
  0xE0, 0x60, 0x01, 0xFE, 0x01, 0xFC, 0x38, 0x00, 0x3F, 0x80, 0x7F, 0x0C,
  0x00, 0x07, 0xE0, 0x0F, 0xF3, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0xC0, 0x00,
  0x3F, 0x00, 0x7C, 0x30, 0x00, 0x07, 0xC0, 0x0C, 0x0C, 0x00, 0x01, 0xF0,
  0x0C, 0x01, 0x00, 0x00, 0x7C, 0x06, 0x00, 0x60, 0x00, 0x0F, 0x07, 0x00,
  0x0C, 0x00, 0x03, 0xC7, 0xC0, 0x03, 0x80, 0x40, 0xF3, 0xF8, 0x00, 0x38,
  0x30, 0x3D, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xC3, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x1F,
  0x80, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x01, 0xFC, 0x00,
  0x0C, 0x01, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x60, 0x0F, 0xE0, 0x07, 0xF8,
  0x30, 0x03, 0xF8, 0x03, 0xFF, 0x08, 0x00, 0xFF, 0x21, 0xBF, 0xEC, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x60, 0x07, 0xFF, 0xFF, 0xE0, 0x06, 0x0F, 0xFF, 0xE0,
  0x0C, 0x00, 0xFF, 0xE0, 0x0C, 0x00, 0x1F, 0xE0, 0x0C, 0x00, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x7F, 0x81, 0xC0, 0x00, 0xFF,
  0xF0, 0xE0, 0x81, 0xFF, 0xFC, 0xF0, 0x23, 0xFF, 0xFF, 0x78, 0x1F, 0xFF,
  0x81, 0xBC, 0x07, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x0B, 0xC0, 0x08, 0x00, 0x05, 0xF0, 0x00, 0x00, 0x02, 0xFC, 0x00,
  0x00, 0x01, 0x7F, 0x00, 0x00, 0x01, 0x9F, 0xC0, 0x00, 0x01, 0x8F, 0xF8,
  0x00, 0x01, 0xC3, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0x81, 0xFF, 0xF0, 0x03, 0x00, 0x1F, 0xFE, 0x03, 0x00, 0x03, 0xFF,
  0x85, 0x00, 0x00, 0x7F, 0xFD, 0x80, 0x03, 0x1F, 0xFC, 0xC0, 0x03, 0x03,
  0xFC, 0x60, 0x03, 0x80, 0xFC, 0x30, 0x03, 0xC0, 0x00, 0x18, 0x03, 0xF0,
  0x00, 0x04, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x3F,
  0xC0, 0x00, 0x30, 0x2F, 0xF8, 0x00, 0x07, 0xE7, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x08,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x70, 0x00, 0x7F,
  0xF0, 0x70, 0x00, 0x7F, 0xFC, 0x70, 0x00, 0x03, 0xFF, 0x40, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x60,
  0x01, 0xFF, 0x80, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x04, 0x03, 0x9C, 0x00,
  0x38, 0x1C, 0x08, 0x01, 0xE0, 0x78, 0x18, 0x0F, 0x81, 0xF0, 0x30, 0x7E,
  0x03, 0xE0, 0x41, 0xFC, 0x0F, 0xC1, 0x87, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0x1F, 0x80,
  0xFF, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01,
  0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0x80, 0x3F, 0x00, 0x0E,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x60, 0x01, 0xF8, 0x01, 0x80,
  0x03, 0xF0, 0x07, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0x80,
  0x3F, 0x83, 0xFF, 0x80, 0xBF, 0x0C, 0x7F, 0xC7, 0x3F, 0x20, 0x7F, 0xFC,
  0x7F, 0xC0, 0x7F, 0xF0, 0xFF, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xFF, 0xE2, 0x1F, 0xC0, 0x3F, 0xFF, 0xF6,
  0x0F, 0xC0, 0x7C, 0x0F, 0xFC, 0x0F, 0xE0, 0x70, 0x03, 0xFC, 0x07, 0xE0,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0xC0, 0x00,
  0xFC, 0x03, 0xF0, 0xC0, 0x00, 0x7C, 0x01, 0xC0, 0xC0, 0x00, 0x7C, 0x00,
  0x80, 0xC0, 0x00, 0x3C, 0x01, 0x80, 0xC0, 0x00, 0x3C, 0x03, 0x00, 0x40,
  0x00, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x3C, 0x0F, 0x80, 0x30, 0x0C, 0x38,
  0x0F, 0xC0, 0x1C, 0x38, 0x78, 0x0F, 0xE0, 0x07, 0xE0, 0x70, 0x0F, 0xF0,
  0x00, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x07, 0xFC, 0x00, 0x00,
  0x80, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x03,
  0xFF, 0xE0, 0x00, 0x38, 0x06, 0x3F, 0xF8, 0x00, 0x30, 0x04, 0x1F, 0xFC,
  0x00, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x80, 0xC0,
  0x00, 0x01, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x03, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xC7, 0xE3,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE6, 0x34, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x18,
  0x0F, 0xE0, 0x3F, 0x1F, 0xF8, 0x18, 0x07, 0xF0, 0x78, 0x03, 0xF8, 0x38,
  0x07, 0xF0, 0x70, 0x01, 0xFC, 0x30, 0x03, 0xF8, 0xE0, 0x00, 0xFC, 0x78,
  0x03, 0xF8, 0xC0, 0x00, 0xFC, 0x78, 0x01, 0xFC, 0xC0, 0x00, 0x7C, 0x78,
  0x00, 0xFE, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x70, 0xC0, 0x00, 0x3C, 0xFE,
  0x00, 0x60, 0xC0, 0x00, 0x3C, 0x7E, 0x00, 0xC0, 0x40, 0x00, 0x3C, 0x7F,
  0x01, 0xC0, 0x60, 0x00, 0x3C, 0x7F, 0x03, 0xE0, 0x30, 0x04, 0x38, 0x3F,
  0x83, 0xE0, 0x18, 0x18, 0x38, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x70, 0x1F,
  0x83, 0xFC, 0x00, 0x00, 0x70, 0x0F, 0xC3, 0xFE, 0x00, 0x00, 0xE0, 0x0F,
  0xC1, 0xFE, 0x00, 0x00, 0xC0, 0x07, 0x81, 0xFF, 0x00, 0x01, 0x80, 0x07,
  0x80, 0x7F, 0x00, 0x01, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x1F, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x0F, 0x03, 0xFF, 0x80, 0x07,
  0x80, 0x0E, 0x0E, 0xFF, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0C, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x08, 0x00, 0x0F, 0xFC, 0xFF,
  0xFC, 0x10, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xE2, 0x0F, 0xFF,
  0x03, 0xFF, 0x1F, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xC3, 0xFE, 0x3E, 0x1F,
  0xC7, 0xFC, 0x78, 0x07, 0xE4, 0x78, 0x70, 0x03, 0xEC, 0x20, 0x60, 0x03,
  0xF8, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x40, 0x01,
  0xF8, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x20, 0x01,
  0xFF, 0xF0, 0x10, 0x03, 0xFF, 0xE0, 0x0E, 0x67, 0xFF, 0xE0, 0x01, 0x8F,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x02, 0xFC, 0x00, 0x00, 0x02,
  0x7E, 0x00, 0x07, 0x82, 0x7F, 0x00, 0x0F, 0xC6, 0x7F, 0x82, 0x0F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x27, 0xF8,
  0x0F, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xF8,
  0x07, 0xFF, 0xF8, 0x87, 0xF0, 0x3F, 0xFF, 0xF4, 0x0F, 0xE1, 0xF0, 0x3F,
  0xF0, 0x3F, 0x87, 0x00, 0x3F, 0xC0, 0x7E, 0x38, 0x00, 0x7F, 0x01, 0xFC,
  0xC0, 0x00, 0xFC, 0x07, 0xF3, 0x00, 0x03, 0xF0, 0x0F, 0xEC, 0x00, 0x07,
  0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0xC0, 0x00, 0x3C, 0x00, 0xC1,
  0x00, 0x00, 0xF0, 0x06, 0x04, 0x00, 0x03, 0xC0, 0x38, 0x18, 0x00, 0x0F,
  0x03, 0xC0, 0x30, 0x0C, 0x38, 0x0F, 0x80, 0x30, 0xC1, 0xE0, 0x7E, 0x00,
  0x3C, 0x07, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x07, 0xF0, 0x00, 0x00, 0x60,
  0x1F, 0xC0, 0x00, 0x03, 0x80, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0x00,
  0x00, 0x60, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x00,
  0x1F, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x20, 0xFE, 0x00,
  0x1F, 0xE3, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0x80, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x00,
  0xF0, 0x00, 0x20, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x00,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xE0, 0x3F, 0xE0, 0x1C,
  0x00, 0x3F, 0x00, 0xC0, 0x00, 0xFC, 0x0E, 0x00, 0x07, 0xE0, 0x60, 0x00,
  0x1F, 0x03, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x07, 0x80, 0x40, 0x00, 0x3C,
  0x03, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0xF0, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x7E, 0x00, 0x01, 0xC7, 0xFC, 0x00, 0x0E, 0x7F, 0xF0, 0x00,
  0x74, 0x7F, 0xC0, 0x07, 0x01, 0xFF, 0x00, 0x30, 0x07, 0xFC, 0x03, 0x00,
  0x1F, 0xF0, 0x30, 0x00, 0x7F, 0xE6, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xFF, 0xFC, 0x00, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7C, 0xF0, 0x38, 0x3C, 0x38, 0x0E, 0x38, 0x03, 0xB8,
  0x00, 0xF8, 0x00, 0x18, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE1, 0xE3, 0xC7, 0xC7, 0x87, 0x07, 0x06, 0x06, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x47, 0xFC, 0x1C, 0x3F, 0x81, 0x80, 0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F,
  0x0F, 0x80, 0xF0, 0xFC, 0x0F, 0x07, 0xC0, 0xF0, 0x7E, 0x0F, 0x07, 0xF0,
  0xF9, 0x3F, 0xBF, 0xE1, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0x70, 0x78, 0x04,
  0x01, 0x80, 0x00, 0xF0, 0x10, 0x70, 0x01, 0x1C, 0x00, 0x27, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x04, 0x03,
  0xC0, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x81, 0xFF, 0xF8, 0x3E, 0x1F, 0x07,
  0x83, 0xF0, 0xF0, 0x3E, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x8F,
  0x01, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F,
  0x03, 0x83, 0xE0, 0x60, 0xFE, 0x18, 0x3F, 0xE2, 0x01, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x03,
  0xE0, 0x1F, 0xC0, 0x67, 0xC1, 0x8F, 0x87, 0x0F, 0x8E, 0x1F, 0x3C, 0x18,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC,
  0x43, 0xFF, 0x03, 0xF8, 0x01, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1B, 0xFC, 0x07, 0x0F, 0xC1, 0xE0, 0x7E,
  0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x01, 0xE1, 0xF0, 0x1F, 0x1F, 0x01,
  0xE1, 0xF0, 0x1E, 0x1F, 0x00, 0xE1, 0xF0, 0x0E, 0x1F, 0x01, 0xC1, 0xF0,
  0x1C, 0x1F, 0x01, 0x83, 0xF8, 0x18, 0x7F, 0xE3, 0x00, 0xFF, 0xA0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x20, 0x03,
  0xE0, 0x1F, 0xC0, 0x67, 0xC1, 0x8F, 0x87, 0x0F, 0x0E, 0x1F, 0x3C, 0x3E,
  0x78, 0x3E, 0xF0, 0x7B, 0xE1, 0xC7, 0xDC, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC,
  0x63, 0xFF, 0x03, 0xF8, 0x01, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x10,
  0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x43, 0x81, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x60, 0x01, 0xE0, 0x0F, 0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0x00, 0xC7,
  0xFC, 0x1C, 0x3F, 0xC3, 0x80, 0xF8, 0x38, 0x03, 0x87, 0x80, 0x30, 0x78,
  0x07, 0x0F, 0x80, 0x70, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x87,
  0x80, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xFF, 0x7C, 0x0F, 0xC7, 0xC0, 0xE0, 0x3E, 0x08, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x38, 0x03, 0x83, 0xC0,
  0x30, 0x3C, 0x06, 0x01, 0xE0, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x3C, 0x02, 0x0E, 0x00, 0x27, 0x80, 0x04, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x80, 0x78,
  0x70, 0x0F, 0x1F, 0x01, 0xEF, 0xF0, 0x3E, 0x7E, 0x07, 0x87, 0xE0, 0xF0,
  0x7E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x8F, 0x01, 0xF1, 0xE0,
  0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0,
  0x78, 0x7C, 0x0F, 0x0F, 0x81, 0xE3, 0xF2, 0x38, 0xFF, 0x8F, 0x0F, 0xE1,
  0xC0, 0xF8, 0x30, 0x06, 0x0C, 0x00, 0x43, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xF0, 0x1F, 0x07, 0xF1, 0xFF, 0x27, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x81, 0xF2, 0x3F, 0x87, 0xF0, 0x7C, 0x07, 0x00, 0x20,
  0x01, 0xC0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x81, 0xFF, 0x1B, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7A,
  0x03, 0x90, 0x3C, 0x41, 0x81, 0x78, 0x04, 0x00, 0x00, 0x00, 0x18, 0x07,
  0x20, 0xE0, 0x8E, 0x06, 0xF1, 0x9F, 0x9C, 0xFD, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xFF, 0xFF, 0xFC, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF9, 0x3F, 0xF0, 0x7F, 0x00,
  0xF0, 0x03, 0x80, 0x08, 0x00, 0x00, 0x38, 0x06, 0x20, 0xE0, 0x8E, 0x06,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF9, 0x3F, 0xF0, 0x7F, 0x00, 0xF0, 0x03, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x06, 0x00, 0xF0, 0x3C, 0x1E,
  0x01, 0xF0, 0xFC, 0x7E, 0x07, 0xF3, 0xFD, 0xFF, 0x8F, 0xF9, 0xFE, 0xFF,
  0xA7, 0xE1, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0xF8, 0x0F, 0x07, 0xC1, 0xF0,
  0x1E, 0x0F, 0x83, 0xE0, 0x3C, 0x1F, 0x07, 0xC0, 0x78, 0x3E, 0x0F, 0x80,
  0xF0, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x7C, 0x07,
  0x83, 0xE0, 0xF8, 0x0F, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x3C,
  0x1F, 0x07, 0xC0, 0xFC, 0x3E, 0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0x27, 0xF9,
  0xFE, 0x3F, 0x87, 0xE1, 0xF0, 0x3F, 0x07, 0x81, 0xC0, 0x7C, 0x06, 0x01,
  0x80, 0x38, 0x08, 0x02, 0x00, 0x20, 0x10, 0x04, 0x00, 0x70, 0x38, 0x03,
  0xE1, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x7F, 0xF2, 0x7E, 0x3F, 0x81, 0xF0,
  0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xE0,
  0xFA, 0x3F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC0, 0xF0, 0x1F, 0x01, 0x80, 0x38,
  0x04, 0x00, 0x60, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0xF9, 0xF8,
  0x3C, 0x7E, 0x0F, 0x0F, 0xC3, 0xC3, 0xF8, 0xF0, 0x7E, 0x3C, 0x0F, 0xCF,
  0x03, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0E, 0x3C, 0x03, 0x9F, 0x81, 0xC7, 0xF0, 0x63, 0xFF, 0x30,
  0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x20, 0x3F, 0x03, 0x81, 0xFC, 0x3C, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0xC0,
  0xF8, 0x7F, 0x03, 0xC1, 0xF8, 0x1E, 0x07, 0xE0, 0xF0, 0x3F, 0x07, 0x80,
  0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x1F, 0x01, 0xC0, 0xF8, 0x1E, 0x3F, 0xC0, 0xE1, 0xFF, 0x06,
  0x1F, 0xFC, 0x60, 0x9F, 0xFA, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0E,
  0x60, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x04,
  0xFE, 0x03, 0x1F, 0xF1, 0x83, 0xF8, 0xE0, 0x7C, 0x78, 0x1F, 0x1C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3,
  0xE0, 0x3C, 0xF8, 0x0F, 0x3F, 0x03, 0xC7, 0xC0, 0xF1, 0xF8, 0x7C, 0x3F,
  0xAF, 0x0F, 0xF3, 0xC1, 0xF0, 0xF0, 0x38, 0x3C, 0x04, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x10, 0x08, 0x78, 0x30, 0xF8,
  0xF3, 0xFB, 0xEF, 0xF7, 0xF3, 0xF7, 0xC7, 0xCF, 0x0F, 0x8C, 0x1F, 0x08,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x83, 0xFE, 0x01, 0xF8,
  0x00, 0xF0, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x41, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x60, 0x20, 0x3C, 0x08, 0x1F, 0xC6,
  0x1F, 0xFF, 0x8C, 0x7F, 0xC6, 0x07, 0xE1, 0x80, 0x30, 0xE0, 0x08, 0x3C,
  0x06, 0x0F, 0x83, 0x83, 0xF1, 0xF8, 0x7F, 0xFE, 0x0F, 0xCF, 0xC1, 0xE1,
  0xF8, 0x70, 0x3E, 0x08, 0x07, 0x84, 0x01, 0xC3, 0xC0, 0x61, 0xFC, 0x18,
  0xFF, 0xCC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFC, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x8F, 0xF8, 0x3F, 0x80,
  0x7C, 0x01, 0xC0, 0x04, 0x00, 0x18, 0x01, 0x80, 0xF0, 0x0E, 0x03, 0xE0,
  0x3C, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xF2, 0x7C, 0x1F, 0x81, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xE3, 0xFA,
  0x3F, 0xFB, 0xF8, 0x3F, 0x8F, 0xC0, 0x3C, 0x1F, 0x00, 0x60, 0x38, 0x01,
  0x00, 0x40, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40, 0x60, 0x06,
  0x03, 0x80, 0x78, 0x3E, 0x0F, 0xC1, 0xF8, 0xFF, 0x0F, 0xF8, 0xFC, 0x3F,
  0x03, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0x80, 0xF8, 0x1C,
  0x07, 0x80, 0xE0, 0x3C, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0xE0, 0xE0,
  0x1F, 0x86, 0x01, 0xFF, 0x60, 0x13, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x41, 0xF8,
  0x1C, 0x03, 0x07, 0xF0, 0xF8, 0x3E, 0x1F, 0xC7, 0xF1, 0xF8, 0x3F, 0x3F,
  0xFB, 0xF0, 0x7F, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8,
  0x3F, 0x0F, 0x03, 0xE0, 0x7C, 0x3C, 0x0F, 0x81, 0xF0, 0xF0, 0x3E, 0x03,
  0xC3, 0xC0, 0xF8, 0x0F, 0x0F, 0x03, 0xE0, 0x3C, 0x3C, 0x0F, 0x80, 0xF0,
  0xF0, 0x3E, 0x03, 0x83, 0xC0, 0xF8, 0x0E, 0x0F, 0x03, 0xE0, 0x70, 0x3E,
  0x0F, 0x81, 0xC0, 0xF8, 0x7F, 0x0E, 0x07, 0xE3, 0xFF, 0x20, 0x3F, 0xC3,
  0xFF, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0x02, 0x07, 0xC3, 0x83,
  0xF3, 0xC3, 0xFB, 0xF1, 0x7F, 0xF9, 0x1F, 0x3E, 0x0F, 0x1C, 0x07, 0x84,
  0x03, 0xC4, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xEF, 0x80, 0x41, 0xC0, 0x20, 0x40,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x30,
  0xF8, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x02, 0x0F, 0xE0, 0xE0, 0x7F,
  0x1F, 0x07, 0xF7, 0xF8, 0x3F, 0x8F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE0,
  0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x3F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF1, 0x1C, 0x3F, 0xE1, 0xC1, 0xFC,
  0x38, 0x07, 0x83, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xE1, 0x0F,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x06, 0x1E,
  0x61, 0xFF, 0x07, 0xFE, 0x03, 0xF8, 0x0B, 0xF0, 0x27, 0xE1, 0x0F, 0x88,
  0x3E, 0x20, 0x79, 0x81, 0xE6, 0x07, 0x90, 0x1F, 0xC0, 0x7B, 0x01, 0xEC,
  0x07, 0xB0, 0x1C, 0x60, 0x71, 0x81, 0x82, 0x0C, 0x0E, 0x60, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8,
};

const GFXglyph UnifrakturMaguntia_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 35, 11, 1, -34 },
  { 41, 16, 13, 19, 1, -34 },
  { 67, 21, 27, 24, 2, -30 },
  { 138, 16, 38, 20, 2, -36 },
  { 214, 31, 33, 34, 1, -33 },
  { 342, 24, 29, 27, 2, -29 },
  { 429, 7, 13, 9, 1, -34 },
  { 441, 10, 38, 12, 1, -37 },
  { 489, 10, 38, 12, 1, -37 },
  { 537, 16, 19, 17, 0, -35 },
  { 575, 15, 17, 19, 2, -24 },
  { 607, 8, 13, 9, 0, -7 },
  { 620, 13, 10, 14, 1, -19 },
  { 637, 8, 8, 9, 1, -7 },
  { 645, 23, 37, 25, 1, -35 },
  { 752, 20, 33, 22, 1, -33 },
  { 835, 15, 32, 15, 0, -32 },
  { 895, 19, 31, 21, 1, -31 },
  { 969, 20, 32, 22, 1, -32 },
  { 1049, 21, 32, 22, 0, -32 },
  { 1133, 20, 33, 22, 1, -33 },
  { 1216, 20, 33, 21, 1, -33 },
  { 1299, 19, 32, 20, 1, -32 },
  { 1375, 20, 33, 22, 1, -33 },
  { 1458, 20, 33, 21, 1, -33 },
  { 1541, 8, 23, 9, 1, -22 },
  { 1564, 9, 28, 8, 0, -22 },
  { 1596, 13, 17, 14, 0, -22 },
  { 1624, 16, 10, 18, 1, -19 },
  { 1644, 13, 17, 14, 0, -22 },
  { 1672, 17, 34, 21, 2, -33 },
  { 1745, 27, 29, 29, 1, -22 },
  { 1843, 36, 34, 38, 1, -33 },
  { 1996, 41, 35, 42, 0, -34 },
  { 2176, 30, 35, 32, 1, -34 },
  { 2308, 36, 36, 38, 1, -34 },
  { 2470, 31, 35, 33, 1, -34 },
  { 2606, 34, 41, 36, 1, -35 },
  { 2781, 34, 35, 36, 1, -34 },
  { 2930, 33, 42, 35, 1, -36 },
  { 3104, 30, 41, 32, 1, -35 },
  { 3258, 31, 47, 33, 1, -35 },
  { 3441, 36, 34, 38, 1, -33 },
  { 3594, 25, 34, 27, 1, -33 },
  { 3701, 50, 35, 52, 1, -33 },
  { 3920, 39, 34, 42, 1, -33 },
  { 4086, 33, 35, 35, 1, -34 },
  { 4231, 40, 41, 42, 1, -33 },
  { 4436, 36, 37, 37, 1, -34 },
  { 4603, 42, 35, 44, 1, -34 },
  { 4787, 33, 35, 36, 1, -34 },
  { 4932, 33, 33, 35, 1, -33 },
  { 5069, 31, 36, 34, 1, -33 },
  { 5209, 40, 35, 42, 1, -34 },
  { 5384, 48, 35, 51, 1, -34 },
  { 5594, 32, 35, 34, 1, -34 },
  { 5734, 38, 41, 40, 1, -34 },
  { 5929, 29, 41, 31, 1, -35 },
  { 6078, 6, 37, 9, 1, -35 },
  { 6106, 29, 33, 5, -9, -31 },
  { 6226, 6, 37, 9, 1, -35 },
  { 6254, 17, 13, 20, 1, -33 },
  { 6282, 22, 3, 21, 0, 6 },
  { 6291, 7, 9, 24, 8, -33 },
  { 6299, 20, 25, 22, 1, -24 },
  { 6362, 19, 33, 21, 1, -32 },
  { 6441, 15, 25, 17, 1, -24 },
  { 6488, 20, 34, 21, 1, -33 },
  { 6573, 15, 25, 17, 1, -24 },
  { 6620, 14, 42, 11, 0, -34 },
  { 6694, 20, 34, 22, 1, -24 },
  { 6779, 19, 41, 21, 1, -33 },
  { 6877, 11, 34, 13, 1, -33 },
  { 6924, 13, 42, 11, -2, -33 },
  { 6993, 13, 34, 15, 1, -33 },
  { 7049, 13, 34, 13, 1, -33 },
  { 7105, 31, 26, 33, 1, -25 },
  { 7206, 22, 25, 24, 1, -24 },
  { 7275, 18, 25, 19, 0, -24 },
  { 7332, 21, 37, 21, 0, -28 },
  { 7430, 18, 34, 20, 1, -24 },
  { 7507, 15, 25, 17, 1, -24 },
  { 7554, 18, 30, 20, 1, -29 },
  { 7622, 13, 31, 15, 1, -30 },
  { 7673, 22, 25, 24, 1, -24 },
  { 7742, 21, 28, 21, -1, -27 },
  { 7816, 30, 29, 32, 1, -28 },
  { 7925, 17, 35, 19, 1, -25 },
  { 8000, 20, 36, 22, 1, -28 },
  { 8090, 14, 33, 16, 1, -24 },
  { 8148, 13, 38, 16, 1, -37 },
  { 8210, 3, 39, 7, 2, -37 },
  { 8225, 13, 38, 16, 1, -37 },
  { 8287, 15, 3, 17, 1, -16 },
};

const GFXfont UnifrakturMaguntia_Regular47pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular47pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular47pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR47PT7B_H_
