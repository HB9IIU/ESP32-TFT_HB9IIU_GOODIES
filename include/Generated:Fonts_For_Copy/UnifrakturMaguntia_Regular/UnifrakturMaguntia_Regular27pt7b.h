#ifndef _UNIFRAKTURMAGUNTIA_REGULAR27PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x3D, 0xEF, 0x31, 0x8C, 0x63, 0x08, 0x44, 0x20, 0x00, 0x23,
  0x3C, 0x40, 0x42, 0x73, 0x9C, 0xE6, 0x32, 0x11, 0x09, 0x08, 0x0C, 0xC0,
  0xCC, 0x18, 0xC1, 0x8C, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98, 0x19, 0x8F,
  0xFE, 0xFF, 0xE3, 0x18, 0x31, 0x83, 0x30, 0x33, 0x00, 0x08, 0x04, 0x02,
  0x03, 0xC6, 0x33, 0x09, 0x07, 0xC3, 0xF1, 0x3C, 0x1F, 0x87, 0xE0, 0xFA,
  0x3F, 0x07, 0x83, 0xC1, 0xA0, 0x8D, 0x81, 0x00, 0x80, 0x40, 0x38, 0x00,
  0x9B, 0x00, 0x4C, 0x60, 0x33, 0x18, 0x18, 0xC6, 0x04, 0x31, 0x82, 0x0C,
  0x61, 0x03, 0x18, 0x80, 0x6C, 0x40, 0x0E, 0x23, 0x80, 0x19, 0xB0, 0x0C,
  0xE6, 0x02, 0x39, 0x81, 0x0E, 0x60, 0x83, 0x9C, 0x40, 0xE6, 0x20, 0x39,
  0x98, 0x06, 0xC4, 0x00, 0xE0, 0x07, 0x00, 0x36, 0x01, 0x8C, 0x06, 0x30,
  0x1C, 0x80, 0x74, 0x01, 0xE0, 0x07, 0x9F, 0x3E, 0x11, 0xBC, 0x4E, 0x72,
  0x39, 0xE8, 0xE7, 0xA3, 0x8F, 0x0E, 0x1E, 0x5C, 0x7E, 0x3E, 0x70, 0x23,
  0x9E, 0x61, 0x10, 0x80, 0x0C, 0x43, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x8E,
  0x38, 0xE1, 0x86, 0x18, 0x70, 0xC3, 0x04, 0x18, 0x10, 0x60, 0xC1, 0x06,
  0x18, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x84,
  0x21, 0x00, 0x00, 0x04, 0x1F, 0x9D, 0x76, 0xB0, 0xE9, 0xFD, 0xD7, 0x3E,
  0x04, 0x02, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x27, 0xF3, 0x32, 0x20, 0x02, 0xFD, 0x80, 0x0F, 0xDF,
  0x00, 0x23, 0x9E, 0x40, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x00, 0x0F, 0x01, 0x9C, 0x38, 0xC3, 0x8E, 0x70, 0xE7, 0x0F,
  0x70, 0x77, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70, 0x77, 0x0F,
  0x70, 0xE3, 0x0E, 0x38, 0xC1, 0x8C, 0x0F, 0x00, 0x04, 0x0C, 0x1C, 0x3C,
  0xDC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3E, 0x7F, 0x0F, 0x83, 0xFC, 0x61, 0xE4, 0x0E, 0x40, 0xE8, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x20, 0x81, 0x10,
  0x23, 0xFE, 0x7F, 0xEF, 0xFE, 0x1F, 0x82, 0x1E, 0x40, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x76, 0x07, 0xF0, 0x67, 0x06, 0x30, 0xC1, 0xF0, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x0B, 0x80, 0xB8, 0x13, 0x82, 0x38, 0x23, 0x84, 0x38, 0x43,
  0x8F, 0xFF, 0xFF, 0xF0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0xFF, 0x38,
  0x63, 0xFC, 0x3F, 0x82, 0x00, 0x20, 0x02, 0x00, 0x2F, 0x83, 0xFC, 0x3F,
  0xE3, 0x0F, 0x40, 0x70, 0x07, 0x00, 0x70, 0x07, 0x60, 0x77, 0x06, 0x70,
  0x63, 0x0C, 0x1F, 0x00, 0x07, 0x81, 0x8C, 0x18, 0xE3, 0x0E, 0x30, 0xE7,
  0x00, 0x70, 0x07, 0x38, 0x7C, 0xE7, 0x8E, 0x70, 0xF7, 0x07, 0x70, 0x77,
  0x07, 0x70, 0x67, 0x06, 0x38, 0xC1, 0x8C, 0x0F, 0x00, 0x7F, 0xEF, 0xFD,
  0x01, 0xC0, 0x20, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0x0F, 0x83,
  0x04, 0x20, 0x66, 0x02, 0x60, 0x67, 0x06, 0x7C, 0x43, 0xF8, 0x1F, 0x81,
  0x7C, 0x21, 0xE6, 0x0E, 0x60, 0x7C, 0x07, 0xC0, 0x76, 0x07, 0x60, 0x63,
  0x0C, 0x1F, 0x80, 0x0F, 0x01, 0x98, 0x30, 0xC7, 0x0E, 0x70, 0xE7, 0x0E,
  0xF0, 0xE7, 0x0F, 0x70, 0xF7, 0x0F, 0x31, 0xE1, 0xEE, 0x00, 0xE0, 0x0E,
  0x70, 0xE7, 0x0C, 0x70, 0xC3, 0x98, 0x1E, 0x00, 0x21, 0x9E, 0x42, 0x00,
  0x00, 0x01, 0x1C, 0xF2, 0x00, 0x21, 0x9E, 0x42, 0x00, 0x00, 0x01, 0x1D,
  0xE3, 0x18, 0x84, 0x02, 0x0C, 0x71, 0xC7, 0x1E, 0x0C, 0x0C, 0x04, 0x04,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xC1, 0xC1, 0xC1, 0xE1, 0xE1,
  0xC7, 0x18, 0x61, 0x80, 0x3F, 0x18, 0xEC, 0x1F, 0x07, 0xE1, 0xF8, 0x70,
  0x7C, 0x7E, 0x3E, 0x1C, 0x06, 0x01, 0x86, 0x31, 0x07, 0x80, 0x00, 0x10,
  0x0E, 0x07, 0xC0, 0x40, 0x03, 0xF0, 0x0E, 0x1C, 0x18, 0x04, 0x30, 0x06,
  0x61, 0xFA, 0x63, 0x32, 0x66, 0x32, 0x4E, 0x72, 0xCE, 0x66, 0xCC, 0xE4,
  0x4C, 0xEC, 0x6F, 0x7B, 0x60, 0x03, 0x20, 0x06, 0x30, 0x0C, 0x0C, 0x18,
  0x07, 0xE0, 0x1F, 0x80, 0x23, 0xFE, 0x0C, 0x41, 0xE3, 0xC8, 0x0F, 0x7C,
  0x80, 0xF3, 0xC8, 0x07, 0x3C, 0x80, 0x73, 0xCE, 0x07, 0x3C, 0xF8, 0x73,
  0xC7, 0xC6, 0x3C, 0x0C, 0xC3, 0xC0, 0x88, 0x3C, 0x01, 0x03, 0xC0, 0x20,
  0x3C, 0x07, 0x03, 0xC1, 0xFC, 0x3C, 0x27, 0xE5, 0xF0, 0x3F, 0x9E, 0x01,
  0xF0, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0xFF, 0xD3,
  0xC3, 0x8F, 0xE3, 0xC6, 0x07, 0x87, 0x98, 0x07, 0x07, 0xB0, 0x0E, 0x0F,
  0x60, 0x0C, 0x08, 0x40, 0x18, 0x70, 0x80, 0x33, 0xF8, 0xC4, 0xCF, 0xF8,
  0x71, 0x00, 0xF0, 0x04, 0x00, 0xE0, 0x10, 0x01, 0xC0, 0x70, 0x01, 0x83,
  0xF0, 0x03, 0x09, 0xF0, 0x0C, 0x01, 0xF8, 0x10, 0x01, 0xFC, 0xC0, 0x00,
  0xFE, 0x00, 0x02, 0x00, 0x0E, 0xCF, 0x0E, 0x1F, 0xE6, 0x09, 0xC7, 0x18,
  0x43, 0x18, 0x03, 0x9E, 0x01, 0xCF, 0x00, 0xE3, 0xC0, 0x71, 0xF0, 0x3C,
  0x7C, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xC0, 0x78, 0x40,
  0x3E, 0x40, 0x0F, 0xC0, 0x43, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xE7, 0xF8, 0x70, 0x8F, 0xCC, 0x18, 0x3C,
  0x83, 0x81, 0xE8, 0x38, 0x0E, 0x83, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xF0,
  0x34, 0x0F, 0x03, 0x22, 0x70, 0x31, 0xC3, 0x03, 0x00, 0x20, 0x20, 0x7C,
  0x02, 0x1F, 0xC0, 0x43, 0xFF, 0x08, 0x43, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x0E, 0x4F, 0x0C, 0x1F, 0xE6, 0x09, 0xC7, 0x18,
  0x43, 0x18, 0x03, 0x9E, 0x01, 0xCF, 0x1C, 0xE3, 0xCF, 0xF1, 0xFF, 0xF8,
  0x7C, 0xDE, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xC0, 0x78, 0x40,
  0x3E, 0x40, 0x0F, 0xC0, 0x43, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xF0, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF9, 0x38, 0x3F, 0xE6, 0x01, 0x78,
  0x40, 0x21, 0x04, 0x06, 0x00, 0x40, 0x70, 0x44, 0x07, 0x8E, 0x40, 0x7D,
  0xF2, 0x03, 0xFE, 0x10, 0x3E, 0x40, 0xF9, 0xF0, 0x00, 0x0F, 0x01, 0xC0,
  0x70, 0x0E, 0x07, 0x80, 0xE0, 0x78, 0x0E, 0x03, 0x00, 0xE0, 0x70, 0x0E,
  0x06, 0x00, 0xE0, 0x60, 0x07, 0x08, 0x00, 0x1F, 0x00, 0x0F, 0xC6, 0x03,
  0x0B, 0xE0, 0xC0, 0xBE, 0x38, 0x63, 0xE7, 0x18, 0x39, 0xC7, 0x02, 0x38,
  0xE1, 0x87, 0x1E, 0x7C, 0xE3, 0xDF, 0xDC, 0x3C, 0x3B, 0xC3, 0xC7, 0xF8,
  0x78, 0x7F, 0x07, 0x0E, 0xE0, 0x61, 0xDE, 0x18, 0x31, 0xE6, 0x06, 0x1C,
  0x01, 0x81, 0xE0, 0x60, 0x1F, 0x30, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x63, 0xE0, 0x18, 0x30, 0x03,
  0x00, 0x00, 0xE0, 0x10, 0x1E, 0x0F, 0x01, 0xE3, 0xF0, 0x3D, 0xBF, 0x03,
  0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x38, 0x07, 0x07, 0x10,
  0xE0, 0xE7, 0x08, 0x1F, 0xF1, 0x03, 0x0F, 0xC0, 0xE0, 0xE0, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x03,
  0xFE, 0x01, 0x87, 0xE0, 0xC0, 0xFE, 0x20, 0x0F, 0x08, 0x01, 0x82, 0x00,
  0xC0, 0x80, 0x70, 0x30, 0x1C, 0x04, 0x07, 0x80, 0xED, 0xE0, 0x04, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x8F,
  0x80, 0x67, 0xF0, 0x18, 0x3E, 0x0C, 0x07, 0xE6, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0xE1, 0xF0, 0x18, 0x1F, 0xC2, 0x00,
  0xF0, 0x40, 0x0C, 0x18, 0x03, 0x01, 0x00, 0x60, 0x20, 0x1C, 0x02, 0x03,
  0xC0, 0x33, 0x78, 0x01, 0x87, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE3, 0xE0, 0x18, 0xFE, 0x03, 0x03, 0xE0, 0x40, 0x3E, 0x10, 0x03, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x0C, 0x02, 0x00, 0xC0, 0x08, 0x0E,
  0x7C, 0x20, 0x67, 0xF1, 0x87, 0x23, 0xCC, 0x3A, 0x0E, 0x21, 0xF0, 0x79,
  0x0F, 0x81, 0xF8, 0x3C, 0x08, 0x81, 0xF1, 0xC8, 0x07, 0xDE, 0x80, 0x1F,
  0x78, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x07, 0x0C, 0x38, 0x7C, 0x41, 0xE4,
  0xFC, 0x07, 0xC3, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x18, 0x30,
  0x60, 0x31, 0xC0, 0x63, 0x80, 0xE7, 0x01, 0xCF, 0x03, 0x9E, 0x06, 0x1F,
  0x38, 0x3D, 0x40, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x80,
  0x1F, 0x81, 0xDF, 0xC4, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x07,
  0x07, 0x03, 0xFC, 0xFD, 0xF8, 0x7F, 0xF3, 0xD3, 0xCC, 0x1F, 0x1E, 0x1C,
  0x80, 0xF0, 0xE1, 0xE8, 0x07, 0x8F, 0x1E, 0x80, 0x78, 0x70, 0xF8, 0x03,
  0x87, 0x0C, 0x80, 0x38, 0x70, 0x87, 0xE3, 0x87, 0x10, 0x3E, 0x38, 0x73,
  0x00, 0x21, 0x86, 0x70, 0x00, 0x30, 0x67, 0x00, 0x03, 0x06, 0x70, 0x00,
  0x20, 0x47, 0x01, 0xC2, 0xC4, 0x78, 0x7E, 0x5F, 0x83, 0xF9, 0xFB, 0xF0,
  0x3E, 0x0F, 0x4E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0xFF,
  0x1F, 0x87, 0xFE, 0x8F, 0x30, 0x7E, 0x1C, 0x80, 0xF0, 0x72, 0x01, 0xE1,
  0xE8, 0x07, 0x83, 0xE0, 0x0E, 0x0C, 0x88, 0x38, 0x61, 0xF8, 0xE1, 0x03,
  0xE1, 0x8C, 0x00, 0x86, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x02,
  0x1C, 0x0F, 0x08, 0x78, 0x7E, 0x40, 0xFC, 0x7E, 0x03, 0xE0, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x0C, 0x3F,
  0x86, 0x00, 0xF9, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0E, 0xFC, 0x01,
  0xCF, 0xE0, 0x18, 0xFC, 0x03, 0x07, 0x80, 0x60, 0x30, 0x0C, 0x04, 0x01,
  0x8F, 0x00, 0x27, 0xF0, 0x08, 0x3F, 0x82, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x60, 0x3F, 0xE1, 0xC0, 0x7F, 0xF7, 0xC0,
  0x40, 0xF9, 0xE0, 0x40, 0x79, 0xF0, 0x80, 0x78, 0xF8, 0x80, 0x78, 0x7C,
  0x40, 0x38, 0x3E, 0x40, 0x38, 0x1E, 0x31, 0x38, 0x0E, 0x0E, 0x38, 0x06,
  0x00, 0x38, 0x06, 0x00, 0x38, 0x02, 0x00, 0x38, 0x06, 0x00, 0x78, 0x04,
  0x00, 0xFC, 0x08, 0x01, 0xFF, 0x18, 0x06, 0x1F, 0xF0, 0x00, 0x17, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x01, 0x87,
  0xF0, 0x60, 0x0F, 0x8E, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1C, 0xFC,
  0x01, 0xC7, 0xF0, 0x0C, 0x3F, 0x00, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x0C, 0x3C, 0x0E, 0x8F, 0xE1, 0xF0, 0x3F, 0xA7, 0xF0, 0xFF, 0xFE,
  0x03, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x81, 0xC0, 0x3F, 0xC3, 0xF0, 0x7F, 0xE4, 0xF0, 0xC1, 0xF8, 0x78, 0x80,
  0x78, 0x78, 0x80, 0x38, 0x3C, 0x80, 0x38, 0x1E, 0x80, 0x38, 0x10, 0x80,
  0x18, 0x60, 0xC0, 0x19, 0xC0, 0x61, 0x1B, 0xE0, 0x1E, 0x18, 0xE0, 0x00,
  0x18, 0xF0, 0x00, 0x10, 0xF0, 0x00, 0x10, 0xF0, 0x1E, 0x20, 0x78, 0x3F,
  0x40, 0x7A, 0x0F, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x00, 0x7F,
  0x88, 0x37, 0xFE, 0x08, 0x1F, 0x82, 0x00, 0x40, 0x80, 0x00, 0x30, 0x01,
  0x06, 0x01, 0xF8, 0xC8, 0x7F, 0x98, 0xFF, 0x8B, 0x0F, 0xC1, 0x70, 0xE0,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x9E, 0x00, 0x33, 0xF8, 0x1C, 0x3F, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x01, 0x87,
  0xF0, 0x40, 0x3F, 0xA8, 0x09, 0xFD, 0x03, 0x0E, 0x20, 0xE0, 0x04, 0x1E,
  0x00, 0x83, 0xE0, 0x0E, 0xBE, 0x00, 0x23, 0xE0, 0x00, 0x1C, 0x03, 0xC3,
  0x80, 0xFC, 0x60, 0x2F, 0xD0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x80, 0x7F,
  0x60, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x43, 0x10, 0x30, 0x61, 0x1C, 0x1C,
  0x47, 0x83, 0x80, 0x70, 0x78, 0x0E, 0x0F, 0x81, 0xC0, 0xF8, 0x38, 0x0F,
  0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x03, 0x80, 0x40, 0x70, 0x10,
  0x0E, 0x07, 0x01, 0xC1, 0xF0, 0x78, 0xDF, 0xB7, 0xC0, 0xFC, 0xFC, 0x0F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x07,
  0xFE, 0x9E, 0x18, 0xFC, 0x38, 0xC0, 0xF0, 0xF2, 0x01, 0xC1, 0xE8, 0x07,
  0x02, 0x20, 0x0C, 0x10, 0x80, 0x30, 0xC2, 0x00, 0xC3, 0x86, 0x22, 0x0F,
  0x07, 0x18, 0x3E, 0x00, 0x40, 0x78, 0x02, 0x00, 0xF0, 0x78, 0x03, 0xC7,
  0xF0, 0x06, 0x23, 0xF0, 0x10, 0x07, 0xE0, 0x80, 0x0F, 0xE4, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x8E, 0x3E, 0x07, 0xFB, 0x59, 0xE1, 0xFF,
  0xC4, 0x1E, 0x60, 0x79, 0x83, 0xC8, 0x07, 0x30, 0x3D, 0x00, 0xE6, 0x07,
  0xA0, 0x0C, 0xE0, 0x44, 0x01, 0x9E, 0x18, 0x80, 0x33, 0xC7, 0x0C, 0x66,
  0x3C, 0xF0, 0x31, 0x87, 0x9F, 0x00, 0x20, 0x71, 0xF0, 0x08, 0x0E, 0x1E,
  0x0E, 0x01, 0x81, 0xC7, 0xE0, 0x30, 0x19, 0x3E, 0x07, 0x82, 0x03, 0xE3,
  0xF8, 0x80, 0x3F, 0x9F, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x64, 0xFF, 0x1F, 0x1F, 0xF3, 0xE6, 0x0F, 0x98,
  0x80, 0xF0, 0x10, 0x1C, 0x02, 0x01, 0x80, 0x40, 0x7F, 0x84, 0x1F, 0xE0,
  0x7B, 0xFC, 0x00, 0xB8, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x05, 0xE0, 0x1C, 0xBC, 0x03, 0xF3, 0xF8, 0xFC, 0x3E, 0x27, 0x83, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x3E, 0x1F, 0xFA, 0x79, 0xC7, 0xE1, 0xEC, 0x0F,
  0x0F, 0x40, 0x38, 0x7A, 0x01, 0xC1, 0xF0, 0x06, 0x06, 0x80, 0x30, 0x44,
  0x01, 0x86, 0x19, 0x8C, 0x78, 0x30, 0xC3, 0xC0, 0x06, 0x1F, 0x00, 0x20,
  0x78, 0x02, 0x03, 0xC0, 0x20, 0x0F, 0x03, 0xC4, 0x78, 0x3F, 0xC3, 0xC0,
  0x7C, 0x1E, 0x01, 0xC0, 0xE0, 0x80, 0x06, 0x02, 0x00, 0x60, 0x0C, 0x06,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x07, 0xC3, 0x00, 0xE1,
  0x00, 0x70, 0x80, 0x38, 0x40, 0x18, 0x10, 0x08, 0x06, 0x08, 0x00, 0x1E,
  0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x1C, 0x01, 0xBF, 0x00, 0xE7, 0xC0, 0x41, 0xF0, 0x40, 0x7E, 0xC0,
  0x0F, 0x80, 0x00, 0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xF0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x00, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xF0, 0x08, 0x07, 0x03, 0xE0, 0xD8, 0x63, 0x30, 0x68,
  0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0xE6, 0x73, 0x10, 0x08, 0x01, 0x80, 0x7C,
  0x13, 0xE6, 0x39, 0x87, 0x30, 0xE6, 0x1C, 0xC3, 0x9C, 0x73, 0x8E, 0x79,
  0xD7, 0xFC, 0x63, 0x88, 0x20, 0x04, 0x13, 0x42, 0xC0, 0x38, 0x07, 0x00,
  0xE2, 0x1C, 0xC3, 0xBC, 0x7B, 0xCE, 0x39, 0xC3, 0x38, 0x67, 0x0C, 0xE1,
  0x9C, 0x33, 0x8C, 0xFD, 0x07, 0xC0, 0x30, 0x04, 0x00, 0x04, 0x1E, 0x2E,
  0x47, 0xC6, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x7F, 0x3C, 0x10,
  0x60, 0x10, 0x03, 0x00, 0x70, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x71,
  0xCE, 0x39, 0xC3, 0xB8, 0x77, 0x0E, 0xE0, 0x9C, 0x33, 0x84, 0xFC, 0x83,
  0xE0, 0x30, 0x00, 0x04, 0x1E, 0x6E, 0x46, 0xC7, 0xC7, 0xCC, 0xF0, 0xE0,
  0xE0, 0xE0, 0x70, 0x7F, 0x3C, 0x10, 0x1D, 0x3F, 0x2E, 0x40, 0x40, 0x30,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x04, 0x01, 0xC0, 0x7C, 0x13, 0xE6,
  0x19, 0x81, 0x30, 0x66, 0x0C, 0xE3, 0x9C, 0x73, 0x8F, 0x38, 0xE7, 0xFC,
  0x63, 0x90, 0x30, 0x06, 0x40, 0xDC, 0x31, 0xC8, 0x06, 0x00, 0x07, 0x13,
  0x02, 0xC0, 0x38, 0x07, 0x00, 0xE4, 0x1C, 0xC3, 0xFC, 0x73, 0x8E, 0x39,
  0xC7, 0x38, 0xE7, 0x0C, 0xE1, 0x9C, 0x33, 0x86, 0x75, 0x9F, 0x30, 0xC4,
  0x11, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x18, 0x70, 0xE0, 0x80, 0x04,
  0x0C, 0x3E, 0xB8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3A, 0x78, 0x70,
  0x00, 0x1C, 0x38, 0x70, 0x80, 0x02, 0x0E, 0x3F, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8C, 0xE0, 0x07, 0x32,
  0xCB, 0xB7, 0xEF, 0x1C, 0x7F, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x7D, 0xF0, 0x60, 0x80, 0x07, 0x32, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7D, 0xF0, 0x60, 0x00, 0x41, 0x08,
  0x39, 0xCE, 0x3D, 0xFB, 0xE7, 0x38, 0xE3, 0x1C, 0x71, 0x8E, 0x38, 0xC7,
  0x1C, 0x63, 0x8E, 0x31, 0xC7, 0x18, 0xE3, 0x8C, 0x71, 0xCF, 0x3C, 0xF7,
  0xBC, 0x79, 0x84, 0x18, 0x82, 0x00, 0x41, 0x06, 0x38, 0xF7, 0xEF, 0x9C,
  0x31, 0xC3, 0x1C, 0x31, 0xC3, 0x1C, 0x31, 0xC3, 0x1C, 0x71, 0xC7, 0x9D,
  0x78, 0xE3, 0x0E, 0x20, 0x40, 0x01, 0x00, 0xE1, 0xFE, 0x39, 0xC7, 0x3C,
  0xE3, 0x9C, 0x33, 0x87, 0x70, 0xCE, 0x19, 0xC2, 0x7E, 0x81, 0xE0, 0x18,
  0x00, 0x00, 0x40, 0x04, 0x00, 0xE0, 0x8F, 0x18, 0x7F, 0xC3, 0x9E, 0x38,
  0xE3, 0x8F, 0x38, 0x73, 0x87, 0x38, 0x63, 0x86, 0x78, 0x4F, 0xE8, 0x1F,
  0x01, 0xE0, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x00, 0x04, 0x00,
  0xC0, 0x3E, 0x09, 0xF2, 0x1C, 0xC3, 0x98, 0x77, 0x0E, 0xE1, 0xCE, 0x39,
  0xC7, 0x3C, 0xE3, 0xFC, 0x33, 0x80, 0x70, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x42, 0x62, 0xF7, 0xFF, 0x72, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x7E, 0xBC, 0x18, 0x00, 0x02, 0x00, 0xB0, 0x01, 0x02, 0x11, 0xE6,
  0x5F, 0x90, 0xE2, 0x08, 0x63, 0x0F, 0xF0, 0xEF, 0x18, 0xE2, 0x0C, 0xF1,
  0x1F, 0xC0, 0xF0, 0x04, 0x00, 0x02, 0x04, 0x0C, 0x18, 0x38, 0x7F, 0xB8,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x7E, 0x0C, 0x08, 0x40,
  0x86, 0x0C, 0xF1, 0xEF, 0x3C, 0x31, 0xC3, 0x1C, 0x31, 0xC3, 0x1C, 0x31,
  0xC3, 0x1C, 0x31, 0xC7, 0x9D, 0x3E, 0xE1, 0x86, 0x00, 0x00, 0x40, 0x04,
  0x08, 0xE3, 0x8F, 0x7C, 0xF9, 0xE7, 0x8E, 0x38, 0xE1, 0x86, 0x18, 0x61,
  0x86, 0x10, 0x61, 0x0C, 0x3C, 0x87, 0xF0, 0x0E, 0x00, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x30, 0x01, 0x1E, 0x30, 0xCF, 0x3D, 0xF3, 0xEF, 0x38, 0xC3,
  0x0E, 0x61, 0x87, 0x30, 0xC3, 0x98, 0x61, 0xCC, 0x30, 0xC6, 0x18, 0x63,
  0x9E, 0x23, 0xCF, 0xA1, 0xE1, 0xE0, 0x60, 0x60, 0x20, 0x10, 0x00, 0x21,
  0x39, 0x9F, 0xF7, 0x73, 0x91, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0xC7, 0xC4, 0xC2, 0x01, 0x00, 0x80, 0x23, 0x8F, 0xC0, 0x00, 0x40, 0x10,
  0x03, 0x84, 0x79, 0xCF, 0xFC, 0xE3, 0x8C, 0x79, 0x87, 0x30, 0xE6, 0x1C,
  0xC3, 0x98, 0x73, 0x0C, 0xE9, 0x9E, 0x20, 0x8C, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x02, 0x00, 0x10, 0x71, 0xF4, 0xE0, 0x82, 0x08, 0xBE, 0xFC, 0x7D,
  0x3A, 0x78, 0x70, 0xE1, 0xC3, 0x85, 0x19, 0xC0, 0x06, 0x30, 0xC1, 0x83,
  0x07, 0x0E, 0x1C, 0x30, 0x63, 0x03, 0x03, 0x06, 0x0E, 0x1C, 0x30, 0x60,
  0xC1, 0x80, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xC0,
  0xC1, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x30, 0x38, 0x43, 0x06, 0x0C, 0x18,
  0x38, 0x70, 0xC1, 0x86, 0x10, 0x00, 0xFF, 0xFF,
};

const GFXglyph UnifrakturMaguntia_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 20, 6, 1, -20 },
  { 14, 9, 7, 11, 1, -19 },
  { 22, 12, 15, 14, 1, -17 },
  { 45, 9, 22, 11, 1, -21 },
  { 70, 18, 19, 19, 1, -19 },
  { 113, 14, 17, 15, 1, -17 },
  { 143, 5, 7, 5, 0, -19 },
  { 148, 6, 22, 7, 0, -21 },
  { 165, 6, 22, 7, 0, -21 },
  { 182, 9, 11, 10, 0, -20 },
  { 195, 9, 10, 11, 1, -14 },
  { 207, 4, 7, 5, 0, -4 },
  { 211, 7, 6, 8, 1, -11 },
  { 217, 5, 4, 5, 0, -4 },
  { 220, 13, 21, 14, 1, -20 },
  { 255, 12, 19, 13, 0, -19 },
  { 284, 8, 18, 9, 0, -18 },
  { 302, 12, 18, 12, 0, -18 },
  { 329, 12, 18, 13, 0, -18 },
  { 356, 12, 18, 12, 0, -18 },
  { 383, 12, 19, 13, 0, -19 },
  { 412, 12, 19, 12, 0, -19 },
  { 441, 11, 18, 12, 0, -18 },
  { 466, 12, 19, 13, 0, -19 },
  { 495, 12, 19, 12, 0, -19 },
  { 524, 5, 13, 5, 0, -13 },
  { 533, 5, 16, 5, 0, -13 },
  { 543, 7, 10, 8, 0, -13 },
  { 552, 9, 6, 10, 1, -11 },
  { 559, 7, 10, 8, 0, -13 },
  { 568, 10, 19, 12, 1, -19 },
  { 592, 16, 17, 16, 0, -13 },
  { 626, 20, 20, 22, 1, -19 },
  { 676, 23, 20, 24, 0, -20 },
  { 734, 17, 20, 19, 1, -20 },
  { 777, 20, 21, 22, 1, -20 },
  { 830, 17, 20, 19, 1, -20 },
  { 873, 20, 24, 20, 0, -21 },
  { 933, 19, 20, 21, 1, -19 },
  { 981, 19, 25, 20, 0, -21 },
  { 1041, 18, 23, 19, 0, -19 },
  { 1093, 19, 26, 19, 0, -19 },
  { 1155, 21, 20, 22, 0, -19 },
  { 1208, 15, 20, 15, 0, -19 },
  { 1246, 28, 20, 30, 1, -19 },
  { 1316, 22, 20, 24, 1, -19 },
  { 1371, 19, 20, 20, 1, -19 },
  { 1419, 24, 24, 24, 0, -19 },
  { 1491, 20, 21, 22, 1, -19 },
  { 1544, 24, 20, 25, 1, -20 },
  { 1604, 19, 19, 20, 1, -19 },
  { 1650, 19, 19, 20, 1, -19 },
  { 1696, 19, 21, 19, 0, -19 },
  { 1746, 22, 21, 24, 1, -20 },
  { 1804, 27, 20, 29, 1, -19 },
  { 1872, 19, 20, 19, 0, -20 },
  { 1920, 21, 24, 23, 1, -20 },
  { 1983, 17, 23, 18, 0, -19 },
  { 2032, 4, 21, 5, 0, -20 },
  { 2043, 16, 19, 3, -5, -18 },
  { 2081, 4, 21, 5, 0, -20 },
  { 2092, 10, 7, 11, 1, -19 },
  { 2101, 13, 2, 12, 0, 3 },
  { 2105, 4, 5, 14, 4, -19 },
  { 2108, 11, 15, 12, 1, -14 },
  { 2129, 11, 20, 12, 1, -19 },
  { 2157, 8, 15, 10, 1, -14 },
  { 2172, 11, 19, 12, 1, -19 },
  { 2199, 8, 15, 10, 1, -14 },
  { 2214, 8, 24, 7, 0, -19 },
  { 2238, 11, 20, 13, 1, -14 },
  { 2266, 11, 24, 12, 1, -19 },
  { 2299, 7, 20, 7, 0, -19 },
  { 2317, 7, 24, 7, -1, -19 },
  { 2338, 7, 20, 9, 1, -19 },
  { 2356, 7, 20, 7, 1, -19 },
  { 2374, 17, 15, 19, 1, -14 },
  { 2406, 12, 15, 14, 1, -14 },
  { 2429, 11, 15, 11, 0, -14 },
  { 2450, 12, 21, 12, 0, -16 },
  { 2482, 11, 20, 12, 0, -14 },
  { 2510, 8, 15, 10, 1, -14 },
  { 2525, 11, 17, 11, 0, -17 },
  { 2549, 8, 18, 8, 0, -17 },
  { 2567, 12, 15, 14, 1, -14 },
  { 2590, 12, 16, 12, 0, -15 },
  { 2614, 17, 17, 19, 1, -16 },
  { 2651, 9, 20, 11, 1, -14 },
  { 2674, 11, 21, 13, 1, -16 },
  { 2703, 7, 19, 9, 1, -14 },
  { 2720, 7, 22, 9, 1, -21 },
  { 2740, 2, 22, 4, 1, -21 },
  { 2746, 7, 22, 9, 1, -21 },
  { 2766, 8, 2, 10, 1, -9 },
};

const GFXfont UnifrakturMaguntia_Regular27pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular27pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular27pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR27PT7B_H_
