#ifndef _UNIFRAKTURMAGUNTIA_REGULAR16PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xB4, 0x92, 0x01, 0xA0, 0x4B, 0xF4, 0x92, 0x2C, 0x53, 0xFB,
  0x44, 0x9F, 0x92, 0x2C, 0x50, 0x23, 0xA5, 0x18, 0xF1, 0xD3, 0x8C, 0x64,
  0xC2, 0x00, 0x70, 0x6B, 0x0B, 0x62, 0x6C, 0x85, 0xA0, 0xEB, 0x82, 0x58,
  0x9B, 0x23, 0x64, 0x2D, 0x07, 0x00, 0x38, 0x68, 0x68, 0x70, 0x77, 0xB2,
  0x9C, 0x9C, 0xCC, 0xF7, 0x5D, 0x20, 0x16, 0x44, 0xCC, 0xCC, 0xCC, 0x44,
  0x30, 0x84, 0x22, 0x33, 0x33, 0x33, 0x22, 0xC0, 0x01, 0xBA, 0x6F, 0x98,
  0x00, 0x21, 0x3E, 0x42, 0x10, 0x5D, 0x20, 0x78, 0x3C, 0x5C, 0x01, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x38,
  0xC9, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0x66, 0xC8, 0xE0, 0x11, 0x9D, 0x63,
  0x18, 0xC6, 0x31, 0x9E, 0x3C, 0x9A, 0x18, 0x30, 0x41, 0x86, 0x08, 0x22,
  0xFF, 0xF8, 0x3C, 0x9C, 0x18, 0x20, 0x87, 0xC1, 0xA3, 0xC6, 0x88, 0xE0,
  0x08, 0x30, 0x61, 0x44, 0x89, 0x22, 0x7F, 0x08, 0x18, 0xF8, 0x44, 0xF9,
  0x02, 0x07, 0xCF, 0xD1, 0x83, 0x83, 0x8D, 0x11, 0xC0, 0x18, 0x49, 0x9A,
  0x24, 0x1F, 0xB9, 0xE3, 0x46, 0xCD, 0x91, 0xC0, 0x7F, 0x08, 0x10, 0x20,
  0x81, 0x06, 0x08, 0x30, 0x61, 0x80, 0x3C, 0x85, 0x0B, 0x27, 0x89, 0x91,
  0xC1, 0xC2, 0x8C, 0xF0, 0x38, 0xD9, 0x1E, 0x3C, 0x78, 0xDF, 0x83, 0x06,
  0x89, 0xB1, 0xC0, 0x4B, 0x80, 0x17, 0x4B, 0x80, 0x17, 0x48, 0x12, 0xC2,
  0x10, 0xFC, 0x0F, 0xC0, 0x86, 0x36, 0x80, 0x7A, 0x28, 0xF2, 0x19, 0x8C,
  0x36, 0x70, 0x03, 0x08, 0x1E, 0x08, 0x44, 0x09, 0x3A, 0x9A, 0xAD, 0xAB,
  0x51, 0xFF, 0x61, 0x87, 0x80, 0x3E, 0x36, 0x3F, 0x20, 0xD9, 0x06, 0xC6,
  0x36, 0x19, 0x30, 0x51, 0x81, 0x0C, 0x1C, 0x63, 0x77, 0xC1, 0xCC, 0x18,
  0x61, 0xFA, 0xC4, 0x73, 0x20, 0xC6, 0x83, 0x12, 0x0D, 0xC6, 0xAB, 0x85,
  0x03, 0x08, 0x0C, 0x78, 0x22, 0x70, 0x80, 0xFC, 0x09, 0x06, 0xBD, 0x9A,
  0x34, 0x06, 0xC0, 0xDC, 0x19, 0xC3, 0x1C, 0x71, 0x06, 0x40, 0xF0, 0x87,
  0xE0, 0x06, 0x01, 0xFE, 0x1C, 0x78, 0x88, 0xE8, 0xC3, 0x47, 0x0A, 0x1C,
  0x49, 0x62, 0x32, 0x10, 0xE0, 0x8F, 0x88, 0x8F, 0x80, 0x00, 0x00, 0x09,
  0x06, 0xBD, 0x9A, 0x34, 0x04, 0xC8, 0xDF, 0xD9, 0xD3, 0x1C, 0x61, 0x06,
  0x40, 0xF0, 0x87, 0xE0, 0x1F, 0x03, 0xFC, 0x41, 0xF8, 0x28, 0x86, 0x48,
  0x77, 0x43, 0xA3, 0x98, 0x31, 0xC1, 0x0C, 0x30, 0xC3, 0x08, 0x11, 0x00,
  0xE0, 0x00, 0x03, 0xFC, 0x22, 0xE6, 0xC6, 0x6C, 0x86, 0xDE, 0xE6, 0x76,
  0x33, 0x63, 0x37, 0x22, 0x34, 0x21, 0xFC, 0x00, 0x01, 0xE0, 0x4E, 0x18,
  0x03, 0x18, 0x77, 0x87, 0x38, 0x63, 0x0E, 0x64, 0x8F, 0xD1, 0x9C, 0x20,
  0x08, 0x0E, 0x00, 0x1E, 0x0C, 0x71, 0x07, 0x20, 0x84, 0x10, 0x43, 0x07,
  0x60, 0x0E, 0x00, 0xC0, 0x09, 0xE1, 0x4E, 0x40, 0xF0, 0x1E, 0x0C, 0x71,
  0x07, 0x20, 0x84, 0x10, 0x83, 0x0F, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x27, 0x85, 0x39, 0x03, 0xC0, 0x07, 0xE0, 0xC8, 0x85, 0xF4, 0x71,
  0xA1, 0x87, 0x8E, 0x48, 0x37, 0x81, 0xD8, 0x24, 0x67, 0xA3, 0x0E, 0x0E,
  0x3F, 0x30, 0x98, 0x6C, 0x37, 0x11, 0xB0, 0x40, 0x40, 0x30, 0x7E, 0xC7,
  0xC0, 0x3C, 0xEE, 0x27, 0xB9, 0xA1, 0xCC, 0xD0, 0x66, 0x38, 0x11, 0x13,
  0xC8, 0x90, 0x24, 0x58, 0x02, 0x2C, 0x02, 0x26, 0x3E, 0xF3, 0xC7, 0xB0,
  0xC0, 0x00, 0x00, 0x3C, 0xF1, 0x3C, 0xC8, 0x31, 0xA0, 0xC7, 0x81, 0x11,
  0xE4, 0x80, 0x92, 0x00, 0x58, 0x12, 0x71, 0xE8, 0xF1, 0xC1, 0x00, 0x07,
  0x01, 0xFC, 0x60, 0xE4, 0x06, 0x60, 0x27, 0x82, 0x1C, 0x20, 0x82, 0x70,
  0x2B, 0xC4, 0x0F, 0x80, 0x3C, 0x61, 0x3F, 0x88, 0x67, 0x20, 0xCE, 0x83,
  0x1D, 0xAC, 0x31, 0x30, 0x40, 0xC2, 0x06, 0x08, 0x3E, 0x40, 0x3E, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x07, 0x01, 0xFC, 0x60, 0xE4, 0x06, 0x60,
  0x27, 0x82, 0x1C, 0x20, 0x82, 0x71, 0xEB, 0xCF, 0x0F, 0x60, 0x00, 0x00,
  0x00, 0x7C, 0xE1, 0xBE, 0xE4, 0x18, 0xC8, 0x10, 0xD0, 0x32, 0x10, 0x78,
  0x1C, 0x98, 0x01, 0x30, 0x22, 0x70, 0xE8, 0x70, 0xE0, 0xC0, 0x0F, 0x23,
  0x3C, 0x40, 0x04, 0x00, 0x43, 0xED, 0xF2, 0xC6, 0x16, 0x01, 0x70, 0x23,
  0xFC, 0x0F, 0x80, 0x3E, 0x04, 0x78, 0x85, 0xF8, 0xC0, 0x8E, 0x07, 0x70,
  0x03, 0x07, 0x10, 0x3A, 0x01, 0xE2, 0x07, 0xC0, 0x38, 0x6C, 0xB9, 0x82,
  0x38, 0x43, 0x88, 0x31, 0x04, 0x21, 0x06, 0x31, 0xDF, 0x5C, 0x73, 0x00,
  0x00, 0x00, 0x00, 0xFB, 0xC4, 0x73, 0x20, 0xC6, 0x83, 0x12, 0x0C, 0xC7,
  0xA3, 0x01, 0x0E, 0x0C, 0x18, 0xF8, 0x20, 0x71, 0x00, 0xF8, 0x3F, 0xFE,
  0x23, 0xA3, 0x20, 0xD0, 0xD0, 0x6C, 0x48, 0x36, 0x62, 0x53, 0xB8, 0xC8,
  0xCE, 0x08, 0x43, 0x3C, 0x31, 0x07, 0x3C, 0x81, 0xE7, 0x80, 0x00, 0x0F,
  0x9D, 0x1D, 0x43, 0x08, 0x20, 0x8F, 0x8F, 0xE0, 0x10, 0x07, 0x00, 0xE0,
  0xEF, 0xFC, 0xE0, 0x00, 0x41, 0xF7, 0x91, 0xCD, 0x06, 0x78, 0x31, 0x41,
  0x91, 0xE8, 0xC0, 0x4E, 0x04, 0x38, 0x20, 0xC3, 0xE6, 0x2E, 0x31, 0x03,
  0x04, 0x30, 0x1E, 0x00, 0x1F, 0x08, 0x62, 0x08, 0x82, 0x31, 0x00, 0xE0,
  0xDC, 0x03, 0x00, 0xC8, 0x1F, 0x04, 0x62, 0x0F, 0x00, 0xFB, 0x6D, 0xB6,
  0xDB, 0x6E, 0x00, 0xC0, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x00, 0xED, 0xB6, 0xDB, 0x6D, 0xBE, 0x10, 0xE6, 0xA1,
  0xFE, 0xA4, 0x10, 0x79, 0x32, 0x6C, 0xC9, 0x9B, 0x9A, 0x31, 0x41, 0x83,
  0x47, 0xCC, 0xD9, 0xB3, 0x64, 0xF0, 0x40, 0x00, 0x32, 0xD5, 0x8C, 0x21,
  0x87, 0xC1, 0x81, 0xC1, 0xE2, 0xCC, 0xD8, 0xB1, 0x64, 0xE8, 0x60, 0x32,
  0xD3, 0xAE, 0x21, 0x87, 0x23, 0xE0, 0x8F, 0x31, 0x8C, 0x63, 0x10, 0x84,
  0x21, 0x00, 0x10, 0x79, 0x1A, 0x2C, 0xC9, 0x99, 0x1F, 0x06, 0x89, 0xE0,
  0xB8, 0xC1, 0x83, 0x47, 0xCC, 0xD9, 0xB3, 0x66, 0xE8, 0x90, 0x41, 0x0C,
  0x00, 0x66, 0x04, 0xF6, 0x66, 0x67, 0x20, 0x31, 0x80, 0x4F, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x64, 0x9D, 0x5E, 0xCF, 0xB1, 0x8C, 0x63, 0x8C, 0xBD,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x88, 0x6D, 0x9E, 0xD8, 0x93, 0x12, 0x62,
  0x4C, 0x49, 0x99, 0xB9, 0xE2, 0x4C, 0x7E, 0xA6, 0x26, 0x26, 0x26, 0x67,
  0x36, 0x19, 0xE4, 0xD1, 0x45, 0x1E, 0x8C, 0x01, 0x03, 0xA3, 0xE6, 0x6C,
  0xD9, 0xB2, 0xF8, 0x60, 0x81, 0x04, 0x00, 0x10, 0xF9, 0x36, 0x6C, 0xD9,
  0x9B, 0x1E, 0x0C, 0x08, 0x20, 0x6B, 0xE6, 0x98, 0x61, 0x87, 0x8C, 0x18,
  0x13, 0x57, 0xC9, 0xE6, 0xD1, 0xF8, 0x40, 0x11, 0x19, 0xF6, 0x31, 0x8C,
  0x71, 0x80, 0x64, 0xEE, 0x26, 0x26, 0x26, 0x26, 0x7F, 0x36, 0x81, 0x13,
  0xF3, 0x32, 0x64, 0xD1, 0x3C, 0x30, 0xC0, 0x0C, 0x91, 0xFF, 0x13, 0x22,
  0x66, 0x4C, 0x89, 0x93, 0x3C, 0x31, 0x00, 0x6A, 0xF3, 0x8C, 0x30, 0xC3,
  0x9C, 0x82, 0x07, 0x80, 0x41, 0x03, 0xB3, 0xE2, 0x64, 0xC9, 0x93, 0x76,
  0x48, 0x20, 0x82, 0x00, 0x37, 0x84, 0x57, 0x2D, 0x73, 0x8C, 0x9C, 0x39,
  0x08, 0x42, 0x23, 0x04, 0x21, 0x08, 0x70, 0xFF, 0xF8, 0xE1, 0x08, 0x42,
  0x08, 0xE4, 0x21, 0x09, 0x80, 0xFC,
};

const GFXglyph UnifrakturMaguntia_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 12, 4, 0, -12 },
  { 6, 6, 4, 6, 0, -11 },
  { 9, 7, 9, 8, 1, -10 },
  { 17, 5, 13, 7, 1, -12 },
  { 26, 11, 11, 11, 0, -11 },
  { 42, 8, 10, 9, 1, -10 },
  { 52, 3, 4, 3, 0, -11 },
  { 54, 4, 13, 4, 0, -13 },
  { 61, 4, 13, 4, 0, -13 },
  { 68, 5, 7, 6, 0, -12 },
  { 73, 5, 6, 6, 1, -8 },
  { 77, 3, 4, 3, 0, -2 },
  { 79, 5, 3, 5, 0, -6 },
  { 81, 3, 2, 3, 0, -2 },
  { 82, 8, 13, 8, 0, -12 },
  { 95, 7, 11, 8, 0, -11 },
  { 105, 5, 11, 5, 0, -11 },
  { 112, 7, 11, 7, 0, -11 },
  { 122, 7, 11, 7, 0, -11 },
  { 132, 7, 11, 7, 0, -11 },
  { 142, 7, 12, 7, 0, -12 },
  { 153, 7, 12, 7, 0, -12 },
  { 164, 7, 11, 7, 0, -11 },
  { 174, 7, 11, 7, 0, -11 },
  { 184, 7, 12, 7, 0, -12 },
  { 195, 3, 8, 3, 0, -8 },
  { 198, 3, 10, 3, 0, -8 },
  { 202, 4, 5, 5, 0, -7 },
  { 205, 6, 3, 6, 0, -6 },
  { 208, 4, 5, 5, 0, -7 },
  { 211, 6, 12, 7, 1, -12 },
  { 220, 10, 10, 10, 0, -8 },
  { 233, 13, 11, 13, 0, -11 },
  { 251, 14, 12, 14, 0, -12 },
  { 272, 11, 12, 11, 0, -12 },
  { 289, 13, 13, 13, 0, -12 },
  { 311, 11, 12, 11, 0, -12 },
  { 328, 12, 14, 12, 0, -12 },
  { 349, 12, 12, 12, 0, -12 },
  { 367, 11, 14, 12, 0, -12 },
  { 387, 11, 13, 11, 0, -11 },
  { 405, 11, 15, 11, 0, -11 },
  { 426, 13, 11, 13, 0, -11 },
  { 444, 9, 11, 9, 0, -11 },
  { 457, 17, 12, 18, 0, -11 },
  { 483, 14, 11, 14, 0, -11 },
  { 503, 12, 11, 12, 0, -11 },
  { 520, 14, 14, 14, 0, -11 },
  { 545, 12, 12, 13, 0, -11 },
  { 563, 15, 12, 15, 0, -12 },
  { 586, 12, 11, 12, 0, -11 },
  { 603, 12, 11, 12, 0, -11 },
  { 620, 11, 12, 11, 0, -11 },
  { 637, 14, 12, 14, 0, -12 },
  { 658, 17, 11, 17, 0, -11 },
  { 682, 11, 12, 12, 0, -12 },
  { 699, 13, 15, 14, 0, -12 },
  { 724, 10, 13, 11, 0, -11 },
  { 741, 3, 13, 3, 0, -12 },
  { 746, 10, 11, 2, -3, -10 },
  { 760, 3, 13, 3, 0, -12 },
  { 765, 6, 4, 7, 0, -11 },
  { 768, 7, 1, 7, 0, 2 },
  { 769, 2, 3, 8, 3, -11 },
  { 770, 7, 8, 7, 0, -8 },
  { 777, 7, 12, 7, 0, -11 },
  { 788, 5, 8, 6, 0, -8 },
  { 793, 7, 11, 7, 0, -11 },
  { 803, 5, 8, 6, 0, -8 },
  { 808, 5, 15, 4, 0, -12 },
  { 818, 7, 11, 7, 0, -8 },
  { 828, 7, 14, 7, 0, -11 },
  { 841, 4, 11, 4, 0, -11 },
  { 847, 5, 14, 4, -1, -11 },
  { 856, 5, 11, 5, 0, -11 },
  { 863, 5, 11, 4, 0, -11 },
  { 870, 11, 8, 11, 0, -8 },
  { 881, 8, 8, 8, 0, -8 },
  { 889, 6, 8, 7, 0, -8 },
  { 895, 7, 13, 7, 0, -10 },
  { 907, 7, 11, 7, 0, -8 },
  { 917, 6, 8, 6, 0, -8 },
  { 923, 6, 10, 7, 0, -10 },
  { 931, 5, 10, 5, 0, -10 },
  { 938, 8, 8, 8, 0, -8 },
  { 946, 7, 9, 7, 0, -9 },
  { 954, 11, 9, 11, 0, -9 },
  { 967, 6, 11, 6, 0, -8 },
  { 976, 7, 13, 8, 0, -10 },
  { 988, 5, 11, 5, 0, -8 },
  { 995, 5, 12, 5, 0, -12 },
  { 1003, 1, 13, 3, 1, -12 },
  { 1005, 5, 12, 5, 0, -12 },
  { 1013, 6, 1, 6, 0, -5 },
};

const GFXfont UnifrakturMaguntia_Regular16pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular16pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular16pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR16PT7B_H_
