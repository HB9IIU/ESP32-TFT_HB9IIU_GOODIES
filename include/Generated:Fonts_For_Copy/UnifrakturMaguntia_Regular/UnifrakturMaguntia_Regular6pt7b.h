#ifndef _UNIFRAKTURMAGUNTIA_REGULAR6PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0xDF, 0xE0, 0xBF, 0x40, 0xDE, 0x3D, 0x4B, 0xF0, 0x80,
  0xF8, 0xF8, 0xE0, 0xB0, 0xC0, 0xC0, 0x80, 0x2A, 0x40, 0xD6, 0xE0, 0xAB,
  0xCD, 0x70, 0xE8, 0xE0, 0x4B, 0xB0, 0xD8, 0xE0, 0xFA, 0xE0, 0xE9, 0x40,
  0xDA, 0xE0, 0xD7, 0x60, 0xA0, 0xB0, 0xF0, 0xC0, 0xB0, 0xDD, 0x6E, 0xEF,
  0xFD, 0xB4, 0xF0, 0xFD, 0x56, 0x70, 0xFA, 0xA7, 0xF5, 0x5B, 0xE0, 0xFB,
  0xA7, 0xFB, 0x55, 0x60, 0xFD, 0xB7, 0x0E, 0x75, 0xD2, 0xFA, 0x59, 0x60,
  0xFA, 0x51, 0xD2, 0x72, 0xD5, 0xB0, 0xF7, 0x30, 0xFD, 0x59, 0xE7, 0xA0,
  0xFD, 0x9D, 0x90, 0xF9, 0x5F, 0xF5, 0x5A, 0xE2, 0x00, 0xF4, 0x95, 0xF0,
  0xFD, 0x5E, 0xD0, 0xFB, 0xD7, 0xFA, 0xE7, 0xD5, 0x9F, 0xFD, 0x92, 0x60,
  0xFE, 0xD5, 0x4F, 0xFB, 0x6F, 0xFD, 0x92, 0xD7, 0x00, 0xFA, 0x59, 0x60,
  0xF0, 0x34, 0x48, 0xF0, 0xC0, 0xE0, 0x80, 0x5B, 0x80, 0xDA, 0xE0, 0x6C,
  0x8A, 0xE0, 0x6C, 0xFA, 0x80, 0x5B, 0x60, 0xDA, 0xE8, 0xAA, 0xF8, 0xFB,
  0xEB, 0xFD, 0xB0, 0xFA, 0x80, 0xFC, 0x9A, 0xE8, 0x7D, 0xEC, 0x7F, 0xFB,
  0xBB, 0x80, 0xD7, 0x00, 0x8D, 0xBA, 0xE7, 0x9A, 0xE4, 0xEF, 0x6A, 0xC0,
  0xF8, 0xAB, 0x80, 0xC0,
};

const GFXglyph UnifrakturMaguntia_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 1, 0, -5 },
  { 13, 1, 5, 1, 0, -5 },
  { 14, 2, 2, 2, 0, -4 },
  { 15, 2, 2, 2, 0, -3 },
  { 16, 1, 2, 1, 0, -1 },
  { 17, 2, 1, 2, 0, -2 },
  { 18, 1, 1, 1, 0, -1 },
  { 19, 3, 4, 3, 0, -4 },
  { 21, 3, 4, 3, 0, -4 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 1, 3, 1, 0, -3 },
  { 41, 1, 4, 1, 0, -3 },
  { 42, 2, 2, 2, 0, -3 },
  { 43, 2, 1, 2, 0, -2 },
  { 44, 2, 2, 2, 0, -3 },
  { 45, 2, 4, 3, 0, -4 },
  { 46, 4, 4, 4, 0, -3 },
  { 48, 5, 4, 5, 0, -4 },
  { 51, 5, 4, 5, 0, -4 },
  { 54, 4, 4, 4, 0, -4 },
  { 56, 5, 4, 5, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 4, 5, 5, 0, -4 },
  { 64, 4, 4, 5, 0, -4 },
  { 66, 4, 6, 4, 0, -5 },
  { 69, 4, 5, 4, 0, -4 },
  { 72, 4, 6, 4, 0, -4 },
  { 75, 5, 4, 5, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 7, 4, 7, 0, -4 },
  { 84, 5, 4, 5, 0, -4 },
  { 87, 4, 4, 5, 0, -4 },
  { 89, 5, 5, 5, 0, -4 },
  { 93, 5, 4, 5, 0, -4 },
  { 96, 5, 4, 6, 0, -4 },
  { 99, 4, 4, 5, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 4, 4, 4, 0, -4 },
  { 105, 5, 4, 5, 0, -4 },
  { 108, 6, 4, 6, 0, -4 },
  { 111, 4, 4, 4, 0, -4 },
  { 113, 5, 5, 5, 0, -4 },
  { 117, 4, 5, 4, 0, -4 },
  { 120, 1, 4, 1, 0, -4 },
  { 121, 4, 4, 1, -1, -4 },
  { 123, 1, 4, 1, 0, -4 },
  { 124, 2, 1, 3, 0, -4 },
  { 125, 3, 1, 3, 0, 0 },
  { 126, 1, 1, 3, 1, -4 },
  { 127, 3, 3, 3, 0, -3 },
  { 129, 3, 4, 3, 0, -4 },
  { 131, 2, 3, 2, 0, -3 },
  { 132, 3, 4, 3, 0, -4 },
  { 134, 2, 3, 2, 0, -3 },
  { 135, 2, 5, 1, 0, -4 },
  { 137, 3, 4, 3, 0, -3 },
  { 139, 3, 5, 3, 0, -4 },
  { 141, 2, 4, 2, 0, -4 },
  { 142, 1, 5, 1, 0, -4 },
  { 143, 2, 4, 2, 0, -4 },
  { 144, 2, 4, 2, 0, -4 },
  { 145, 4, 3, 4, 0, -3 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 2, 3, 2, 0, -3 },
  { 150, 3, 5, 3, 0, -4 },
  { 152, 2, 4, 3, 0, -3 },
  { 153, 2, 3, 2, 0, -3 },
  { 154, 2, 4, 3, 0, -4 },
  { 155, 2, 4, 2, 0, -4 },
  { 156, 3, 3, 3, 0, -3 },
  { 158, 3, 3, 3, 0, -3 },
  { 160, 4, 4, 4, 0, -4 },
  { 162, 2, 4, 2, 0, -3 },
  { 163, 3, 5, 3, 0, -4 },
  { 165, 2, 4, 2, 0, -3 },
  { 166, 2, 5, 2, 0, -5 },
  { 168, 1, 5, 1, 0, -5 },
  { 169, 2, 5, 2, 0, -5 },
  { 171, 2, 1, 2, 0, -2 },
};

const GFXfont UnifrakturMaguntia_Regular6pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular6pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular6pt7bGlyphs,
  0x20, 0x7E, 6
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR6PT7B_H_
