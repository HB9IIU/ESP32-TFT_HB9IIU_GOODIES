#ifndef _UNIFRAKTURMAGUNTIA_REGULAR65PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x00, 0x40, 0x0E, 0x01, 0xF0, 0x3F, 0x8F, 0xFE, 0xFF, 0xE7,
  0xFC, 0x7F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00,
  0xE0, 0x1F, 0x03, 0xF8, 0x7F, 0xE3, 0xF8, 0x1F, 0x00, 0xE0, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x30, 0x03, 0x01, 0xE0, 0x1E, 0x0F, 0xC0, 0xFC,
  0x7F, 0x87, 0xFF, 0xFF, 0x3F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF0, 0x3F, 0x0F,
  0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1C, 0x06, 0x00,
  0x70, 0x18, 0x01, 0x80, 0x40, 0x04, 0x03, 0x00, 0x30, 0x08, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x03, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xC1, 0xE0, 0x1E, 0x01, 0xC0, 0x78,
  0x01, 0xC0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x8F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFE, 0x00, 0xF9, 0xFE, 0x01,
  0xE1, 0xFE, 0x01, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x3C,
  0x01, 0xFE, 0x78, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x1C, 0x00,
  0x3C, 0x38, 0x00, 0x78, 0x38, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x3E, 0x3E,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x7C,
  0xF0, 0x00, 0x00, 0x0E, 0x1F, 0x0F, 0x00, 0x00, 0x03, 0x83, 0xE1, 0xF0,
  0x00, 0x00, 0xE0, 0xF8, 0x3F, 0x00, 0x00, 0x38, 0x1F, 0x07, 0xE0, 0x00,
  0x07, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x70,
  0x1F, 0x81, 0xF8, 0x00, 0x1C, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x1F,
  0x80, 0x0E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x83, 0xF0, 0x0E, 0x00,
  0x01, 0xF0, 0x7E, 0x03, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0xE0, 0x00, 0x03,
  0xE1, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x07, 0x00, 0x00, 0x03, 0xFE,
  0x01, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x70, 0x3F, 0xE0, 0x00, 0x00, 0x1C,
  0x0F, 0x1E, 0x00, 0x00, 0x07, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xC0, 0xF8,
  0x3E, 0x00, 0x00, 0x70, 0x1F, 0x07, 0xC0, 0x00, 0x0E, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0x80, 0xFC, 0x1F, 0x80, 0x00, 0xE0, 0x3F, 0x83, 0xF0, 0x00,
  0x38, 0x07, 0xF0, 0x7E, 0x00, 0x0E, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3C, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0x00, 0x0F, 0xE0, 0xFC, 0x01, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x70, 0x00, 0x1F, 0x83, 0xF0, 0x1C, 0x00, 0x03, 0xF0, 0x7C, 0x07,
  0x00, 0x00, 0x3E, 0x0F, 0x81, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x70, 0x00,
  0x00, 0x3C, 0x78, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x01, 0xF8, 0x1E, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x1F, 0xC1, 0xE0,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x00, 0x7F, 0x9C,
  0x00, 0x00, 0x0F, 0xEE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x0F,
  0xFE, 0x00, 0xF0, 0x07, 0xBF, 0xC0, 0x3C, 0x03, 0xCF, 0xF0, 0x0E, 0x01,
  0xE1, 0xFE, 0x01, 0x80, 0xF8, 0x7F, 0x80, 0xE0, 0x3E, 0x1F, 0xF0, 0x30,
  0x1F, 0x03, 0xFC, 0x0C, 0x07, 0xC0, 0xFF, 0x83, 0x03, 0xF0, 0x1F, 0xE1,
  0x80, 0xFE, 0x07, 0xFC, 0x60, 0x3F, 0x80, 0xFF, 0x30, 0x0F, 0xE0, 0x3F,
  0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x09, 0xFE, 0x01, 0xFF, 0x8F, 0x3F,
  0xC0, 0x3F, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0xFF, 0xE0,
  0x1F, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x04, 0x03, 0x81,
  0xE0, 0xFC, 0x7F, 0xFF, 0xF1, 0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0x38, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x10, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x0C, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x1E, 0x00,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x33, 0xF3, 0x0F, 0xC7, 0x9F, 0xDF, 0x9E, 0x7E,
  0x7E, 0x31, 0xF9, 0xFC, 0xCF, 0xC3, 0xFB, 0x7F, 0x0E, 0xFF, 0xFC, 0x00,
  0x78, 0x00, 0x83, 0xF0, 0x47, 0xFB, 0xFF, 0x1F, 0xCD, 0xFC, 0x7E, 0x33,
  0xF9, 0xF8, 0xC7, 0xEF, 0xE7, 0x9F, 0x83, 0x3F, 0x71, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x04, 0x00, 0xC0, 0x38, 0x0F, 0x83, 0xFC, 0xFF, 0xCF,
  0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x08, 0x01,
  0x80, 0x38, 0x0F, 0x87, 0xF9, 0xFF, 0x8F, 0xE0, 0xF8, 0x0E, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFE,
  0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0,
  0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE1,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xDF,
  0xE0, 0x61, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xE1, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0x07, 0xFF, 0x0F, 0x00, 0x3F, 0xE1, 0xC0, 0x03, 0xFE, 0x78,
  0x00, 0x7F, 0xCE, 0x00, 0x07, 0xF9, 0x80, 0x00, 0xFF, 0x30, 0x00, 0x1F,
  0xF6, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x00, 0xF0, 0x00, 0x60,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x70, 0x00,
  0x06, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0xF0, 0x3F, 0xF0, 0x1C, 0x00, 0xFF, 0x83, 0x80, 0x07, 0xFC, 0x30, 0x00,
  0x3F, 0xC2, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x7E, 0xFF, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x7C, 0x7F, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0xF8, 0x3F, 0x80, 0x1F,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1B, 0xF8, 0x00, 0x03,
  0x3F, 0x80, 0x00, 0x33, 0xF8, 0x00, 0x06, 0x3F, 0x80, 0x00, 0xE3, 0xF8,
  0x00, 0x0C, 0x3F, 0x80, 0x01, 0x83, 0xF8, 0x00, 0x18, 0x3F, 0x80, 0x03,
  0x03, 0xF8, 0x00, 0x60, 0x3F, 0x80, 0x06, 0x03, 0xF8, 0x00, 0xC0, 0x3F,
  0x80, 0x18, 0x03, 0xF8, 0x01, 0x80, 0x3F, 0x80, 0x30, 0x03, 0xF8, 0x06,
  0x00, 0x3F, 0x80, 0x60, 0x03, 0xF8, 0x0C, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0xFC, 0x00, 0x0D, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0xFF, 0xC1, 0xE0, 0x03,
  0xFE, 0x1C, 0x00, 0x1F, 0xE3, 0x00, 0x00, 0xFF, 0x20, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFF, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x7E, 0x7F, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0x83, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0xF0, 0x1F, 0x80, 0x1E, 0x03, 0xF0, 0x07,
  0x80, 0x7F, 0x01, 0xF0, 0x0F, 0xF0, 0x3E, 0x01, 0xFE, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xC3, 0xF8,
  0x00, 0x20, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xF0, 0x3F, 0xCC,
  0x7F, 0x87, 0xFB, 0x03, 0xF8, 0xFF, 0x40, 0x7F, 0x1F, 0xF8, 0x07, 0xF3,
  0xFE, 0x00, 0xFE, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00,
  0x7F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01,
  0xFD, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F,
  0x00, 0x1F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xF8, 0x0F, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x01, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x3C, 0x3F,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x78, 0x3F, 0xE0, 0x07, 0x83, 0xFF, 0x80,
  0xF0, 0x1F, 0xFC, 0x1E, 0x01, 0xFF, 0xF3, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x19, 0xFF, 0xF0, 0x07, 0x07, 0xFF, 0x80, 0xE0, 0x1F, 0xFC,
  0x1E, 0x00, 0xFF, 0xC3, 0xC0, 0x03, 0xFC, 0x3C, 0x00, 0x1F, 0xE7, 0x80,
  0x00, 0xFE, 0x78, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7C, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x87, 0xE0, 0x01, 0xE0, 0x7E, 0x00,
  0x78, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0x3F,
  0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF0, 0x03, 0xFE, 0xFE, 0x00, 0x7F,
  0xDF, 0xE0, 0x1F, 0xF9, 0xFC, 0x02, 0xFF, 0x3F, 0x80, 0xDF, 0xE3, 0xF8,
  0x33, 0xFC, 0x3F, 0xDC, 0x7F, 0x83, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x81, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x87,
  0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0x81, 0xFC, 0x03,
  0xE0, 0x3F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x00, 0x3F, 0x03, 0xC0, 0x03,
  0xF0, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x01,
  0x80, 0x38, 0x0F, 0x87, 0xF9, 0xFF, 0x8F, 0xE0, 0xF8, 0x0E, 0x01, 0x80,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x70, 0x1F, 0x0F, 0xF3, 0xFF, 0x1F,
  0xC1, 0xF0, 0x1C, 0x01, 0x00, 0x00, 0x04, 0x00, 0x60, 0x07, 0x00, 0xF8,
  0x3F, 0xC7, 0xFE, 0x1F, 0xC0, 0xF8, 0x07, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x06, 0x00, 0xE0, 0x1F, 0x03, 0xFC, 0x7F, 0xE3, 0xFE,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x1F, 0x83, 0x80, 0x07, 0xE3, 0xC0, 0x03, 0xF9, 0xC0, 0x00, 0xFD, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x02, 0x01, 0xF0, 0x03, 0x00, 0xF8, 0x01, 0x80, 0x3C, 0x00, 0x80, 0x1F,
  0x00, 0xC0, 0x07, 0xE1, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x7C, 0x00, 0xFB, 0xE3, 0x83, 0xE0, 0x0F, 0xFF, 0x8F, 0x0F,
  0x80, 0x7C, 0xFE, 0x3C, 0x3C, 0x03, 0xC3, 0xF0, 0xF1, 0xF0, 0x1F, 0x0F,
  0xC1, 0xC7, 0x80, 0xF8, 0x3F, 0x0F, 0x1E, 0x07, 0xE0, 0xF8, 0x3C, 0xF8,
  0x3F, 0x03, 0xE0, 0xF3, 0xE0, 0xFC, 0x1F, 0x83, 0xCF, 0x87, 0xE0, 0x7C,
  0x0F, 0x3C, 0x1F, 0x81, 0xF0, 0x78, 0xF0, 0x7C, 0x0F, 0xC1, 0xE3, 0xC3,
  0xF0, 0x3F, 0x07, 0x8F, 0x0F, 0xC1, 0xF8, 0x3C, 0x3E, 0x3F, 0x0F, 0xE1,
  0xF0, 0xF8, 0xFC, 0x7F, 0x8F, 0x81, 0xE3, 0xF3, 0xFE, 0x7C, 0x07, 0x87,
  0xFF, 0xFF, 0xE3, 0xDE, 0x0F, 0xF3, 0xFF, 0x0E, 0x3C, 0x1F, 0x07, 0xE0,
  0x78, 0xF0, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x1C, 0x01, 0xFF,
  0xE0, 0x1F, 0xF0, 0x07, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xC0, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x30, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x0E, 0x00,
  0x00, 0xFF, 0x81, 0xFE, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x30,
  0x00, 0x01, 0xFF, 0x07, 0xF8, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x01,
  0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x38, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x07, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x78, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0x80,
  0x7C, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0x01, 0xFE,
  0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x3F, 0xC0, 0x00, 0x06, 0x07, 0x80, 0x07, 0xF8, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x38, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0E, 0x7F,
  0xFE, 0x03, 0x7F, 0xE6, 0x00, 0x03, 0xFF, 0xF1, 0xC7, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xE1, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFD, 0x80,
  0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFD, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3C,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x70, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0xFF, 0xF0, 0x1E,
  0x00, 0x10, 0x3E, 0x3F, 0xFF, 0xF8, 0x0F, 0x00, 0x30, 0x7C, 0x7F, 0xFF,
  0xFC, 0x07, 0xE0, 0xE0, 0x78, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x70,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x20, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0xC7, 0xFF, 0xB0, 0x3E, 0x00,
  0x27, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0xFF,
  0xF8, 0x1F, 0x80, 0x0C, 0x0F, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0xF0, 0x0F,
  0xC0, 0x3C, 0x00, 0x10, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x3F,
  0xF8, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xC8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0x00, 0x01,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x30, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x1C, 0x01, 0xFF, 0xE0, 0x3E, 0x00,
  0x1E, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x7F, 0xE1, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x70,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xCF,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF3, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFE,
  0x60, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x98, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xE6, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0x70, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xCC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xF3, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x60, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xE0, 0x3F, 0x3C, 0x0F, 0xE0, 0x00, 0x38, 0x01, 0xFE, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x1C, 0x0F, 0xFF, 0xFF, 0x9F, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07,
  0x00, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xC1, 0xFF, 0x00,
  0x07, 0xC0, 0x18, 0xFF, 0xF6, 0x03, 0xE0, 0x02, 0x7F, 0xFF, 0x80, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0x00, 0x18,
  0x1F, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0xE0, 0x1E, 0x00, 0x08,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xFE, 0x01,
  0xE0, 0x1F, 0xC1, 0xFF, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0x8F, 0xF3, 0xFE, 0x01, 0xFF,
  0xF1, 0xF8, 0xFF, 0x80, 0x3F, 0xFE, 0x1C, 0x3F, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x00,
  0x3F, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x01, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0x00, 0x07, 0xFF, 0x90,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0x80, 0x00,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x01, 0xE0, 0x00, 0x01, 0x87, 0xF8, 0x03, 0x80, 0x00, 0x06, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xC0, 0x06, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x1E, 0x0E,
  0x00, 0x01, 0xFF, 0x80, 0x7E, 0x0C, 0x00, 0x01, 0xFF, 0x81, 0xFE, 0x1C,
  0x00, 0x03, 0xFF, 0x83, 0xFE, 0x18, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x38,
  0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x0F, 0xFF, 0x1F, 0x80, 0x3C, 0x07, 0x8F, 0xFE, 0x0E, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x08, 0x00, 0x01, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0x80,
  0x00, 0x01, 0xF0, 0x70, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x61, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x8F, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0x7F, 0xF8, 0x00,
  0x3E, 0x00, 0x06, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xE0, 0x0F,
  0xC0, 0x03, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x18, 0x03, 0xFF, 0x81, 0xF8,
  0x01, 0xC0, 0x07, 0xFF, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xF8, 0x3F, 0x80,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x00, 0x3C, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x70, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFC, 0x07, 0xFE, 0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x3F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFB, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xDF,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0xFF,
  0x80, 0x07, 0xE0, 0x07, 0xF3, 0xFE, 0x00, 0x0F, 0x80, 0x1F, 0x87, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x3F, 0xE0,
  0x0E, 0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0x70, 0x00, 0x3F, 0x01, 0xFF, 0x03,
  0x00, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x30,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x38, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xE3, 0xCF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x70,
  0x03, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0xF0, 0xFF, 0x80,
  0x78, 0x00, 0x3F, 0x8F, 0xFE, 0x03, 0x80, 0x01, 0xFC, 0xFF, 0xF8, 0x1C,
  0x00, 0x0F, 0xCD, 0xFF, 0xE0, 0xC0, 0x00, 0x7E, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xF1, 0x83, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x78, 0x00, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x70,
  0x00, 0x07, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x8F, 0xF8, 0x00, 0x07, 0xF3, 0xF3, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0x00, 0x03,
  0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x3F, 0xFF, 0xC0, 0x00, 0x1E, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0x8C, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x80,
  0x18, 0x00, 0x00, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xF1, 0x80, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x7F, 0xFE, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x1C, 0x00,
  0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x70,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x00,
  0x33, 0xFE, 0x00, 0x00, 0x7C, 0x1E, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x0E, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xE0, 0xC1, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0xFF, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x7F, 0xFE, 0x03, 0xC0, 0x03,
  0xF0, 0x7F, 0xFF, 0xC0, 0x70, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1E, 0x00,
  0x3F, 0x0F, 0x07, 0xFE, 0x03, 0x80, 0x1F, 0xC3, 0x00, 0xFF, 0xC0, 0xE0,
  0x07, 0xF0, 0x80, 0x1F, 0xF0, 0x3C, 0x01, 0xFC, 0x60, 0x03, 0xFE, 0x0F,
  0x00, 0x7F, 0x98, 0x00, 0xFF, 0x83, 0xC0, 0x1F, 0xE4, 0x00, 0x3F, 0xF0,
  0xF0, 0x07, 0xFD, 0x00, 0x07, 0xFC, 0x3C, 0x01, 0xFF, 0x40, 0x01, 0xFF,
  0xCF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE3, 0x80, 0x0F, 0xFE, 0x00, 0x07,
  0xE0, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x7F, 0xF0, 0x00,
  0x60, 0x18, 0x00, 0x1F, 0xFC, 0x00, 0x70, 0x0C, 0x00, 0x03, 0xFF, 0x80,
  0x7C, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xC7, 0x00, 0x00, 0x1F, 0xFC,
  0x3F, 0xF1, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x04,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0xE0, 0x03,
  0xFC, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x70, 0x01, 0xFF, 0x01,
  0xFF, 0xF0, 0x18, 0x00, 0x7F, 0xC0, 0xFF, 0xFE, 0x0C, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC6, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7C, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x80,
  0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xC0, 0x00, 0x7E,
  0x1F, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xF0, 0x00,
  0x7E, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xFE,
  0x7F, 0xF8, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x9F, 0xFF, 0xF8, 0x00, 0x1F, 0x3F, 0xFF, 0xC0, 0x06, 0x00, 0xFF, 0xFE,
  0x03, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xE1, 0xDF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x30, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFE, 0x03, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xE0,
  0x78, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0xC0, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x88, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC8,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC8, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x30, 0x07, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x06, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x1C, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0x7F, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE1, 0xC0,
  0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC3, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x38, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0xE0, 0x00, 0x60, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0C, 0x7C, 0x06,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0x8F, 0xE0, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0xF8, 0x19, 0xFF, 0x08, 0x00, 0xFF, 0xE7, 0x1F, 0xFF, 0xC3, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE3, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x9C, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF1, 0x07, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x07, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x30, 0x1F, 0xF0,
  0x1F, 0x00, 0x7F, 0xFC, 0x80, 0x3F, 0xC0, 0x78, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0x81, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x0C, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xF8, 0x30, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC2, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x88,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xA0, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE3, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3E, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x01, 0xE3,
  0xFC, 0x01, 0xFC, 0x00, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x07, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0x01,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x08, 0x0C, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x00,
  0x80, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x1C, 0x00, 0x7F, 0xE0,
  0x83, 0xFF, 0xE0, 0xE0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0x00, 0x03,
  0xFF, 0xF0, 0xC3, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x00,
  0x00, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF9, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x07,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x38, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x06, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x18, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x83, 0xFF, 0xFC,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFC,
  0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xF7,
  0x3F, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xFE, 0x3F, 0xF0, 0x00, 0x70, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00,
  0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x0F,
  0xFF, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0xC0, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0xE0, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x60, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xFC, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x18, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFE, 0x0C, 0x00, 0x63, 0xFC, 0x00, 0x03, 0xFE,
  0x07, 0x81, 0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x79, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3E, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7E, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x08, 0x00, 0x07, 0x0E,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF3, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0xC7, 0xFE, 0x06, 0x83, 0xFF, 0xFC, 0x00,
  0x7F, 0xE3, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0x0F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE3, 0x01, 0xFF, 0x80, 0x3F, 0x83, 0xFF, 0xF9,
  0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0xFD, 0x80, 0x3F, 0xF0, 0x1E, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x0E, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x83, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF9, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFC, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x60, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x30, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xF0, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x0E, 0x00, 0x10,
  0x0F, 0xCF, 0xFC, 0x00, 0x03, 0xC0, 0x18, 0x07, 0xCF, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0xF0, 0x00, 0x01, 0x00, 0x03, 0x80, 0x0F, 0xF8, 0x00, 0x03,
  0xF0, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xC0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x1F, 0xFD, 0xC2, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x1F,
  0xFF, 0xFF, 0xC7, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x83, 0xE0, 0x20, 0x1F, 0xFF, 0xFF, 0x0F,
  0x80, 0xC1, 0xFF, 0xFF, 0xFE, 0x3E, 0x01, 0xFF, 0xFF, 0xF8, 0x3C, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x33, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x4F, 0x80,
  0x0F, 0xFF, 0x80, 0x01, 0xBF, 0x00, 0x1F, 0xF8, 0x00, 0x06, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x1B, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x2F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xBF, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x19, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x63, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x13, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x8F, 0xFF, 0xF9, 0x80, 0x00, 0x38, 0x1F, 0xFF,
  0x8C, 0x00, 0x03, 0x80, 0x7F, 0xF8, 0x60, 0x00, 0x3C, 0x00, 0xFF, 0x83,
  0x00, 0x03, 0xF0, 0x01, 0xF0, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x0D, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0xFC, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x70, 0x00, 0x00, 0x03, 0xFF,
  0xE6, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0,
  0x07, 0xC3, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x18, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x0C, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x0C, 0x0F, 0xFC, 0x00, 0xFE, 0x01, 0x81,
  0xFF, 0xC0, 0x0F, 0xE0, 0x30, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xBF, 0xC0, 0x63,
  0xFF, 0xE0, 0x73, 0xFE, 0x0C, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x18, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x60, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x80, 0x7F, 0xC0,
  0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0x80, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x01, 0xE0, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x03, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x86, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x38, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x70, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x07, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0x00, 0x08, 0x1F, 0x00,
  0x7F, 0x80, 0x07, 0x00, 0x70, 0x3C, 0x00, 0xFF, 0x80, 0x07, 0xC7, 0x80,
  0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x7F,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE1, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC1, 0xFC,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x71, 0xC6, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xCC, 0x0D, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xFF, 0xC0, 0x18, 0x00, 0xFF,
  0xC0, 0x3F, 0x00, 0x3F, 0xFC, 0x07, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0x81, 0xE0, 0x01, 0xFF, 0x81, 0xE0, 0x00, 0x1F, 0xF0, 0x3C, 0x00,
  0x1F, 0xF0, 0x3C, 0x00, 0x01, 0xFF, 0x0F, 0x80, 0x03, 0xFE, 0x07, 0x00,
  0x00, 0x3F, 0xE1, 0xF0, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x03, 0xFC, 0x3E,
  0x00, 0x07, 0xFF, 0x18, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0xE3,
  0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE0, 0x60, 0x00, 0x00, 0x7E,
  0x3F, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0F, 0xC7, 0xFC, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0xF8, 0xFF, 0x80, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x3F, 0x0F, 0xF8, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x07, 0xE1, 0xFF, 0x80,
  0x3E, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x06, 0x00,
  0x00, 0x1F, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0x60, 0x03, 0x83, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x07, 0x01, 0xC0, 0x78, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x1E, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0x00, 0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x06, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0xFC, 0x10, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xE1, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0xC7,
  0x3F, 0x83, 0xC0, 0x01, 0xFE, 0x60, 0xF0, 0x78, 0x00, 0x0F, 0xE4, 0x00,
  0x07, 0x80, 0x00, 0xFE, 0xC0, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x1C, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0x03, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xE3, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x09, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x9F, 0xF8, 0x00, 0x01, 0xF8, 0x18, 0xFF, 0xC0, 0x00, 0x3F,
  0xC3, 0x8F, 0xFE, 0x06, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0xC3, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xCC, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x40, 0x3F, 0xE0, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x81,
  0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF3, 0x80, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0x9C, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xE3, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x18,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x04, 0x0F,
  0x80, 0x3F, 0x00, 0x0E, 0x00, 0xC0, 0x7C, 0x03, 0xFC, 0x00, 0x1F, 0xFC,
  0x07, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x3E, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x1C, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xE1, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x08, 0xFF,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0xC0, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0x80, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x0F,
  0xC0, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x38, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0x87, 0xFF, 0x80, 0x00, 0x07, 0x87, 0xFF, 0xE0, 0x00, 0x03, 0xC7, 0xFF,
  0xF8, 0x00, 0x03, 0xC6, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0x80,
  0x00, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC1, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xC3, 0xF0, 0x0F,
  0x80, 0xF8, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x70,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x7C, 0x3F, 0x1F, 0x8F, 0xE3, 0xF0, 0xF8,
  0x3C, 0x0F, 0x03, 0x80, 0xC0, 0x30, 0x08, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xDF, 0xFE, 0x00, 0x18, 0xFF, 0xF8, 0x07,
  0x83, 0xFF, 0x00, 0xF0, 0x1F, 0xE0, 0x0F, 0x00, 0x7E, 0x01, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x21, 0xFF, 0x0F, 0xF6, 0x1F, 0xFF, 0x7F,
  0xC0, 0xFF, 0xE7, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x03, 0xF8, 0x01,
  0xE0, 0x1F, 0x00, 0x08, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xE0, 0x02, 0x01, 0xE0, 0x00, 0x20, 0x78, 0x00, 0x06,
  0x1E, 0x00, 0x00, 0x67, 0xC0, 0x00, 0x05, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x1F, 0xC0, 0x30, 0x03, 0xF8, 0x1E,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0xC0, 0x3F,
  0xE7, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0x83, 0xF8, 0x01, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0x81, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x3C, 0x07, 0xF0, 0x07, 0x80,
  0xFE, 0x01, 0xE0, 0x3F, 0xF0, 0x38, 0x0F, 0xFF, 0x0C, 0x01, 0xFF, 0xFB,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80,
  0x31, 0xFC, 0x03, 0x87, 0xF0, 0x38, 0x3F, 0x83, 0xC0, 0xFE, 0x1E, 0x07,
  0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF3, 0x83, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x06, 0x3F, 0xF0, 0x0F, 0x03, 0xFE,
  0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x1F, 0x1F, 0xC0, 0x07, 0xC7, 0xF0, 0x01, 0xF1, 0xFC, 0x00, 0x7C,
  0x7F, 0x00, 0x1E, 0x1F, 0xC0, 0x07, 0x87, 0xF0, 0x01, 0xE1, 0xFC, 0x00,
  0x70, 0x7F, 0x00, 0x3C, 0x1F, 0xE0, 0x0E, 0x0F, 0xFC, 0x03, 0x87, 0xFF,
  0xC1, 0xC0, 0x7F, 0xFC, 0x60, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xBF, 0x00,
  0x31, 0xFC, 0x03, 0x8F, 0xE0, 0x3C, 0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x07,
  0xF1, 0xF0, 0x3F, 0x8F, 0x81, 0xFC, 0x7C, 0x07, 0xF7, 0xE0, 0x3F, 0xBF,
  0x00, 0xF1, 0xF8, 0x1C, 0x0F, 0xC7, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF3, 0x83, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1,
  0x01, 0xFF, 0xB0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0x3F,
  0xC0, 0x60, 0x70, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0C, 0xFF, 0xF0,
  0x03, 0x87, 0xFF, 0xC0, 0x78, 0x3F, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xF0,
  0x03, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xE0, 0x3E, 0x00, 0x1E,
  0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03,
  0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F, 0xE1, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x3C, 0x01, 0xFC, 0x03, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x03, 0xF0, 0x01, 0xE0, 0x1F,
  0x80, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x0F, 0xC0, 0x70, 0x00, 0x7F, 0x3C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x3C, 0x00, 0x04, 0x1F, 0x00,
  0x00, 0x47, 0xC0, 0x00, 0x0C, 0xF8, 0x00, 0x00, 0xBF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x40, 0x03, 0xF8, 0x1C, 0x00, 0x7F,
  0x0F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00,
  0xF8, 0x1F, 0xC0, 0x1F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xF8, 0x1F,
  0xE2, 0x1F, 0x07, 0xFF, 0x83, 0xC0, 0x7F, 0xE0, 0x78, 0x07, 0xF8, 0x1E,
  0x00, 0x3E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF, 0xC6, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x87, 0xFB,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x0C, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x67, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xCC, 0x01, 0xF1, 0x00,
  0xF8, 0x60, 0x3C, 0x0C, 0x3C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xC2, 0x01, 0xE0, 0x20, 0x78, 0x02, 0x1F, 0x00, 0x67,
  0xC1, 0xC4, 0xF8, 0xF8, 0xFF, 0x1F, 0x0F, 0xE7, 0xE1, 0xFD, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xFA, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x60, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC2, 0x01, 0xE0, 0x20, 0x78,
  0x02, 0x1F, 0x00, 0x67, 0xC0, 0x05, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x60,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF,
  0x87, 0xFE, 0xCF, 0xF6, 0xFF, 0xF2, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x0F,
  0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0xC1, 0xFE, 0x07, 0xF1, 0x3F, 0xF8, 0xFF, 0xC1,
  0xFF, 0xC7, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0x1F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0x00, 0xE0,
  0x03, 0x00, 0x07, 0x80, 0x10, 0x00, 0xC0, 0x00, 0x40, 0x08, 0x00, 0x60,
  0x00, 0xF0, 0x03, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0x91, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xE2, 0x7F,
  0xF0, 0x7F, 0xB3, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0x00,
  0x7F, 0x80, 0xF0, 0x01, 0xFC, 0x03, 0x80, 0x07, 0xC0, 0x08, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0xC0, 0xFE,
  0x1F, 0xF0, 0x7F, 0x0F, 0xF8, 0x3F, 0x83, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFC,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x00,
  0xF8, 0xFE, 0x00, 0x78, 0x7F, 0x00, 0x3C, 0x3F, 0xC0, 0x3C, 0x3F, 0xF8,
  0x1C, 0x3F, 0xFE, 0x1C, 0x07, 0xFF, 0xDC, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x08, 0x07, 0xF8, 0x01, 0x80, 0x7F, 0xC0, 0x7C, 0x07, 0xFE,
  0x0F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x7F, 0xF0, 0x0F, 0xFD, 0xFF,
  0x80, 0x7F, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x01, 0xFE, 0x07,
  0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xF0,
  0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xF0, 0x07, 0xC1, 0xFF, 0x00, 0x78,
  0x7F, 0xF0, 0x07, 0x87, 0xFF, 0xC0, 0xF0, 0xFF, 0xFE, 0x0E, 0x0F, 0xFF,
  0xF9, 0xC0, 0x83, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0x3F, 0xF8, 0x03, 0x0F, 0xFF, 0x83, 0x81, 0xFF,
  0x83, 0x80, 0x7F, 0x83, 0xC0, 0x1F, 0xC3, 0xE0, 0x0F, 0xE1, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F,
  0xC0, 0x3F, 0x1F, 0xE0, 0x1F, 0x87, 0xF8, 0x1F, 0xC3, 0xFF, 0x1F, 0xE0,
  0xFF, 0xF3, 0xF0, 0x3F, 0xF1, 0xF8, 0x0F, 0xF0, 0xFC, 0x03, 0xE0, 0x7E,
  0x00, 0xE0, 0x3F, 0x00, 0x60, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x78,
  0x06, 0x07, 0xE0, 0x78, 0x3F, 0x87, 0xC3, 0xFE, 0x7F, 0x3F, 0xF3, 0xFD,
  0x3F, 0xFF, 0xF0, 0xFF, 0x7F, 0x07, 0xF1, 0xF0, 0x3F, 0x0F, 0x01, 0xF8,
  0x38, 0x0F, 0xC1, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x84, 0x01, 0xFE, 0x20, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x38, 0x01, 0x00, 0x3E, 0x00, 0xC0, 0x3F, 0x80,
  0xC0, 0x3F, 0xF9, 0xE0, 0x7F, 0xFF, 0xF0, 0x63, 0xFF, 0xF0, 0x60, 0x7F,
  0xF0, 0x70, 0x0F, 0xF0, 0x30, 0x01, 0xF0, 0x3C, 0x00, 0x30, 0x1E, 0x00,
  0x30, 0x0F, 0x80, 0x38, 0x07, 0xE0, 0x3E, 0x03, 0xF8, 0x3F, 0x81, 0xFE,
  0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x03,
  0xF0, 0x7F, 0x80, 0xF0, 0x0F, 0xC0, 0x70, 0x07, 0xF0, 0x30, 0x01, 0xF0,
  0x10, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1F, 0xC0, 0x18, 0x1F, 0xF8, 0x18,
  0x1F, 0xFF, 0x08, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC2, 0x0F,
  0xFD, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x38, 0x00, 0x18,
  0x00, 0xF0, 0x00, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x1B, 0xF8, 0x0F, 0xF8, 0x47,
  0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE,
  0x0F, 0xF1, 0x1F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xE0, 0x3F, 0xF0,
  0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xE0, 0x07,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x08, 0x01, 0xC0, 0x01, 0xC0, 0x1E,
  0x00, 0x1E, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x87,
  0xFF, 0x83, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E,
  0x00, 0xFE, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x7E, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x38, 0x00, 0xF0, 0x01, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xFC, 0x03, 0x80, 0x0F, 0xF8, 0x38, 0x00, 0xFF, 0xE1,
  0x80, 0x07, 0xFF, 0xD8, 0x00, 0x6F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0x03, 0xFC, 0x00, 0xE0, 0x01, 0x81, 0xFF,
  0x00, 0xF8, 0x01, 0xE0, 0xFF, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0xF0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0xE7, 0xFF, 0x03, 0xFC, 0xCF, 0xFC, 0x7F,
  0xC0, 0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0x81, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x7E,
  0x01, 0xF8, 0x03, 0xC0, 0x3F, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0xFF,
  0xC1, 0xC0, 0x1F, 0xE0, 0xFF, 0xF0, 0xC0, 0x1F, 0xF8, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x80, 0x60, 0x1F, 0x81, 0xE0, 0x3F, 0x83, 0xC0,
  0xFF, 0x8F, 0xC3, 0xFF, 0x3F, 0x87, 0xFF, 0xFF, 0x99, 0xFF, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xE0, 0x0F, 0xC1, 0x80, 0x1F,
  0x82, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x80, 0x1F, 0xFA, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x38, 0x7C, 0x00, 0xC0,
  0x78, 0x01, 0x80, 0x20, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x40, 0x30, 0x03,
  0xE0, 0x38, 0x0F, 0xC0, 0x3C, 0x7F, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x18, 0x07, 0xFC, 0x03, 0x80, 0x7F, 0xE0, 0x7C, 0x07,
  0xFE, 0x1F, 0xE0, 0x3F, 0xE7, 0xFF, 0x01, 0xFF, 0xDF, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7C, 0x07, 0xF1, 0x07, 0xC0,
  0xFF, 0x38, 0x78, 0x1F, 0xFE, 0x0F, 0x80, 0xFF, 0xC0, 0xF0, 0x03, 0xF8,
  0x0E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0xC1, 0x87, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x03, 0x03, 0x81, 0xC0, 0xF8, 0x60, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1B, 0xFC, 0x06, 0x3F, 0xC0, 0x83,
  0xF8, 0x30, 0x7F, 0x8C, 0x07, 0xF1, 0x80, 0xFE, 0x70, 0x1F, 0xCC, 0x01,
  0xFB, 0x80, 0x3F, 0x70, 0x07, 0xEE, 0x00, 0xFD, 0xC0, 0x1F, 0xB8, 0x03,
  0xF7, 0x00, 0x7C, 0xE0, 0x0F, 0x9C, 0x01, 0xF3, 0x80, 0x3C, 0x30, 0x07,
  0x06, 0x00, 0xE0, 0x60, 0x38, 0x0C, 0x0E, 0x00, 0x63, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80,
};

const GFXglyph UnifrakturMaguntia_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 12, 48, 15, 2, -47 },
  { 73, 22, 18, 26, 2, -46 },
  { 123, 29, 37, 33, 2, -42 },
  { 258, 23, 52, 27, 2, -49 },
  { 408, 43, 45, 46, 2, -46 },
  { 650, 34, 41, 37, 2, -40 },
  { 825, 10, 18, 13, 1, -46 },
  { 848, 14, 53, 16, 1, -51 },
  { 941, 14, 53, 16, 1, -51 },
  { 1034, 22, 25, 23, 0, -48 },
  { 1103, 22, 23, 26, 2, -33 },
  { 1167, 11, 18, 12, 0, -10 },
  { 1192, 18, 13, 19, 2, -26 },
  { 1222, 11, 11, 13, 1, -10 },
  { 1238, 31, 52, 34, 2, -49 },
  { 1440, 29, 46, 31, 1, -45 },
  { 1607, 19, 44, 21, 1, -44 },
  { 1712, 27, 44, 29, 1, -44 },
  { 1861, 28, 45, 30, 1, -45 },
  { 2019, 28, 44, 30, 1, -44 },
  { 2173, 28, 46, 30, 1, -46 },
  { 2334, 27, 46, 30, 1, -46 },
  { 2490, 26, 44, 28, 1, -44 },
  { 2633, 28, 46, 30, 1, -46 },
  { 2794, 27, 46, 30, 1, -46 },
  { 2950, 11, 32, 13, 1, -31 },
  { 2994, 12, 39, 11, 0, -31 },
  { 3053, 18, 24, 19, 0, -30 },
  { 3107, 23, 15, 25, 1, -27 },
  { 3151, 18, 24, 19, 0, -30 },
  { 3205, 25, 48, 30, 2, -47 },
  { 3355, 38, 39, 40, 1, -30 },
  { 3541, 51, 47, 53, 1, -46 },
  { 3841, 56, 48, 58, 0, -47 },
  { 4177, 41, 48, 45, 2, -47 },
  { 4423, 50, 50, 53, 1, -48 },
  { 4736, 42, 48, 46, 2, -47 },
  { 4988, 47, 56, 49, 1, -48 },
  { 5317, 46, 49, 50, 2, -47 },
  { 5599, 45, 59, 48, 1, -50 },
  { 5931, 42, 55, 45, 1, -47 },
  { 6220, 44, 64, 46, 1, -47 },
  { 6572, 50, 47, 53, 1, -46 },
  { 6866, 35, 47, 37, 1, -46 },
  { 7072, 68, 49, 72, 2, -46 },
  { 7489, 54, 47, 57, 2, -46 },
  { 7807, 46, 48, 49, 1, -47 },
  { 8083, 56, 57, 58, 1, -46 },
  { 8482, 50, 52, 52, 1, -47 },
  { 8807, 57, 48, 60, 2, -47 },
  { 9149, 46, 48, 49, 2, -47 },
  { 9425, 45, 47, 49, 2, -46 },
  { 9690, 44, 49, 46, 1, -45 },
  { 9960, 55, 48, 58, 1, -47 },
  { 10290, 67, 48, 70, 1, -47 },
  { 10692, 44, 48, 47, 1, -47 },
  { 10956, 53, 58, 56, 1, -48 },
  { 11341, 41, 56, 43, 1, -47 },
  { 11628, 9, 51, 12, 1, -48 },
  { 11686, 40, 45, 7, -12, -42 },
  { 11911, 9, 51, 12, 1, -48 },
  { 11969, 24, 17, 27, 1, -46 },
  { 12020, 31, 5, 30, -1, 7 },
  { 12040, 9, 13, 33, 11, -46 },
  { 12055, 28, 35, 30, 1, -33 },
  { 12178, 27, 47, 29, 1, -45 },
  { 12337, 21, 34, 23, 1, -33 },
  { 12427, 26, 46, 30, 2, -45 },
  { 12577, 21, 34, 24, 1, -33 },
  { 12667, 20, 58, 16, -1, -47 },
  { 12812, 28, 48, 30, 1, -34 },
  { 12980, 27, 57, 29, 1, -46 },
  { 13173, 15, 46, 18, 1, -45 },
  { 13260, 18, 58, 16, -3, -46 },
  { 13391, 19, 47, 21, 1, -45 },
  { 13503, 19, 46, 18, 1, -45 },
  { 13613, 42, 35, 46, 2, -34 },
  { 13797, 29, 35, 33, 2, -33 },
  { 13924, 25, 34, 27, 0, -33 },
  { 14031, 28, 52, 29, 0, -39 },
  { 14213, 25, 47, 28, 1, -34 },
  { 14360, 21, 34, 24, 1, -33 },
  { 14450, 25, 42, 27, 1, -41 },
  { 14582, 18, 44, 20, 1, -42 },
  { 14681, 30, 35, 33, 1, -34 },
  { 14813, 29, 38, 29, -1, -37 },
  { 14951, 41, 40, 45, 2, -38 },
  { 15156, 23, 47, 26, 1, -34 },
  { 15292, 28, 50, 30, 1, -39 },
  { 15467, 19, 46, 22, 1, -34 },
  { 15577, 18, 52, 22, 1, -51 },
  { 15694, 4, 54, 10, 3, -51 },
  { 15721, 18, 52, 22, 1, -51 },
  { 15838, 21, 5, 24, 1, -22 },
};

const GFXfont UnifrakturMaguntia_Regular65pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular65pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular65pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR65PT7B_H_
