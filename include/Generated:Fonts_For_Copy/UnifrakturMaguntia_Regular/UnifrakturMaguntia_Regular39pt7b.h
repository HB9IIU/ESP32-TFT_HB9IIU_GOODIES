#ifndef _UNIFRAKTURMAGUNTIA_REGULAR39PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0x71, 0xF7, 0xF7, 0xCF, 0x9F, 0x1C, 0x38, 0x70, 0xE1, 0xC1,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x00, 0x00, 0x04, 0x1C, 0x7C, 0xFC,
  0xE0, 0x80, 0x00, 0x20, 0x21, 0x81, 0x1E, 0x1D, 0xFB, 0xF3, 0xC7, 0x8E,
  0x1C, 0x60, 0xE3, 0x02, 0x10, 0x30, 0x81, 0x08, 0x10, 0x03, 0x8E, 0x00,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0C, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x18, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x0E, 0x38, 0x03,
  0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x07, 0x1C, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0xC0, 0x71, 0x83, 0x03, 0x0C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9E, 0x06, 0x7E, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x98, 0x3F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x01, 0xD8, 0x06, 0x60, 0x38, 0xC0, 0xC1, 0x86, 0x03, 0xF0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x07, 0xC0,
  0x00, 0x63, 0x98, 0x00, 0x11, 0xC7, 0x00, 0x08, 0x71, 0xC0, 0x06, 0x3C,
  0x78, 0x03, 0x0F, 0x1E, 0x01, 0x83, 0xC7, 0x80, 0xC0, 0xF1, 0xE0, 0x60,
  0x3C, 0x78, 0x30, 0x0F, 0x1E, 0x08, 0x01, 0xC7, 0x06, 0x00, 0x71, 0xC3,
  0x00, 0x0E, 0x61, 0x80, 0x01, 0xF0, 0xC3, 0xC0, 0x00, 0x61, 0x9C, 0x00,
  0x30, 0xE3, 0x80, 0x08, 0x78, 0xE0, 0x04, 0x1E, 0x38, 0x03, 0x07, 0x8F,
  0x01, 0x81, 0xE3, 0xC0, 0xC0, 0x78, 0xF0, 0x60, 0x1E, 0x38, 0x30, 0x07,
  0x8E, 0x18, 0x00, 0xE3, 0x84, 0x00, 0x19, 0xC3, 0x00, 0x03, 0xC0, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x39, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0xF0, 0xC0, 0x0F, 0x1C, 0x00, 0x79, 0x80, 0x07, 0xA0,
  0x00, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0xFE, 0x0C, 0x1F, 0xE0, 0xC3, 0xBF,
  0x08, 0x71, 0xF0, 0x87, 0x1F, 0x88, 0xF0, 0xF9, 0x0F, 0x0F, 0xF0, 0xF0,
  0x7E, 0x0F, 0x87, 0xE0, 0x78, 0x3F, 0x17, 0xC1, 0xFE, 0x3E, 0x1F, 0xE0,
  0xFE, 0x38, 0x20, 0xC7, 0xBF, 0x7C, 0xE1, 0x86, 0x10, 0x82, 0x00, 0x01,
  0x04, 0x08, 0x18, 0x38, 0x30, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x03, 0x80, 0x60, 0x30, 0x18, 0x1C,
  0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x18,
  0x18, 0x30, 0xC0, 0x02, 0x00, 0x10, 0x01, 0xC0, 0x3F, 0x8F, 0x77, 0xB9,
  0x39, 0xEB, 0xC9, 0xF6, 0x47, 0x13, 0xD7, 0x9E, 0xBD, 0xE6, 0xF1, 0x7C,
  0x07, 0x80, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x83, 0xFF, 0xE0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x10, 0xC7, 0xBF, 0x3C, 0x71, 0xC6, 0x10, 0x42,
  0x00, 0x1F, 0xE7, 0xF8, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x3F, 0x00, 0x20,
  0xC7, 0xBF, 0x70, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x38, 0x07,
  0x0E, 0x07, 0x83, 0x83, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x7D, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF,
  0x03, 0xE7, 0x81, 0xF3, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x38, 0x1C, 0x38,
  0x07, 0x18, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x38, 0x07, 0x80, 0xF8, 0x1F,
  0x83, 0xF8, 0x7F, 0x88, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xFC, 0x7F, 0xF0, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x70, 0xFE, 0x60, 0x3E, 0xC0, 0x3E, 0x80, 0x1E,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0x06, 0x01,
  0x0C, 0x01, 0x08, 0x03, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x07, 0xE0, 0x0F, 0xFC, 0x0C, 0x3F, 0x0C, 0x07, 0xC4, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x39, 0xE0, 0x18, 0x78, 0x1C, 0x1C, 0x18, 0x03, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0B,
  0xC0, 0x05, 0xE0, 0x04, 0xF0, 0x02, 0x78, 0x02, 0x3C, 0x02, 0x1E, 0x01,
  0x0F, 0x01, 0x07, 0x81, 0x03, 0xC0, 0x81, 0xE0, 0x80, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x20, 0x04,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x13, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xF1, 0xE0, 0xFC, 0xC0, 0x3E, 0x40, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x3D, 0xE0,
  0x1C, 0xF0, 0x0C, 0x3C, 0x0C, 0x0E, 0x0C, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x06, 0x38, 0x0C, 0x3C, 0x1C, 0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x0E,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0x7C, 0xFC, 0x3E,
  0xFC, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x1C, 0x18,
  0x0C, 0x30, 0x07, 0xE0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x28,
  0x00, 0xD0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x70,
  0x06, 0x70, 0x06, 0x70, 0x06, 0x70, 0x06, 0x78, 0x0E, 0x7E, 0x0C, 0x7F,
  0x98, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x30, 0xFE, 0x70,
  0x7E, 0x60, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0C, 0x38, 0x38, 0x0F, 0xE0, 0x07,
  0xC0, 0x0C, 0x70, 0x18, 0x38, 0x38, 0x3C, 0x70, 0x3C, 0x70, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0x78, 0x7F, 0x7C, 0xDF, 0x3F, 0x9E, 0x1F, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x70, 0x1C, 0xF8, 0x3C, 0xF8, 0x38, 0x78,
  0x38, 0x78, 0x30, 0x3C, 0x60, 0x0F, 0x80, 0x00, 0x87, 0x3F, 0x78, 0xC2,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x83, 0x1E, 0xFD, 0xC2, 0x00, 0x00, 0x20,
  0xE3, 0xF3, 0xC3, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0C, 0x3C,
  0xFC, 0x78, 0x70, 0xE1, 0x82, 0x04, 0x10, 0x00, 0x60, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0x00, 0x0F, 0xE0, 0x70, 0xF1, 0xC0, 0xF3, 0x00, 0xEE, 0x01, 0xFF,
  0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xF0, 0x7F,
  0x81, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x18, 0x08, 0x38, 0x20,
  0x38, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0E, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x31, 0xC0,
  0x00, 0x67, 0x03, 0xF9, 0xB8, 0x39, 0xE6, 0xE1, 0xC7, 0x1B, 0x87, 0x1C,
  0x6C, 0x38, 0x71, 0xB1, 0xE3, 0xC6, 0xC7, 0x0E, 0x1B, 0x1C, 0x78, 0xCC,
  0xF1, 0xE3, 0x39, 0xCF, 0x98, 0xE7, 0xFE, 0xCD, 0x8E, 0x3E, 0x73, 0x00,
  0x01, 0x8E, 0x00, 0x0C, 0x1C, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x10, 0x1F, 0xF0, 0x00, 0xC1, 0xFF, 0xF0, 0x0E,
  0x0C, 0x1F, 0xC1, 0xF8, 0x60, 0x3F, 0x8F, 0xC1, 0x00, 0x7F, 0x1F, 0x0C,
  0x00, 0xFC, 0x7C, 0x20, 0x01, 0xF1, 0xF0, 0x80, 0x07, 0xC7, 0xC3, 0x00,
  0x1F, 0x1F, 0x0E, 0x00, 0x3C, 0x7C, 0x3E, 0x00, 0xF1, 0xF0, 0x7E, 0x07,
  0x87, 0xC0, 0xFC, 0x1E, 0x1F, 0x01, 0xF8, 0x70, 0x7C, 0x01, 0xE1, 0x81,
  0xF0, 0x03, 0x8C, 0x07, 0xC0, 0x0C, 0x60, 0x1F, 0x00, 0x01, 0x00, 0x7C,
  0x00, 0x08, 0x01, 0xF0, 0x00, 0x60, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x3F, 0xC0, 0x7C, 0x03, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0x17, 0xFC, 0x01,
  0xFF, 0x8F, 0xE0, 0x03, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xE0, 0x03, 0xFF, 0xC3, 0xFE, 0x01, 0xFF,
  0xF9, 0x9F, 0x80, 0xFF, 0xFF, 0x43, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x1C,
  0x01, 0xF8, 0x1F, 0x86, 0x00, 0x3E, 0x03, 0xE1, 0x80, 0x0F, 0x80, 0xF8,
  0x40, 0x01, 0xE0, 0x3F, 0x90, 0x00, 0x78, 0x07, 0x84, 0x00, 0x1E, 0x03,
  0x01, 0x80, 0x07, 0x83, 0xE0, 0x60, 0x01, 0xE3, 0xFE, 0x0C, 0x04, 0x73,
  0xFF, 0xC1, 0xC6, 0x1C, 0x1F, 0xF8, 0x0E, 0x06, 0x00, 0x7E, 0x00, 0x03,
  0x00, 0x0F, 0xC0, 0x01, 0x80, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x7F, 0xC0, 0x00, 0xE0,
  0x37, 0xF8, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0x0F, 0xF0, 0x0E,
  0x00, 0x01, 0xFF, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x70, 0x03, 0x86, 0x7E,
  0x03, 0x81, 0x7F, 0xE3, 0xC0, 0xFF, 0xE1, 0xC0, 0xC3, 0xC1, 0xE0, 0xC0,
  0x40, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C,
  0x00, 0x3E, 0x3F, 0x80, 0x1F, 0x0F, 0xE0, 0x0F, 0x87, 0xF8, 0x07, 0xC1,
  0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3C, 0x03, 0xF0, 0x1C, 0x00,
  0xFC, 0x1C, 0x00, 0x7F, 0x18, 0x00, 0x1F, 0xD0, 0x00, 0x07, 0xF8, 0x01,
  0x81, 0xFF, 0xEF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xFE, 0x07,
  0xC0, 0x43, 0xFC, 0x1C, 0x06, 0x03, 0xF8, 0xE0, 0x38, 0x07, 0xE3, 0x00,
  0xE0, 0x0F, 0xCC, 0x07, 0xC0, 0x1F, 0x30, 0x1F, 0x00, 0x3E, 0xC0, 0x7F,
  0x00, 0x7A, 0x01, 0xFE, 0x01, 0xEC, 0x03, 0xF8, 0x03, 0x90, 0x07, 0xF0,
  0x0E, 0x60, 0x0F, 0xC0, 0x18, 0xC0, 0x1F, 0x00, 0x61, 0xEC, 0x3C, 0x01,
  0x80, 0xC0, 0x70, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x40,
  0x0F, 0x40, 0x03, 0x00, 0xFF, 0x00, 0x08, 0x07, 0xFF, 0x00, 0x40, 0x7F,
  0xFF, 0x02, 0x03, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x70, 0x01, 0xC3, 0x3F,
  0x00, 0xE0, 0x5F, 0xF8, 0x70, 0x1F, 0xFC, 0x1C, 0x0C, 0x3C, 0x0F, 0x06,
  0x02, 0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1E,
  0x3F, 0x04, 0x0F, 0x8F, 0xE3, 0xC3, 0xE1, 0xFD, 0xFF, 0xF8, 0x7F, 0xFF,
  0xBE, 0x0F, 0xF3, 0xCF, 0x81, 0xFE, 0x63, 0xF0, 0x3F, 0x80, 0x7C, 0x07,
  0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3F,
  0x01, 0xC0, 0x07, 0xE0, 0xE0, 0x01, 0xFC, 0x60, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x01, 0x80, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xB3, 0xE0, 0x7F, 0xFE, 0x78, 0x00,
  0xFF, 0x87, 0x00, 0x13, 0xF0, 0x60, 0x03, 0x0C, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x0E, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0xC0, 0x0F, 0x81, 0x8C, 0x00,
  0xFC, 0x3C, 0x40, 0x0F, 0xE3, 0xE6, 0x00, 0x7E, 0x7F, 0x30, 0x07, 0xFF,
  0xE1, 0x81, 0x3F, 0x9C, 0x07, 0xE1, 0xF8, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x7E, 0x00, 0x78, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80,
  0x70, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF8, 0x08, 0x00, 0x38, 0x63, 0xC0, 0x07, 0x02, 0x7E, 0x00, 0xE0,
  0x1F, 0xF0, 0x1E, 0x02, 0x3F, 0x83, 0xC0, 0x41, 0xFC, 0x3C, 0x18, 0x0F,
  0xE7, 0x83, 0x80, 0x78, 0x78, 0x78, 0x03, 0x07, 0x87, 0x80, 0xC0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xC7, 0xF8, 0xF8, 0x7E, 0xFF, 0xCF, 0x83, 0xF0,
  0x7E, 0xF8, 0x3F, 0x83, 0xEF, 0x81, 0xF8, 0x3E, 0xFC, 0x0F, 0xC1, 0xFF,
  0xC0, 0x7C, 0x1F, 0x7C, 0x07, 0xC1, 0xF7, 0xE0, 0x3C, 0x0F, 0x7E, 0x03,
  0x81, 0xE3, 0xE0, 0x30, 0x1E, 0x1F, 0x06, 0x01, 0xE1, 0xF8, 0xC0, 0x1C,
  0x0F, 0xC0, 0x03, 0x80, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x0E, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x04, 0x3F, 0xC0, 0x00, 0x81, 0xF8, 0x00, 0x18, 0x0F, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x08, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0xC0, 0x7F, 0x00, 0x7E, 0x1F, 0xF0, 0x03, 0xF3, 0xFF, 0x80, 0x3F,
  0xC1, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x80, 0xF0, 0x1E, 0x1E, 0x06, 0x01, 0xE3, 0xF0, 0x60,
  0x1E, 0x7F, 0x8C, 0x01, 0xC0, 0xFF, 0x80, 0x3C, 0x07, 0xF0, 0x03, 0x80,
  0x3C, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xC3, 0xFE, 0x03, 0x80, 0x7F,
  0x91, 0x80, 0x1F, 0xF0, 0xC0, 0x03, 0xF0, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38, 0x06, 0x00, 0x3C, 0x03, 0x00,
  0x1F, 0x00, 0xC0, 0x0F, 0x80, 0x30, 0x07, 0xE0, 0x0F, 0xFB, 0xF0, 0x00,
  0x80, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x1F, 0xE0, 0x07, 0xBF, 0xF8, 0x03, 0x91, 0xFE, 0x01,
  0x80, 0x7F, 0x80, 0xC0, 0x1F, 0xE0, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x70, 0x7F, 0xC0, 0x38, 0x07, 0xF9, 0x0C, 0x00, 0xFF,
  0x86, 0x00, 0x0F, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x1C, 0x06, 0x00, 0x0E, 0x00, 0x80, 0x07, 0xC0, 0x30, 0x01, 0xF0, 0x06,
  0x00, 0x7C, 0x00, 0xC0, 0x1F, 0x80, 0x1F, 0xF3, 0xE0, 0x00, 0xC0, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x07, 0xC0, 0x01, 0xC7, 0xFC, 0x00, 0x63, 0xFF, 0x80,
  0x18, 0x0F, 0xF0, 0x0C, 0x01, 0xFE, 0x02, 0x00, 0x3F, 0xC1, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x01, 0xE0, 0x00, 0x60, 0x07, 0x0F, 0xE0, 0xC0, 0x3C, 0x7F, 0xC3, 0x81,
  0xE3, 0xFF, 0x86, 0x07, 0x98, 0x3E, 0x18, 0x1E, 0x40, 0xFC, 0x60, 0x7D,
  0x01, 0xF1, 0x81, 0xF4, 0x07, 0xE7, 0x07, 0xF0, 0x0F, 0xD8, 0x0F, 0xC0,
  0x1C, 0x60, 0x3F, 0x80, 0x43, 0x00, 0x7E, 0x06, 0x18, 0x01, 0xFC, 0x7C,
  0xC0, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x78, 0x3E, 0x03, 0xC0, 0xE0, 0xF8, 0x1F,
  0x83, 0x03, 0xF0, 0xFF, 0x08, 0x07, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFE,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x78, 0x02, 0x00, 0x00, 0x80, 0x03, 0xFF,
  0x00, 0x38, 0x1E, 0x07, 0x80, 0x78, 0x38, 0x01, 0xC3, 0xC0, 0x0F, 0x1E,
  0x00, 0x79, 0xF0, 0x01, 0xCF, 0xC0, 0x0E, 0x7E, 0x00, 0xF1, 0xF8, 0x07,
  0x8F, 0xC0, 0x38, 0x7F, 0x03, 0xC1, 0xFB, 0xF8, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x41, 0xFF,
  0x04, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00,
  0x07, 0xF8, 0x1F, 0x03, 0xF0, 0x07, 0xFE, 0x3F, 0xE3, 0xFC, 0x0F, 0xFF,
  0x9F, 0xFA, 0x3F, 0x07, 0xFF, 0xF0, 0xFE, 0x0F, 0x86, 0x03, 0xF8, 0x3F,
  0x07, 0xC6, 0x00, 0xFE, 0x0F, 0x81, 0xF2, 0x00, 0x3F, 0x07, 0xE0, 0xF9,
  0x00, 0x0F, 0xC1, 0xF0, 0x7C, 0x80, 0x03, 0xE0, 0xF8, 0x3F, 0xC0, 0x01,
  0xF0, 0x3C, 0x0F, 0x20, 0x00, 0x78, 0x1E, 0x03, 0x18, 0x00, 0x3C, 0x0F,
  0x02, 0x07, 0x7C, 0x1E, 0x07, 0x83, 0x03, 0xFF, 0x0F, 0x03, 0xC3, 0x00,
  0x7F, 0x83, 0x81, 0xE3, 0x80, 0x00, 0x41, 0xC0, 0xE1, 0xC0, 0x00, 0x20,
  0xE0, 0x71, 0xE0, 0x00, 0x00, 0x60, 0x38, 0xF0, 0x00, 0x00, 0x70, 0x1C,
  0xF8, 0x00, 0x00, 0x30, 0x0C, 0x7C, 0x00, 0x00, 0x18, 0x06, 0x3F, 0x00,
  0x3C, 0x09, 0x82, 0x0F, 0x80, 0x7F, 0x09, 0xE2, 0x07, 0xE0, 0x7F, 0xCD,
  0xFF, 0x01, 0xFF, 0x27, 0xFD, 0xFF, 0x00, 0xFF, 0x01, 0xFD, 0xBF, 0x00,
  0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x01, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xF0, 0x07, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xE3, 0x7F, 0x07, 0xDF, 0xFA,
  0x0F, 0x83, 0x01, 0xFF, 0x07, 0xC3, 0x00, 0x3F, 0x01, 0xF1, 0x00, 0x0F,
  0x80, 0xF8, 0x80, 0x07, 0xE0, 0x7E, 0x40, 0x01, 0xF0, 0x1F, 0xA0, 0x00,
  0xF8, 0x0F, 0x10, 0x00, 0x3C, 0x03, 0x0C, 0x00, 0x1E, 0x02, 0x03, 0xFE,
  0x0F, 0x03, 0x00, 0xFF, 0x83, 0x83, 0x00, 0x3F, 0xC1, 0xC3, 0x80, 0x00,
  0x20, 0xE1, 0xC0, 0x00, 0x10, 0x71, 0xE0, 0x00, 0x00, 0x30, 0xF0, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x18, 0x3E, 0x00, 0x00, 0x0C, 0x1F, 0x00,
  0x1E, 0x04, 0x0F, 0xC0, 0x3F, 0x86, 0x07, 0xE2, 0x3F, 0xE6, 0x01, 0xFF,
  0x23, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0C, 0x07,
  0xFC, 0x06, 0x00, 0x3F, 0xC1, 0x80, 0x01, 0xFC, 0x70, 0x00, 0x1F, 0x8E,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1E, 0xFF, 0x80, 0x03, 0xCF, 0xFC, 0x00, 0x78, 0xFF, 0x80, 0x07, 0x07,
  0xF8, 0x00, 0xE0, 0x3E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x10, 0x00,
  0x60, 0x64, 0x00, 0x0C, 0x3F, 0x00, 0x03, 0x1F, 0xF0, 0x00, 0x47, 0xFF,
  0x80, 0x10, 0x0F, 0xF8, 0x04, 0x00, 0x7F, 0xE3, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xC0, 0x0F,
  0xFE, 0x01, 0xC0, 0x0F, 0xFF, 0x83, 0xE0, 0x0E, 0x1F, 0xE7, 0xF0, 0x0E,
  0x03, 0xFC, 0xFC, 0x06, 0x00, 0xFC, 0x7F, 0x02, 0x00, 0x3E, 0x1F, 0xC1,
  0x00, 0x1F, 0x07, 0xF0, 0x80, 0x07, 0x83, 0xFC, 0x40, 0x03, 0xC0, 0x7F,
  0x20, 0x01, 0xE0, 0x1F, 0xC8, 0x00, 0xF8, 0x07, 0xE6, 0x00, 0x7C, 0x01,
  0xF9, 0xC7, 0x3E, 0x00, 0x7C, 0x1C, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x20, 0x01, 0xFE,
  0x00, 0x20, 0x01, 0xFF, 0xC0, 0x20, 0x01, 0xFF, 0xF8, 0x30, 0x00, 0x83,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x00,
  0x70, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0x01,
  0xFF, 0x00, 0x60, 0x03, 0xFC, 0x06, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x1F,
  0x83, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xCF,
  0xF0, 0x00, 0x1E, 0x3F, 0xE0, 0x00, 0xF1, 0xFF, 0xC0, 0x07, 0x83, 0xFE,
  0x00, 0x1C, 0x07, 0xF8, 0x00, 0xE0, 0x0F, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x64, 0x01, 0x88, 0x0F, 0xC0, 0x3F, 0xC1,
  0xFF, 0x03, 0xFC, 0x1F, 0xFE, 0x37, 0xE1, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF8, 0xFF, 0x80, 0x7F, 0xFC, 0xF8, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFC,
  0x67, 0xE0, 0x3F, 0xFF, 0x90, 0xFC, 0x1C, 0x0F, 0xF8, 0x1F, 0x86, 0x00,
  0xFE, 0x07, 0xE3, 0x00, 0x1F, 0x80, 0xF8, 0xC0, 0x03, 0xE0, 0x3F, 0xB0,
  0x00, 0x78, 0x07, 0xCC, 0x00, 0x1F, 0x00, 0xE3, 0x00, 0x03, 0xC0, 0x60,
  0xC0, 0x00, 0xF0, 0x20, 0x10, 0x00, 0x3C, 0x30, 0x06, 0x00, 0x0F, 0x3E,
  0x00, 0xC0, 0x43, 0xDF, 0xC0, 0x0F, 0xE0, 0xFB, 0xF0, 0x00, 0x00, 0x38,
  0x7E, 0x00, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x00,
  0xC0, 0xF8, 0x00, 0x00, 0x30, 0x3F, 0x00, 0x7C, 0x18, 0x0F, 0xC0, 0x3F,
  0x84, 0x01, 0xF8, 0x1F, 0xE3, 0x00, 0x7F, 0x40, 0xFF, 0x80, 0x0F, 0xE0,
  0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x40,
  0x1F, 0xFF, 0xFC, 0x03, 0x07, 0xFF, 0x80, 0x40, 0x1F, 0xE0, 0x08, 0x00,
  0x7C, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x7C, 0x06, 0x00, 0x1F, 0xF0, 0xE1, 0x07, 0xFF, 0x8E, 0x09,
  0xFF, 0xFC, 0xE0, 0xFF, 0xF0, 0x6E, 0x07, 0xFC, 0x02, 0xF0, 0x3F, 0x00,
  0x2F, 0x00, 0xC0, 0x02, 0xF8, 0x00, 0x00, 0x27, 0xC0, 0x00, 0x02, 0x7E,
  0x00, 0x00, 0x63, 0xF0, 0x00, 0x0C, 0x3F, 0xC0, 0x03, 0xC1, 0xFF, 0xC3,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x1C, 0x1F, 0xFC, 0x06, 0x00, 0x7F, 0xC0, 0x80, 0x03, 0xFE, 0x70,
  0x01, 0x3F, 0xF4, 0x00, 0xC1, 0xFC, 0x80, 0x38, 0x1F, 0x10, 0x0F, 0x00,
  0x02, 0x01, 0xF0, 0x00, 0x20, 0x3F, 0x00, 0x06, 0x03, 0xF8, 0x00, 0x61,
  0x7F, 0x80, 0x03, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0xE0, 0xE0, 0x07, 0xFE,
  0x18, 0x01, 0x1F, 0xEC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x01, 0x80, 0x0F, 0xF8, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x01, 0x83, 0x84, 0x01, 0xC1, 0xC0, 0x81, 0xE0,
  0x70, 0x21, 0xF8, 0x3C, 0x10, 0xFC, 0x0F, 0x08, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x07, 0xF0, 0x1F, 0x01, 0xFC,
  0x07, 0xC0, 0x3F, 0x80, 0xF0, 0x07, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00,
  0x3E, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0x80, 0x3C, 0x00, 0xC0, 0x0F,
  0x00, 0x60, 0x03, 0xC0, 0x30, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0xE0,
  0x1F, 0x07, 0xFC, 0x1B, 0xC2, 0x3F, 0xCC, 0xFF, 0x07, 0xFE, 0x3F, 0x80,
  0xFF, 0x0F, 0xC0, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xCC,
  0xFC, 0x07, 0xFF, 0xE4, 0x3E, 0x07, 0x03, 0xFC, 0x1F, 0x87, 0x00, 0x7E,
  0x07, 0xC3, 0x00, 0x1F, 0x03, 0xF1, 0x80, 0x0F, 0x80, 0xFC, 0x80, 0x03,
  0xC0, 0x30, 0x40, 0x01, 0xE0, 0x10, 0x20, 0x00, 0x70, 0x18, 0x18, 0x00,
  0x38, 0x1C, 0x04, 0x00, 0x1C, 0x1E, 0x01, 0x01, 0x1C, 0x0F, 0x80, 0x73,
  0x0E, 0x07, 0xE0, 0x06, 0x06, 0x03, 0xF8, 0x00, 0x06, 0x00, 0xFE, 0x00,
  0x02, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0xC0, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0x70, 0x33, 0xFE, 0x00, 0x30,
  0x20, 0xFF, 0x80, 0x10, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0x07, 0xFC, 0x10,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xE0, 0x10, 0x0F, 0x00, 0x0F, 0xFC, 0x3C, 0x7F, 0xC0, 0x1F,
  0xFE, 0x66, 0x8F, 0xE0, 0x3F, 0xFF, 0xC3, 0x03, 0xF0, 0x7C, 0x7F, 0x83,
  0x03, 0xF0, 0x70, 0x1F, 0xC6, 0x01, 0xF8, 0xE0, 0x0F, 0xC6, 0x00, 0xF8,
  0xC0, 0x07, 0xCF, 0x00, 0xFC, 0xC0, 0x03, 0xCF, 0x00, 0x7E, 0x80, 0x03,
  0xCF, 0x80, 0x30, 0x80, 0x01, 0xCF, 0x80, 0x20, 0xC0, 0x01, 0xCF, 0xC0,
  0x60, 0x40, 0x01, 0xC7, 0xE0, 0xE0, 0x20, 0x21, 0xC7, 0xE1, 0xF0, 0x18,
  0x43, 0x83, 0xE1, 0xF8, 0x0F, 0x83, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0x01,
  0xF0, 0xFE, 0x00, 0x06, 0x01, 0xF0, 0xFF, 0x00, 0x0C, 0x00, 0xE0, 0x3F,
  0x00, 0x08, 0x00, 0xE0, 0x1F, 0x03, 0xF8, 0x00, 0xC0, 0x0F, 0x07, 0xFC,
  0x00, 0xE0, 0x0E, 0x1F, 0xFE, 0x01, 0xF0, 0x06, 0x00, 0xFF, 0x03, 0xF8,
  0x0C, 0x00, 0x3F, 0x87, 0xFC, 0x08, 0x00, 0x3F, 0xFC, 0xFF, 0x10, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x08, 0x03, 0xFE, 0x07, 0x93, 0xFF, 0xC3, 0xFC,
  0xFF, 0xF8, 0xFE, 0x78, 0x7E, 0x7F, 0x98, 0x07, 0xD1, 0xCC, 0x00, 0xF4,
  0x03, 0x00, 0x3E, 0x00, 0xC0, 0x0F, 0x80, 0x30, 0x01, 0xE0, 0x04, 0x00,
  0x78, 0x01, 0x00, 0x3F, 0xF8, 0x20, 0x0F, 0xFE, 0x06, 0x67, 0xFF, 0x00,
  0x63, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0xE1, 0x3E, 0x00, 0x7C, 0x4F, 0xE2, 0x1F, 0xF1, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xE1, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xF0, 0x7F,
  0x80, 0xFF, 0xF9, 0x9F, 0x83, 0xFF, 0xFC, 0x1F, 0x0E, 0x07, 0xF8, 0x3F,
  0x38, 0x03, 0xF0, 0x3E, 0x60, 0x03, 0xE0, 0x7E, 0xC0, 0x07, 0xC0, 0xFD,
  0x00, 0x07, 0x80, 0xFE, 0x00, 0x0F, 0x00, 0xF4, 0x00, 0x0E, 0x01, 0x8C,
  0x00, 0x1C, 0x06, 0x08, 0x00, 0x38, 0x1C, 0x08, 0x08, 0xE0, 0x78, 0x0F,
  0xE1, 0xC1, 0xF0, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x06, 0x07, 0xE0, 0x00,
  0x18, 0x0F, 0xE0, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0xC0, 0x1F, 0xC0, 0x01,
  0x00, 0x1F, 0x80, 0x06, 0x00, 0x3F, 0x00, 0x1E, 0x0C, 0x3F, 0x00, 0x7F,
  0x30, 0x7E, 0x01, 0xFF, 0xC0, 0xFC, 0x04, 0xFF, 0x01, 0xF0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x40, 0x00, 0x0F, 0x00, 0x40, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0x03, 0xF8, 0x0C, 0x00, 0xFC, 0x0C, 0x00, 0x7C, 0x18,
  0x00, 0x3C, 0x18, 0x00, 0x3C, 0x18, 0x00, 0x3C, 0x08, 0x00, 0x38, 0x0C,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x03, 0x80, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x0C, 0x00, 0x0F, 0x3F, 0x00, 0x0E, 0x7F, 0x80, 0x0E, 0x9F,
  0xC0, 0x0C, 0x0F, 0xE0, 0x0C, 0x07, 0xF0, 0x18, 0x03, 0xFC, 0x20, 0x00,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x7F, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0x73, 0x83, 0x87, 0x1C, 0x0E, 0xC0,
  0x0E, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x73, 0xC7,
  0x8E, 0x18, 0x30, 0x40, 0x01, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xF0,
  0x09, 0xFC, 0x18, 0xFE, 0x30, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x38,
  0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0x78, 0x78, 0x78,
  0x7C, 0x7D, 0x3F, 0xBE, 0x1F, 0x3E, 0x0C, 0x1C, 0x08, 0x04, 0x01, 0xC0,
  0x86, 0x00, 0x8C, 0x00, 0x5C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x10, 0x3C, 0x30, 0x3C, 0x78, 0x3D, 0xFC, 0x3E, 0x7C, 0x3C, 0x3E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E,
  0x3C, 0x0E, 0x3C, 0x0C, 0x3C, 0x1C, 0x3E, 0x18, 0x7F, 0xA0, 0x1F, 0xC0,
  0x07, 0x80, 0x03, 0x80, 0x01, 0x00, 0x00, 0x80, 0x7C, 0x0B, 0xC1, 0x1E,
  0x31, 0xE7, 0x0F, 0x70, 0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7E, 0x03, 0xFF, 0x1F, 0xC0, 0xF0,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x02, 0xFC,
  0x04, 0x7E, 0x3C, 0x1E, 0x3C, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x07,
  0x3C, 0x07, 0x3C, 0x07, 0x3C, 0x06, 0x3C, 0x06, 0x3C, 0x0C, 0x7F, 0x0C,
  0x7F, 0x88, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x02, 0x00, 0x00, 0x80,
  0x7C, 0x0B, 0xC3, 0x3E, 0x31, 0xE7, 0x1E, 0x70, 0xFF, 0x0F, 0xF0, 0xCF,
  0x70, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7E, 0x03,
  0xFF, 0x1F, 0xC0, 0xF0, 0x06, 0x00, 0x04, 0x03, 0xF4, 0x7F, 0x8F, 0xE1,
  0x18, 0x40, 0x08, 0x00, 0x80, 0x3C, 0x0F, 0xFA, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x09, 0xFE, 0x18, 0x7C, 0x30, 0x3C, 0x70, 0x0C, 0xF0, 0x18, 0xF0,
  0x38, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x3C, 0x78,
  0x3E, 0x7C, 0x3E, 0x3E, 0x7E, 0x1F, 0x9E, 0x1C, 0x1E, 0x10, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x30, 0x1C, 0x70, 0x1C, 0x78, 0x10, 0x3C, 0x60, 0x0F,
  0x80, 0x01, 0xE0, 0x87, 0x00, 0x8E, 0x00, 0x5C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x20, 0x3C, 0x70, 0x3C, 0xF0, 0x3F, 0xF8, 0x3C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C,
  0x9C, 0x7F, 0x18, 0x3E, 0x18, 0x0C, 0x30, 0x08, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x0E, 0x07, 0xC1,
  0xF0, 0x78, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x0F, 0x87, 0xF1, 0x7E,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x7D, 0x1F, 0x83, 0xC0, 0x70, 0x08, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x20, 0x06, 0x01, 0xE0, 0x7E, 0x0F,
  0xE2, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7A, 0x0E, 0x43, 0x87, 0xC0, 0x00, 0x01, 0xD0, 0xE2,
  0x38, 0x2E, 0x33, 0xCE, 0x7B, 0xCF, 0xF9, 0xF0, 0x3E, 0x07, 0xFF, 0xFF,
  0x9E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFE, 0x7F, 0x81, 0xE0, 0x18, 0x01, 0x00,
  0x01, 0xF0, 0xC2, 0x38, 0x2E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFE, 0x7F, 0x01, 0xE0,
  0x18, 0x01, 0x00, 0x30, 0x30, 0x30, 0x0E, 0x1E, 0x1E, 0x07, 0xCF, 0xCF,
  0xC1, 0xFE, 0xFD, 0xFC, 0x9E, 0x1E, 0x3E, 0x07, 0x87, 0x87, 0x81, 0xE1,
  0xE1, 0xE0, 0x78, 0x78, 0x78, 0x1E, 0x1E, 0x1E, 0x07, 0x87, 0x87, 0x81,
  0xE1, 0xE1, 0xE0, 0x78, 0x78, 0x78, 0x1E, 0x1E, 0x1E, 0x07, 0x87, 0x87,
  0x81, 0xE1, 0xE1, 0xE0, 0x78, 0x78, 0x78, 0x3F, 0x3F, 0x1F, 0xDF, 0x8F,
  0xC7, 0xE1, 0xC1, 0xE0, 0xF0, 0x30, 0x30, 0x1C, 0x08, 0x08, 0x02, 0x00,
  0x20, 0x20, 0x0E, 0x0C, 0x07, 0xC7, 0x81, 0xF3, 0xFC, 0xBF, 0x3F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0x78,
  0x3F, 0x1E, 0x5F, 0x87, 0xE1, 0xC0, 0xF0, 0x30, 0x1C, 0x08, 0x02, 0x00,
  0x00, 0x20, 0x01, 0xC0, 0x3F, 0xC3, 0xCF, 0x87, 0x8F, 0x8F, 0x1F, 0x9E,
  0x1F, 0x3C, 0x1F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x80,
  0xEF, 0x03, 0x9F, 0x06, 0x3F, 0x0C, 0xFF, 0xB0, 0x3F, 0x80, 0x1E, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x01,
  0x0F, 0xC1, 0x83, 0xF3, 0xE0, 0xFB, 0xF0, 0x3E, 0x7C, 0x1E, 0x1F, 0x0F,
  0x0F, 0x87, 0x83, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1C,
  0x3C, 0x0E, 0x1E, 0x07, 0x3F, 0x03, 0x3F, 0xC3, 0x1F, 0xF9, 0x08, 0xFF,
  0x00, 0x7F, 0x00, 0x3B, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x3F, 0x81, 0x9F, 0xE6, 0x1F, 0x9C, 0x1E, 0x38,
  0x3C, 0xE0, 0x79, 0xC0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x07,
  0x3E, 0x0E, 0x7C, 0x1C, 0x7C, 0x78, 0x7F, 0x70, 0xF8, 0xE0, 0xE1, 0xC1,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x20, 0x43, 0x86, 0x7C, 0xEF, 0xDF, 0xBE, 0xF1, 0xE7,
  0x1C, 0x61, 0xC4, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xE4, 0x3F, 0x87, 0xF8, 0x0F, 0x00, 0x60, 0x02, 0x00, 0x03,
  0xE0, 0x00, 0x60, 0x00, 0x80, 0x01, 0x02, 0x04, 0x1C, 0x11, 0xFF, 0xC9,
  0xFF, 0x41, 0xFB, 0x00, 0x8E, 0x04, 0x3C, 0x38, 0xF9, 0xF1, 0xFF, 0xE7,
  0xEF, 0x8E, 0x1F, 0x10, 0x3C, 0x80, 0x63, 0x81, 0x9F, 0x84, 0xFF, 0xE0,
  0x7F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x0E, 0x07, 0x81, 0xFF, 0x7F, 0xE3, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3F, 0xCF, 0xF0, 0x3C, 0x03, 0x00, 0x20, 0x30, 0x0C, 0x0E, 0x03, 0x07,
  0xC1, 0xE1, 0xF0, 0xFC, 0xBE, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3F, 0x3F, 0xDF, 0xF7, 0xE0,
  0xF8, 0xF0, 0x1C, 0x1C, 0x02, 0x00, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x06, 0x1C, 0x07, 0x0F, 0x0F, 0xC7, 0xDF, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x18, 0x1C, 0x0C, 0x0E, 0x0F, 0x06, 0x07, 0xE6, 0x07,
  0xFE, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x0F, 0xC1, 0x81, 0x87,
  0xE1, 0xE1, 0xE1, 0xFB, 0xFB, 0xF8, 0x7F, 0x3E, 0x3E, 0x1E, 0x1E, 0x0F,
  0x0F, 0x0F, 0x07, 0xC7, 0x87, 0x81, 0xE3, 0xC3, 0xC0, 0xF1, 0xE1, 0xE0,
  0x78, 0xF0, 0xF0, 0x3C, 0x78, 0x78, 0x1C, 0x3C, 0x3C, 0x0E, 0x1E, 0x1E,
  0x07, 0x0F, 0x0F, 0x03, 0x07, 0x87, 0xE3, 0x07, 0xE7, 0xFB, 0x03, 0xF0,
  0x7F, 0x00, 0xF0, 0x1F, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x43, 0xE3, 0x0F, 0x9E, 0x7F, 0xF8, 0x3D, 0xF0, 0xF3, 0x03,
  0xCC, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x20, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xC3, 0x02,
  0x08, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x81, 0x83, 0x1F, 0x03, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x1E, 0x02, 0x0F, 0xC3,
  0x87, 0xE7, 0xC1, 0xFD, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E, 0x0F, 0x0F, 0x87,
  0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0x87, 0xD9, 0xC7, 0xF8, 0xC0, 0xF8,
  0xE0, 0x38, 0x60, 0x08, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x0C, 0x03, 0xE0, 0xFE, 0x3F, 0xC0,
  0x78, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x23, 0x18, 0xFC, 0x7F, 0x81, 0xF8,
  0x3F, 0x8C, 0xF9, 0x1F, 0x61, 0xE8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81,
  0xF0, 0x76, 0x0E, 0x41, 0x84, 0x20, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0xE0,
  0x78, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x07, 0x03, 0x80, 0x38, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x38, 0x06, 0x00, 0xE0, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0x70,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x01,
  0x80, 0x38, 0x07, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x18, 0x1C, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0,
};

const GFXglyph UnifrakturMaguntia_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 29, 9, 1, -28 },
  { 27, 13, 11, 16, 1, -28 },
  { 45, 18, 22, 20, 1, -25 },
  { 95, 14, 32, 16, 1, -30 },
  { 151, 26, 28, 28, 1, -28 },
  { 242, 20, 24, 22, 1, -24 },
  { 302, 6, 11, 8, 1, -28 },
  { 311, 8, 32, 10, 1, -31 },
  { 343, 8, 32, 10, 1, -31 },
  { 375, 13, 16, 14, 0, -30 },
  { 401, 13, 14, 15, 1, -20 },
  { 424, 6, 11, 7, 0, -6 },
  { 433, 11, 7, 12, 1, -15 },
  { 443, 6, 7, 8, 1, -6 },
  { 449, 19, 31, 20, 1, -29 },
  { 523, 17, 27, 18, 1, -27 },
  { 581, 12, 27, 13, 0, -27 },
  { 622, 16, 26, 18, 1, -26 },
  { 674, 17, 27, 18, 1, -27 },
  { 732, 17, 27, 18, 0, -27 },
  { 790, 17, 28, 18, 1, -28 },
  { 850, 16, 27, 18, 1, -27 },
  { 904, 15, 26, 17, 1, -26 },
  { 953, 16, 27, 18, 1, -27 },
  { 1007, 16, 28, 18, 1, -28 },
  { 1063, 6, 20, 8, 1, -19 },
  { 1078, 7, 24, 7, 0, -19 },
  { 1099, 11, 14, 11, 0, -18 },
  { 1119, 13, 9, 15, 1, -16 },
  { 1134, 11, 14, 11, 0, -18 },
  { 1154, 15, 29, 18, 1, -28 },
  { 1209, 22, 23, 24, 1, -18 },
  { 1273, 30, 29, 32, 1, -28 },
  { 1382, 34, 29, 35, 0, -28 },
  { 1506, 25, 29, 27, 1, -28 },
  { 1597, 30, 30, 32, 1, -29 },
  { 1710, 26, 28, 27, 1, -28 },
  { 1801, 28, 34, 29, 1, -29 },
  { 1920, 28, 29, 30, 1, -28 },
  { 2022, 28, 35, 29, 0, -30 },
  { 2145, 25, 33, 27, 1, -28 },
  { 2249, 26, 38, 28, 1, -28 },
  { 2373, 30, 29, 32, 1, -28 },
  { 2482, 21, 28, 22, 1, -27 },
  { 2556, 41, 29, 43, 1, -27 },
  { 2705, 33, 29, 34, 1, -28 },
  { 2825, 27, 29, 29, 1, -28 },
  { 2923, 33, 34, 35, 1, -27 },
  { 3064, 29, 31, 31, 1, -28 },
  { 3177, 34, 29, 36, 1, -28 },
  { 3301, 28, 28, 30, 1, -28 },
  { 3399, 27, 28, 29, 1, -28 },
  { 3494, 26, 29, 28, 1, -27 },
  { 3589, 33, 29, 35, 1, -28 },
  { 3709, 40, 29, 42, 1, -28 },
  { 3854, 26, 29, 28, 1, -28 },
  { 3949, 31, 35, 33, 1, -29 },
  { 4085, 24, 33, 26, 1, -28 },
  { 4184, 5, 31, 7, 1, -29 },
  { 4204, 24, 27, 4, -7, -25 },
  { 4285, 5, 31, 7, 1, -29 },
  { 4305, 14, 10, 16, 1, -27 },
  { 4323, 18, 3, 18, 0, 4 },
  { 4330, 6, 7, 20, 6, -27 },
  { 4336, 16, 21, 18, 1, -20 },
  { 4378, 16, 28, 17, 1, -27 },
  { 4434, 12, 21, 14, 1, -20 },
  { 4466, 16, 28, 18, 1, -27 },
  { 4522, 12, 21, 14, 1, -20 },
  { 4554, 11, 34, 10, 0, -28 },
  { 4601, 16, 28, 18, 1, -20 },
  { 4657, 16, 34, 17, 1, -27 },
  { 4725, 10, 28, 11, 0, -27 },
  { 4760, 11, 35, 9, -2, -28 },
  { 4809, 11, 28, 13, 1, -27 },
  { 4848, 11, 28, 11, 1, -27 },
  { 4887, 26, 21, 28, 1, -20 },
  { 4956, 18, 21, 20, 1, -20 },
  { 5004, 15, 21, 16, 0, -20 },
  { 5044, 17, 31, 18, 0, -23 },
  { 5110, 15, 28, 17, 1, -20 },
  { 5163, 12, 21, 14, 1, -20 },
  { 5195, 14, 25, 16, 1, -24 },
  { 5239, 11, 26, 12, 0, -25 },
  { 5275, 18, 21, 20, 1, -20 },
  { 5323, 17, 23, 18, 0, -22 },
  { 5372, 25, 24, 27, 1, -23 },
  { 5447, 14, 29, 15, 1, -21 },
  { 5498, 17, 30, 18, 1, -23 },
  { 5562, 11, 27, 13, 1, -20 },
  { 5600, 10, 31, 13, 1, -30 },
  { 5639, 2, 32, 6, 2, -30 },
  { 5647, 10, 31, 13, 1, -30 },
  { 5686, 12, 3, 14, 1, -13 },
};

const GFXfont UnifrakturMaguntia_Regular39pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular39pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular39pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR39PT7B_H_
