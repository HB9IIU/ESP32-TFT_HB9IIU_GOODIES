#ifndef _UNIFRAKTURMAGUNTIA_REGULAR68PT7B_H_
#define _UNIFRAKTURMAGUNTIA_REGULAR68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UnifrakturMaguntia-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UnifrakturMaguntia_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xF7,
  0xFE, 0x7F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0xF0, 0x1F, 0x87, 0xFC, 0x7F, 0xE3, 0xF8, 0x0F, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x04, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x78, 0x03,
  0xC1, 0xF8, 0x0F, 0xC7, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xCF, 0xF0, 0x7F,
  0x8F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0,
  0x3C, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x06, 0x01, 0x80, 0x0C, 0x02,
  0x00, 0x30, 0x0C, 0x00, 0x40, 0x10, 0x01, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x7E, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xC1, 0xE0, 0x0F, 0x80,
  0x70, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00,
  0x3E, 0x3F, 0x80, 0x3E, 0x3F, 0xC0, 0x1C, 0x3F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x78, 0x03, 0xFF, 0x7C, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0xF8, 0x07, 0x01, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0x83, 0xC7, 0x80, 0x00, 0x00, 0x38, 0x3C, 0x3E, 0x00, 0x00, 0x03, 0x83,
  0xE0, 0xF8, 0x00, 0x00, 0x38, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0x81, 0xF8,
  0x3F, 0x00, 0x00, 0x3C, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xC0, 0xFE, 0x0F,
  0xC0, 0x00, 0x1C, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xC0, 0x3F, 0x03, 0xF8,
  0x00, 0x1C, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xC0, 0x0F, 0xC0, 0xFE, 0x00,
  0x1C, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0E,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x0E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x0E, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x0E, 0x00, 0x00, 0x0F,
  0x0F, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x70, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x70, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x70,
  0x3F, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x3E, 0x00, 0x00, 0x38, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x38, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0x80, 0x3F, 0x03, 0xF0, 0x00, 0x38, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3C, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1C, 0x00, 0x1F, 0x81, 0xF8, 0x01,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x1C, 0x00, 0x07, 0xE0, 0x7E, 0x01, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xC0, 0x00,
  0x07, 0xE1, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0xE0, 0x00, 0x00,
  0x7C, 0xF8, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x07, 0xF0,
  0x3C, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x01,
  0xFC, 0x78, 0x00, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1C, 0x03, 0xE7, 0xF8, 0x03, 0x80, 0xF8, 0xFF, 0x80, 0x60, 0x1E,
  0x1F, 0xF0, 0x0C, 0x07, 0xC1, 0xFF, 0x01, 0x81, 0xF8, 0x3F, 0xE0, 0x60,
  0x3F, 0x03, 0xFE, 0x0C, 0x07, 0xE0, 0x7F, 0xC1, 0x81, 0xFC, 0x07, 0xFC,
  0x60, 0x3F, 0x80, 0xFF, 0x8C, 0x07, 0xF0, 0x0F, 0xFB, 0x00, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x06, 0x7F, 0x80, 0x7F, 0xE1,
  0xCF, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF7,
  0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x04,
  0x01, 0xC0, 0x3C, 0x0F, 0xC7, 0xFC, 0xFF, 0xC7, 0xF8, 0x7F, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0x3F,
  0xB8, 0x7E, 0x3E, 0x7F, 0x7E, 0x38, 0xFC, 0xFC, 0x73, 0xF8, 0xFC, 0xC7,
  0xE1, 0xFC, 0x9F, 0xC3, 0xBF, 0xFF, 0x80, 0x0F, 0x00, 0x08, 0x3F, 0x86,
  0x1F, 0xEB, 0xFC, 0x7F, 0x93, 0xF8, 0xFE, 0x73, 0xF9, 0xF8, 0xE7, 0xF7,
  0xF3, 0xC7, 0xE0, 0xE7, 0xCE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x3C, 0x0F, 0xC3, 0xFC,
  0xFF, 0xC7, 0xF8, 0x7F, 0x07, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0,
  0x00, 0x04, 0x01, 0xC0, 0x7C, 0x1F, 0xC7, 0xFD, 0xFF, 0xCF, 0xE0, 0xF8,
  0x0E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE,
  0x7F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE,
  0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xE3, 0xFC, 0x08, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x1E, 0x00, 0xFF, 0xE3, 0xC0,
  0x03, 0xFE, 0x38, 0x00, 0x3F, 0xE7, 0x00, 0x01, 0xFE, 0x70, 0x00, 0x1F,
  0xF6, 0x00, 0x01, 0xFF, 0x60, 0x00, 0x1F, 0xF4, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0xF0, 0x00,
  0x30, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x03, 0x07,
  0x80, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xC0, 0xFF, 0xE0, 0x1E, 0x00, 0xFF, 0xC0, 0x60, 0x00,
  0xFF, 0x83, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xE0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xC0, 0xFE, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0x80,
  0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0D, 0xFC, 0x00, 0x00, 0xCF, 0xE0,
  0x00, 0x0E, 0x7F, 0x00, 0x00, 0x63, 0xF8, 0x00, 0x06, 0x1F, 0xC0, 0x00,
  0x30, 0xFE, 0x00, 0x03, 0x07, 0xF0, 0x00, 0x30, 0x3F, 0x80, 0x01, 0x81,
  0xFC, 0x00, 0x18, 0x0F, 0xE0, 0x01, 0x80, 0x7F, 0x00, 0x0C, 0x03, 0xF8,
  0x00, 0xC0, 0x1F, 0xC0, 0x0E, 0x00, 0xFE, 0x00, 0x60, 0x07, 0xF0, 0x06,
  0x00, 0x3F, 0x80, 0x70, 0x01, 0xFC, 0x03, 0x00, 0x0F, 0xE0, 0x30, 0x00,
  0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x3F, 0xE0, 0x00, 0x37, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x1E, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x3F,
  0xC1, 0x80, 0x00, 0x7F, 0x84, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x1F,
  0x03, 0xF8, 0x00, 0x7C, 0x0F, 0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x1F, 0xC0, 0x01, 0xE0,
  0x7F, 0x00, 0x1E, 0x01, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x7F,
  0x80, 0xF8, 0x03, 0xFC, 0x07, 0xC0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x03,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3C, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xFC, 0x07,
  0xF8, 0xFF, 0xF8, 0x3F, 0xCE, 0x3F, 0xE1, 0xFE, 0xE0, 0xFF, 0x0F, 0xF6,
  0x03, 0xFC, 0x7F, 0xE0, 0x1F, 0xE3, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x03,
  0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F,
  0xC0, 0x1E, 0x00, 0x7E, 0x01, 0xE0, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xE1,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xC0, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x78, 0x7E, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x1E, 0x1F,
  0xC0, 0x01, 0xF0, 0xFF, 0x80, 0x0F, 0x07, 0xFE, 0x00, 0xF8, 0x1F, 0xFC,
  0x07, 0x80, 0xFF, 0xF8, 0x78, 0x03, 0xFF, 0xE7, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xDF, 0xFF, 0x80, 0x1C, 0x3F, 0xFE, 0x01, 0xC0,
  0x7F, 0xF8, 0x1C, 0x00, 0xFF, 0xC1, 0xC0, 0x03, 0xFF, 0x1E, 0x00, 0x07,
  0xF9, 0xF0, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0xFF, 0x78, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x78, 0x3F, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF8, 0xFE, 0x00,
  0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF,
  0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFE, 0x3F, 0xC0, 0x2F,
  0xF1, 0xFE, 0x03, 0x7F, 0x87, 0xF8, 0x33, 0xFC, 0x1F, 0xE3, 0x1F, 0xE0,
  0x7F, 0xF0, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xE0, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x3C, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1,
  0xFE, 0x00, 0x7E, 0x0F, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x1F, 0x01, 0xFC,
  0x01, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0x78, 0x00, 0xFC, 0x07,
  0x80, 0x03, 0xF0, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x04, 0x01, 0xC0, 0x38, 0x0F, 0x87, 0xFD, 0xFF, 0xCF, 0xE0, 0xF8, 0x0E,
  0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x70, 0x1F, 0x07, 0xF1,
  0xFF, 0x7F, 0xF3, 0xF8, 0x3E, 0x03, 0x80, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x70, 0x07, 0x00, 0xF8, 0x3F, 0xE7, 0xFF, 0x1F, 0xC0, 0xF8, 0x07, 0x00,
  0x20, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x0F, 0x01,
  0xF8, 0x3F, 0xC7, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0xFC, 0x1F, 0xC0, 0x78, 0x01, 0xF8, 0x3C, 0x00, 0x3F, 0x1E, 0x00,
  0x0F, 0xE7, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xF1, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x04, 0x03, 0xE0, 0x03, 0x00, 0x78, 0x00, 0xC0, 0x1F,
  0x00, 0x60, 0x03, 0xE0, 0x38, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x1F, 0x00,
  0x1F, 0x7C, 0x78, 0x1F, 0x00, 0x7F, 0xFC, 0x38, 0x3E, 0x00, 0xF9, 0xFC,
  0x3C, 0x3E, 0x03, 0xE1, 0xFC, 0x3C, 0x7C, 0x07, 0xE1, 0xF8, 0x3C, 0x7C,
  0x07, 0xC1, 0xF8, 0x3C, 0x7C, 0x0F, 0x81, 0xF8, 0x3C, 0x78, 0x1F, 0x81,
  0xF0, 0x3C, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0xF8, 0x3F, 0x03, 0xF0, 0x38,
  0xF8, 0x3F, 0x03, 0xF0, 0x78, 0xF8, 0x7E, 0x07, 0xE0, 0x78, 0xF8, 0x7E,
  0x07, 0xE0, 0xF8, 0xF8, 0x7E, 0x0F, 0xE0, 0xF0, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF0, 0xF8, 0x7C, 0x1F, 0xC3, 0xE0, 0x78, 0x7E, 0x3F, 0xC7, 0xC0, 0x78,
  0x7E, 0x7F, 0xCF, 0x80, 0x78, 0x7F, 0xFF, 0xFF, 0x8F, 0x3C, 0x3F, 0xE7,
  0xFE, 0x1E, 0x3C, 0x1F, 0x83, 0xF8, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0,
  0x38, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0x00, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x60, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x06, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0x80, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xF8, 0x0C, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0C, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0E, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x07,
  0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xF8,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x07, 0xFE, 0x03,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x7F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x7F, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x18, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x10, 0x7F, 0xFE, 0x07, 0x7F, 0xE7, 0x00, 0x03, 0xFF, 0xF9, 0xE7, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x83,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x83, 0x87, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xC0, 0x7F, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x98, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x1C,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE3, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x0E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xF8,
  0x03, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x40, 0xF8, 0x7F, 0xFF,
  0xF0, 0x0F, 0x80, 0x18, 0x1E, 0x3F, 0xFF, 0xFF, 0x00, 0xFC, 0x1E, 0x07,
  0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x7C, 0x00,
  0x01, 0xF0, 0x18, 0x1F, 0xE0, 0x00, 0x7C, 0x01, 0x8F, 0xFF, 0xB0, 0x1F,
  0x00, 0x13, 0xFF, 0xFE, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x7E, 0x00, 0x1C, 0x1F, 0xF0, 0x0F, 0xC0, 0x0E, 0x00,
  0x7C, 0x03, 0xF8, 0x03, 0x80, 0x03, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE0,
  0x00, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0xFE, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0x81, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x06, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0x80, 0x3F, 0xFE, 0x07, 0xE0,
  0x00, 0xE0, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x38, 0x00, 0x1F, 0xFC, 0x3E,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC7, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0xF8,
  0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x9C, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF3, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x70, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xEC, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFD, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xB0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFD, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xB8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x38,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x78,
  0x3E, 0x0E, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x01,
  0xC0, 0x01, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x02,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0x81, 0xFE,
  0x00, 0x01, 0xF0, 0x06, 0x3F, 0xFE, 0xC0, 0x1F, 0x00, 0x13, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x70, 0x7F, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0xE0, 0x00, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x20, 0x03, 0xF8, 0x1F, 0xF8, 0x07,
  0xC0, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0x6F, 0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0x87, 0xF8, 0xFF,
  0x80, 0x3F, 0xFE, 0x1F, 0x87, 0xFC, 0x00, 0xFF, 0xF8, 0x78, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x00,
  0x03, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0x01, 0xF8, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x70, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0x80, 0x04, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x03, 0x80,
  0x00, 0x3F, 0xF0, 0x07, 0xC0, 0xC0, 0x00, 0x1F, 0xFC, 0x03, 0xF8, 0x60,
  0x00, 0x07, 0xFF, 0x03, 0xFE, 0x38, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0x8E,
  0x00, 0x00, 0xFF, 0xE3, 0xFF, 0xC3, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC1,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x47, 0xFF, 0x87, 0xC0,
  0x0F, 0x01, 0xE3, 0xFF, 0xC1, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x40,
  0x00, 0x1E, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x07,
  0xE0, 0x60, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x18, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x06, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0x7F, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xEF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xC3, 0xFF, 0xC0, 0x07,
  0xE0, 0x01, 0xC0, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0x03, 0xF8, 0x03, 0xC0, 0x03, 0xFF, 0x81,
  0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0E, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1E, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x7F, 0xFF,
  0xC3, 0xFE, 0x03, 0xFF, 0x37, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xF0,
  0x07, 0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFE,
  0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0x8F, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC7, 0xFE, 0x00, 0x0F,
  0x80, 0x0F, 0xE1, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0xFF, 0xC0, 0x07,
  0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x03, 0x80, 0x03, 0xF8, 0x1F, 0xF8, 0x03,
  0x80, 0x01, 0xF8, 0x07, 0xFE, 0x03, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x03,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xFF, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x83, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xF3, 0xC3, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x07,
  0xE0, 0x07, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x1F,
  0xF8, 0x07, 0x80, 0x01, 0xFC, 0x7F, 0xFC, 0x07, 0x00, 0x01, 0xFC, 0xFF,
  0xFE, 0x06, 0x00, 0x01, 0xF8, 0xCF, 0xFF, 0x0C, 0x00, 0x03, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0x86, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x19, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0xFC,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0x8C, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF1, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x63, 0xFE, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3C, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0x83, 0x87, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xF0,
  0x03, 0x80, 0x00, 0x7E, 0x07, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x7F,
  0xFF, 0x80, 0x78, 0x00, 0x3F, 0x07, 0xFF, 0xFE, 0x03, 0xC0, 0x03, 0xF8,
  0x7C, 0x7F, 0xF8, 0x0E, 0x00, 0x1F, 0xC3, 0x80, 0xFF, 0xC0, 0x78, 0x00,
  0xFE, 0x18, 0x03, 0xFF, 0x03, 0xC0, 0x0F, 0xF1, 0x80, 0x0F, 0xF8, 0x1E,
  0x00, 0x7F, 0x8C, 0x00, 0x7F, 0xE0, 0xF0, 0x03, 0xFE, 0x40, 0x01, 0xFF,
  0x07, 0x80, 0x1F, 0xF2, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x7F, 0xD0, 0x00,
  0x3F, 0xF9, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xF8, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x83, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x70, 0x38, 0x00, 0x1F, 0xFE, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0x03, 0xFC, 0x38, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0xF1, 0x80, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x67, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xF0,
  0x38, 0x00, 0x3F, 0xF0, 0x33, 0xFF, 0xC1, 0x80, 0x01, 0xFF, 0xC4, 0x0F,
  0xFF, 0x38, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0x0F, 0xF8,
  0x00, 0x01, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xC3, 0xFF, 0x00, 0x00, 0x7E,
  0x1F, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0x03, 0xFF, 0x80,
  0x01, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0x88, 0x3F, 0xC0, 0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x02, 0x7F, 0xFF, 0xF8, 0x00, 0x36, 0x0F, 0xFF, 0xF0, 0x03,
  0x00, 0x1F, 0xFF, 0xE0, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xC0, 0x7F, 0xC0,
  0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x3C, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x70, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x60, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFE, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFE, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xC0,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0E, 0x00, 0x78, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1C, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x0F,
  0xC0, 0x78, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0xF0, 0x00,
  0x01, 0xF0, 0xE0, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x1F, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x1C, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x1C,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x71, 0xC0, 0x18, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x63, 0xF0, 0x38, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0xC7, 0xF8, 0x30, 0x03, 0xFF, 0x02, 0x0F, 0xFF, 0xC1, 0xCF, 0xFE, 0x60,
  0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0x9F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x30, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0xE7, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x07, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0x01, 0xFF, 0x00, 0x7C,
  0x03, 0xFF, 0xF3, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x7F, 0xFD, 0x00, 0x3F,
  0xE0, 0x38, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x38, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFC, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x0C, 0x00,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x06, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC2, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF1, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x60, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF0,
  0x18, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x70, 0x01, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x00, 0x38, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3C, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x18, 0x1C,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x06, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x02, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xE0, 0x01, 0xFF,
  0xC3, 0x07, 0xFF, 0xE0, 0xE0, 0x00, 0x7F, 0xFF, 0x87, 0x7F, 0xF8, 0xE0,
  0x00, 0x3F, 0xFF, 0x06, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC7, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xC4, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x33, 0xFF,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xE7, 0x7F, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0xFF, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xF8,
  0x3F, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xC0, 0x30, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFF,
  0x03, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xFC, 0x30, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x86, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF1, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFC, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x8C, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xE1, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x38,
  0x00, 0x83, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xC1, 0xE0, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xFC, 0x3C, 0x00,
  0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xDF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xFC, 0xC0, 0x00, 0x7E, 0x38, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF3, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x26, 0x7F,
  0xFF, 0xC1, 0x87, 0xFF, 0x07, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE3,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x70, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x86, 0x03, 0xFF, 0x00, 0x3F,
  0xC7, 0xFF, 0xFC, 0xC0, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xE8, 0x01,
  0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x0E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x8C, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x0C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x1F,
  0xE0, 0x00, 0x1C, 0x00, 0x10, 0x0F, 0xC7, 0xFF, 0x00, 0x00, 0xF0, 0x03,
  0x00, 0xFD, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xC3, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x60, 0x00, 0x1F, 0xFC, 0x20, 0x7F, 0xFF,
  0x0C, 0x00, 0x00, 0xFF, 0xFE, 0x08, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xF8, 0x08, 0x00, 0xFF,
  0xFF, 0xE0, 0xF8, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0xF8, 0x06, 0x0F, 0xFF,
  0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1C, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0C, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x06, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x06, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x06, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x02, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xFF,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x02, 0x60, 0x00, 0x00, 0x3F,
  0xFF, 0xCE, 0xE0, 0x00, 0x03, 0x1F, 0xFF, 0xFC, 0xC0, 0x00, 0x07, 0x07,
  0xFF, 0xF8, 0xC0, 0x00, 0x1E, 0x03, 0xFF, 0xE0, 0xC0, 0x00, 0x3C, 0x00,
  0xFF, 0xC0, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0xFE, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x03, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x3E,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xF0,
  0x00, 0x00, 0x43, 0xFF, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0xE3, 0xC0, 0x00,
  0x0E, 0x00, 0x3E, 0x03, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x06, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x18, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x60, 0x0F, 0xF0,
  0x01, 0xF8, 0x01, 0x80, 0xFF, 0xC0, 0x0F, 0xE0, 0x0C, 0x07, 0xFF, 0x00,
  0x3F, 0x80, 0x70, 0x0F, 0xFC, 0x00, 0xFF, 0x01, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1D, 0xFF, 0x01, 0x87, 0xFF, 0xE1, 0xE3, 0xFE, 0x28, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x38,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x8C, 0x0F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF6, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xFD, 0x80, 0x7F, 0xE0,
  0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x86, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x01, 0xFE,
  0x00, 0x1C, 0x00, 0x10, 0x3E, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x18, 0x0F,
  0x80, 0x1F, 0xF0, 0x00, 0x3E, 0x3C, 0x03, 0xC0, 0x07, 0xFE, 0x00, 0x03,
  0xFC, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xE3, 0xFF,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x20, 0x3F, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x1C, 0x71, 0x83, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x60, 0x76, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x78, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFE, 0x01, 0xC0, 0x03, 0xFF,
  0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x07, 0x80, 0x03, 0xFF, 0x01, 0xF0, 0x00,
  0x0F, 0xFC, 0x0F, 0x00, 0x07, 0xFE, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x3E,
  0x00, 0x07, 0xFC, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x0F, 0xFC,
  0x0E, 0x00, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x0F, 0xFC, 0x18, 0x00, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xFC, 0x30, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x1F, 0xE0, 0x60, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00,
  0xFE, 0x3F, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0xE0,
  0x01, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xC0, 0x07, 0x80, 0x06,
  0x00, 0x00, 0x07, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x06, 0x00, 0x00, 0x0F,
  0xC1, 0xFF, 0x80, 0x7F, 0x00, 0x0E, 0x00, 0x08, 0x1F, 0x01, 0xFF, 0x80,
  0xFF, 0x00, 0x0E, 0x00, 0x30, 0x3E, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0x01, 0xC0, 0x78, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xF0,
  0x03, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xFC, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xD8, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0xF7, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x38,
  0x03, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0C, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xC1, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xF1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x00, 0xFF,
  0xC7, 0xFF, 0xC3, 0xE0, 0x01, 0xFF, 0x38, 0x7E, 0x0F, 0x00, 0x03, 0xFC,
  0xC0, 0x60, 0x78, 0x00, 0x07, 0xFA, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0x83, 0x9F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0B, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0x3F, 0xF0, 0x00, 0x00, 0xF8, 0x0C, 0x7F, 0xE0,
  0x00, 0x07, 0xF0, 0x31, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0x83, 0xFF, 0xC3,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x10, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0xC0, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFD, 0x80, 0x7F, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xE0, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x3C, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x70,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFE, 0x60, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x60, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xE0,
  0x60, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x70, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0C,
  0x00, 0x10, 0x3E, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x60, 0x3E, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7C,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x18, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x70, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF9, 0xE0, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x06, 0x3F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x78,
  0xC3, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x3F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x19,
  0xFF, 0xE0, 0x03, 0x0F, 0xFF, 0x80, 0x70, 0x3F, 0xF0, 0x0E, 0x01, 0xFE,
  0x01, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7C,
  0x00, 0xFE, 0x07, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0xC0, 0xFE, 0x33, 0xFF, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xC7, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x40, 0x38, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x21, 0xF0,
  0x00, 0x03, 0x3F, 0x00, 0x00, 0x13, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x0F, 0xE0, 0x1C,
  0x00, 0xFE, 0x03, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xF0, 0x0F,
  0xE7, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3E,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xC0, 0xFE,
  0x00, 0x7C, 0x0F, 0xE0, 0x07, 0x80, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x0E,
  0x01, 0xFF, 0xC1, 0xC0, 0x3F, 0xFE, 0x18, 0x01, 0xFF, 0xFB, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3B,
  0xFC, 0x03, 0x8F, 0xE0, 0x38, 0x7F, 0x83, 0xC1, 0xFC, 0x3E, 0x0F, 0xF1,
  0xE0, 0x3F, 0x9F, 0x01, 0xF8, 0xF8, 0x06, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x13, 0xFF, 0x80, 0x06, 0x0F, 0xFC, 0x0F, 0xC0, 0x7F,
  0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3E, 0x1F, 0xC0, 0x03, 0xE1,
  0xFC, 0x00, 0x3E, 0x1F, 0xC0, 0x03, 0xE1, 0xFC, 0x00, 0x3C, 0x1F, 0xC0,
  0x03, 0xC1, 0xFC, 0x00, 0x3C, 0x1F, 0xC0, 0x03, 0x81, 0xFE, 0x00, 0x78,
  0x1F, 0xF0, 0x07, 0x03, 0xFF, 0xC0, 0x70, 0x7F, 0xFE, 0x0E, 0x00, 0xFF,
  0xF8, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3B, 0xF8,
  0x03, 0x8F, 0xE0, 0x38, 0x7F, 0x03, 0xC1, 0xFC, 0x3E, 0x0F, 0xE1, 0xE0,
  0x7F, 0x9F, 0x01, 0xFC, 0xF8, 0x0F, 0xE7, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0x9F, 0x81, 0xE0, 0xFC, 0x3C, 0x07, 0xEF, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC2, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x61, 0xF8, 0x02, 0x01, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xDF, 0xFC, 0x00, 0x18, 0xFF, 0xF8, 0x03, 0x07, 0xFF, 0xC0, 0xF0,
  0x3F, 0xF8, 0x1E, 0x00, 0xFF, 0x81, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC,
  0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xF1, 0xFC, 0x0F, 0xFC, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x70, 0x00, 0xFC, 0x04, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x01,
  0xE0, 0x3F, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0x00, 0x0F, 0xC1, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x60, 0xF8, 0x00,
  0x02, 0x1F, 0x00, 0x00, 0x33, 0xF0, 0x00, 0x01, 0x7E, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x0F, 0xE0, 0x30, 0x00,
  0xFE, 0x07, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0xE0, 0x0F, 0xEF,
  0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0,
  0xFE, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x10, 0xF8, 0x1F, 0xF3,
  0x0F, 0x83, 0xFF, 0xE0, 0xF0, 0x1F, 0xFC, 0x1F, 0x00, 0x7F, 0x81, 0xE0,
  0x03, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xFC, 0x6F, 0xF8, 0xCF, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF1, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x30, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x6F, 0xF8, 0x0C, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xD8, 0x00, 0xF8, 0xC0, 0x0F, 0x04, 0x01, 0xF0, 0x20,
  0x3C, 0x03, 0x0F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF0,
  0x40, 0x3C, 0x06, 0x07, 0x80, 0x20, 0xF0, 0x03, 0x1F, 0x06, 0x1B, 0xF1,
  0xE1, 0xFF, 0x3E, 0x0F, 0xF3, 0xE0, 0xFF, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x08, 0x0F,
  0xF8, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x78, 0x20, 0x1E, 0x0C, 0x0F, 0x80, 0x43, 0xE0,
  0x0C, 0x7C, 0x00, 0xDF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x41,
  0xFF, 0x10, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE1, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF,
  0x0F, 0xFF, 0x8F, 0xFE, 0x7F, 0xF8, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x88, 0xFF, 0xF3,
  0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xF0, 0x8F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x80, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x47, 0xFF, 0x03, 0xFF, 0x87, 0xFE,
  0x03, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x80,
  0x0F, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFF, 0x01, 0xFC, 0x3F, 0xF0, 0x3F, 0x83, 0xFE, 0x07, 0xF0, 0x3F, 0xE0,
  0xFE, 0x07, 0xFE, 0x1F, 0xC0, 0x7F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xE1, 0xFC, 0x00, 0x7C, 0x3F,
  0x80, 0x0F, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0x80, 0x78, 0x3F, 0xFC, 0x1E,
  0x0F, 0xFF, 0xC3, 0x80, 0x3F, 0xFE, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x1F, 0xF0, 0x07, 0x80, 0x7F, 0xE0,
  0x7E, 0x01, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFD, 0xFF,
  0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x01, 0xFF,
  0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0,
  0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0x83, 0xFF, 0x00, 0x3C,
  0x1F, 0xFE, 0x00, 0xF0, 0x7F, 0xFE, 0x07, 0x83, 0xFF, 0xFE, 0x18, 0x0F,
  0xFF, 0xFC, 0xC0, 0x20, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF0,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x37, 0xFF, 0x00, 0x0C, 0x7F, 0xF8, 0x03, 0x87, 0xFF, 0xC0, 0xE0, 0x7F,
  0xF4, 0x3C, 0x03, 0xFC, 0x0F, 0x00, 0x3F, 0x83, 0xE0, 0x07, 0xF0, 0x7C,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xE0,
  0x3F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xF3, 0xFE, 0x07, 0xFF, 0xDF, 0xC0,
  0x7F, 0xE3, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0x00,
  0xFC, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x3C, 0x01, 0x80, 0xF8, 0x0F, 0x07, 0xF0, 0x3C,
  0x3F, 0xE1, 0xF8, 0xFF, 0x8F, 0xE7, 0xFF, 0x7F, 0xD3, 0xFF, 0xFF, 0x87,
  0xF9, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x0F, 0x01, 0xFC, 0x18, 0x07, 0xF0,
  0x60, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x10, 0x07, 0xFC, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x1F, 0x80,
  0x30, 0x0F, 0xF8, 0x1C, 0x07, 0xFF, 0xFE, 0x06, 0x7F, 0xFF, 0x83, 0x0F,
  0xFF, 0xC1, 0x80, 0xFF, 0xE0, 0xE0, 0x0F, 0xF0, 0x38, 0x00, 0x78, 0x1E,
  0x00, 0x0C, 0x07, 0xC0, 0x06, 0x01, 0xF0, 0x03, 0x80, 0x7E, 0x01, 0xE0,
  0x1F, 0xE0, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x07,
  0x80, 0x3F, 0x80, 0xC0, 0x07, 0xE0, 0x60, 0x01, 0xF0, 0x38, 0x00, 0x3C,
  0x1F, 0x80, 0x0E, 0x0F, 0xF8, 0x03, 0x07, 0xFF, 0x81, 0x81, 0xFF, 0xFC,
  0xC0, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x20, 0xFF, 0x8C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xFC,
  0x00, 0x7C, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFC, 0x4F, 0xF0, 0x1F, 0xF0, 0x8F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x87, 0xFE, 0x47, 0xFF, 0x9B, 0xFF, 0x8F, 0xFF, 0xE7, 0xFE, 0x01,
  0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x01, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0x07, 0xFC, 0xE3, 0xFE,
  0x1F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1,
  0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00,
  0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x7F, 0x01, 0xE0, 0x03, 0xFF, 0x06, 0x00, 0x0F,
  0xFF, 0x30, 0x00, 0x7F, 0xFF, 0x80, 0x02, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x06,
  0x00, 0x06, 0x07, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0xFF, 0xC0, 0x3F, 0x00,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x81, 0xFF, 0x87, 0xFF, 0x1F, 0xF8,
  0x1F, 0xF1, 0xFF, 0xEF, 0xFF, 0x81, 0xFF, 0x63, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0x1F, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1E, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0x80,
  0x3F, 0x80, 0xFF, 0x80, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x18, 0x01, 0xFF,
  0x0F, 0xFF, 0xC6, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x08, 0x03, 0xE0, 0x18, 0x07, 0xF0, 0x3C, 0x07,
  0xF8, 0x7E, 0x0F, 0xF8, 0xFE, 0x1F, 0xFD, 0xFF, 0x1B, 0xFF, 0xFF, 0x11,
  0xFE, 0x7F, 0x01, 0xFE, 0x7E, 0x01, 0xFC, 0x3E, 0x01, 0xFC, 0x3C, 0x01,
  0xFC, 0x18, 0x01, 0xFC, 0x10, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x10, 0x01,
  0xFF, 0x30, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x1C, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x0C,
  0x01, 0xF8, 0x07, 0x03, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x40, 0x1F, 0xE0, 0x03, 0x00, 0x7F,
  0xE0, 0x3E, 0x01, 0xFF, 0x81, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFD,
  0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F,
  0x80, 0x7F, 0x88, 0x3E, 0x03, 0xFE, 0x60, 0xF0, 0x1F, 0xFF, 0x07, 0xC0,
  0x1F, 0xF8, 0x1E, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x80, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x81, 0x07, 0xF8, 0x40, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0xE0, 0xE0, 0x70, 0x7F, 0x98, 0x1F, 0xFC, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xCF, 0xF8, 0x30, 0xFF, 0x0E, 0x1F, 0xE3, 0x81, 0xFE, 0x60, 0x3F, 0xDC,
  0x03, 0xFB, 0x80, 0x7F, 0x60, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xB8, 0x01, 0xF7, 0x00, 0x3E, 0xE0,
  0x07, 0x9C, 0x00, 0xF1, 0x80, 0x1C, 0x30, 0x07, 0x03, 0x00, 0xC0, 0x20,
  0x30, 0x02, 0x0C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
};

const GFXglyph UnifrakturMaguntia_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 12, 50, 16, 2, -49 },
  { 76, 23, 18, 27, 2, -48 },
  { 128, 31, 39, 35, 2, -44 },
  { 280, 24, 55, 28, 2, -52 },
  { 445, 45, 47, 49, 2, -48 },
  { 710, 35, 43, 39, 2, -42 },
  { 899, 11, 18, 14, 1, -48 },
  { 924, 15, 56, 17, 1, -54 },
  { 1029, 15, 55, 17, 1, -53 },
  { 1133, 23, 27, 24, 0, -51 },
  { 1211, 22, 24, 27, 3, -34 },
  { 1277, 11, 18, 12, 0, -10 },
  { 1302, 19, 13, 20, 2, -27 },
  { 1333, 11, 11, 14, 1, -10 },
  { 1349, 33, 54, 36, 2, -51 },
  { 1572, 30, 48, 32, 1, -47 },
  { 1752, 20, 47, 22, 1, -47 },
  { 1870, 28, 46, 31, 1, -46 },
  { 2031, 30, 47, 32, 1, -47 },
  { 2208, 29, 46, 31, 1, -46 },
  { 2375, 30, 48, 32, 1, -48 },
  { 2555, 29, 49, 31, 1, -48 },
  { 2733, 27, 47, 29, 1, -47 },
  { 2892, 29, 48, 32, 1, -48 },
  { 3066, 29, 48, 31, 1, -48 },
  { 3240, 11, 33, 14, 1, -32 },
  { 3286, 12, 40, 12, 0, -32 },
  { 3346, 19, 25, 20, 0, -32 },
  { 3406, 23, 15, 26, 2, -28 },
  { 3450, 19, 25, 20, 0, -32 },
  { 3510, 26, 50, 31, 2, -49 },
  { 3673, 40, 40, 41, 1, -31 },
  { 3873, 52, 49, 55, 2, -48 },
  { 4192, 59, 50, 61, 0, -49 },
  { 4561, 43, 50, 47, 2, -49 },
  { 4830, 51, 53, 55, 2, -50 },
  { 5168, 45, 50, 48, 2, -49 },
  { 5450, 49, 58, 51, 1, -50 },
  { 5806, 49, 51, 52, 2, -49 },
  { 6119, 48, 62, 50, 1, -53 },
  { 6491, 44, 59, 47, 1, -50 },
  { 6816, 46, 67, 48, 1, -50 },
  { 7202, 53, 50, 55, 1, -48 },
  { 7534, 37, 49, 39, 1, -48 },
  { 7761, 72, 52, 75, 2, -48 },
  { 8229, 57, 49, 60, 2, -48 },
  { 8579, 49, 51, 51, 1, -49 },
  { 8892, 58, 59, 61, 1, -48 },
  { 9320, 52, 54, 54, 1, -49 },
  { 9671, 60, 50, 63, 2, -49 },
  { 10046, 48, 50, 52, 2, -49 },
  { 10346, 48, 49, 51, 2, -48 },
  { 10640, 46, 52, 48, 1, -48 },
  { 10939, 58, 51, 60, 1, -50 },
  { 11309, 71, 50, 73, 1, -49 },
  { 11753, 46, 51, 49, 1, -50 },
  { 12047, 56, 61, 58, 1, -50 },
  { 12474, 43, 59, 45, 1, -50 },
  { 12792, 10, 53, 12, 1, -50 },
  { 12859, 42, 47, 7, -13, -44 },
  { 13106, 10, 53, 12, 1, -50 },
  { 13173, 26, 18, 28, 1, -48 },
  { 13232, 33, 5, 31, -1, 8 },
  { 13253, 10, 13, 34, 11, -48 },
  { 13270, 28, 37, 31, 2, -35 },
  { 13400, 28, 49, 30, 1, -47 },
  { 13572, 21, 36, 24, 2, -35 },
  { 13667, 28, 48, 31, 2, -47 },
  { 13835, 21, 36, 25, 2, -35 },
  { 13930, 21, 61, 17, -1, -49 },
  { 14091, 28, 49, 32, 2, -35 },
  { 14263, 28, 60, 30, 1, -48 },
  { 14473, 16, 48, 19, 1, -47 },
  { 14569, 20, 60, 17, -4, -48 },
  { 14719, 20, 49, 22, 1, -47 },
  { 14842, 19, 50, 19, 1, -48 },
  { 14961, 45, 37, 48, 2, -36 },
  { 15170, 31, 37, 34, 2, -35 },
  { 15314, 27, 36, 28, 0, -35 },
  { 15436, 30, 54, 31, 0, -40 },
  { 15639, 27, 49, 29, 1, -35 },
  { 15805, 22, 36, 25, 1, -35 },
  { 15904, 26, 43, 28, 1, -42 },
  { 16044, 19, 45, 21, 1, -43 },
  { 16151, 31, 36, 34, 2, -35 },
  { 16291, 30, 40, 31, -1, -39 },
  { 16441, 43, 42, 47, 2, -40 },
  { 16667, 24, 50, 27, 1, -36 },
  { 16817, 30, 53, 32, 1, -41 },
  { 17016, 19, 48, 23, 2, -36 },
  { 17130, 19, 54, 23, 1, -53 },
  { 17259, 4, 56, 11, 3, -53 },
  { 17287, 19, 54, 23, 1, -53 },
  { 17416, 21, 5, 25, 2, -23 },
};

const GFXfont UnifrakturMaguntia_Regular68pt7b PROGMEM = {
  (uint8_t  *)UnifrakturMaguntia_Regular68pt7bBitmaps,
  (GFXglyph *)UnifrakturMaguntia_Regular68pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _UNIFRAKTURMAGUNTIA_REGULAR68PT7B_H_
