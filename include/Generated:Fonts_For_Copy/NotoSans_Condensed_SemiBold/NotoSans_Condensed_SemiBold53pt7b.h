#ifndef _NOTOSANS_CONDENSED_SEMIBOLD53PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFE, 0xFF,
  0xFE, 0xFE, 0x7E, 0x10, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07,
  0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F,
  0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF8, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFC, 0xC3, 0xC7, 0xE3, 0x02, 0x3F, 0x0C, 0x00, 0xFC,
  0x30, 0x03, 0xF0, 0xC0, 0x07, 0xE3, 0x00, 0x1F, 0x8C, 0x00, 0x7F, 0xB0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x37, 0xF8, 0x00,
  0xCF, 0xE0, 0x03, 0x1F, 0x80, 0x0C, 0x3F, 0x00, 0x30, 0xFC, 0x00, 0xC3,
  0xEC, 0x03, 0x1F, 0xBC, 0x0C, 0xFE, 0xFF, 0x3F, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x0F, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xCF, 0xC0, 0x3E, 0x00,
  0x3C, 0x3E, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0x80,
  0xF8, 0x00, 0xF8, 0x3E, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE1, 0xF0,
  0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0xF8, 0x00, 0x1F, 0x07,
  0x87, 0x87, 0xF0, 0xF8, 0x7C, 0x7C, 0x7F, 0xC3, 0xC3, 0xE3, 0xE7, 0xFF,
  0x1F, 0x1F, 0x3E, 0x3F, 0xFC, 0xFF, 0xF1, 0xF3, 0xF3, 0xE3, 0xFF, 0x9F,
  0x1F, 0x1F, 0x0F, 0xF8, 0xF8, 0xF8, 0x7C, 0x3F, 0x87, 0x8F, 0x83, 0xE0,
  0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0xF8, 0x00, 0x3E, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0x83,
  0xE0, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0xF0, 0x01, 0xF0,
  0x0F, 0x8F, 0x80, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0x80, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xE3, 0xFF, 0xF0,
  0x7F, 0x3F, 0xFF, 0x83, 0xF1, 0xFC, 0xFE, 0x1F, 0x9F, 0xC3, 0xF9, 0xFC,
  0xFE, 0x0F, 0xEF, 0xE7, 0xE0, 0x7F, 0x7E, 0x3F, 0x01, 0xFF, 0xF1, 0xF8,
  0x07, 0xFF, 0x0F, 0xC0, 0x1F, 0xF8, 0x7E, 0x00, 0xFF, 0x83, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xDF, 0xC1, 0xFF, 0xF8, 0x7F, 0x03,
  0xFF, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x40, 0x7C, 0x0B, 0xE3, 0xC3, 0xDF, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x7F, 0x07,
  0xC1, 0xF0, 0x1C, 0x0E, 0x00, 0x20, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1,
  0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E,
  0x10, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFE, 0x3F,
  0x83, 0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x38, 0x7F, 0x10, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFC, 0x3F, 0xC3, 0x80, 0x7F, 0x0C, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3E, 0x07,
  0xF8, 0xC0, 0x1F, 0xC4, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7B, 0xF0, 0x00, 0xFB,
  0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xE3,
  0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83,
  0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFD, 0xF8, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC7, 0xF8, 0x3F, 0x3F, 0xF0, 0xFD, 0xFF, 0xE3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xE0, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x07,
  0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xF0,
  0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x7E,
  0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F,
  0x03, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0x7F, 0x87, 0xF8, 0xFF, 0x1F, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC7, 0xE0, 0x7F, 0x3F, 0x80, 0xFC,
  0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFE, 0xF8,
  0xFF, 0xFB, 0xE1, 0xFF, 0xCF, 0x83, 0xFE, 0x7E, 0x00, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x7C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0x10, 0x1E, 0x1F, 0x9F, 0xCF,
  0xF7, 0xFB, 0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x78, 0x3F, 0xCC, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0xFF, 0x07, 0xC3, 0xE0, 0x3F, 0xFC, 0x3E, 0x3E, 0x07,
  0xFF, 0xC3, 0xE3, 0xC0, 0xFF, 0xFC, 0x1E, 0x7C, 0x1F, 0x87, 0xC1, 0xE7,
  0xC1, 0xF0, 0x7C, 0x1F, 0x7C, 0x3E, 0x07, 0xC1, 0xF7, 0x83, 0xE0, 0x7C,
  0x1F, 0x78, 0x3E, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF8, 0x3C,
  0x07, 0xC1, 0xFF, 0x83, 0xC0, 0x7C, 0x1F, 0xF8, 0x3C, 0x07, 0xC1, 0xEF,
  0x83, 0xC0, 0x7C, 0x1E, 0xF8, 0x3E, 0x0F, 0xC1, 0xE7, 0x83, 0xE0, 0xFC,
  0x3E, 0x78, 0x3E, 0x0F, 0xC3, 0xC7, 0x83, 0xF1, 0xFC, 0x7C, 0x7C, 0x1F,
  0xFD, 0xFF, 0xC7, 0xC0, 0xFF, 0x9F, 0xF8, 0x7C, 0x0F, 0xF8, 0xFF, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x10, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x83, 0xFF,
  0xBF, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF,
  0x00, 0xFE, 0x7E, 0x07, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0xFC, 0x0F, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFE, 0x0F, 0x8F, 0xF8, 0x02, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x02, 0x1F, 0xF0, 0x3C, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xF0, 0x1F, 0xF1,
  0xF8, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xF3,
  0xF0, 0x07, 0xF9, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFE, 0x07,
  0xC1, 0xFE, 0x00, 0x30, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x7F, 0x1F, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xF0,
  0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F,
  0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF3, 0xF8,
  0x01, 0xF9, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFC,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x83,
  0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xFC, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0xFF, 0xFF,
  0xC0, 0x07, 0xDF, 0xFE, 0xF8, 0x01, 0xFB, 0xFF, 0xDF, 0x00, 0x3E, 0x7F,
  0xFB, 0xF0, 0x07, 0xCF, 0xFF, 0x3E, 0x01, 0xF9, 0xFF, 0xE7, 0xC0, 0x3E,
  0x3F, 0xFC, 0xFC, 0x07, 0xC7, 0xFF, 0x9F, 0x80, 0xF8, 0xFF, 0xF1, 0xF0,
  0x3F, 0x1F, 0xFE, 0x3E, 0x07, 0xC3, 0xFF, 0xC7, 0xE0, 0xF8, 0x7F, 0xF8,
  0x7C, 0x3F, 0x0F, 0xFF, 0x0F, 0x87, 0xC1, 0xFF, 0xE1, 0xF8, 0xF8, 0x3F,
  0xFC, 0x3F, 0x3F, 0x07, 0xFF, 0x83, 0xE7, 0xC0, 0xFF, 0xF0, 0x7C, 0xF8,
  0x1F, 0xFE, 0x0F, 0xDF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFC,
  0x07, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F,
  0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0xDF, 0xC0, 0x7F, 0xF9, 0xF8,
  0x0F, 0xFF, 0x3F, 0x81, 0xFF, 0xE3, 0xF0, 0x3F, 0xFC, 0x7F, 0x07, 0xFF,
  0x87, 0xE0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x0F, 0xC3, 0xFF, 0xC1, 0xFC,
  0x7F, 0xF8, 0x1F, 0x8F, 0xFF, 0x03, 0xF9, 0xFF, 0xE0, 0x3F, 0x3F, 0xFC,
  0x07, 0xE7, 0xFF, 0x80, 0x7E, 0xFF, 0xF0, 0x0F, 0xDF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3,
  0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xBF,
  0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE,
  0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC3, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07,
  0xF0, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFC, 0x7E, 0x7F, 0x00, 0xE7, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xFC, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFE,
  0x7F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xE0, 0x07,
  0xE3, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x87,
  0xE0, 0x1F, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0x80,
  0x7D, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0x3F, 0x03, 0xF7,
  0xC0, 0xFE, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0x9F, 0x03,
  0xF0, 0x1F, 0x81, 0xF3, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x3E, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC7, 0xC3, 0xF8, 0x07, 0xE1, 0xF0, 0xF8, 0x7E, 0x00, 0xFC,
  0x3E, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC3, 0xF1, 0xF8, 0x01, 0xF9, 0xF8,
  0x3E, 0x3F, 0x00, 0x3F, 0x3E, 0x07, 0xCF, 0xE0, 0x07, 0xE7, 0xC0, 0xF9,
  0xF8, 0x00, 0xFC, 0xF8, 0x1F, 0xBF, 0x00, 0x0F, 0x9F, 0x01, 0xF7, 0xE0,
  0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xDF, 0x00, 0x07,
  0xFF, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0x7F, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E,
  0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0,
  0x07, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x06,
  0x03, 0xF8, 0x20, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFE, 0x7F, 0x7F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xBF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0x7E, 0x7F, 0xF1, 0xF1,
  0xFE, 0x0F, 0x80, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xFE, 0x1F, 0x9F, 0xFE, 0x3F, 0x7F, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFF, 0x83, 0xF9, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7,
  0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x7F, 0x00,
  0x7E, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xBF, 0xFE, 0x3F, 0x3F, 0xF8, 0x7C, 0x3F, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0x83, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x09, 0xFC, 0x06,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xC7, 0xF0, 0xFF, 0xCF, 0xE3, 0xFF, 0xCF, 0xC7, 0xFF, 0xDF, 0x9F, 0xFF,
  0xFF, 0x3F, 0x83, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F,
  0x00, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xEF, 0xC3, 0xFF, 0x9F, 0x83, 0xFE, 0x1F, 0x00, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF9, 0xF8, 0x03, 0xEF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x8F, 0xE0, 0x0C, 0x3F, 0xF3, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x1F, 0xFC, 0xFC, 0x7F, 0xF9,
  0xF8, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF, 0xE7, 0xF0, 0x7F, 0xDF, 0xC0, 0x7F,
  0xBF, 0x80, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x7F, 0x9F, 0xC1,
  0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xF7,
  0xF0, 0x7F, 0x8F, 0xE0, 0x08, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF9, 0x00, 0x07, 0xF1, 0x80, 0x1F, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x8F, 0xE0, 0xFC, 0xFF, 0xE3, 0xF7, 0xFF, 0xCF, 0xDF, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFB, 0xFC, 0x07, 0xEF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x38, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8,
  0x3C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xFC,
  0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F,
  0xC3, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03,
  0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFE, 0x00, 0xFB, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0x7F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xCF, 0xFE, 0x1F, 0xF8,
  0xFD, 0xFF, 0xE3, 0xFF, 0xCF, 0xDF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF8, 0x7F, 0xF0, 0xFE, 0xFF, 0x03, 0xFE, 0x07, 0xEF, 0xF0,
  0x3F, 0xC0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F,
  0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFE, 0x01, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0x80, 0x3F, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F,
  0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFE, 0x01, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0x80, 0x3F, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F,
  0xFE, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0xF8, 0x3F, 0x83, 0xF3, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0x0F, 0xEF, 0xF0, 0x1F, 0xBF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFC, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xE0,
  0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x3F, 0x81, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0x80, 0xFE,
  0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xEF, 0xE0,
  0x0F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0xC1, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFB, 0xFF, 0xE3, 0xF7, 0xFF, 0xC7, 0xE7, 0xFF, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC0, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x7E, 0x1F, 0xFC, 0xFC, 0x7F, 0xF9, 0xF8, 0xFF,
  0xFB, 0xF3, 0xFF, 0xFF, 0xE7, 0xF0, 0x7F, 0xDF, 0xC0, 0x7F, 0xBF, 0x80,
  0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7,
  0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x7F, 0x9F, 0xC1, 0xFF, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x7F, 0xFB, 0xF8, 0x7F, 0xF7, 0xF0, 0x7F,
  0x8F, 0xE0, 0x08, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0xFE, 0xFD, 0xFE, 0xFD,
  0xFE, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xF0, 0x3B, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xC7, 0xFF, 0x80, 0x08, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFE, 0x00, 0x20, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0xDF, 0xC1, 0xFF, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xEF, 0xC7, 0xFF, 0x1F, 0x0F, 0xF8,
  0x7C, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFB,
  0xF0, 0x0F, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x80, 0xFC, 0xFC, 0x03, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0xE0, 0x3F, 0x1F, 0x81, 0xFF, 0x01, 0xF8, 0xFC,
  0x0F, 0x78, 0x1F, 0x87, 0xE0, 0x7B, 0xE0, 0xFC, 0x3F, 0x07, 0xDF, 0x07,
  0xE0, 0xFC, 0x3E, 0xF8, 0x3F, 0x07, 0xE1, 0xF3, 0xC1, 0xF0, 0x3F, 0x0F,
  0x9F, 0x1F, 0x81, 0xF8, 0x78, 0xF8, 0xFC, 0x07, 0xC7, 0xC7, 0xC7, 0xE0,
  0x3F, 0x3E, 0x3E, 0x3F, 0x01, 0xF9, 0xF0, 0xF3, 0xF0, 0x0F, 0xCF, 0x87,
  0xDF, 0x80, 0x7E, 0x78, 0x3E, 0xFC, 0x01, 0xF7, 0xC1, 0xF7, 0xE0, 0x0F,
  0xBE, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x3D, 0xF0, 0x03, 0xFF, 0x81, 0xEF,
  0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F,
  0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x7E, 0x01, 0xFC,
  0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03,
  0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x81,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0x00, 0x05, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0xFF, 0xA0, 0x03, 0xFC,
};

const GFXglyph NotoSans_Condensed_SemiBold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 39, 14, 3, -38 },
  { 40, 17, 14, 23, 3, -38 },
  { 70, 26, 38, 28, 1, -38 },
  { 194, 22, 43, 26, 2, -40 },
  { 313, 37, 38, 41, 2, -38 },
  { 489, 29, 39, 31, 2, -38 },
  { 631, 6, 14, 12, 3, -38 },
  { 642, 13, 46, 17, 2, -38 },
  { 717, 13, 46, 17, 1, -38 },
  { 792, 21, 21, 24, 2, -40 },
  { 848, 22, 25, 26, 2, -31 },
  { 917, 9, 13, 13, 2, -6 },
  { 932, 12, 6, 16, 2, -17 },
  { 941, 8, 8, 13, 3, -7 },
  { 949, 19, 38, 21, 1, -38 },
  { 1040, 22, 39, 26, 2, -38 },
  { 1148, 16, 38, 26, 3, -38 },
  { 1224, 22, 38, 26, 2, -38 },
  { 1329, 21, 39, 26, 2, -38 },
  { 1432, 24, 38, 26, 1, -38 },
  { 1546, 20, 39, 26, 3, -38 },
  { 1644, 22, 39, 26, 2, -38 },
  { 1752, 23, 38, 26, 1, -38 },
  { 1862, 22, 39, 26, 2, -38 },
  { 1970, 22, 39, 26, 2, -38 },
  { 2078, 8, 30, 14, 3, -29 },
  { 2108, 9, 36, 14, 2, -29 },
  { 2149, 22, 26, 26, 2, -32 },
  { 2221, 22, 15, 26, 2, -26 },
  { 2263, 22, 26, 26, 2, -32 },
  { 2335, 19, 39, 20, 0, -38 },
  { 2428, 36, 42, 40, 2, -38 },
  { 2617, 29, 38, 29, 0, -38 },
  { 2755, 23, 38, 29, 4, -38 },
  { 2865, 23, 39, 28, 3, -38 },
  { 2978, 25, 38, 32, 4, -38 },
  { 3097, 18, 38, 25, 4, -38 },
  { 3183, 18, 38, 24, 4, -38 },
  { 3269, 26, 39, 32, 3, -38 },
  { 3396, 25, 38, 33, 4, -38 },
  { 3515, 14, 38, 17, 2, -38 },
  { 3582, 13, 49, 14, -3, -38 },
  { 3662, 25, 38, 28, 4, -38 },
  { 3781, 18, 38, 23, 4, -38 },
  { 3867, 35, 38, 43, 4, -38 },
  { 4034, 27, 38, 35, 4, -38 },
  { 4163, 28, 39, 34, 3, -38 },
  { 4300, 22, 38, 27, 4, -38 },
  { 4405, 28, 47, 34, 3, -38 },
  { 4570, 24, 38, 29, 4, -38 },
  { 4684, 20, 39, 24, 2, -38 },
  { 4782, 23, 38, 24, 1, -38 },
  { 4892, 25, 39, 32, 4, -38 },
  { 5014, 28, 38, 28, 0, -38 },
  { 5147, 43, 38, 42, 0, -38 },
  { 5352, 27, 38, 27, 0, -38 },
  { 5481, 26, 38, 26, 0, -38 },
  { 5605, 22, 38, 24, 1, -38 },
  { 5710, 12, 46, 17, 3, -38 },
  { 5779, 19, 38, 21, 1, -38 },
  { 5870, 12, 46, 17, 1, -38 },
  { 5939, 25, 23, 28, 1, -38 },
  { 6011, 22, 3, 22, 0, 5 },
  { 6020, 12, 9, 16, 2, -41 },
  { 6034, 21, 30, 26, 2, -29 },
  { 6113, 23, 41, 28, 3, -40 },
  { 6231, 19, 30, 22, 2, -29 },
  { 6303, 23, 41, 28, 2, -40 },
  { 6421, 22, 30, 26, 2, -29 },
  { 6504, 17, 41, 16, 1, -41 },
  { 6592, 23, 42, 28, 2, -29 },
  { 6713, 22, 40, 28, 3, -40 },
  { 6823, 7, 40, 13, 3, -40 },
  { 6858, 12, 53, 13, -2, -40 },
  { 6938, 22, 40, 26, 4, -40 },
  { 7048, 7, 40, 13, 3, -40 },
  { 7083, 36, 29, 42, 3, -29 },
  { 7214, 22, 29, 28, 3, -29 },
  { 7294, 23, 30, 27, 2, -29 },
  { 7381, 23, 42, 28, 3, -29 },
  { 7502, 23, 42, 28, 2, -29 },
  { 7623, 16, 29, 19, 3, -29 },
  { 7681, 17, 30, 21, 2, -29 },
  { 7745, 16, 36, 18, 1, -35 },
  { 7817, 22, 30, 28, 3, -29 },
  { 7900, 24, 29, 24, 0, -29 },
  { 7987, 37, 29, 37, 0, -29 },
  { 8122, 23, 29, 24, 0, -29 },
  { 8206, 24, 42, 24, 0, -29 },
  { 8332, 18, 29, 20, 1, -29 },
  { 8398, 16, 46, 19, 1, -38 },
  { 8490, 5, 52, 25, 10, -40 },
  { 8523, 16, 46, 19, 2, -38 },
  { 8615, 22, 8, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_SemiBold53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD53PT7B_H_
