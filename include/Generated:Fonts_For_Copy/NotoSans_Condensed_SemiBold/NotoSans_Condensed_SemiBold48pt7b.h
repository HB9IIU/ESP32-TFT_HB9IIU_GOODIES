#ifndef _NOTOSANS_CONDENSED_SEMIBOLD48PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x00, 0x00, 0x00,
  0x01, 0xCF, 0xDF, 0xBF, 0xFF, 0xFC, 0xF8, 0xC0, 0xFC, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1E, 0xF8,
  0x3D, 0xF0, 0x7B, 0xE0, 0xF7, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1,
  0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x87, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x7E, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7E, 0x63, 0xDF, 0x8C,
  0x0B, 0xF1, 0x80, 0x7C, 0x30, 0x0F, 0xC6, 0x01, 0xF8, 0xC0, 0x1F, 0x98,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1B, 0xF8, 0x03, 0x3F, 0x00, 0x63,
  0xE0, 0x0C, 0x7C, 0x01, 0x8F, 0xE0, 0x31, 0xFF, 0x06, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xE0, 0x0F, 0xFE,
  0x01, 0xF0, 0x07, 0xDF, 0x00, 0xF0, 0x07, 0xC7, 0xC0, 0x78, 0x03, 0xC3,
  0xE0, 0x7C, 0x01, 0xE0, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x3E, 0x00, 0x78,
  0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x1F, 0x00, 0x1E, 0x0F, 0x0F, 0x00, 0x0F,
  0x07, 0x87, 0x80, 0x07, 0x83, 0xC7, 0xC0, 0x03, 0xC1, 0xE3, 0xC3, 0xE1,
  0xE1, 0xF3, 0xE3, 0xFC, 0xF8, 0xF9, 0xE3, 0xFF, 0x3E, 0xF9, 0xF3, 0xFF,
  0x9F, 0xFC, 0xF1, 0xE3, 0xE7, 0xFC, 0x79, 0xF1, 0xF1, 0xFC, 0x7C, 0xF8,
  0x78, 0x38, 0x3C, 0x7C, 0x3C, 0x00, 0x3E, 0x3C, 0x1E, 0x00, 0x1E, 0x1E,
  0x0F, 0x00, 0x0F, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x83, 0xC0, 0x07, 0x83,
  0xC1, 0xE0, 0x07, 0xC1, 0xF0, 0xF0, 0x03, 0xC0, 0xF8, 0x78, 0x03, 0xE0,
  0x7C, 0x3C, 0x01, 0xE0, 0x1E, 0x3E, 0x00, 0xF0, 0x0F, 0xFE, 0x00, 0xF0,
  0x03, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x81, 0xF8,
  0x7F, 0xF0, 0x3F, 0x1F, 0xFF, 0x07, 0xE3, 0xF3, 0xF0, 0xFC, 0xFE, 0x7F,
  0x3F, 0x1F, 0x87, 0xE7, 0xE3, 0xF0, 0x7E, 0xFC, 0x7C, 0x07, 0xFF, 0x1F,
  0x80, 0xFF, 0xE3, 0xF0, 0x0F, 0xF8, 0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x1F,
  0xC0, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xDF, 0x81, 0xFF, 0xF1, 0xF8, 0x1F, 0xF8, 0x3F, 0x80, 0xFF, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0xFC, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x70, 0xF0, 0xE7, 0xFF, 0x7E, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0x9F, 0x00, 0xF9, 0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x07, 0x06,
  0x00, 0x20, 0x40, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFB, 0xF7,
  0xFF, 0xDF, 0xBF, 0x08, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x3F, 0x1F, 0x83, 0xF3,
  0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE,
  0x03, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x8F, 0xEF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xBF, 0xFC, 0xFD, 0xE3,
  0xF3, 0x0F, 0xC8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFC, 0x3F, 0x9E, 0x03, 0xF1,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x3F, 0x8C, 0x03, 0xF1,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xBF, 0x00, 0x3E,
  0xFC, 0x00, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1E, 0x3F, 0x00, 0xF8, 0xFC,
  0x03, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x78, 0x3F, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xCE, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFC,
  0x01, 0xFD, 0xF9, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFE, 0x04, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x87,
  0xE0, 0xF9, 0xFF, 0x0F, 0xBF, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x3E,
  0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0xBF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xE0, 0xFC, 0x7C, 0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x07, 0xE7, 0xC0,
  0x7E, 0x7C, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0x3F, 0xC7, 0xE0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xEF, 0xC0, 0x7E, 0xFE, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFE, 0x3F, 0x3F, 0x83, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xBE, 0x3F, 0xE7, 0xC1, 0xF0, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x18, 0x3F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x7D, 0xFB, 0xF7, 0xFF, 0xDF, 0x9E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xDF, 0xBF,
  0xFF, 0xFC, 0xF8, 0xC0, 0x3E, 0x7E, 0x7F, 0x7F, 0x7E, 0x7E, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x1F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xE1, 0xFC, 0xC0, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x07, 0xFE, 0x1E, 0x3C, 0x0F, 0xFE, 0x1E,
  0x7C, 0x1F, 0xFE, 0x1F, 0x78, 0x3E, 0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0x0F,
  0x78, 0x7C, 0x1E, 0x0F, 0xF8, 0x78, 0x1E, 0x0F, 0xF8, 0x78, 0x1E, 0x0F,
  0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0xF8, 0x1E, 0x0F, 0xF0, 0xF8, 0x1E, 0x0F,
  0xF0, 0xF8, 0x3E, 0x0F, 0xF0, 0x78, 0x3E, 0x0F, 0xF8, 0x78, 0x3E, 0x1E,
  0xF8, 0x78, 0x3E, 0x1E, 0xF8, 0x7C, 0x7F, 0x3E, 0x78, 0x3F, 0xFF, 0xFC,
  0x78, 0x3F, 0xE7, 0xF8, 0x7C, 0x1F, 0xC3, 0xF0, 0x7C, 0x03, 0x00, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x80, 0x07, 0xE0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xF8, 0x7F, 0xEF, 0x80, 0xFE, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF,
  0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC3, 0xC1, 0xFC, 0x01, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x61, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xE0, 0x3F, 0xCF, 0x80, 0x7F,
  0x3E, 0x00, 0xFE, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0xBE, 0x01, 0xFC, 0xF8, 0x1F,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF8,
  0x3E, 0x1F, 0xE0, 0x04, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x7C, 0x07, 0xFF, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x1F, 0xC0,
  0x3F, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFC, 0xFF, 0x87, 0xE0, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xEF, 0x80, 0x3F,
  0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xE3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3E,
  0x0F, 0xE0, 0xF8, 0x3F, 0x03, 0xE1, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x3F,
  0x00, 0xF9, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFE,
  0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0x7F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF8, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFE, 0xF8, 0x01, 0xFB, 0xE0,
  0x07, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xDF, 0xFF, 0xC0, 0x0F, 0xBF, 0xF7, 0x80, 0x1F,
  0x7F, 0xEF, 0x80, 0x3E, 0xFF, 0xDF, 0x00, 0xF9, 0xFF, 0xBE, 0x01, 0xF3,
  0xFF, 0x3E, 0x03, 0xEF, 0xFE, 0x7C, 0x07, 0x9F, 0xFC, 0xF8, 0x1F, 0x3F,
  0xF8, 0xF0, 0x3E, 0x7F, 0xF1, 0xF0, 0x78, 0xFF, 0xE3, 0xE1, 0xF1, 0xFF,
  0xC7, 0xC3, 0xE3, 0xFF, 0x87, 0xC7, 0x87, 0xFF, 0x0F, 0x9F, 0x0F, 0xFE,
  0x1F, 0x3E, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0xF8, 0x3E, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x81,
  0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07,
  0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFC, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFB, 0xE0, 0x1F, 0xFB, 0xF0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF9, 0xF8,
  0x1F, 0xF9, 0xF8, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8, 0x1F,
  0x9F, 0xF8, 0x1F, 0x9F, 0xF8, 0x0F, 0xDF, 0xF8, 0x0F, 0xDF, 0xF8, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x07,
  0xE7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x3F,
  0xBE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xF7, 0xC0, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFC, 0x7F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xE0, 0x7F, 0x8F, 0x80, 0xFE, 0x3E, 0x01,
  0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF8,
  0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x8F, 0x80, 0xFC, 0x3E, 0x1F, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF8, 0x7E,
  0x03, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0x8F, 0x80, 0x7F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xFB, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF,
  0x9F, 0xEF, 0xE7, 0xE0, 0x1B, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xE7,
  0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x03,
  0xF3, 0xE0, 0x07, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xE0, 0x0F, 0xCF, 0xC0,
  0x3F, 0xC0, 0x1F, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x1F, 0x00, 0xFF, 0x80,
  0xFC, 0x3E, 0x01, 0xFF, 0x01, 0xF8, 0x7E, 0x07, 0xFE, 0x03, 0xE0, 0xFC,
  0x0F, 0xBC, 0x07, 0xC1, 0xF8, 0x1F, 0x78, 0x1F, 0x81, 0xF0, 0x3C, 0xF8,
  0x3F, 0x03, 0xE0, 0x79, 0xF0, 0x7E, 0x07, 0xE1, 0xF3, 0xE0, 0xF8, 0x0F,
  0xC3, 0xE7, 0xC1, 0xF0, 0x0F, 0x87, 0xC7, 0x87, 0xE0, 0x1F, 0x0F, 0x0F,
  0x8F, 0xC0, 0x3E, 0x3E, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x3E, 0x3E, 0x00,
  0xFC, 0xF8, 0x3C, 0x7C, 0x00, 0xF9, 0xF0, 0x7D, 0xF8, 0x01, 0xF3, 0xC0,
  0xFB, 0xF0, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0x07, 0xDF, 0x03, 0xEF, 0x80,
  0x0F, 0xFE, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x07, 0xBE, 0x00, 0x1F, 0xF0,
  0x0F, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x03,
  0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x8F,
  0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0x60, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0x87, 0x07, 0xF1, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x0F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xCF, 0xFC, 0xF1,
  0xFC, 0x3C, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC1, 0x00, 0xFC, 0xFF, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0x8F, 0xEF, 0xE0, 0x7E, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xEF, 0xF8, 0xFE, 0xFF, 0xFF,
  0xCF, 0xBF, 0xFC, 0xF9, 0xFF, 0x8F, 0x8F, 0xF0, 0x00, 0x20, 0x01, 0xFF,
  0x83, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFC, 0x39, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x08, 0xFE, 0x3C, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x08, 0x1F, 0x07, 0xF1, 0xF1, 0xFF, 0x9F,
  0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xE0, 0x7F, 0x7E, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7,
  0xF9, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x1F, 0xF9, 0xF0, 0x7F, 0x0F,
  0x00, 0x40, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x8F, 0xE0, 0x71, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xC3, 0xF8, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x1F, 0x1F, 0xF9, 0xF1, 0xFF,
  0xDF, 0x3F, 0xFF, 0xF7, 0xF8, 0xFF, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7C,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x9F,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFD, 0xF1, 0xFF, 0x9F, 0x07, 0xF1, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x60,
  0x07, 0xE7, 0xE1, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x82, 0x03, 0xF3, 0xFC, 0x7E, 0xFF, 0xCF, 0xBF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xE7, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3F, 0x7F, 0xEF, 0xFD,
  0xFF, 0x3F, 0xC0, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFD, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x00, 0xFD,
  0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x80, 0xF8, 0xFF,
  0x07, 0xF8, 0xF9, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x9F, 0xFC, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x07,
  0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07,
  0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07,
  0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07,
  0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07,
  0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07,
  0xE0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x08, 0x1F, 0x1F, 0xE3, 0xE7,
  0xFE, 0x7D, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0x00,
  0x60, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xC7, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7C, 0x03, 0xF7, 0xE0,
  0x0F, 0xBF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00,
  0x7C, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x03, 0xF0, 0xFE, 0x3F, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x10,
  0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0,
  0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0xFF, 0x8F, 0xEF, 0xFF, 0xFC, 0xFB, 0xFF,
  0xCF, 0xDF, 0xF8, 0xFC, 0xFF, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x7F, 0x1F, 0x1F, 0xF9, 0xF1, 0xFF, 0xDF, 0x3F, 0xFF,
  0xF7, 0xF8, 0xFF, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x8F, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFD, 0xF1, 0xFF, 0x9F, 0x07, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x13, 0xE3, 0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xFB, 0xFF,
  0xEF, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x80, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFC, 0x1C, 0xF8, 0x04, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3E, 0xF0, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE1, 0x1F, 0xFC, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0xFE, 0x7F, 0xDF, 0xFF, 0xFB, 0xFF,
  0xDF, 0x3F, 0xF9, 0xE1, 0xFC, 0x3C, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0x7E,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xFC, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xBE, 0x03,
  0xF8, 0x07, 0xDF, 0x01, 0xFE, 0x07, 0xEF, 0xC0, 0xFF, 0x03, 0xF7, 0xE0,
  0x7F, 0x81, 0xF1, 0xF0, 0x3F, 0xC0, 0xF8, 0xF8, 0x3F, 0xE0, 0x7C, 0x7E,
  0x1E, 0xF8, 0x7E, 0x3F, 0x0F, 0x3C, 0x3E, 0x0F, 0x87, 0x9E, 0x1F, 0x07,
  0xC3, 0xCF, 0x0F, 0x83, 0xF3, 0xE7, 0xCF, 0xC1, 0xF9, 0xE3, 0xE7, 0xC0,
  0x7C, 0xF0, 0xF3, 0xE0, 0x3E, 0x78, 0x79, 0xF0, 0x1F, 0x3C, 0x3C, 0xF8,
  0x0F, 0xBE, 0x1E, 0xF8, 0x03, 0xDE, 0x0F, 0x7C, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF9, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x3E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3F, 0x3F,
  0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3E, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x81, 0xF8,
  0x7C, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7E, 0x7E, 0x03, 0xF7,
  0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x4F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC3, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFC, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x17, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC8, 0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_SemiBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 35, 12, 3, -34 },
  { 32, 15, 12, 21, 3, -34 },
  { 55, 24, 34, 26, 1, -34 },
  { 157, 19, 39, 23, 2, -36 },
  { 250, 33, 35, 37, 2, -35 },
  { 395, 27, 35, 28, 1, -35 },
  { 514, 6, 12, 11, 3, -34 },
  { 523, 12, 42, 15, 2, -34 },
  { 586, 12, 42, 15, 1, -34 },
  { 649, 20, 20, 22, 1, -37 },
  { 699, 20, 23, 23, 2, -28 },
  { 757, 8, 12, 12, 2, -6 },
  { 769, 12, 5, 15, 1, -15 },
  { 777, 7, 8, 12, 3, -7 },
  { 784, 17, 35, 19, 1, -35 },
  { 859, 19, 35, 23, 2, -35 },
  { 943, 14, 34, 23, 3, -34 },
  { 1003, 19, 35, 23, 2, -35 },
  { 1087, 19, 35, 23, 2, -35 },
  { 1171, 22, 34, 23, 1, -34 },
  { 1265, 19, 34, 23, 2, -34 },
  { 1346, 20, 35, 23, 2, -35 },
  { 1434, 21, 34, 23, 1, -34 },
  { 1524, 20, 35, 23, 2, -35 },
  { 1612, 19, 35, 23, 2, -35 },
  { 1696, 7, 27, 12, 3, -26 },
  { 1720, 8, 32, 12, 2, -26 },
  { 1752, 20, 23, 23, 2, -29 },
  { 1810, 20, 14, 23, 2, -24 },
  { 1845, 20, 23, 23, 2, -29 },
  { 1903, 17, 36, 18, 0, -35 },
  { 1980, 32, 39, 36, 2, -35 },
  { 2136, 26, 34, 26, 0, -34 },
  { 2247, 20, 34, 27, 4, -34 },
  { 2332, 22, 35, 25, 2, -35 },
  { 2429, 22, 34, 29, 4, -34 },
  { 2523, 16, 34, 22, 4, -34 },
  { 2591, 16, 34, 22, 4, -34 },
  { 2659, 24, 35, 29, 2, -35 },
  { 2764, 22, 34, 30, 4, -34 },
  { 2858, 13, 34, 16, 1, -34 },
  { 2914, 12, 44, 13, -3, -34 },
  { 2980, 22, 34, 26, 4, -34 },
  { 3074, 16, 34, 21, 4, -34 },
  { 3142, 31, 34, 39, 4, -34 },
  { 3274, 24, 34, 32, 4, -34 },
  { 3376, 26, 35, 31, 2, -35 },
  { 3490, 19, 34, 25, 4, -34 },
  { 3571, 26, 43, 31, 2, -35 },
  { 3711, 22, 34, 26, 4, -34 },
  { 3805, 18, 35, 22, 2, -35 },
  { 3884, 20, 34, 22, 1, -34 },
  { 3969, 23, 34, 29, 3, -34 },
  { 4067, 25, 34, 25, 0, -34 },
  { 4174, 39, 34, 38, 0, -34 },
  { 4340, 24, 34, 24, 0, -34 },
  { 4442, 24, 34, 24, 0, -34 },
  { 4544, 20, 34, 22, 1, -34 },
  { 4629, 11, 42, 15, 3, -34 },
  { 4687, 17, 35, 19, 1, -35 },
  { 4762, 11, 42, 15, 1, -34 },
  { 4820, 23, 20, 25, 1, -34 },
  { 4878, 20, 3, 20, 0, 4 },
  { 4886, 11, 8, 15, 2, -37 },
  { 4897, 18, 27, 23, 2, -27 },
  { 4958, 20, 36, 25, 3, -36 },
  { 5048, 17, 27, 20, 2, -27 },
  { 5106, 20, 36, 25, 2, -36 },
  { 5196, 19, 27, 23, 2, -27 },
  { 5261, 15, 37, 15, 1, -37 },
  { 5331, 20, 39, 25, 2, -27 },
  { 5429, 19, 36, 25, 3, -36 },
  { 5515, 6, 36, 12, 3, -36 },
  { 5542, 11, 48, 12, -2, -36 },
  { 5608, 21, 36, 24, 3, -36 },
  { 5703, 6, 36, 12, 3, -36 },
  { 5730, 32, 27, 38, 3, -27 },
  { 5838, 19, 27, 25, 3, -27 },
  { 5903, 21, 27, 25, 2, -27 },
  { 5974, 20, 39, 25, 3, -27 },
  { 6072, 20, 39, 25, 2, -27 },
  { 6170, 14, 27, 17, 3, -27 },
  { 6218, 16, 27, 19, 2, -27 },
  { 6272, 14, 32, 16, 1, -32 },
  { 6328, 19, 26, 25, 3, -26 },
  { 6390, 22, 26, 22, 0, -26 },
  { 6462, 33, 26, 34, 0, -26 },
  { 6570, 21, 26, 22, 0, -26 },
  { 6639, 22, 38, 22, 0, -26 },
  { 6744, 16, 26, 18, 1, -26 },
  { 6796, 15, 42, 17, 1, -34 },
  { 6875, 4, 48, 22, 9, -37 },
  { 6899, 14, 42, 17, 2, -34 },
  { 6973, 20, 8, 23, 2, -21 },
};

const GFXfont NotoSans_Condensed_SemiBold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD48PT7B_H_
