#ifndef _NOTOSANS_CONDENSED_SEMIBOLD13PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xA2, 0xC0, 0xBB, 0xB0, 0x34, 0x59, 0xF9, 0x42, 0x9F, 0x9A,
  0x24, 0x58, 0x23, 0xFD, 0x4E, 0x38, 0xF7, 0xF1, 0x08, 0x73, 0x14, 0x8D,
  0x41, 0x56, 0x7E, 0x82, 0xB0, 0xAC, 0x4A, 0x31, 0x80, 0x78, 0x68, 0x68,
  0x38, 0x72, 0x5A, 0xCE, 0x4C, 0x7F, 0xE0, 0x7A, 0x49, 0x24, 0xD9, 0x80,
  0xCC, 0x92, 0x49, 0x2F, 0x00, 0x32, 0xDF, 0xCC, 0x78, 0x10, 0x41, 0x3F,
  0x10, 0x41, 0x00, 0x69, 0x60, 0xF0, 0xB0, 0x18, 0x84, 0x62, 0x31, 0x08,
  0xC0, 0x79, 0x24, 0xD3, 0xCD, 0x34, 0xDA, 0x38, 0x7F, 0xB3, 0x33, 0x33,
  0x30, 0xF9, 0x30, 0xC2, 0x18, 0xC2, 0x10, 0xFC, 0xF9, 0x30, 0x86, 0x38,
  0x30, 0xE3, 0xF8, 0x18, 0x62, 0x8A, 0x4B, 0x2F, 0xC2, 0x08, 0xF4, 0x21,
  0xEB, 0x0C, 0x72, 0xF0, 0x39, 0x84, 0x1E, 0xEF, 0x34, 0xDB, 0x38, 0xFC,
  0x30, 0x86, 0x18, 0x43, 0x08, 0x60, 0x79, 0x34, 0xDE, 0x39, 0x3C, 0xD3,
  0x78, 0x79, 0x2C, 0xF3, 0x7C, 0xF0, 0x86, 0x70, 0xE0, 0x2C, 0x68, 0x00,
  0xD2, 0xC0, 0x04, 0x77, 0x30, 0x38, 0x30, 0xFC, 0x0F, 0xC0, 0x83, 0x83,
  0x83, 0x33, 0x00, 0xF0, 0xC6, 0x62, 0x30, 0x0C, 0x60, 0x3E, 0x43, 0x9D,
  0xA5, 0xA5, 0xA5, 0xBD, 0x92, 0xC0, 0x3C, 0x38, 0x50, 0xA1, 0x66, 0xCF,
  0x9F, 0x63, 0xC6, 0xFB, 0x2C, 0xB6, 0xFB, 0x3C, 0xF6, 0xF8, 0x7E, 0x31,
  0x08, 0x43, 0x19, 0x78, 0xFB, 0x3C, 0xF3, 0xC7, 0x3C, 0xF6, 0xF0, 0xFC,
  0xCF, 0xFC, 0xCC, 0xF0, 0xFC, 0xCC, 0xFC, 0xCC, 0xC0, 0x7F, 0x0C, 0x20,
  0x9E, 0x1C, 0x71, 0x7C, 0xC7, 0x1C, 0x7F, 0xFF, 0x1C, 0x71, 0xC4, 0xF6,
  0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x32, 0xEC, 0xCF, 0x6F,
  0x3C, 0xF3, 0x4D, 0xB2, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC3, 0xE3,
  0xA7, 0xA5, 0xB5, 0xB5, 0x9D, 0x99, 0x99, 0xC7, 0xCE, 0x9D, 0xB9, 0x73,
  0xE3, 0xC7, 0x86, 0x7D, 0x9A, 0x14, 0x38, 0x70, 0xF1, 0x66, 0x78, 0xFE,
  0xF3, 0x9F, 0xF3, 0x18, 0xC0, 0x7D, 0x9A, 0x1C, 0x38, 0x70, 0xF1, 0x66,
  0x78, 0x10, 0x30, 0xFB, 0x6C, 0xB6, 0xF3, 0x4D, 0xB6, 0xCC, 0x7A, 0x50,
  0xC3, 0x8C, 0x33, 0xF8, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x8E,
  0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0x78, 0xC7, 0x89, 0x12, 0x66, 0xC5, 0x0A,
  0x1C, 0x30, 0xCC, 0x73, 0x14, 0xED, 0x3B, 0x5A, 0x9E, 0xA7, 0x28, 0xCE,
  0x31, 0x80, 0xCC, 0xD0, 0xE1, 0xC3, 0x07, 0x1A, 0x26, 0xC6, 0xCD, 0x36,
  0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xF8, 0x21, 0x84, 0x31, 0x86, 0x30, 0xFC,
  0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x18, 0x42, 0x18, 0x42, 0x18, 0xE4,
  0x92, 0x49, 0x27, 0x80, 0x10, 0xE2, 0x93, 0xC4, 0xF8, 0xD0, 0x79, 0x20,
  0xDF, 0xCF, 0x37, 0xC0, 0x84, 0x21, 0x7D, 0xC6, 0x31, 0xDD, 0x80, 0x7C,
  0x88, 0x8D, 0x70, 0x08, 0x43, 0xD9, 0xCE, 0x33, 0xDF, 0x40, 0x74, 0xE7,
  0xF8, 0x65, 0xC0, 0x37, 0x6F, 0x66, 0x66, 0x66, 0xEC, 0xE7, 0x19, 0xEF,
  0xA1, 0x9F, 0x80, 0x84, 0x21, 0x7D, 0xC6, 0x31, 0x8C, 0x40, 0xDF, 0xC0,
  0x51, 0x55, 0x55, 0xC0, 0x84, 0x21, 0x39, 0x53, 0x96, 0x9C, 0xC0, 0xFF,
  0xC0, 0xBF, 0x6C, 0xA6, 0x73, 0x39, 0x9C, 0xCE, 0x66, 0xBE, 0xE3, 0x18,
  0xC6, 0x20, 0xF4, 0xE3, 0x18, 0xED, 0xC0, 0xBE, 0xE3, 0x18, 0xEE, 0xD0,
  0x84, 0x00, 0xEC, 0xE7, 0x19, 0xEF, 0xA1, 0x08, 0x40, 0xBC, 0x88, 0x88,
  0x80, 0x7E, 0x18, 0xE1, 0xCF, 0xC0, 0x44, 0xF4, 0x44, 0x46, 0x70, 0x8C,
  0x63, 0x19, 0xEF, 0xA0, 0xCF, 0x24, 0x9E, 0x78, 0xC3, 0x00, 0xCD, 0xEE,
  0xD5, 0x4A, 0xA7, 0x53, 0xB8, 0xC8, 0xCD, 0xE3, 0x0C, 0x71, 0x6C, 0xC0,
  0xCD, 0x24, 0x9E, 0x78, 0xC3, 0x0C, 0x23, 0x80, 0xF8, 0x8C, 0x46, 0x23,
  0xE0, 0x32, 0x22, 0x6C, 0x22, 0x22, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0xE2,
  0x22, 0x21, 0x22, 0x26, 0xE0, 0x47, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 11, 6, 1, -10 },
  { 21, 10, 9, 10, 0, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 1, 3, 3, 1, -9 },
  { 43, 3, 11, 4, 1, -9 },
  { 48, 3, 11, 4, 0, -9 },
  { 53, 6, 5, 6, 0, -10 },
  { 57, 6, 7, 6, 0, -8 },
  { 63, 3, 4, 3, 0, -2 },
  { 65, 4, 1, 4, 0, -4 },
  { 66, 2, 2, 3, 1, -2 },
  { 67, 5, 9, 5, 0, -9 },
  { 73, 6, 9, 6, 0, -9 },
  { 80, 4, 9, 6, 1, -9 },
  { 85, 6, 9, 6, 0, -9 },
  { 92, 6, 9, 6, 0, -9 },
  { 99, 6, 9, 6, 0, -9 },
  { 106, 5, 9, 6, 1, -9 },
  { 112, 6, 9, 6, 0, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 6, 9, 6, 0, -9 },
  { 133, 6, 9, 6, 0, -9 },
  { 140, 2, 7, 3, 1, -7 },
  { 142, 3, 9, 3, 0, -7 },
  { 146, 6, 6, 6, 0, -8 },
  { 151, 6, 3, 6, 0, -6 },
  { 154, 6, 6, 6, 0, -8 },
  { 159, 5, 9, 5, 0, -9 },
  { 165, 8, 10, 10, 1, -9 },
  { 175, 7, 9, 7, 0, -9 },
  { 183, 6, 9, 7, 1, -9 },
  { 190, 5, 9, 7, 1, -9 },
  { 196, 6, 9, 8, 1, -9 },
  { 203, 4, 9, 6, 1, -9 },
  { 208, 4, 9, 6, 1, -9 },
  { 213, 6, 9, 8, 1, -9 },
  { 220, 6, 9, 8, 1, -9 },
  { 227, 4, 9, 4, 0, -9 },
  { 232, 4, 12, 4, -1, -9 },
  { 238, 6, 9, 7, 1, -9 },
  { 245, 4, 9, 6, 1, -9 },
  { 250, 8, 9, 10, 1, -9 },
  { 259, 7, 9, 9, 1, -9 },
  { 267, 7, 9, 8, 1, -9 },
  { 275, 5, 9, 7, 1, -9 },
  { 281, 7, 11, 8, 1, -9 },
  { 291, 6, 9, 7, 1, -9 },
  { 298, 5, 9, 6, 0, -9 },
  { 304, 6, 9, 6, 0, -9 },
  { 311, 6, 9, 8, 1, -9 },
  { 318, 7, 9, 7, 0, -9 },
  { 326, 10, 9, 10, 0, -9 },
  { 338, 7, 9, 7, 0, -9 },
  { 346, 6, 9, 6, 0, -9 },
  { 353, 6, 9, 6, 0, -9 },
  { 360, 3, 11, 4, 1, -9 },
  { 365, 5, 9, 5, 0, -9 },
  { 371, 3, 11, 4, 0, -9 },
  { 376, 6, 5, 7, 0, -9 },
  { 380, 5, 1, 5, 0, 1 },
  { 381, 2, 2, 4, 1, -10 },
  { 382, 6, 7, 6, 0, -7 },
  { 388, 5, 10, 7, 1, -10 },
  { 395, 4, 7, 5, 1, -7 },
  { 399, 5, 10, 7, 1, -10 },
  { 406, 5, 7, 6, 1, -7 },
  { 411, 4, 10, 4, 0, -10 },
  { 416, 5, 10, 7, 1, -7 },
  { 423, 5, 10, 7, 1, -10 },
  { 430, 1, 10, 3, 1, -10 },
  { 432, 2, 13, 3, 0, -10 },
  { 436, 5, 10, 6, 1, -10 },
  { 443, 1, 10, 3, 1, -10 },
  { 445, 9, 7, 10, 1, -7 },
  { 453, 5, 7, 7, 1, -7 },
  { 458, 5, 7, 7, 1, -7 },
  { 463, 5, 10, 7, 1, -7 },
  { 470, 5, 10, 7, 1, -7 },
  { 477, 4, 7, 5, 1, -7 },
  { 481, 5, 7, 5, 0, -7 },
  { 486, 4, 9, 4, 0, -9 },
  { 491, 5, 7, 7, 1, -7 },
  { 496, 6, 7, 6, 0, -7 },
  { 502, 9, 7, 9, 0, -7 },
  { 510, 6, 7, 6, 0, -7 },
  { 516, 6, 10, 6, 0, -7 },
  { 524, 5, 7, 5, 0, -7 },
  { 529, 4, 11, 5, 0, -9 },
  { 535, 2, 13, 6, 2, -10 },
  { 539, 4, 11, 5, 0, -9 },
  { 545, 6, 2, 6, 0, -6 },
};

const GFXfont NotoSans_Condensed_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD13PT7B_H_
