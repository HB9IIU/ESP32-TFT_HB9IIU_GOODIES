#ifndef _NOTOSANS_CONDENSED_SEMIBOLD25PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x66, 0x60, 0x27, 0xF7, 0xE7, 0xE7,
  0x67, 0x63, 0x63, 0x63, 0x63, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x18,
  0xCF, 0xFF, 0xFF, 0xF1, 0x98, 0x19, 0x83, 0x98, 0x31, 0x8F, 0xFE, 0xFF,
  0xE3, 0x30, 0x33, 0x03, 0x30, 0x63, 0x06, 0x70, 0x0C, 0x03, 0x01, 0xF9,
  0xFF, 0xFD, 0xBB, 0x0E, 0xC3, 0xB0, 0x7C, 0x0F, 0x80, 0xF8, 0x3F, 0x0D,
  0xC3, 0x78, 0xDF, 0xFF, 0xFF, 0x8F, 0x80, 0xC0, 0x30, 0x38, 0x1C, 0x3E,
  0x0C, 0x3B, 0x8E, 0x19, 0xC6, 0x0C, 0x67, 0x06, 0x33, 0x03, 0x19, 0x81,
  0x9D, 0x9E, 0xEE, 0xDF, 0xBE, 0xEC, 0xCE, 0x66, 0x60, 0x77, 0x30, 0x33,
  0x98, 0x19, 0xCC, 0x18, 0x66, 0x0C, 0x33, 0x0E, 0x1F, 0x86, 0x07, 0x80,
  0x1F, 0x00, 0xFE, 0x07, 0xB8, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0xEF, 0x73, 0xB9, 0xFC, 0xE3, 0xF3, 0x87,
  0xCE, 0x0E, 0x3C, 0xFC, 0x7F, 0xF8, 0xFC, 0xF0, 0xFD, 0xB6, 0xD8, 0x1C,
  0x63, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x71,
  0xC3, 0x0E, 0x18, 0x70, 0xC3, 0x87, 0x1C, 0x30, 0xE3, 0x86, 0x18, 0x71,
  0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE7, 0x1C, 0xE3, 0x00, 0x1C, 0x03, 0x00,
  0xC3, 0xBF, 0xFF, 0xC7, 0x83, 0xE0, 0xDC, 0x73, 0x88, 0x80, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x77, 0x6E, 0xEC, 0xFF, 0xFF, 0xC0, 0x27, 0xF7, 0x01, 0xC0, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x00, 0x1E, 0x0F, 0xC7, 0xF9,
  0xCE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x77, 0x1D, 0xCE, 0x7F, 0x8F, 0xC0, 0x07, 0x0F, 0x1F, 0x3F, 0xF7,
  0x67, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x3E, 0x1F, 0xEF, 0xF9, 0x0F, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x3F, 0xEF, 0x79, 0x0F, 0x01, 0xC0, 0x70, 0x38, 0x3C, 0x3E, 0x0F,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x1F, 0xFF, 0xBF, 0xC0, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x39,
  0xC3, 0x1C, 0x71, 0xC6, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xFC,
  0xFF, 0x91, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0x9E, 0xFF, 0xBF,
  0x80, 0x0F, 0x87, 0xE3, 0xE9, 0xC0, 0x70, 0x38, 0x0E, 0x23, 0xBE, 0xFF,
  0xBC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1D, 0xEF, 0x3F, 0x87, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x00, 0x3F,
  0x1F, 0xE7, 0x3F, 0x87, 0xE1, 0xF8, 0x77, 0x38, 0xFE, 0x1E, 0x0F, 0xC7,
  0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0x7F, 0x8F, 0xC0, 0x3E, 0x1F,
  0xC7, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xDF, 0xF7, 0xFC,
  0x67, 0x01, 0xC0, 0x60, 0x3A, 0x3C, 0x7F, 0x1F, 0x00, 0x2F, 0xF7, 0x00,
  0x00, 0x00, 0x27, 0xF7, 0x27, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x76, 0xEE,
  0xC0, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x80, 0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x3C, 0x3E, 0x3E,
  0x3E, 0x0E, 0x02, 0x00, 0x3E, 0x7F, 0x9D, 0xE8, 0x70, 0x38, 0x1C, 0x0E,
  0x0E, 0x0E, 0x0E, 0x06, 0x03, 0x01, 0x80, 0x00, 0x20, 0x78, 0x3C, 0x0E,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00, 0xC7, 0x00, 0x33,
  0x1F, 0x99, 0x9F, 0xCF, 0xCC, 0x63, 0xC6, 0x31, 0xE7, 0x18, 0xF3, 0x8C,
  0x79, 0xC6, 0x7C, 0x67, 0x37, 0x3E, 0xF9, 0x8F, 0x78, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x04, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x01, 0xCC, 0x07, 0x38, 0x1C, 0xE0,
  0xE3, 0x83, 0x87, 0x0F, 0xFC, 0x3F, 0xF1, 0xC1, 0xC7, 0x03, 0x9C, 0x0E,
  0xF0, 0x3B, 0x80, 0xF0, 0xFE, 0x1F, 0xF3, 0xFF, 0x70, 0xEE, 0x1D, 0xC3,
  0xB8, 0x77, 0x3C, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0xFE, 0x0F, 0xC1, 0xF8,
  0x7F, 0xFE, 0xFF, 0x9F, 0xE0, 0x0F, 0xC3, 0xFC, 0xFF, 0xBC, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0,
  0x1E, 0x01, 0xF7, 0x1F, 0xE1, 0xFC, 0xFE, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xEE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xE0, 0xFF,
  0xCF, 0xFC, 0xF0, 0x27, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xE0, 0xE7, 0x8F, 0x1F,
  0xF8, 0x7F, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xF7, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0xFF, 0xF0, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFB,
  0xEF, 0x00, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x38, 0xE7, 0x8E, 0x70, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0E, 0x70, 0xE7, 0x8E, 0x38, 0xE3,
  0xCE, 0x1C, 0xE1, 0xEE, 0x0F, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xEC, 0x37, 0xEC, 0x37, 0xEE, 0x77, 0xE6, 0x67, 0xE6, 0x67, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1, 0x87, 0xF0,
  0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xB8, 0xFD, 0xC7,
  0xE7, 0x3F, 0x39, 0xF9, 0xEF, 0xC7, 0x7E, 0x3F, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xE0, 0xFF, 0x03, 0xC0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x70, 0x39, 0xC0, 0xEF, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x0F, 0x70, 0x39, 0xC0, 0xE7, 0x87, 0x8F, 0x3C, 0x3F, 0xE0, 0x3F,
  0x00, 0xFE, 0x3F, 0xEF, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3,
  0xBF, 0xEF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00,
  0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xEF, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0x70, 0x39, 0xC0,
  0xE7, 0x87, 0x8F, 0x3C, 0x3F, 0xF0, 0x3F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0xFE, 0x1F, 0xF3, 0xFE, 0x71, 0xEE, 0x1D, 0xC3, 0xB8,
  0x77, 0x1E, 0xFF, 0x9F, 0xE3, 0xF8, 0x73, 0x8E, 0x71, 0xC7, 0x38, 0xF7,
  0x0E, 0xE1, 0xFC, 0x1C, 0x3F, 0x1F, 0xE7, 0xFB, 0x82, 0xE0, 0x38, 0x0F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x3B, 0xFE,
  0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0xDF, 0x7F, 0xC7, 0xF0, 0xE0, 0x3F, 0x01, 0xDC, 0x0E, 0xE0, 0xE7,
  0x07, 0x38, 0x38, 0xE1, 0x87, 0x1C, 0x38, 0xE0, 0xC7, 0x07, 0x30, 0x3B,
  0x81, 0xDC, 0x06, 0xC0, 0x36, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0xE0,
  0x60, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x77, 0x0F, 0x0E, 0x70, 0xF0, 0xE7,
  0x1F, 0x8E, 0x71, 0xF8, 0xE3, 0x1D, 0x8E, 0x39, 0x99, 0xC3, 0x99, 0x9C,
  0x3B, 0x9D, 0xC3, 0xB9, 0xDC, 0x1B, 0x0D, 0x81, 0xB0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xE0, 0x70, 0xF0, 0x73, 0x87, 0x8E,
  0x38, 0x73, 0xC1, 0xDC, 0x0E, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x3F, 0x01, 0xDC, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0x77,
  0x83, 0xC0, 0xE0, 0x77, 0x07, 0x70, 0xE7, 0x0E, 0x39, 0xC3, 0x9C, 0x1D,
  0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x70, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x0C, 0x01, 0xC0, 0x78, 0x0F,
  0x81, 0xB0, 0x77, 0x0C, 0x63, 0x8E, 0x60, 0xDC, 0x1F, 0x01, 0x80, 0xFF,
  0xFF, 0xFC, 0xF1, 0xC3, 0x87, 0x1E, 0x1F, 0xE7, 0xF8, 0x0E, 0x01, 0xC0,
  0x73, 0xFD, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xFF, 0xDF, 0x70, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0x8D, 0xFB, 0xFE, 0xE3, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xB7, 0xED, 0xF0, 0x0F,
  0x1F, 0xDF, 0xCE, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0F,
  0x37, 0xF9, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x39, 0xCF,
  0xBB, 0xFF, 0x71, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0x73, 0xEF, 0xFC, 0xFB, 0x80, 0x1E, 0x0F, 0xE7, 0xF9, 0xC7, 0xE1,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x01, 0xC3, 0x3F, 0xC7, 0xE0,
  0x0F, 0x8F, 0x8F, 0x47, 0x03, 0x81, 0xFB, 0xFD, 0xFE, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x1C, 0xE7,
  0xDD, 0xFF, 0xB8, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xB9, 0xF7, 0xEE, 0x7D, 0xC0, 0x38, 0x06, 0x01, 0xCE, 0xF9, 0xFE,
  0x1F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0x8D, 0xFB, 0xFE,
  0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1C, 0x6F, 0x72, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70,
  0x18, 0xF1, 0xC2, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xEF, 0xBE, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x7E, 0x3B, 0x9E, 0xE7, 0x3B, 0x8F, 0xC3, 0x70, 0xFE, 0x3F,
  0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0xEE, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xCE, 0x1C, 0xDF, 0xBE, 0xFF, 0xFF, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xCF, 0x37, 0xEF, 0xFB, 0x8F,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x70, 0x1E, 0x07, 0xF1, 0xFF, 0x38, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1D, 0xC7, 0x38, 0xE3, 0xF8, 0x3E, 0x00, 0xCE, 0x37, 0xEF,
  0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCE,
  0xDF, 0xB3, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1C, 0xE7,
  0xDD, 0xFF, 0xB8, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xB9, 0xF7, 0xEE, 0x7D, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0xCF, 0xBF, 0x7F, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x00, 0x3C, 0x7F, 0xF7, 0xE0, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0x07, 0xC7, 0xFF, 0xFE, 0x18, 0x18, 0x38, 0x3F, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x3F,
  0x9F, 0xFF, 0xDF, 0x70, 0xE0, 0xFC, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0x63,
  0x8E, 0x71, 0xDC, 0x3B, 0x83, 0x70, 0x7C, 0x0F, 0x80, 0xF0, 0x1C, 0x00,
  0xE1, 0xC1, 0xF0, 0xF1, 0xDC, 0x78, 0xEE, 0x3C, 0x77, 0x36, 0x33, 0x9B,
  0xB8, 0xCC, 0xDC, 0x76, 0x6E, 0x3F, 0x36, 0x1F, 0x9B, 0x07, 0x8D, 0x83,
  0xC7, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0xF0, 0xEE, 0x39, 0xE7, 0x1D, 0xC1,
  0xB8, 0x3E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0x70, 0xEE, 0x1C, 0xE7, 0x1D,
  0xE1, 0xC0, 0xE0, 0xFC, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0x73, 0x8E, 0x71,
  0xDC, 0x1B, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x0F, 0x81, 0xE0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0x0E, 0x3C, 0xF9, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0xF3, 0xC7, 0x87, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xE1, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1F, 0x1F, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0x30, 0x7F, 0x9F,
  0xFE, 0x1E,
};

const GFXglyph NotoSans_Condensed_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 18, 6, 1, -18 },
  { 10, 8, 7, 11, 1, -18 },
  { 17, 12, 18, 13, 1, -18 },
  { 44, 10, 20, 12, 1, -19 },
  { 69, 17, 18, 19, 1, -18 },
  { 108, 14, 18, 15, 1, -18 },
  { 140, 3, 7, 6, 1, -18 },
  { 143, 6, 22, 8, 1, -18 },
  { 160, 6, 22, 8, 1, -18 },
  { 177, 10, 10, 12, 1, -19 },
  { 190, 10, 12, 12, 1, -15 },
  { 205, 4, 6, 6, 1, -3 },
  { 208, 6, 3, 8, 1, -8 },
  { 211, 4, 4, 6, 1, -4 },
  { 213, 10, 18, 10, 0, -18 },
  { 236, 10, 18, 12, 1, -18 },
  { 259, 8, 18, 12, 1, -18 },
  { 277, 10, 18, 12, 1, -18 },
  { 300, 10, 18, 12, 1, -18 },
  { 323, 12, 18, 12, 0, -18 },
  { 350, 10, 18, 12, 1, -18 },
  { 373, 10, 18, 12, 1, -18 },
  { 396, 10, 18, 12, 1, -18 },
  { 419, 10, 18, 12, 1, -18 },
  { 442, 10, 18, 12, 1, -18 },
  { 465, 4, 14, 6, 1, -14 },
  { 472, 4, 17, 6, 1, -14 },
  { 481, 10, 12, 12, 1, -15 },
  { 496, 10, 7, 12, 1, -12 },
  { 505, 10, 12, 12, 1, -15 },
  { 520, 9, 18, 10, 0, -18 },
  { 541, 17, 20, 19, 1, -18 },
  { 584, 14, 18, 14, 0, -18 },
  { 616, 11, 18, 14, 2, -18 },
  { 641, 11, 18, 13, 1, -18 },
  { 666, 12, 18, 15, 2, -18 },
  { 693, 8, 18, 12, 2, -18 },
  { 711, 8, 18, 11, 2, -18 },
  { 729, 13, 18, 15, 1, -18 },
  { 759, 12, 18, 16, 2, -18 },
  { 786, 6, 18, 8, 1, -18 },
  { 800, 6, 23, 7, -1, -18 },
  { 818, 12, 18, 13, 2, -18 },
  { 845, 8, 18, 11, 2, -18 },
  { 863, 16, 18, 20, 2, -18 },
  { 899, 13, 18, 17, 2, -18 },
  { 929, 14, 18, 16, 1, -18 },
  { 961, 10, 18, 13, 2, -18 },
  { 984, 14, 22, 16, 1, -18 },
  { 1023, 11, 18, 13, 2, -18 },
  { 1048, 10, 18, 11, 1, -18 },
  { 1071, 11, 18, 11, 0, -18 },
  { 1096, 11, 18, 15, 2, -18 },
  { 1121, 13, 18, 13, 0, -18 },
  { 1151, 20, 18, 20, 0, -18 },
  { 1196, 13, 18, 13, 0, -18 },
  { 1226, 12, 18, 12, 0, -18 },
  { 1253, 10, 18, 11, 1, -18 },
  { 1276, 5, 22, 8, 2, -18 },
  { 1290, 10, 18, 10, 0, -18 },
  { 1313, 5, 22, 8, 1, -18 },
  { 1327, 11, 11, 13, 1, -18 },
  { 1343, 11, 2, 11, 0, 2 },
  { 1346, 6, 4, 8, 1, -19 },
  { 1349, 10, 14, 12, 1, -14 },
  { 1367, 10, 19, 13, 2, -19 },
  { 1391, 9, 14, 10, 1, -14 },
  { 1407, 11, 19, 13, 1, -19 },
  { 1434, 10, 14, 12, 1, -14 },
  { 1452, 9, 19, 8, 0, -19 },
  { 1474, 11, 20, 13, 1, -14 },
  { 1502, 10, 19, 13, 2, -19 },
  { 1526, 4, 19, 6, 1, -19 },
  { 1536, 6, 25, 6, -1, -19 },
  { 1555, 10, 19, 12, 2, -19 },
  { 1579, 3, 19, 6, 2, -19 },
  { 1587, 16, 14, 20, 2, -14 },
  { 1615, 10, 14, 13, 2, -14 },
  { 1633, 11, 14, 13, 1, -14 },
  { 1653, 10, 20, 13, 2, -14 },
  { 1678, 11, 20, 13, 1, -14 },
  { 1706, 7, 14, 9, 2, -14 },
  { 1719, 8, 14, 10, 1, -14 },
  { 1733, 8, 17, 8, 0, -17 },
  { 1750, 10, 14, 13, 2, -14 },
  { 1768, 11, 14, 11, 0, -14 },
  { 1788, 17, 14, 18, 0, -14 },
  { 1818, 11, 14, 11, 0, -14 },
  { 1838, 11, 20, 11, 0, -14 },
  { 1866, 8, 14, 10, 1, -14 },
  { 1880, 7, 22, 9, 1, -18 },
  { 1900, 2, 25, 12, 5, -19 },
  { 1907, 8, 22, 9, 1, -18 },
  { 1929, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD25PT7B_H_
