#ifndef _NOTOSANS_CONDENSED_SEMIBOLD37PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0x80, 0x00, 0x3F, 0xFF, 0xFB, 0xC0, 0xF9, 0xFF, 0x9F, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE0, 0x03, 0x8F, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE1,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0xF1, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x83, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE1, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x07, 0xFC, 0x3F, 0xFD, 0xFF, 0xFF, 0xF7, 0xBC, 0xC2, 0xF3, 0x03, 0xCC,
  0x0F, 0x30, 0x3E, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x0D, 0xF0, 0x33, 0xC0, 0xCF, 0x03, 0x3E, 0x0C, 0xFF, 0x37, 0xFF,
  0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x08, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x0F, 0x01, 0xEF, 0x03,
  0x80, 0x71, 0xC0, 0xE0, 0x3C, 0x70, 0x78, 0x0F, 0x1E, 0x1C, 0x03, 0xC7,
  0x8F, 0x00, 0xF1, 0xE3, 0x80, 0x3C, 0x79, 0xE0, 0x0F, 0x1E, 0x70, 0x01,
  0xC7, 0x1C, 0x7C, 0x71, 0xCF, 0x7F, 0x9E, 0xF3, 0x9F, 0xE3, 0xF9, 0xEF,
  0x3C, 0xFE, 0x73, 0xC7, 0x0E, 0x3C, 0xE1, 0xC0, 0x0E, 0x3C, 0x70, 0x03,
  0x8E, 0x1C, 0x01, 0xE3, 0x87, 0x00, 0x70, 0xE1, 0xC0, 0x3C, 0x38, 0x70,
  0x0E, 0x0F, 0x1C, 0x07, 0x81, 0xCF, 0x01, 0xC0, 0x7F, 0x80, 0x70, 0x0F,
  0xE0, 0x3C, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x80, 0x3E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x78, 0xFF, 0x87, 0xCF, 0xFE, 0x3E, 0x7C, 0xF9,
  0xE7, 0xC7, 0xDF, 0x3E, 0x1F, 0xF9, 0xF0, 0x7F, 0x8F, 0x81, 0xFC, 0x7C,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xCF,
  0x83, 0xFC, 0x7E, 0xFF, 0xFD, 0xEF, 0x79, 0xCE, 0x70, 0x07, 0x87, 0x83,
  0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0xF0,
  0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x06, 0x38, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0xC0, 0x7B, 0xC1, 0xF7, 0xC3,
  0xC7, 0x83, 0x8E, 0x02, 0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0xF7, 0xDF, 0x79, 0xE7, 0x1C,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7C, 0x7C, 0x3C, 0x78, 0x3E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFB,
  0xFE, 0x7B, 0x8F, 0x21, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7,
  0x87, 0xC6, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x7F, 0xE3, 0xFF,
  0xE3, 0xFF, 0xE7, 0x07, 0xC4, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xE0, 0x0F, 0xFC, 0xFE, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0x7C, 0x0F, 0x7C, 0x0E, 0x7C, 0x1E, 0x7C, 0x1C, 0x7C, 0x3C, 0x7C,
  0x38, 0x7C, 0x78, 0x7C, 0x70, 0x7C, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xDE, 0x0F, 0xFE, 0x3F, 0xFC, 0xFF,
  0xF8, 0x83, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7E, 0x03, 0xFF, 0xBF, 0xBF, 0xFC, 0xFF, 0xE1, 0xFF, 0x00,
  0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x79, 0xF0, 0x7B, 0xF8,
  0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x3E, 0x7E,
  0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xF8, 0x3E, 0xFC, 0x7C, 0x7E, 0x78, 0x3E, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x7C, 0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1F, 0x78, 0x3E, 0x7C, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xDE, 0x06, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x23, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xF0, 0x3D,
  0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0xF7, 0xDF, 0x79, 0xE7, 0x9C, 0xF0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x0F, 0x81, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0x0F, 0xA0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00,
  0x7C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x78, 0x1C, 0x0E, 0x78, 0x7F,
  0xCF, 0x70, 0xFF, 0xC7, 0xF1, 0xE3, 0xC7, 0xE1, 0xC3, 0x87, 0xE3, 0xC3,
  0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83,
  0x87, 0xE3, 0xC3, 0x87, 0xE3, 0xC7, 0x8F, 0xE1, 0xC7, 0xCE, 0xE1, 0xFF,
  0xFE, 0xF0, 0xFC, 0xFC, 0x70, 0x38, 0x70, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x07, 0xDE, 0x00, 0x79, 0xE0,
  0x07, 0x9E, 0x00, 0x79, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x07, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x01, 0xE7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0x00, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x06, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1E, 0x3F, 0xCF, 0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xEF, 0x01, 0xF7, 0x83, 0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF0,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x83, 0x8F, 0x80, 0x27, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF3, 0xE0,
  0x3C, 0xFF, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xF7, 0xF8, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xFC,
  0xFF, 0xFD, 0xFE, 0xFE, 0x18, 0x00, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x0F,
  0x9E, 0x0F, 0x8F, 0x07, 0xC7, 0x87, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0xF3,
  0xE0, 0x79, 0xF0, 0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xF3, 0xE0, 0xF1, 0xF0, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F,
  0x8F, 0x07, 0xC7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x3E, 0xF0, 0x1F, 0x78,
  0x07, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xEF, 0xF7, 0x01, 0xEF, 0xF7, 0x81, 0xEF,
  0xF7, 0x81, 0xCF, 0xF7, 0x81, 0xCF, 0xF3, 0x83, 0xCF, 0xF3, 0xC3, 0xCF,
  0xF3, 0xC3, 0x8F, 0xF1, 0xC7, 0x8F, 0xF1, 0xE7, 0x8F, 0xF1, 0xE7, 0x0F,
  0xF1, 0xEF, 0x0F, 0xF0, 0xEF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xBC, 0x0F, 0xF7, 0x81,
  0xFE, 0xF8, 0x3F, 0xCF, 0x07, 0xF9, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3, 0xE3,
  0xFC, 0x3C, 0x7F, 0x87, 0xCF, 0xF0, 0x79, 0xFE, 0x0F, 0xBF, 0xC0, 0xF7,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0x80,
  0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x3E, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0x8F, 0xEF, 0x07, 0xDE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF,
  0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x01,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x3F, 0x8F, 0x07, 0xE7,
  0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C, 0xF0, 0x3E, 0x78, 0x1F, 0x3C, 0x1F,
  0x1E, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xE3, 0xC0, 0xF1,
  0xF0, 0x78, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0xC7, 0x81, 0xE3,
  0xC0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1F, 0x78, 0x0F, 0xC0, 0x03, 0xC0, 0x1F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xE3, 0xCF, 0x81, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xB8, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x01, 0xF1, 0xE0, 0x3C, 0x3E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F,
  0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xE7, 0x80, 0xF8, 0x07, 0x9E, 0x03,
  0xF0, 0x3E, 0x78, 0x0F, 0xC0, 0xF9, 0xF0, 0x7F, 0x03, 0xC7, 0xC1, 0xFC,
  0x0F, 0x0F, 0x07, 0xF8, 0x3C, 0x3C, 0x1D, 0xE1, 0xF0, 0xF0, 0x77, 0x87,
  0xC3, 0xE3, 0xCE, 0x1E, 0x0F, 0x8F, 0x38, 0x78, 0x1E, 0x3C, 0xF1, 0xE0,
  0x78, 0xE3, 0xCF, 0x81, 0xE7, 0x8F, 0x3E, 0x07, 0xDE, 0x1C, 0xF0, 0x0F,
  0x78, 0x73, 0xC0, 0x3D, 0xE1, 0xEF, 0x00, 0xF7, 0x07, 0xBC, 0x03, 0xDC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x7C, 0x07, 0xC7, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0x81, 0xF1,
  0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F,
  0x01, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xE3, 0xE0, 0x3C, 0x7C, 0x07,
  0xDF, 0x00, 0xFC, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x3E,
  0x3E, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03,
  0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x1C, 0x70, 0x1E, 0x3C, 0x0E, 0x0E, 0x0F,
  0x07, 0x87, 0x01, 0xC7, 0x80, 0xF3, 0xC0, 0x3B, 0xC0, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x1F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xC3, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xE1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x7E, 0xFF, 0xFD, 0xFF, 0x79, 0xFC,
  0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xFE,
  0x7E, 0xFC, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1E, 0xFE, 0x7E, 0xFF, 0xFC, 0xF7, 0xFC, 0xF3, 0xF8, 0x0F, 0xF9, 0xFF,
  0x8F, 0xFC, 0xF8, 0x6F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x01, 0x7E,
  0x73, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x1F, 0x9E, 0x7F,
  0xBD, 0xFF, 0xFB, 0xE7, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x1F, 0x7C, 0xFE, 0xFF, 0xFC, 0xFF, 0x78, 0xFC, 0x70, 0x0F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xE3, 0xCF, 0x83, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x1E, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x02, 0x7C, 0x1C, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F,
  0xC0, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x61, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3F, 0xE7, 0xFF, 0x3F, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x1F,
  0x9E, 0x7F, 0xBD, 0xFF, 0xFB, 0xE3, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0xFE, 0xFF, 0xFC, 0xFF, 0x78, 0xFC,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x40, 0x7C, 0xFF, 0xF9,
  0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFB, 0xF9, 0xFF,
  0xFB, 0xDF, 0xF7, 0xF3, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF0, 0x77,
  0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xE0,
  0xFB, 0xC3, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x7C, 0x3D, 0xF0, 0x7B, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x7C, 0xF0, 0x79, 0xE0, 0xFB, 0xC0, 0xF7, 0x81, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xF8, 0xFE, 0x7B, 0xFE, 0xFF, 0xBD,
  0xFF, 0x7F, 0xDF, 0xCF, 0xF3, 0xFF, 0xC3, 0xF0, 0xFF, 0xC1, 0xF0, 0x3F,
  0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03,
  0xFE, 0x07, 0x81, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0,
  0x3F, 0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F,
  0x03, 0xFE, 0x07, 0x81, 0xFF, 0x03, 0xC0, 0xF0, 0xF3, 0xF9, 0xEF, 0xFB,
  0xDF, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF0, 0x0F, 0xE0,
  0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x7C, 0x3F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xE0, 0xF3, 0xF8, 0xF7, 0xFC, 0xF7, 0xFC, 0xFE, 0x3E, 0xFC, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0xFE, 0x7E,
  0xFF, 0xFC, 0xFF, 0xFC, 0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB, 0xE7, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x7E, 0xFF, 0xFC, 0xFF, 0x78,
  0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF,
  0xFF, 0xE1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0xE1, 0xFF, 0x9F, 0xFD, 0xF0, 0xCF, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0,
  0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x1E, 0xF1, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0x1C, 0x03, 0x80, 0xF0,
  0x1E, 0x07, 0xFD, 0xFF, 0xBF, 0xF1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xE2, 0x7F, 0xC7, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0x7E,
  0xFE, 0xFF, 0xFC, 0xFF, 0x38, 0xFC, 0x70, 0xF8, 0x0F, 0xBC, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xE7, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x7C,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x3D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x1F, 0x07, 0xDE, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0x79,
  0xE0, 0xFC, 0x1E, 0x7C, 0x3F, 0x07, 0x8F, 0x1F, 0xE3, 0xC3, 0xC7, 0x38,
  0xF0, 0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x07, 0x9C, 0xF7, 0x81, 0xEF,
  0x3D, 0xE0, 0x7B, 0x87, 0x78, 0x1E, 0xE1, 0xDE, 0x07, 0xB8, 0x77, 0x80,
  0xEE, 0x1D, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x7C, 0x1E, 0x3C,
  0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F,
  0x7C, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x7C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0xDF, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0xFC, 0x3F, 0x87,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x7C, 0x3F, 0x87, 0xC0, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFE, 0x1F,
  0xC1, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0xFE, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0x00, 0x3E, 0x01, 0x7F, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_Condensed_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 10, 2, -26 },
  { 18, 12, 9, 16, 2, -26 },
  { 32, 18, 26, 20, 1, -26 },
  { 91, 14, 30, 18, 2, -28 },
  { 144, 26, 27, 29, 1, -27 },
  { 232, 21, 27, 22, 1, -27 },
  { 303, 5, 9, 9, 2, -26 },
  { 309, 9, 33, 12, 2, -27 },
  { 347, 9, 33, 12, 1, -27 },
  { 385, 15, 15, 17, 1, -28 },
  { 414, 16, 18, 18, 1, -22 },
  { 450, 6, 9, 9, 1, -4 },
  { 457, 9, 4, 11, 1, -12 },
  { 462, 5, 5, 9, 2, -5 },
  { 466, 14, 27, 15, 0, -27 },
  { 514, 16, 27, 18, 1, -27 },
  { 568, 11, 26, 18, 2, -26 },
  { 604, 15, 27, 18, 1, -27 },
  { 655, 15, 27, 18, 1, -27 },
  { 706, 16, 26, 18, 1, -26 },
  { 758, 14, 26, 18, 2, -26 },
  { 804, 16, 27, 18, 1, -27 },
  { 858, 16, 26, 18, 1, -26 },
  { 910, 16, 27, 18, 1, -27 },
  { 964, 16, 27, 18, 1, -27 },
  { 1018, 5, 20, 9, 2, -20 },
  { 1031, 6, 25, 10, 1, -20 },
  { 1050, 16, 18, 18, 1, -22 },
  { 1086, 16, 10, 18, 1, -18 },
  { 1106, 16, 18, 18, 1, -22 },
  { 1142, 13, 27, 14, 0, -27 },
  { 1186, 24, 30, 28, 2, -27 },
  { 1276, 20, 26, 20, 0, -26 },
  { 1341, 16, 26, 20, 3, -26 },
  { 1393, 16, 27, 19, 2, -27 },
  { 1447, 17, 26, 22, 3, -26 },
  { 1503, 12, 26, 17, 3, -26 },
  { 1542, 12, 26, 17, 3, -26 },
  { 1581, 18, 27, 22, 2, -27 },
  { 1642, 17, 26, 23, 3, -26 },
  { 1698, 10, 26, 12, 1, -26 },
  { 1731, 9, 34, 10, -2, -26 },
  { 1770, 17, 26, 20, 3, -26 },
  { 1826, 13, 26, 16, 3, -26 },
  { 1869, 24, 26, 30, 3, -26 },
  { 1947, 19, 26, 25, 3, -26 },
  { 2009, 20, 27, 24, 2, -27 },
  { 2077, 15, 26, 19, 3, -26 },
  { 2126, 20, 33, 24, 2, -27 },
  { 2209, 17, 26, 20, 3, -26 },
  { 2265, 15, 27, 17, 1, -27 },
  { 2316, 15, 26, 17, 1, -26 },
  { 2365, 17, 26, 23, 3, -26 },
  { 2421, 19, 26, 19, 0, -26 },
  { 2483, 30, 26, 30, 0, -26 },
  { 2581, 19, 26, 19, 0, -26 },
  { 2643, 18, 26, 18, 0, -26 },
  { 2702, 15, 26, 17, 1, -26 },
  { 2751, 9, 33, 12, 2, -27 },
  { 2789, 14, 27, 15, 0, -27 },
  { 2837, 8, 33, 12, 1, -27 },
  { 2870, 17, 15, 19, 1, -26 },
  { 2902, 16, 3, 16, 0, 3 },
  { 2908, 9, 6, 11, 1, -28 },
  { 2915, 15, 20, 18, 1, -20 },
  { 2953, 16, 28, 20, 2, -28 },
  { 3009, 13, 20, 15, 2, -20 },
  { 3042, 15, 28, 20, 2, -28 },
  { 3095, 15, 20, 18, 2, -20 },
  { 3133, 13, 28, 11, 0, -28 },
  { 3179, 15, 29, 20, 2, -20 },
  { 3234, 15, 28, 20, 2, -28 },
  { 3287, 5, 28, 9, 2, -28 },
  { 3305, 8, 37, 9, -1, -28 },
  { 3342, 15, 28, 18, 3, -28 },
  { 3395, 5, 28, 9, 2, -28 },
  { 3413, 25, 20, 29, 2, -20 },
  { 3476, 15, 20, 20, 2, -20 },
  { 3514, 16, 20, 19, 2, -20 },
  { 3554, 16, 29, 20, 2, -20 },
  { 3612, 15, 29, 20, 2, -20 },
  { 3667, 11, 20, 13, 2, -20 },
  { 3695, 13, 20, 15, 1, -20 },
  { 3728, 11, 24, 12, 1, -24 },
  { 3761, 15, 20, 20, 2, -20 },
  { 3799, 17, 20, 17, 0, -20 },
  { 3842, 26, 20, 26, 0, -20 },
  { 3907, 16, 20, 17, 0, -20 },
  { 3947, 17, 29, 17, 0, -20 },
  { 4009, 12, 20, 14, 1, -20 },
  { 4039, 11, 32, 13, 1, -26 },
  { 4083, 3, 37, 17, 7, -28 },
  { 4097, 12, 32, 13, 1, -26 },
  { 4145, 16, 6, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD37PT7B_H_
