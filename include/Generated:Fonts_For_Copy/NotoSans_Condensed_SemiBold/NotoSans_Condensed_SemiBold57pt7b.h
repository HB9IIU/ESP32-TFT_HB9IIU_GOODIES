#ifndef _NOTOSANS_CONDENSED_SEMIBOLD57PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x0C, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F,
  0xDF, 0x03, 0xE7, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF7, 0x87, 0x3F,
  0x1E, 0x04, 0xFC, 0x78, 0x03, 0xF1, 0xE0, 0x0F, 0xC7, 0x80, 0x3F, 0x1E,
  0x00, 0xFE, 0x78, 0x03, 0xFD, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1E, 0x7F, 0x00, 0x78,
  0xFC, 0x01, 0xE3, 0xF0, 0x07, 0x8F, 0xC0, 0x1E, 0x3F, 0x80, 0x78, 0xFF,
  0x81, 0xE7, 0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0xFC,
  0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x00, 0xFC,
  0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0x00,
  0xF8, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x1F, 0x07,
  0xE0, 0xFC, 0x3F, 0x1F, 0x0F, 0xF0, 0x7C, 0x3E, 0x3F, 0x1F, 0xF8, 0x7C,
  0x3E, 0x3E, 0x3F, 0xFC, 0x7E, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x7C,
  0x7C, 0x3E, 0x1F, 0xFC, 0x7C, 0x7C, 0x3E, 0x1F, 0xF8, 0xF8, 0xFC, 0x3F,
  0x07, 0xE0, 0xF8, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x0F, 0x80,
  0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x3E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFC, 0x1F, 0xFF, 0x01, 0xFC, 0x3F, 0xFF,
  0x81, 0xFC, 0x7F, 0xBF, 0xC1, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x0F,
  0xE3, 0xF8, 0xFE, 0x07, 0xF3, 0xF8, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x03,
  0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE, 0x00,
  0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF3, 0xFC, 0x0F, 0xFF, 0xE1, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x1C, 0x1F, 0x07, 0x7F, 0x3C, 0x7E, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x9F, 0xC0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0xF0, 0x3C, 0x00, 0x60,
  0x30, 0x00, 0x40, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF9,
  0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03,
  0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80,
  0x7E, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFF, 0x3F,
  0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x9F, 0xDF, 0xFF, 0xCF, 0xEF, 0xC7, 0xF3, 0xC3, 0xF8, 0xC1, 0xFC,
  0x40, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0x1E, 0x00, 0xFE, 0x10, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x8F, 0x00, 0xFF, 0x08, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xF7, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xE0,
  0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x9E, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xE0, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xEC, 0x00, 0x7F, 0xBF,
  0x07, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x0A, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0x38, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x7E, 0x7F, 0xE0, 0xFE, 0xFF,
  0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xE7, 0xFC, 0xFF, 0x81,
  0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x83,
  0xFC, 0x1F, 0xC7, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xCF, 0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFF, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFD,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF8, 0x7F, 0xEF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xDF, 0x8F, 0xFF, 0xBF, 0x0F, 0xFE, 0x7E, 0x0F, 0xF8,
  0xFC, 0x01, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0x01, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x0C, 0x1F, 0x1F, 0xDF, 0xEF, 0xF7,
  0xF9, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F,
  0xC7, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xF0, 0x1F, 0xC2, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xF0, 0x7C, 0x3E, 0x03, 0xFF, 0xE1,
  0xF1, 0xF8, 0x1F, 0xFF, 0x83, 0xE7, 0xC0, 0xFF, 0xFE, 0x0F, 0x9F, 0x07,
  0xF0, 0xF8, 0x3E, 0xFC, 0x1F, 0x83, 0xE0, 0xFB, 0xE0, 0xFC, 0x0F, 0x83,
  0xEF, 0x83, 0xE0, 0x3E, 0x07, 0xFE, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x3E,
  0x03, 0xE0, 0x7F, 0xE0, 0xF8, 0x0F, 0x81, 0xFF, 0x87, 0xE0, 0x3E, 0x07,
  0xFE, 0x1F, 0x81, 0xF8, 0x3E, 0xF8, 0x7E, 0x07, 0xE0, 0xFB, 0xE1, 0xF8,
  0x1F, 0x83, 0xEF, 0x83, 0xE0, 0x7E, 0x0F, 0xBE, 0x0F, 0x81, 0xF8, 0x3E,
  0xF8, 0x3E, 0x0F, 0xE1, 0xF3, 0xE0, 0xFC, 0x3F, 0x87, 0xCF, 0x81, 0xFF,
  0xEF, 0xFE, 0x3F, 0x07, 0xFF, 0x3F, 0xF8, 0x7C, 0x0F, 0xFC, 0x7F, 0xC1,
  0xF0, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x04, 0x00, 0x40, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xF8, 0x0F, 0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03,
  0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x7F, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0x38,
  0x3F, 0xC0, 0x04, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0xC3, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0x81,
  0xFF, 0xC7, 0xF0, 0x07, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xFB,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xE3, 0xF8, 0x0F, 0xFC,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x01, 0xC1, 0xFF, 0x00, 0x04, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0,
  0x07, 0xF3, 0xFE, 0x00, 0x7F, 0x1F, 0xF0, 0x07, 0xF0, 0xFF, 0xE3, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xC3, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x07,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xEC, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xE0, 0x38, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE1,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF9, 0xFC,
  0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF7, 0xC0, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x07, 0xFF,
  0xFF, 0x7E, 0x00, 0x1F, 0x7F, 0xFE, 0xF8, 0x00, 0xFD, 0xFF, 0xFB, 0xF0,
  0x03, 0xF7, 0xFF, 0xEF, 0xC0, 0x0F, 0x9F, 0xFF, 0xBF, 0x00, 0x7E, 0x7F,
  0xFE, 0x7E, 0x01, 0xF9, 0xFF, 0xF9, 0xF8, 0x07, 0xE7, 0xFF, 0xE7, 0xE0,
  0x1F, 0x1F, 0xFF, 0x8F, 0x80, 0xFC, 0x7F, 0xFE, 0x3F, 0x03, 0xF1, 0xFF,
  0xF8, 0xFC, 0x0F, 0x87, 0xFF, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0x87, 0xE1,
  0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xC1, 0xFF, 0xF8, 0x7E, 0x3F, 0x07, 0xFF,
  0xE0, 0xF8, 0xFC, 0x1F, 0xFF, 0x83, 0xF3, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF,
  0x81, 0xFF, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x7E, 0x00, 0x7F, 0xFB, 0xF8, 0x03, 0xFF, 0xCF, 0xC0, 0x1F, 0xFE, 0x7F,
  0x00, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xFE, 0x3F, 0x01,
  0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0x87, 0xE0, 0x7F, 0xFC, 0x3F, 0x83, 0xFF,
  0xE1, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0x87, 0xFF, 0xC0,
  0xFE, 0x3F, 0xFE, 0x07, 0xF1, 0xFF, 0xF0, 0x1F, 0xCF, 0xFF, 0x80, 0xFE,
  0x7F, 0xFC, 0x03, 0xFB, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0,
  0x7F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F,
  0x1F, 0xC0, 0x0C, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFE,
  0x01, 0xFF, 0x1F, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0x1F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE7, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xC3, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7D,
  0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF7, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xCF,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0x8F, 0xC1,
  0xFC, 0x03, 0xF8, 0x7E, 0x3F, 0x07, 0xF0, 0x0F, 0xE1, 0xF8, 0x7C, 0x1F,
  0x80, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x87, 0xE3, 0xF8,
  0x01, 0xF8, 0x7C, 0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xF0, 0x3E, 0x3F, 0x80,
  0x1F, 0xCF, 0xC0, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xF8, 0x0F, 0xDF, 0xC0, 0x03, 0xF3, 0xE0, 0x3F, 0x7F, 0x00, 0x0F,
  0xDF, 0x80, 0x7D, 0xFC, 0x00, 0x3F, 0x7E, 0x01, 0xF7, 0xE0, 0x00, 0x7F,
  0xF8, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0x7E, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00,
  0x08, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xF0, 0x3F, 0xC2, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xE3,
  0xF7, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xF9, 0xF3, 0xFF, 0xC7,
  0xC3, 0xFC, 0x1F, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0xFC, 0xFF, 0xE0,
  0xFD, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFC,
  0xFF, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0xC3, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xF0, 0xF8, 0xFF, 0xE0,
  0xF8, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xE0, 0xE3,
  0xFC, 0x02, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0x3F,
  0xE0, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x20, 0x3F, 0x03, 0xFC, 0x3F, 0x07, 0xFF, 0x3F, 0x0F,
  0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0x3F,
  0x80, 0xFF, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0x1F, 0x03,
  0xFE, 0x1F, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0x8F, 0xE0,
  0x3F, 0x1F, 0x80, 0x7F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x04, 0x7F, 0xC0, 0x38, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0A,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x03, 0xFC, 0x20, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xBF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x30,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x20, 0x00, 0xFE, 0x3C, 0x03, 0xFE, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x20, 0x0F, 0xC3, 0xFC, 0x1F, 0x9F, 0xFE, 0x3F, 0x7F, 0xFE, 0x7E,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0x8F, 0xFB, 0xFE, 0x07, 0xF7, 0xF8,
  0x0F, 0xEF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81,
  0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0xA3, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x3C, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8,
  0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00,
  0xFD, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0x80, 0xFE, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x04, 0x03, 0xE1,
  0xFF, 0x01, 0xFF, 0x0F, 0x8F, 0xFE, 0x1F, 0xFE, 0x3E, 0x7F, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC,
  0x7F, 0xFC, 0xFF, 0xBF, 0xC0, 0xFF, 0xC0, 0xFE, 0xFF, 0x01, 0xFE, 0x03,
  0xFB, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x01,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x06, 0x01, 0xF0, 0x7F, 0x83, 0xE3, 0xFF, 0xC7, 0xCF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0x7F, 0x80,
  0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xF7,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07,
  0xF7, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0xF8, 0x3F, 0xC0,
  0xF8, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC3, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFC,
  0xFF, 0xC3, 0xFC, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xF8, 0xFD, 0xFF, 0xF0,
  0xFC, 0xFF, 0xE0, 0xFC, 0x3F, 0xC0, 0xFC, 0x04, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0xBF,
  0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0x3F, 0x80, 0xFF,
  0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0x3F, 0x03, 0xFC, 0x3F,
  0x00, 0x20, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x04, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0x80, 0xE7, 0xF0, 0x04, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xE0, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x02, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x7F, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x01, 0xC0, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFB,
  0xF3, 0xFF, 0xE7, 0xE3, 0xFF, 0x8F, 0xC3, 0xFE, 0x1F, 0x80, 0x40, 0x00,
  0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x7E, 0x00,
  0xFF, 0x00, 0x7E, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x7F, 0x00, 0xFF, 0x80,
  0xFE, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F,
  0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xF7,
  0xC1, 0xFC, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8,
  0x1F, 0xC3, 0xE7, 0xC1, 0xF8, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x0F, 0xC7,
  0xE3, 0xE3, 0xF8, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3,
  0xF0, 0x0F, 0xE7, 0xC3, 0xE3, 0xF0, 0x07, 0xE7, 0xC3, 0xE7, 0xF0, 0x07,
  0xE7, 0xC1, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81,
  0xF7, 0xE0, 0x03, 0xEF, 0x81, 0xF7, 0xE0, 0x03, 0xEF, 0x81, 0xF7, 0xC0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF3, 0xF8,
  0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xF1, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x80,
  0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBold57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 42, 15, 3, -41 },
  { 43, 18, 15, 24, 3, -41 },
  { 77, 28, 41, 30, 1, -41 },
  { 221, 22, 46, 28, 3, -43 },
  { 348, 40, 42, 44, 2, -41 },
  { 558, 32, 42, 34, 2, -41 },
  { 726, 7, 15, 13, 3, -41 },
  { 740, 13, 50, 18, 3, -41 },
  { 822, 14, 50, 18, 1, -41 },
  { 910, 23, 23, 26, 2, -43 },
  { 977, 24, 28, 28, 2, -34 },
  { 1061, 9, 14, 14, 2, -7 },
  { 1077, 14, 6, 17, 2, -18 },
  { 1088, 8, 9, 14, 3, -8 },
  { 1097, 21, 41, 22, 1, -41 },
  { 1205, 23, 42, 28, 2, -41 },
  { 1326, 17, 41, 28, 3, -41 },
  { 1414, 23, 41, 28, 2, -41 },
  { 1532, 23, 42, 28, 2, -41 },
  { 1653, 26, 41, 28, 1, -41 },
  { 1787, 22, 42, 28, 3, -41 },
  { 1903, 24, 42, 28, 2, -41 },
  { 2029, 24, 41, 28, 2, -41 },
  { 2152, 24, 42, 28, 2, -41 },
  { 2278, 23, 42, 28, 2, -41 },
  { 2399, 8, 32, 15, 3, -31 },
  { 2431, 9, 38, 15, 2, -31 },
  { 2474, 24, 27, 28, 2, -34 },
  { 2555, 24, 16, 28, 2, -28 },
  { 2603, 24, 27, 28, 2, -34 },
  { 2684, 21, 42, 22, 0, -41 },
  { 2795, 38, 46, 43, 3, -41 },
  { 3014, 31, 41, 31, 0, -41 },
  { 3173, 25, 41, 32, 4, -41 },
  { 3302, 25, 42, 30, 3, -41 },
  { 3434, 27, 41, 34, 4, -41 },
  { 3573, 20, 41, 26, 4, -41 },
  { 3676, 19, 41, 26, 4, -41 },
  { 3774, 28, 42, 35, 3, -41 },
  { 3921, 27, 41, 36, 4, -41 },
  { 4060, 15, 41, 18, 2, -41 },
  { 4137, 14, 53, 15, -3, -41 },
  { 4230, 27, 41, 31, 4, -41 },
  { 4369, 20, 41, 25, 4, -41 },
  { 4472, 38, 41, 46, 4, -41 },
  { 4667, 29, 41, 38, 4, -41 },
  { 4816, 31, 42, 36, 3, -41 },
  { 4979, 23, 41, 29, 4, -41 },
  { 5097, 31, 51, 36, 3, -41 },
  { 5295, 26, 41, 31, 4, -41 },
  { 5429, 22, 42, 26, 2, -41 },
  { 5545, 24, 41, 26, 1, -41 },
  { 5668, 27, 42, 35, 4, -41 },
  { 5810, 30, 41, 30, 0, -41 },
  { 5964, 46, 41, 46, 0, -41 },
  { 6200, 29, 41, 29, 0, -41 },
  { 6349, 28, 41, 28, 0, -41 },
  { 6493, 23, 41, 26, 1, -41 },
  { 6611, 13, 50, 18, 4, -41 },
  { 6693, 21, 41, 22, 1, -41 },
  { 6801, 13, 50, 18, 1, -41 },
  { 6883, 27, 25, 30, 1, -41 },
  { 6968, 24, 4, 24, 0, 5 },
  { 6980, 13, 9, 17, 2, -44 },
  { 6995, 22, 33, 28, 2, -32 },
  { 7086, 24, 44, 30, 4, -43 },
  { 7218, 20, 33, 24, 2, -32 },
  { 7301, 24, 44, 30, 2, -43 },
  { 7433, 23, 32, 28, 2, -31 },
  { 7525, 19, 44, 18, 1, -44 },
  { 7630, 24, 46, 30, 2, -32 },
  { 7768, 23, 43, 30, 4, -43 },
  { 7892, 8, 43, 14, 3, -43 },
  { 7935, 13, 57, 14, -2, -43 },
  { 8028, 24, 43, 28, 4, -43 },
  { 8157, 6, 43, 14, 4, -43 },
  { 8190, 38, 32, 45, 4, -32 },
  { 8342, 23, 32, 30, 4, -32 },
  { 8434, 25, 33, 29, 2, -32 },
  { 8538, 24, 46, 30, 4, -32 },
  { 8676, 24, 46, 30, 2, -32 },
  { 8814, 16, 32, 21, 4, -32 },
  { 8878, 19, 33, 23, 2, -32 },
  { 8957, 17, 39, 19, 1, -38 },
  { 9040, 23, 32, 30, 4, -31 },
  { 9132, 26, 31, 26, 0, -31 },
  { 9233, 40, 31, 40, 0, -31 },
  { 9388, 25, 31, 26, 0, -31 },
  { 9485, 26, 45, 26, 0, -31 },
  { 9632, 19, 31, 22, 1, -31 },
  { 9706, 18, 50, 21, 1, -41 },
  { 9819, 6, 56, 26, 10, -43 },
  { 9861, 18, 50, 21, 2, -41 },
  { 9974, 24, 8, 28, 2, -24 },
};

const GFXfont NotoSans_Condensed_SemiBold57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD57PT7B_H_
