#ifndef _NOTOSANS_CONDENSED_SEMIBOLD33PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0xCF, 0x7F, 0xFE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x7F,
  0x1F, 0x87, 0xE1, 0xC0, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x0E, 0x30, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x07, 0xFE, 0x3F,
  0xF9, 0xFF, 0xE7, 0xB1, 0x1C, 0xC0, 0x73, 0x01, 0xEC, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0x3C, 0x0C, 0xF0,
  0x33, 0xF0, 0xDE, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x7E, 0x03, 0x81, 0xFC, 0x0E,
  0x03, 0x9C, 0x1C, 0x0E, 0x38, 0x38, 0x1C, 0x70, 0xE0, 0x38, 0xE1, 0xC0,
  0x71, 0xC7, 0x00, 0xE3, 0x8E, 0x01, 0xC7, 0x38, 0x03, 0x8E, 0x73, 0xE3,
  0x9C, 0xEF, 0xE7, 0xFB, 0x9D, 0xE7, 0xE7, 0x79, 0xC7, 0x1C, 0xE3, 0x80,
  0x39, 0xC7, 0x00, 0xE3, 0x8E, 0x01, 0xC7, 0x1C, 0x03, 0x8E, 0x38, 0x0E,
  0x1C, 0x70, 0x1C, 0x1C, 0xE0, 0x70, 0x3B, 0xC0, 0xE0, 0x7F, 0x03, 0x80,
  0x7C, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1E, 0x78, 0x03, 0xC7,
  0x00, 0x70, 0xF0, 0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x3C, 0xFF, 0x8F, 0x1E, 0x79,
  0xE7, 0x8F, 0xBC, 0xF0, 0xFF, 0x1E, 0x0F, 0xE3, 0xC0, 0xF8, 0x7C, 0x1F,
  0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFD, 0xE0, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE0, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0,
  0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x0F, 0xE0, 0xF0, 0x70, 0x38,
  0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x0E, 0x1F, 0x77, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF0, 0x0F, 0xC0, 0xEE, 0x0F, 0x38, 0xF1, 0xE1, 0x84, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x7D, 0xE7, 0x9E, 0x79, 0xCF, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0x67, 0xBF, 0xEF, 0x00, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x7F, 0x83,
  0xFF, 0x0F, 0xFC, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0xBC, 0x0E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x39, 0xC1, 0xE7, 0x87, 0x9E, 0x1E, 0x7C, 0xF8, 0xFF, 0xC1, 0xFE,
  0x03, 0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDE, 0xFF, 0x3D, 0x8F,
  0x23, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x80, 0xFF, 0x87,
  0xFF, 0x3F, 0xFE, 0x70, 0x78, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x81, 0xFF, 0x8F, 0xFF, 0x1F, 0x7E, 0x20, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC1, 0xFE, 0x07, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0xC0, 0xFB, 0xFF, 0xCF, 0xFF, 0x1F, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0x78, 0x0E,
  0xF0, 0x39, 0xE0, 0x73, 0xC1, 0xC7, 0x83, 0x8F, 0x0E, 0x1E, 0x3C, 0x3C,
  0x70, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9, 0xFF, 0xCF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF8, 0x3F, 0xF1, 0xFF,
  0xC7, 0x7F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xEC, 0x1F, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x01, 0xF8, 0x1F, 0xE1,
  0xFF, 0x87, 0xE6, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xCF, 0x8F, 0x7F, 0x3F, 0xFE, 0xFC, 0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3D, 0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x7C, 0x78, 0xFF, 0xE1, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7F, 0x83,
  0xFF, 0x1F, 0x3E, 0x78, 0x79, 0xC0, 0xE7, 0x07, 0x9E, 0x1E, 0x78, 0x78,
  0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0x9E, 0x1E,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x79, 0xFF, 0xE3, 0xFF,
  0x07, 0xF8, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x78, 0x7B, 0xC1,
  0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xDE, 0x1F, 0x7F,
  0xFD, 0xFF, 0xF3, 0xFB, 0x81, 0x8E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xF7, 0xBF, 0xE7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x33, 0xDF, 0xFF, 0x80, 0x39, 0xE7, 0xDE, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x79, 0xE7, 0x9C, 0xF3,
  0x80, 0x00, 0x04, 0x00, 0x70, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7C, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x1F, 0x87, 0xFC, 0x7F, 0xE7, 0xFF, 0x40, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7C, 0x07,
  0x81, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x02, 0x0E, 0x1C, 0x3F, 0x8E,
  0x70, 0xFF, 0x1C, 0xE3, 0xCE, 0x39, 0xC7, 0x1C, 0x33, 0x9E, 0x38, 0x76,
  0x38, 0x70, 0xDC, 0x70, 0xE1, 0xB8, 0xE1, 0xC7, 0x31, 0xC3, 0x8E, 0x73,
  0xC7, 0x1C, 0xE3, 0x9F, 0x71, 0xC7, 0xF7, 0xE3, 0x87, 0xCF, 0x83, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7B, 0x80, 0x1C,
  0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF1, 0xC0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xC0, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0x3F, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F,
  0xFF, 0x9E, 0x1F, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x81, 0xFF, 0x07, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x03, 0xF0,
  0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x7C, 0x09, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x0C, 0xFF,
  0xF1, 0xFF, 0xC1, 0xFE, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF1, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xEF, 0xFD, 0xFF, 0xB8, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x01, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3E, 0x02, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x0F,
  0x7C, 0x0F, 0x3E, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE7, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xFB, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0F,
  0x0F, 0xFF, 0xFE, 0xFC, 0x78, 0xE0, 0x3F, 0xC0, 0x7B, 0x81, 0xE7, 0x07,
  0xCE, 0x0F, 0x1C, 0x3C, 0x38, 0xF8, 0x71, 0xE0, 0xE7, 0xC1, 0xCF, 0x03,
  0xBC, 0x07, 0x78, 0x0F, 0xF8, 0x1F, 0xF0, 0x3C, 0xF0, 0x71, 0xE0, 0xE1,
  0xE1, 0xC3, 0xC3, 0x83, 0xC7, 0x07, 0xCE, 0x07, 0x9C, 0x0F, 0xB8, 0x0F,
  0x70, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFD, 0xC0, 0xFF, 0xEE,
  0x07, 0x7F, 0x78, 0x3B, 0xF9, 0xC1, 0xDF, 0xCE, 0x1E, 0xFE, 0x70, 0xE7,
  0xF3, 0xC7, 0x3F, 0x8E, 0x79, 0xFC, 0x73, 0x8F, 0xE3, 0xDC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0x78, 0x3F,
  0x83, 0xC1, 0xFC, 0x1E, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xEF, 0x07, 0xEF, 0x07, 0xE7,
  0x87, 0xE7, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1, 0xE7, 0xE1, 0xE7, 0xE0,
  0xF7, 0xE0, 0xF7, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0xF9,
  0xF0, 0x3C, 0x7E, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF,
  0x03, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0x7B, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x3E, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFC, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0xF9,
  0xF0, 0x3C, 0x7E, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0,
  0x1F, 0x07, 0xC0, 0xFF, 0xCF, 0xFC, 0xFF, 0xE7, 0x81, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xFF, 0x1F, 0x7F,
  0xFB, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xF0, 0xF0, 0x07, 0xF8, 0x03, 0xDC, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF3,
  0xC0, 0x78, 0xE0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x07,
  0x83, 0xC3, 0x81, 0xE3, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1E, 0x70, 0x0F,
  0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x7B, 0xC0,
  0x78, 0x0F, 0x38, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x7E, 0x07,
  0x1E, 0x0F, 0xC1, 0xE3, 0xC1, 0xFC, 0x3C, 0x38, 0x3B, 0x87, 0x87, 0x8F,
  0x70, 0xF0, 0xF1, 0xCE, 0x3C, 0x1E, 0x39, 0xC7, 0x81, 0xC7, 0x3C, 0xF0,
  0x3D, 0xE3, 0x9E, 0x07, 0xBC, 0x73, 0x80, 0xF7, 0x0E, 0xF0, 0x1E, 0xE1,
  0xDE, 0x01, 0xDC, 0x3F, 0xC0, 0x3B, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x78, 0x0F, 0x3C, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC1, 0xE3, 0xC0,
  0xF1, 0xE0, 0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC1, 0xE3, 0xC0, 0xF1,
  0xE0, 0x7D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1E, 0x78, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x70,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0x70,
  0xE0, 0xE3, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x3C, 0x3C, 0x1E, 0x07, 0x1F, 0xE1, 0xFF, 0x8F, 0xFC,
  0x21, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE1, 0xFF, 0x3F, 0xFB, 0xFF, 0xFE,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xEF, 0xFF, 0x7F, 0xB9, 0xF9,
  0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0xF8, 0xF7, 0xF3, 0xFF, 0xEF, 0xC7, 0xBE, 0x1E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF8, 0x7F, 0xE1, 0xEF, 0xFF, 0xBF, 0xFC, 0xE7, 0xE0, 0x0F, 0xE1, 0xFF,
  0x3F, 0xE7, 0xC2, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x33, 0xFF, 0x1F, 0xF0, 0xFE,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC7, 0xEF, 0x3F, 0xDC, 0xFF, 0xF7, 0xC7, 0xDE, 0x0F, 0x78, 0x3D, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x78,
  0x3D, 0xF1, 0xF3, 0xFF, 0xCF, 0xF7, 0x1F, 0x9C, 0x0F, 0xC0, 0x7F, 0xC3,
  0xFF, 0x1E, 0x1E, 0x78, 0x39, 0xC0, 0xF7, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x8F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xC0, 0x07, 0xE1, 0xFC, 0x7F, 0x8F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xFE, 0xFF, 0xDF, 0xF8, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0x0F, 0x9C, 0xFF, 0x73, 0xFF, 0xDF, 0x1F, 0x78, 0x3D,
  0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xDC, 0x0F,
  0x78, 0x3D, 0xE0, 0xF7, 0xC7, 0xCF, 0xFF, 0x3F, 0xFC, 0x7E, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3D, 0x00, 0xF7, 0x8F, 0x9F, 0xFE, 0x7F, 0xF0, 0x7F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x7C, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x38, 0x6F, 0xFF, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x3C, 0x78, 0xF0, 0xC0,
  0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0xFF, 0x7E, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x1F, 0xF0, 0x7B, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xDE,
  0x0F, 0x70, 0x3F, 0xE0, 0xFF, 0xC3, 0xEF, 0x0F, 0x1E, 0x3C, 0x78, 0xF0,
  0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xE3, 0xF3,
  0xBF, 0xDF, 0xEF, 0xFF, 0xFF, 0xFE, 0x3F, 0x9F, 0xF8, 0x7C, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF,
  0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0xE3,
  0xE7, 0x7F, 0xBF, 0xFF, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3,
  0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7B, 0x80, 0xE7, 0x83, 0xCF, 0x07, 0x9F, 0x1F, 0x1F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0xE3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF8, 0x7F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0xBF, 0xFE, 0xFF, 0xF3, 0xCF, 0x8F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x0F, 0x9C, 0xFF, 0x73, 0xFF, 0xDF, 0x1F, 0x78, 0x3D, 0xE0, 0xF7,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xDC, 0x0F, 0x78, 0x3D,
  0xE0, 0xF7, 0xC7, 0xCF, 0xFF, 0x3F, 0xFC, 0x7E, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xE3,
  0xF9, 0xEF, 0xFB, 0xFE, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0xCF,
  0xFD, 0xFF, 0x78, 0x2F, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0x80, 0xF0, 0x1E, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xCF, 0xF0, 0x18,
  0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0xFE, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0xF3, 0xF8, 0xFC,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3,
  0xEF, 0xFF, 0x7F, 0xB9, 0xF9, 0xC0, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0xC7, 0x07, 0x0F, 0x1E, 0x1E, 0x3C, 0x1C, 0x70, 0x39,
  0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x7C, 0x1E, 0xE0, 0xF8, 0x3D, 0xE1, 0xF0,
  0x73, 0xC3, 0xF1, 0xE7, 0x86, 0xE3, 0xC7, 0x1D, 0xC7, 0x8F, 0x3B, 0x8E,
  0x1E, 0x77, 0x1C, 0x3C, 0xE7, 0x78, 0x7B, 0x8E, 0xF0, 0x77, 0x1D, 0xC0,
  0xEE, 0x3B, 0x81, 0xFC, 0x77, 0x03, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0xF0, 0x78,
  0xF1, 0xE1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xEF, 0x03, 0xDE, 0x0F, 0x1E,
  0x1E, 0x3C, 0x78, 0x3D, 0xF0, 0x7C, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0xC7, 0x87, 0x0F, 0x1E, 0x1E, 0x3C, 0x1C, 0x70, 0x3D,
  0xE0, 0x7B, 0xC0, 0x77, 0x80, 0xEE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x17,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC1, 0xF0, 0xFC,
  0x7E, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x3F, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xFC, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x3E,
  0x0F, 0xC1, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x03, 0xF0, 0x3C, 0x1F, 0x0F, 0x87, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x8F, 0xC3, 0xF0, 0xF8, 0x00, 0x7E,
  0x07, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 24, 8, 2, -24 },
  { 16, 10, 9, 14, 2, -24 },
  { 28, 16, 24, 18, 1, -24 },
  { 76, 14, 27, 16, 1, -25 },
  { 124, 23, 24, 26, 1, -24 },
  { 193, 19, 24, 20, 1, -24 },
  { 250, 4, 9, 8, 2, -24 },
  { 255, 8, 29, 10, 2, -24 },
  { 284, 8, 29, 10, 1, -24 },
  { 313, 13, 13, 15, 1, -25 },
  { 335, 14, 16, 16, 1, -20 },
  { 363, 6, 8, 8, 1, -4 },
  { 369, 8, 4, 10, 1, -11 },
  { 373, 5, 5, 8, 2, -5 },
  { 377, 13, 24, 13, 0, -24 },
  { 416, 14, 24, 16, 1, -24 },
  { 458, 10, 24, 16, 2, -24 },
  { 488, 14, 24, 16, 1, -24 },
  { 530, 14, 24, 16, 1, -24 },
  { 572, 15, 24, 16, 1, -24 },
  { 617, 13, 24, 16, 2, -24 },
  { 656, 14, 24, 16, 1, -24 },
  { 698, 14, 24, 16, 1, -24 },
  { 740, 14, 24, 16, 1, -24 },
  { 782, 14, 24, 16, 1, -24 },
  { 824, 5, 18, 8, 2, -18 },
  { 836, 6, 22, 8, 1, -18 },
  { 853, 14, 16, 16, 1, -20 },
  { 881, 14, 9, 16, 1, -16 },
  { 897, 14, 16, 16, 1, -20 },
  { 925, 12, 24, 13, 0, -24 },
  { 961, 23, 27, 25, 1, -24 },
  { 1039, 18, 24, 18, 0, -24 },
  { 1093, 15, 24, 18, 2, -24 },
  { 1138, 14, 24, 17, 2, -24 },
  { 1180, 16, 24, 20, 2, -24 },
  { 1228, 11, 24, 15, 3, -24 },
  { 1261, 11, 24, 15, 3, -24 },
  { 1294, 16, 24, 20, 2, -24 },
  { 1342, 15, 24, 21, 3, -24 },
  { 1387, 9, 24, 11, 1, -24 },
  { 1414, 8, 31, 9, -2, -24 },
  { 1445, 15, 24, 18, 3, -24 },
  { 1490, 12, 24, 14, 2, -24 },
  { 1526, 21, 24, 27, 3, -24 },
  { 1589, 16, 24, 22, 3, -24 },
  { 1637, 18, 24, 21, 2, -24 },
  { 1691, 14, 24, 17, 2, -24 },
  { 1733, 18, 30, 21, 2, -24 },
  { 1801, 16, 24, 18, 2, -24 },
  { 1849, 13, 24, 15, 1, -24 },
  { 1888, 15, 24, 15, 0, -24 },
  { 1933, 16, 24, 20, 2, -24 },
  { 1981, 17, 24, 17, 0, -24 },
  { 2032, 27, 24, 26, 0, -24 },
  { 2113, 17, 24, 17, 0, -24 },
  { 2164, 16, 24, 16, 0, -24 },
  { 2212, 13, 24, 15, 1, -24 },
  { 2251, 8, 29, 10, 2, -24 },
  { 2280, 13, 24, 13, 0, -24 },
  { 2319, 7, 29, 10, 1, -24 },
  { 2345, 15, 15, 17, 1, -24 },
  { 2374, 14, 2, 14, 0, 3 },
  { 2378, 8, 5, 10, 1, -25 },
  { 2383, 13, 18, 16, 1, -18 },
  { 2413, 14, 25, 17, 2, -25 },
  { 2457, 12, 18, 14, 1, -18 },
  { 2484, 14, 25, 17, 1, -25 },
  { 2528, 14, 18, 16, 1, -18 },
  { 2560, 11, 25, 10, 0, -25 },
  { 2595, 14, 26, 17, 1, -18 },
  { 2641, 13, 25, 17, 2, -25 },
  { 2682, 4, 25, 8, 2, -25 },
  { 2695, 7, 33, 8, -1, -25 },
  { 2724, 14, 25, 16, 2, -25 },
  { 2768, 4, 25, 8, 2, -25 },
  { 2781, 22, 18, 26, 2, -18 },
  { 2831, 13, 18, 17, 2, -18 },
  { 2861, 15, 18, 17, 1, -18 },
  { 2895, 14, 26, 17, 2, -18 },
  { 2941, 14, 26, 17, 1, -18 },
  { 2987, 10, 18, 12, 2, -18 },
  { 3010, 11, 18, 13, 1, -18 },
  { 3035, 9, 22, 11, 1, -22 },
  { 3060, 13, 18, 17, 2, -18 },
  { 3090, 15, 18, 15, 0, -18 },
  { 3124, 23, 18, 23, 0, -18 },
  { 3176, 15, 18, 15, 0, -18 },
  { 3210, 15, 26, 15, 0, -18 },
  { 3259, 11, 18, 13, 1, -18 },
  { 3284, 10, 29, 12, 1, -24 },
  { 3321, 3, 33, 15, 6, -25 },
  { 3334, 10, 29, 12, 1, -24 },
  { 3371, 14, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD33PT7B_H_
