#ifndef _NOTOSANS_CONDENSED_SEMIBOLD49PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x9F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0, 0x80, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xE0, 0x00, 0xF8,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3,
  0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x83,
  0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x07, 0x87, 0x80, 0x0F, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xE7, 0xC7, 0xE6, 0x0C, 0xFC, 0x60, 0x0F, 0xC6,
  0x00, 0xFC, 0x60, 0x0F, 0xC6, 0x00, 0x7E, 0x60, 0x07, 0xF6, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x06, 0x7E, 0x00, 0x63, 0xF0, 0x06, 0x3F,
  0x00, 0x63, 0xF8, 0x06, 0x3F, 0xC0, 0x63, 0xEF, 0x86, 0x7E, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1F,
  0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01,
  0xFF, 0xC0, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x80, 0x3E, 0x3E, 0x03, 0xC0,
  0x0F, 0x07, 0x81, 0xF0, 0x03, 0xC1, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x1E,
  0x00, 0x3C, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xF1,
  0xF0, 0x00, 0xF0, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x3E, 0x04, 0x0F, 0x07,
  0x8F, 0x0F, 0xE3, 0xE3, 0xE3, 0xC7, 0xFC, 0x78, 0xF9, 0xF3, 0xFF, 0x1F,
  0xFC, 0x78, 0xFF, 0xE3, 0xFF, 0x3E, 0x7C, 0x78, 0xFF, 0x8F, 0x1E, 0x1F,
  0x1F, 0xC7, 0xC7, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0xF0, 0x00, 0x78, 0xF8,
  0x3C, 0x00, 0x3E, 0x3E, 0x0F, 0x00, 0x0F, 0x0F, 0x83, 0xC0, 0x07, 0xC3,
  0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x3C, 0x00, 0xF8, 0x1E, 0x1F, 0x00, 0x3C,
  0x07, 0x87, 0xC0, 0x0F, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x7C, 0x78, 0x01,
  0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x7F, 0xC0,
  0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x01, 0xF8, 0xFF, 0xF0, 0x3E, 0x3F, 0xFF, 0x0F, 0xC7,
  0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x3F, 0x3F, 0x07, 0xEF, 0xC7, 0xE0, 0xFF,
  0xF8, 0xF8, 0x0F, 0xFF, 0x1F, 0x00, 0xFF, 0xC3, 0xF0, 0x0F, 0xF8, 0x7E,
  0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xC1, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xE3, 0xF8, 0x3F,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0x78, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x06,
  0x0F, 0x06, 0x7E, 0xF3, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xF0, 0x0F, 0x9F,
  0x01, 0xF8, 0xF8, 0x3F, 0x0F, 0xC0, 0xF0, 0x78, 0x02, 0x06, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x18,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F,
  0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x7F, 0xF3,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xF3, 0xF7, 0x8F, 0xCC, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xC0, 0xFC, 0x30, 0x07, 0xE2, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x7F, 0xC7, 0x80, 0xFE, 0x20, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x80, 0x07, 0xEC, 0x00, 0xFE, 0xFC, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x10, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x80, 0x0F,
  0xEE, 0x01, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xF8, 0xC1, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x10,
  0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF9,
  0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x07, 0xE7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F,
  0xC3, 0xF9, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFB, 0xF8, 0x7F, 0x1F, 0xC7, 0xE0, 0xFE, 0xFC,
  0x07, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xE0, 0xFC, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xF7, 0xF1, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFB,
  0xF0, 0xFF, 0x3E, 0x01, 0x83, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x61,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0,
  0x80, 0x3C, 0x7E, 0x7F, 0x7F, 0x7F, 0x7E, 0x3E, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8C, 0x07, 0xF2, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x1E, 0x1F, 0x00, 0xFE, 0x0F, 0x8F, 0x81, 0xFF, 0xC3, 0xC7,
  0x81, 0xFF, 0xE1, 0xE7, 0xC1, 0xFF, 0xF0, 0xF3, 0xC1, 0xF0, 0xF8, 0x7D,
  0xE0, 0xF0, 0x7C, 0x3E, 0xF0, 0xF8, 0x3E, 0x0F, 0xF8, 0x7C, 0x1F, 0x07,
  0xFC, 0x3C, 0x0F, 0x83, 0xFE, 0x1E, 0x07, 0xC1, 0xFF, 0x0F, 0x03, 0xE0,
  0xFF, 0x87, 0x81, 0xF0, 0xFF, 0xC3, 0xC0, 0xF8, 0x7F, 0xE1, 0xE0, 0x78,
  0x3D, 0xF0, 0xF8, 0x7E, 0x1E, 0xF8, 0x7C, 0x3F, 0x1F, 0x3C, 0x1F, 0x3F,
  0x9F, 0x1E, 0x0F, 0xFD, 0xFF, 0x8F, 0x83, 0xFC, 0x7F, 0x87, 0xC0, 0xFC,
  0x3F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x01, 0xFC,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x1F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xF8, 0x1F, 0xEF, 0xC0,
  0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x03,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x80, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x60, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x83, 0xFE, 0x3F, 0x01, 0xFE, 0x7E,
  0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF,
  0xC0, 0x7F, 0x1F, 0x83, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x70, 0x7F,
  0x00, 0x08, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xDF, 0x80, 0xFF, 0xEF, 0xC0, 0x7F, 0xF7, 0xE0, 0x3F, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFF,
  0x00, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xD1,
  0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81,
  0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xF7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFB,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0xFB, 0xE0,
  0x0F, 0xBF, 0xFB, 0xE0, 0x0F, 0xBF, 0xF9, 0xF0, 0x0F, 0xBF, 0xF9, 0xF0,
  0x0F, 0x3F, 0xF9, 0xF0, 0x1F, 0x3F, 0xF9, 0xF0, 0x1F, 0x3F, 0xF8, 0xF8,
  0x1E, 0x3F, 0xF8, 0xF8, 0x3E, 0x3F, 0xF8, 0xF8, 0x3E, 0x3F, 0xF8, 0x7C,
  0x3E, 0x3F, 0xF8, 0x7C, 0x7C, 0x3F, 0xF8, 0x7C, 0x7C, 0x3F, 0xF8, 0x7C,
  0x7C, 0x3F, 0xF8, 0x3E, 0x78, 0x3F, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07,
  0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFD, 0xF0, 0x0F, 0xFE, 0xFC, 0x07,
  0xFF, 0x7E, 0x03, 0xFF, 0x9F, 0x81, 0xFF, 0xCF, 0xC0, 0xFF, 0xE3, 0xF0,
  0x7F, 0xF1, 0xF8, 0x3F, 0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x0F, 0xFE, 0x0F,
  0xC7, 0xFF, 0x07, 0xE3, 0xFF, 0x81, 0xF9, 0xFF, 0xC0, 0xFC, 0xFF, 0xE0,
  0x3F, 0x7F, 0xF0, 0x1F, 0xBF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF7, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xF8,
  0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0x8F, 0xC0, 0xFE, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x07, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFE, 0x07, 0x3F, 0x80, 0x27, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xEC, 0x00,
  0xFD, 0xE0, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xE7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F,
  0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0xC0, 0x3F, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x3E, 0x01,
  0xFF, 0x00, 0xFC, 0x7E, 0x03, 0xDE, 0x01, 0xF0, 0xFC, 0x07, 0xBE, 0x07,
  0xE1, 0xF8, 0x1F, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0xF8, 0x1F, 0x83, 0xE0,
  0x7D, 0xF0, 0x3E, 0x07, 0xE0, 0xF9, 0xE0, 0xFC, 0x0F, 0xC3, 0xE3, 0xE1,
  0xF8, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x1F, 0x0F, 0x8F, 0x87, 0xE0, 0x3E,
  0x1F, 0x1F, 0x0F, 0x80, 0x7E, 0x3E, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x3E,
  0x7E, 0x00, 0xF9, 0xF0, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0xF9, 0xF8, 0x03,
  0xE7, 0xC0, 0xF3, 0xE0, 0x07, 0xEF, 0x01, 0xE7, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE0,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xFC, 0x03, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF3, 0xFC, 0x30, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xF9, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xFF, 0xDF, 0x7F, 0xFB, 0xE7, 0xFE, 0x7C, 0x7F, 0x87, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x1F, 0x81, 0xF9, 0xFF, 0x0F, 0xDF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xE0, 0xFE, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0x7F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0xE0, 0xFE,
  0xFF, 0x8F, 0xE7, 0xFF, 0xFF, 0x3E, 0xFF, 0xF1, 0xF3, 0xFF, 0x0F, 0x8F,
  0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFC, 0x19, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x04, 0xFF, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0xF8, 0x7E, 0x1F, 0xF3, 0xF1, 0xFF, 0xDF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xE0, 0xFF,
  0x3F, 0x9F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xF9, 0xF0, 0x7F,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0xDF, 0xC3, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x02, 0x3F, 0xC1, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xE6, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x03, 0xF0, 0xF8, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0x83, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7E, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x83, 0xFC, 0xFE, 0x7F,
  0xE7, 0xFF, 0xFF, 0x1F, 0xFD, 0xF8, 0x7F, 0xCF, 0xC1, 0xFC, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x40, 0x07, 0xF3, 0xE0, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x0F, 0xCF,
  0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x7E, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xF0, 0x7B, 0xFF, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xFF, 0xFD, 0xFF, 0xBF,
  0xE7, 0xF8, 0x3C, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x07, 0xEF,
  0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x3F,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0x9F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0x3F, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7E,
  0x03, 0xF8, 0x7C, 0xFF, 0xC3, 0xFE, 0x3E, 0xFF, 0xF3, 0xFF, 0x9F, 0x7F,
  0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xC1, 0xFB, 0xF8,
  0x1F, 0xE0, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x1F, 0xFE,
  0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0x03, 0xFF,
  0xC0, 0x3E, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x7F,
  0xF8, 0x07, 0xC0, 0x3F, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F,
  0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0x01,
  0xFF, 0xE0, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x7F, 0xF8, 0x07, 0xC0,
  0x3F, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xFF, 0x00, 0xF8,
  0x07, 0xE0, 0xF8, 0x7F, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF, 0xCF, 0xBF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xF0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E,
  0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0xFE, 0x3F, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0xF8, 0x7E, 0x07,
  0xC7, 0xFC, 0x3E, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x83,
  0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7D, 0xFC,
  0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x83, 0xFB, 0xFF, 0x7F, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC7, 0xEF, 0xFC, 0x3F, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x83, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF,
  0x83, 0xFC, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFD, 0xF8, 0x7F, 0xEF,
  0xC1, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xF8,
  0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x1F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0x3E, 0xFC, 0x04, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF3, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0x7F, 0xBF, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFD, 0xF3, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00,
  0xFC, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7E,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xDF, 0x00, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x80,
  0xFD, 0xF8, 0x1F, 0xE0, 0x3E, 0x7E, 0x07, 0xF8, 0x0F, 0x8F, 0x81, 0xFF,
  0x07, 0xE3, 0xE0, 0x7F, 0xC1, 0xF8, 0xFC, 0x1E, 0xF0, 0x7C, 0x3F, 0x0F,
  0xBC, 0x1F, 0x07, 0xC3, 0xCF, 0x07, 0xC1, 0xF0, 0xF3, 0xE3, 0xF0, 0x7E,
  0x3C, 0x78, 0xF8, 0x1F, 0x9F, 0x1E, 0x3E, 0x07, 0xE7, 0xC7, 0x8F, 0x80,
  0xF9, 0xE1, 0xE7, 0xE0, 0x3E, 0x78, 0x7D, 0xF8, 0x0F, 0x9E, 0x1F, 0x7C,
  0x03, 0xF7, 0x83, 0xDF, 0x00, 0x7F, 0xE0, 0xF7, 0xC0, 0x1F, 0xF0, 0x3D,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xC0, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x01, 0xF8,
  0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xFE, 0x0F, 0xF0, 0x1F,
  0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x81, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x17, 0xFE,
  0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x1F, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 36, 13, 3, -35 },
  { 33, 15, 13, 21, 3, -35 },
  { 58, 24, 35, 26, 1, -35 },
  { 163, 20, 40, 24, 2, -37 },
  { 263, 34, 35, 38, 2, -35 },
  { 412, 27, 35, 29, 2, -35 },
  { 531, 6, 13, 11, 3, -35 },
  { 541, 12, 43, 15, 2, -35 },
  { 606, 12, 43, 15, 1, -35 },
  { 671, 20, 19, 23, 1, -37 },
  { 719, 20, 23, 24, 2, -29 },
  { 777, 8, 12, 12, 2, -6 },
  { 789, 12, 5, 15, 1, -16 },
  { 797, 7, 8, 12, 3, -7 },
  { 804, 18, 35, 19, 1, -35 },
  { 883, 20, 36, 24, 2, -36 },
  { 973, 14, 35, 24, 3, -35 },
  { 1035, 20, 35, 24, 2, -35 },
  { 1123, 20, 35, 24, 2, -35 },
  { 1211, 22, 35, 24, 1, -35 },
  { 1308, 20, 35, 24, 2, -35 },
  { 1396, 20, 35, 24, 2, -35 },
  { 1484, 21, 35, 24, 1, -35 },
  { 1576, 20, 35, 24, 2, -35 },
  { 1664, 20, 35, 24, 2, -35 },
  { 1752, 7, 28, 13, 3, -27 },
  { 1777, 8, 33, 13, 2, -27 },
  { 1810, 20, 23, 24, 2, -29 },
  { 1868, 20, 14, 24, 2, -24 },
  { 1903, 20, 23, 24, 2, -29 },
  { 1961, 18, 36, 19, 0, -35 },
  { 2042, 33, 39, 37, 2, -35 },
  { 2203, 27, 35, 27, 0, -35 },
  { 2322, 21, 35, 27, 4, -35 },
  { 2414, 22, 35, 25, 2, -35 },
  { 2511, 23, 35, 29, 4, -35 },
  { 2612, 16, 35, 23, 4, -35 },
  { 2682, 16, 35, 22, 4, -35 },
  { 2752, 25, 35, 30, 2, -35 },
  { 2862, 23, 35, 31, 4, -35 },
  { 2963, 13, 35, 16, 1, -35 },
  { 3020, 13, 45, 13, -3, -35 },
  { 3094, 23, 35, 26, 4, -35 },
  { 3195, 17, 35, 22, 4, -35 },
  { 3270, 32, 35, 39, 4, -35 },
  { 3410, 25, 35, 32, 4, -35 },
  { 3520, 27, 36, 31, 2, -36 },
  { 3642, 20, 35, 25, 4, -35 },
  { 3730, 27, 44, 31, 2, -36 },
  { 3879, 22, 35, 26, 4, -35 },
  { 3976, 19, 35, 22, 2, -35 },
  { 4060, 21, 35, 22, 1, -35 },
  { 4152, 22, 35, 30, 4, -35 },
  { 4249, 26, 35, 26, 0, -35 },
  { 4363, 39, 35, 39, 0, -35 },
  { 4534, 25, 35, 25, 0, -35 },
  { 4644, 24, 35, 24, 0, -35 },
  { 4749, 20, 35, 22, 1, -35 },
  { 4837, 11, 43, 16, 3, -35 },
  { 4897, 18, 35, 19, 1, -35 },
  { 4976, 11, 43, 16, 1, -35 },
  { 5036, 23, 21, 25, 1, -35 },
  { 5097, 21, 4, 21, 0, 4 },
  { 5108, 11, 8, 15, 2, -38 },
  { 5119, 19, 27, 24, 2, -27 },
  { 5184, 21, 37, 26, 3, -37 },
  { 5282, 17, 27, 20, 2, -27 },
  { 5340, 21, 37, 26, 2, -37 },
  { 5438, 20, 27, 24, 2, -27 },
  { 5506, 16, 37, 15, 1, -37 },
  { 5580, 21, 39, 26, 2, -27 },
  { 5683, 20, 37, 26, 3, -37 },
  { 5776, 6, 37, 12, 3, -37 },
  { 5804, 11, 49, 12, -2, -37 },
  { 5872, 21, 37, 24, 3, -37 },
  { 5970, 6, 37, 12, 3, -37 },
  { 5998, 33, 27, 39, 3, -27 },
  { 6110, 20, 27, 26, 3, -27 },
  { 6178, 21, 27, 25, 2, -27 },
  { 6249, 21, 39, 26, 3, -27 },
  { 6352, 21, 39, 26, 2, -27 },
  { 6455, 14, 27, 18, 3, -27 },
  { 6503, 16, 27, 20, 2, -27 },
  { 6557, 14, 32, 16, 1, -32 },
  { 6613, 20, 27, 26, 3, -27 },
  { 6681, 22, 27, 22, 0, -27 },
  { 6756, 34, 27, 35, 0, -27 },
  { 6871, 22, 27, 22, 0, -27 },
  { 6946, 22, 39, 22, 0, -27 },
  { 7054, 17, 27, 19, 1, -27 },
  { 7112, 15, 43, 18, 1, -35 },
  { 7193, 5, 48, 23, 9, -37 },
  { 7223, 15, 43, 18, 2, -35 },
  { 7304, 20, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_SemiBold49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD49PT7B_H_
