#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_SemiBold
// Headers: 67

#include "NotoSans_Condensed_SemiBold6pt7b.h"
#include "NotoSans_Condensed_SemiBold7pt7b.h"
#include "NotoSans_Condensed_SemiBold8pt7b.h"
#include "NotoSans_Condensed_SemiBold9pt7b.h"
#include "NotoSans_Condensed_SemiBold10pt7b.h"
#include "NotoSans_Condensed_SemiBold11pt7b.h"
#include "NotoSans_Condensed_SemiBold12pt7b.h"
#include "NotoSans_Condensed_SemiBold13pt7b.h"
#include "NotoSans_Condensed_SemiBold14pt7b.h"
#include "NotoSans_Condensed_SemiBold15pt7b.h"
#include "NotoSans_Condensed_SemiBold16pt7b.h"
#include "NotoSans_Condensed_SemiBold17pt7b.h"
#include "NotoSans_Condensed_SemiBold18pt7b.h"
#include "NotoSans_Condensed_SemiBold19pt7b.h"
#include "NotoSans_Condensed_SemiBold20pt7b.h"
#include "NotoSans_Condensed_SemiBold21pt7b.h"
#include "NotoSans_Condensed_SemiBold22pt7b.h"
#include "NotoSans_Condensed_SemiBold23pt7b.h"
#include "NotoSans_Condensed_SemiBold24pt7b.h"
#include "NotoSans_Condensed_SemiBold25pt7b.h"
#include "NotoSans_Condensed_SemiBold26pt7b.h"
#include "NotoSans_Condensed_SemiBold27pt7b.h"
#include "NotoSans_Condensed_SemiBold28pt7b.h"
#include "NotoSans_Condensed_SemiBold29pt7b.h"
#include "NotoSans_Condensed_SemiBold30pt7b.h"
#include "NotoSans_Condensed_SemiBold31pt7b.h"
#include "NotoSans_Condensed_SemiBold32pt7b.h"
#include "NotoSans_Condensed_SemiBold33pt7b.h"
#include "NotoSans_Condensed_SemiBold34pt7b.h"
#include "NotoSans_Condensed_SemiBold35pt7b.h"
#include "NotoSans_Condensed_SemiBold36pt7b.h"
#include "NotoSans_Condensed_SemiBold37pt7b.h"
#include "NotoSans_Condensed_SemiBold38pt7b.h"
#include "NotoSans_Condensed_SemiBold39pt7b.h"
#include "NotoSans_Condensed_SemiBold40pt7b.h"
#include "NotoSans_Condensed_SemiBold41pt7b.h"
#include "NotoSans_Condensed_SemiBold42pt7b.h"
#include "NotoSans_Condensed_SemiBold43pt7b.h"
#include "NotoSans_Condensed_SemiBold44pt7b.h"
#include "NotoSans_Condensed_SemiBold45pt7b.h"
#include "NotoSans_Condensed_SemiBold46pt7b.h"
#include "NotoSans_Condensed_SemiBold47pt7b.h"
#include "NotoSans_Condensed_SemiBold48pt7b.h"
#include "NotoSans_Condensed_SemiBold49pt7b.h"
#include "NotoSans_Condensed_SemiBold50pt7b.h"
#include "NotoSans_Condensed_SemiBold51pt7b.h"
#include "NotoSans_Condensed_SemiBold52pt7b.h"
#include "NotoSans_Condensed_SemiBold53pt7b.h"
#include "NotoSans_Condensed_SemiBold54pt7b.h"
#include "NotoSans_Condensed_SemiBold55pt7b.h"
#include "NotoSans_Condensed_SemiBold56pt7b.h"
#include "NotoSans_Condensed_SemiBold57pt7b.h"
#include "NotoSans_Condensed_SemiBold58pt7b.h"
#include "NotoSans_Condensed_SemiBold59pt7b.h"
#include "NotoSans_Condensed_SemiBold60pt7b.h"
#include "NotoSans_Condensed_SemiBold61pt7b.h"
#include "NotoSans_Condensed_SemiBold62pt7b.h"
#include "NotoSans_Condensed_SemiBold63pt7b.h"
#include "NotoSans_Condensed_SemiBold64pt7b.h"
#include "NotoSans_Condensed_SemiBold65pt7b.h"
#include "NotoSans_Condensed_SemiBold66pt7b.h"
#include "NotoSans_Condensed_SemiBold67pt7b.h"
#include "NotoSans_Condensed_SemiBold68pt7b.h"
#include "NotoSans_Condensed_SemiBold69pt7b.h"
#include "NotoSans_Condensed_SemiBold70pt7b.h"
#include "NotoSans_Condensed_SemiBold71pt7b.h"
#include "NotoSans_Condensed_SemiBold72pt7b.h"
