#ifndef _NOTOSANS_CONDENSED_SEMIBOLD35PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0x07, 0x7F, 0xFF, 0xF0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0x71, 0xE0, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8E,
  0x01, 0xC7, 0x00, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xF0, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF,
  0x3C, 0xC4, 0xE3, 0x03, 0x8C, 0x0F, 0x30, 0x3E, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0D, 0xE0, 0x33, 0xC0, 0xCF, 0x83,
  0x3B, 0x0D, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x3F, 0x00, 0xE0, 0x1F, 0xC0, 0x70, 0x1F, 0xE0, 0x70,
  0x0E, 0x78, 0x38, 0x0F, 0x1C, 0x3C, 0x07, 0x8E, 0x1C, 0x03, 0x87, 0x1E,
  0x01, 0xC3, 0x8E, 0x00, 0xE1, 0xC7, 0x00, 0x78, 0xE7, 0x00, 0x3C, 0x73,
  0x9F, 0x0E, 0x7B, 0xDF, 0xC7, 0xF9, 0xCF, 0xF1, 0xFD, 0xEF, 0x38, 0x7C,
  0xE7, 0x1E, 0x00, 0x73, 0x87, 0x00, 0x71, 0xC3, 0x80, 0x38, 0xE1, 0xC0,
  0x3C, 0x70, 0xE0, 0x1C, 0x38, 0xF0, 0x1E, 0x1C, 0x78, 0x0E, 0x07, 0x38,
  0x07, 0x03, 0xFC, 0x07, 0x01, 0xFC, 0x03, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC3,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC1, 0xE3, 0xFE, 0x3E, 0x7D, 0xE3, 0xC7,
  0x8F, 0x3C, 0xF8, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x3F, 0x8F, 0x81, 0xF0,
  0xF8, 0x1F, 0x07, 0xCF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xBE, 0x1F, 0xE3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x0F, 0x0E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E,
  0x07, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0xF0, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x43, 0x8F, 0xED, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x3F, 0x01, 0xFE, 0x0F, 0x3C, 0x7C, 0xF8, 0x61, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3D, 0xF7, 0x9E, 0x79, 0xE7, 0x3C, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE7, 0xC7, 0xC7, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0xC7, 0xC7, 0xDF, 0x0F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0,
  0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xBD, 0xCF, 0x23, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xE3,
  0xFF, 0xE3, 0xC7, 0xC3, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xE3, 0xC7, 0xE2, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE8, 0x07, 0xDC, 0x1F,
  0xBF, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xDE, 0x03, 0xBC, 0x0E, 0x78, 0x3C,
  0xF0, 0x71, 0xE1, 0xE3, 0xC3, 0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x78, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xF9, 0xFF,
  0xEF, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x0F, 0xF0, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0x80, 0x03, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0xF8, 0x23, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE7, 0xC3, 0xDF, 0xE7, 0xFF, 0xCF, 0xEF, 0xDF, 0x07,
  0xBE, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE7,
  0xC3, 0xC7, 0xCF, 0x8F, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x7F, 0xF0,
  0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x7C,
  0x7C, 0x7D, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xFE, 0x1F, 0x3E,
  0x3C, 0x3E, 0xF8, 0x3D, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xEF,
  0x07, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0, 0x7F, 0xE0, 0xFF,
  0xE3, 0xE7, 0xC7, 0x87, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFB, 0xC1, 0xF7, 0xCF, 0xEF, 0xFB, 0x8F, 0xF7, 0x0F,
  0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x88, 0x3E,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xDF, 0xFF, 0xFC, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3D, 0xE7, 0x9E, 0x79, 0xCF, 0x38,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x3F,
  0xC7, 0xFF, 0x1F, 0xFC, 0xF3, 0xE4, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x9F,
  0x80, 0xF8, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1E, 0x06, 0x07,
  0x38, 0x7F, 0xCE, 0x71, 0xFF, 0x9D, 0xC3, 0x8E, 0x1F, 0x8F, 0x1C, 0x3F,
  0x1C, 0x38, 0x7E, 0x38, 0x70, 0xFC, 0x70, 0xE1, 0xF8, 0xE1, 0xC3, 0xF1,
  0xC3, 0x87, 0xE3, 0x87, 0x1D, 0xC7, 0x1E, 0x3B, 0x8F, 0xFF, 0xF7, 0x0F,
  0xCF, 0xCF, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x01, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B,
  0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0x9E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x1E, 0x1E, 0x03,
  0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x9F, 0xEF, 0x07, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xFF, 0xE7, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x3C, 0x1F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xC0,
  0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xF8, 0xE7, 0xE0, 0x4F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x27, 0xF3, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xF1, 0xE3, 0xE0, 0x13, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xDE, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x79, 0xFC, 0x7C, 0x7F, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF3, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xEF, 0xF7, 0xFB, 0xF9, 0xF8,
  0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0,
  0xF1, 0xF0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF1, 0xF0,
  0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xB8, 0x07, 0x7E, 0xE0, 0x1D, 0xFB,
  0xC0, 0xF7, 0xEF, 0x03, 0xDF, 0xDC, 0x0E, 0x7F, 0x78, 0x3B, 0xFD, 0xE1,
  0xEF, 0xF3, 0x87, 0x3F, 0xCE, 0x1C, 0xFF, 0x3C, 0xF3, 0xFC, 0xF3, 0x8F,
  0xF1, 0xCE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0x0F, 0xF0,
  0xFC, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78,
  0x3C, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFE, 0xF0, 0x3F, 0xBC, 0x0F, 0xE7, 0x83, 0xFD, 0xE0, 0xFF,
  0x3C, 0x3F, 0xCF, 0x0F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1F, 0x3F, 0xC3,
  0xCF, 0xF0, 0xFB, 0xFC, 0x1E, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8,
  0x7E, 0x7F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE,
  0x3F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDF, 0x00,
  0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0x7E, 0x7F, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF3, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xF3, 0xE0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1F, 0x0F, 0xF0,
  0xFF, 0xF3, 0xFF, 0x9F, 0xBE, 0x78, 0x09, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xC0, 0x7B, 0xF7,
  0xEF, 0xFF, 0x3F, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1E, 0xFE, 0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xF0, 0x03,
  0xFE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x78, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x07, 0x3C,
  0x01, 0xEF, 0x00, 0x7B, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x0F, 0xF8, 0x0F, 0x01, 0xF7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81,
  0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE3, 0xC3, 0xFC, 0x3E, 0x3C,
  0x3F, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9C,
  0x3C, 0x1E, 0x79, 0xE7, 0x81, 0xE7, 0x9E, 0x78, 0x1E, 0x70, 0xE7, 0x81,
  0xE7, 0x0E, 0x78, 0x1E, 0xF0, 0xE7, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x78,
  0x0F, 0x9F, 0x03, 0xC3, 0xC1, 0xF0, 0xF8, 0x78, 0x1E, 0x1E, 0x07, 0x8F,
  0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0x78, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x1E, 0x0F, 0x07,
  0xC7, 0xC0, 0xF1, 0xE0, 0x3E, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xBC, 0x07,
  0xDE, 0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x0F, 0x7C, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0xFF, 0xFF,
  0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C,
  0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x1F, 0xE0, 0xFF,
  0xE3, 0xFF, 0x84, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0x1F,
  0xFC, 0xFF, 0xF7, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFE,
  0x3F, 0x7F, 0xFD, 0xFE, 0xF3, 0xF1, 0xC0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xF1,
  0xEF, 0xF3, 0xFF, 0xF7, 0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x07,
  0xFE, 0x0F, 0x7E, 0x3E, 0xFF, 0xFD, 0xEF, 0xF3, 0xCF, 0xC0, 0x07, 0xF0,
  0xFF, 0xCF, 0xFC, 0x7C, 0x67, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC2,
  0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x9E, 0x3F, 0xFC,
  0xFF, 0xFB, 0xE3, 0xF7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDF, 0x0F,
  0xBE, 0x3F, 0x3F, 0xFE, 0x3F, 0xDC, 0x3F, 0x38, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE1, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x07, 0xBC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x06, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xE0, 0xFF, 0x0F,
  0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xEF, 0xFE, 0xFF,
  0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x0F, 0xCE, 0x3F, 0xDC, 0xFF, 0xFB, 0xE3, 0xF7, 0xC3, 0xEF, 0x03,
  0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7,
  0x81, 0xEF, 0x03, 0xDE, 0x0F, 0xBE, 0x3F, 0x3F, 0xFE, 0x3F, 0xBC, 0x3E,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xB8, 0x3E, 0x7F, 0xFC,
  0xFF, 0xF0, 0xFF, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xFF,
  0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xC0, 0xF7, 0xFF, 0xE0, 0x00, 0x1E, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x1E, 0x1F, 0x1F,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F,
  0xE0, 0xFB, 0xC1, 0xE7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C, 0xF0, 0x7B,
  0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xCF, 0x0F, 0x1F, 0x1E, 0x1E,
  0x3C, 0x3E, 0x78, 0x3C, 0xF0, 0x7D, 0xE0, 0x7B, 0xC0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF3, 0xF1, 0xF8, 0xF7, 0xFB, 0xFC, 0xFF, 0xFB, 0xFE, 0xFC, 0xFF, 0x3E,
  0xF8, 0x7E, 0x1E, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF3, 0xF3, 0xDF,
  0xEF, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3C, 0x3C, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C,
  0x3E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF3, 0xF1, 0xEF,
  0xF3, 0xFF, 0xF7, 0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFE,
  0x0F, 0x7E, 0x3E, 0xFF, 0xFD, 0xEF, 0xF3, 0xCF, 0xC7, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x0F, 0x8E, 0x3F, 0xDC, 0xFF, 0xFB, 0xE3, 0xF7, 0xC3, 0xEF, 0x03, 0xDE,
  0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81,
  0xEF, 0x03, 0xDE, 0x0F, 0xBE, 0x3F, 0x3F, 0xFE, 0x3F, 0xBC, 0x3E, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0xF3, 0xFD, 0xFF, 0x7F, 0xFF, 0xFC, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x00, 0x1F, 0xE7, 0xFF, 0x7F, 0xEF, 0x86, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFE, 0x1F, 0xFF, 0xEF, 0xFE, 0x7F, 0x80, 0x1C, 0x07, 0x03, 0xC0,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF1, 0x3F, 0xCF, 0xF1,
  0xFC, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x87, 0xDF, 0x3F, 0x7F, 0xFD, 0xFF, 0x71, 0xF9, 0xC0, 0xF0,
  0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0xF0, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x7E,
  0x0F, 0x78, 0x7F, 0x1E, 0x3C, 0x77, 0x1E, 0x3C, 0x77, 0x1E, 0x3C, 0xF7,
  0x1E, 0x3C, 0xE7, 0x3C, 0x1C, 0xE3, 0xBC, 0x1E, 0xE3, 0xBC, 0x1E, 0xE3,
  0xBC, 0x1E, 0xE3, 0xB8, 0x1F, 0xC3, 0xB8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x78, 0x1E,
  0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1E, 0xF8, 0x1E, 0x78, 0x3C, 0x7C, 0x3C, 0x3C, 0x78, 0x3E, 0xF8, 0x1F,
  0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x1F, 0x8F, 0xC3, 0xE0, 0xFC, 0x0F, 0x81, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF0, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0xF8,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x0F, 0xE1, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x7F, 0x0F, 0xC1,
  0xF8, 0x20, 0x00, 0x3E, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F,
  0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 11, 9, 15, 2, -25 },
  { 30, 17, 25, 19, 1, -25 },
  { 84, 14, 29, 17, 2, -27 },
  { 135, 25, 25, 27, 1, -25 },
  { 214, 20, 25, 21, 1, -25 },
  { 277, 4, 9, 8, 2, -25 },
  { 282, 8, 31, 11, 2, -25 },
  { 313, 8, 31, 11, 1, -25 },
  { 344, 14, 14, 16, 1, -27 },
  { 369, 15, 17, 17, 1, -21 },
  { 401, 6, 9, 9, 1, -4 },
  { 408, 9, 3, 11, 1, -11 },
  { 412, 5, 5, 9, 2, -5 },
  { 416, 13, 25, 14, 0, -25 },
  { 457, 15, 25, 17, 1, -25 },
  { 504, 10, 25, 17, 2, -25 },
  { 536, 15, 25, 17, 1, -25 },
  { 583, 15, 25, 17, 1, -25 },
  { 630, 15, 25, 17, 1, -25 },
  { 677, 13, 25, 17, 2, -25 },
  { 718, 15, 25, 17, 1, -25 },
  { 765, 15, 25, 17, 1, -25 },
  { 812, 15, 25, 17, 1, -25 },
  { 859, 15, 25, 17, 1, -25 },
  { 906, 5, 19, 9, 2, -19 },
  { 918, 6, 24, 9, 1, -19 },
  { 936, 15, 17, 17, 1, -21 },
  { 968, 15, 10, 17, 1, -17 },
  { 987, 15, 17, 17, 1, -21 },
  { 1019, 13, 25, 13, 0, -25 },
  { 1060, 23, 28, 26, 2, -25 },
  { 1141, 19, 25, 19, 0, -25 },
  { 1201, 15, 25, 19, 3, -25 },
  { 1248, 15, 25, 18, 2, -25 },
  { 1295, 16, 25, 21, 3, -25 },
  { 1345, 11, 25, 16, 3, -25 },
  { 1380, 11, 25, 16, 3, -25 },
  { 1415, 17, 25, 21, 2, -25 },
  { 1469, 16, 25, 22, 3, -25 },
  { 1519, 9, 25, 11, 1, -25 },
  { 1548, 9, 32, 9, -2, -25 },
  { 1584, 16, 25, 19, 3, -25 },
  { 1634, 12, 25, 15, 3, -25 },
  { 1672, 22, 25, 28, 3, -25 },
  { 1741, 18, 25, 23, 3, -25 },
  { 1798, 19, 25, 22, 2, -25 },
  { 1858, 14, 25, 18, 3, -25 },
  { 1902, 19, 31, 22, 2, -25 },
  { 1976, 16, 25, 19, 3, -25 },
  { 2026, 14, 25, 16, 1, -25 },
  { 2070, 16, 25, 16, 0, -25 },
  { 2120, 16, 25, 21, 3, -25 },
  { 2170, 18, 25, 18, 0, -25 },
  { 2227, 28, 25, 28, 0, -25 },
  { 2315, 18, 25, 18, 0, -25 },
  { 2372, 17, 25, 17, 0, -25 },
  { 2426, 14, 25, 16, 1, -25 },
  { 2470, 8, 31, 11, 2, -25 },
  { 2501, 13, 25, 14, 0, -25 },
  { 2542, 8, 31, 11, 1, -25 },
  { 2573, 16, 15, 18, 1, -25 },
  { 2603, 15, 2, 15, 0, 3 },
  { 2607, 8, 6, 11, 1, -27 },
  { 2613, 14, 19, 17, 1, -19 },
  { 2647, 15, 27, 18, 2, -27 },
  { 2698, 13, 19, 15, 1, -19 },
  { 2729, 15, 27, 18, 1, -27 },
  { 2780, 15, 19, 17, 1, -19 },
  { 2816, 12, 27, 11, 0, -27 },
  { 2857, 15, 27, 18, 1, -19 },
  { 2908, 14, 27, 19, 2, -27 },
  { 2956, 5, 26, 9, 2, -26 },
  { 2973, 8, 34, 9, -1, -26 },
  { 3007, 15, 27, 17, 2, -27 },
  { 3058, 4, 27, 9, 2, -27 },
  { 3072, 24, 19, 28, 2, -19 },
  { 3129, 14, 19, 19, 2, -19 },
  { 3163, 16, 19, 18, 1, -19 },
  { 3201, 15, 27, 18, 2, -19 },
  { 3252, 15, 27, 18, 1, -19 },
  { 3303, 10, 19, 13, 2, -19 },
  { 3327, 12, 19, 14, 1, -19 },
  { 3356, 10, 23, 12, 1, -23 },
  { 3385, 14, 19, 19, 2, -19 },
  { 3419, 16, 19, 16, 0, -19 },
  { 3457, 24, 19, 25, 0, -19 },
  { 3514, 16, 19, 16, 0, -19 },
  { 3552, 16, 27, 16, 0, -19 },
  { 3606, 12, 19, 13, 1, -19 },
  { 3635, 10, 31, 13, 1, -25 },
  { 3674, 4, 35, 16, 6, -27 },
  { 3692, 11, 31, 13, 1, -25 },
  { 3735, 15, 5, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD35PT7B_H_
