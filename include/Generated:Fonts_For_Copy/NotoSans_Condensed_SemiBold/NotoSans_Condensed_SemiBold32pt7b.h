#ifndef _NOTOSANS_CONDENSED_SEMIBOLD32PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x00, 0x2F, 0xFF,
  0xF0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x86, 0x07,
  0x18, 0x07, 0x18, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E,
  0x30, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x60, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0xE0, 0x18, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x03, 0x00, 0x18,
  0x01, 0xF0, 0x7F, 0xF7, 0xFF, 0xBF, 0xB9, 0xCC, 0x1E, 0x60, 0x73, 0x03,
  0xD8, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x6F, 0x03,
  0x38, 0x19, 0xF0, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x3E, 0x01, 0xC0, 0xFE, 0x07, 0x01, 0xDC, 0x0E,
  0x07, 0x1C, 0x38, 0x0E, 0x38, 0x70, 0x1C, 0x71, 0xC0, 0x38, 0xE3, 0x80,
  0x71, 0xC7, 0x00, 0xE3, 0x9C, 0x01, 0xC7, 0x39, 0xE1, 0x8E, 0xE7, 0xE3,
  0xB9, 0xDF, 0xE7, 0xF7, 0x39, 0xC7, 0xCE, 0x73, 0x80, 0x1C, 0xE3, 0x80,
  0x71, 0xC7, 0x00, 0xE3, 0x8E, 0x03, 0x87, 0x1C, 0x07, 0x0E, 0x70, 0x0C,
  0x1C, 0xE0, 0x38, 0x3D, 0xC0, 0x70, 0x3F, 0x01, 0xC0, 0x3E, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xF3, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x8F, 0x00, 0xF3, 0xC0, 0x1D, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0xFE, 0x1E, 0x7F, 0xC7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF3, 0xC3, 0xFC, 0xF0,
  0xFF, 0x3C, 0x1F, 0x8F, 0x03, 0xC3, 0xE1, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFC, 0x7C, 0xFF, 0xFF, 0xEE, 0xEE, 0x07, 0x0E, 0x1E, 0x1C, 0x3C,
  0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x78, 0x78, 0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38,
  0x78, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x8E, 0x2F, 0xFF, 0xFF,
  0xFD, 0xFF, 0x81, 0xF0, 0x1D, 0xC1, 0xEF, 0x1E, 0x3C, 0x31, 0x80, 0x88,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0xFF, 0xFF, 0xFF, 0x2F, 0xFF,
  0xF0, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0xF9, 0xE7, 0x87, 0x3C, 0x3D, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0x70, 0x7B, 0x83, 0xDE, 0x1C, 0xF1, 0xE3, 0xFF, 0x0F, 0xF0,
  0x3F, 0x00, 0x03, 0x83, 0xC3, 0xE7, 0xF7, 0xFF, 0xFF, 0xDE, 0xCF, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0xC3, 0xFF, 0x3F, 0xFC, 0xF1, 0xE2, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC3, 0xFF, 0x3F, 0xFC, 0xE1,
  0xE4, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x81, 0xFF, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x81, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x03, 0xBC, 0x1C, 0xF0,
  0x73, 0xC3, 0x8F, 0x0E, 0x3C, 0x70, 0xF1, 0xC3, 0xCE, 0x0F, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00,
  0x03, 0xF0, 0x7F, 0x87, 0xFC, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x71, 0xC7, 0xBF, 0x3F, 0xFD, 0xFB, 0xFF, 0x87, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3B, 0x83, 0xDE, 0x1E, 0xF9, 0xF3, 0xFF, 0x0F, 0xF0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xF7, 0x07,
  0xB8, 0x3D, 0xC1, 0xEF, 0x0F, 0x3C, 0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x83,
  0xFE, 0x3E, 0x79, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0xF7, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1,
  0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E,
  0xF1, 0xF7, 0xFB, 0x9F, 0xDC, 0x79, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x03, 0xC7, 0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0x2F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x02, 0xFF, 0xFF, 0x33, 0xDE, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0x7B, 0xDC, 0xEF, 0x70, 0x00, 0x0C, 0x00, 0xF0, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x03,
  0xC0, 0x0C, 0x00, 0x00, 0x3F, 0x8F, 0xFC, 0x7F, 0xE6, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x7C, 0x03,
  0xC0, 0x38, 0x1C, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0x87, 0xE3, 0x9C, 0x3F,
  0xCE, 0x71, 0xE7, 0x1D, 0xC7, 0x1C, 0x77, 0x38, 0x71, 0xD8, 0xE1, 0xC7,
  0xE3, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0x71, 0x98, 0xE3, 0xCE, 0x63,
  0xCF, 0x39, 0xC7, 0xEF, 0xC7, 0x0F, 0x9E, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x18, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x70, 0x1E, 0x1E, 0x07, 0x07, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x1E,
  0x78, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7C, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBC, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC7,
  0xEF, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0x8F, 0x86, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x86, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xF3,
  0xFC, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF1, 0xF8, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF9, 0xF8, 0x67, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1D, 0xE0, 0x3B, 0xF0, 0x73, 0xFF, 0xE3, 0xFF,
  0xC1, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7F, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0xFF, 0xFE, 0xFC, 0x20, 0xF0, 0x1F, 0xE0, 0x7B, 0xC1, 0xF7,
  0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xEF,
  0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3C, 0x78, 0x78, 0xF0,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC1, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xFC,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0E, 0xFE, 0xE0, 0x77, 0xF7, 0x07, 0xBF, 0xB8, 0x39,
  0xFC, 0xE1, 0xCF, 0xE7, 0x0E, 0x7F, 0x38, 0xE3, 0xF9, 0xE7, 0x1F, 0xC7,
  0x38, 0xFE, 0x3B, 0xC7, 0xF1, 0xDC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F,
  0xE1, 0xF0, 0x7F, 0x0F, 0x83, 0xF8, 0x3C, 0x1F, 0xC1, 0xC0, 0xE0, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xEF, 0x0F, 0xF7, 0x87, 0xF9, 0xE3, 0xFC, 0xF1, 0xFE, 0x3C,
  0xFF, 0x1E, 0x7F, 0x87, 0xBF, 0xC3, 0xDF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3E,
  0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xC7, 0xC7, 0x81, 0xF7, 0xC0,
  0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0x7C, 0x07, 0x9E, 0x07, 0xCF, 0x87, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE7, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xEF, 0xFF, 0x7F, 0xE3,
  0xFC, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xC7, 0xC7,
  0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0x7C, 0x07, 0x9E, 0x07, 0xCF, 0x87, 0xC3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x9F, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7,
  0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x3C, 0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC1, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x80, 0x0F,
  0xE1, 0xFF, 0x9F, 0xFC, 0xF9, 0xE7, 0x81, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xA0, 0x3D, 0xE3, 0xEF, 0xFE, 0x7F, 0xF1, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0x7B, 0xE1, 0xF7, 0xFF, 0xC7, 0xFF, 0x03,
  0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0x9C, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x70, 0xE0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0E, 0x07,
  0x0F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x1E, 0xF0,
  0x0F, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xEF, 0x01, 0xE0,
  0x79, 0xC0, 0xF8, 0x1E, 0x78, 0x3E, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83,
  0xF0, 0x70, 0xE1, 0xFC, 0x3C, 0x38, 0x77, 0x0F, 0x0F, 0x1D, 0xE3, 0xC3,
  0xC7, 0x38, 0xE0, 0xF1, 0xCE, 0x38, 0x1C, 0xF3, 0x9E, 0x07, 0x38, 0xE7,
  0x81, 0xEE, 0x1D, 0xE0, 0x7B, 0x87, 0x70, 0x1E, 0xE1, 0xDC, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x1F, 0x78, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E,
  0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xF1,
  0xE0, 0xE3, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0xFF, 0x0F, 0xFC, 0x71,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x7F, 0x3F, 0xFB, 0xFF, 0xDE, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0x7F, 0xF9, 0xF1, 0xC0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x18,
  0x3D, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x87, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0,
  0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF8,
  0x7B, 0xFF, 0xCE, 0xFF, 0x39, 0xF8, 0x03, 0x81, 0xFF, 0x3F, 0xE3, 0xEE,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x7C, 0x23, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x63, 0xC7, 0xEF, 0x3F,
  0xFD, 0xFF, 0xF7, 0x87, 0xDE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDE, 0x0F, 0x78, 0x7C, 0xFF, 0xF3,
  0xFF, 0xC7, 0xE7, 0x07, 0x80, 0xFF, 0x0F, 0xFC, 0x79, 0xE7, 0x87, 0xB8,
  0x1D, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xF0, 0x27, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xE3, 0xFC,
  0x7F, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x03, 0xFE, 0xFF, 0xDF, 0xF8, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x7E, 0x73, 0xFF, 0xDF,
  0xFF, 0x78, 0x7D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xE0, 0xF7, 0x87, 0xCF, 0xFF, 0x3F, 0xFC,
  0x7E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3D, 0x01, 0xE7, 0xFF, 0x9F, 0xFC,
  0x7F, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC7, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF0, 0x00,
  0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xBE, 0x38, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x1E, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xF7, 0x83, 0xDC, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xCF, 0x0F, 0x1E, 0x3C, 0x78, 0xF0, 0xF3,
  0xC3, 0xCF, 0x07, 0xBC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC1, 0xC7, 0x3F, 0x3F, 0xBB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x87, 0xF8, 0x3C, 0x3F, 0xC1, 0xE0, 0xFE,
  0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0,
  0x7F, 0x07, 0x83, 0xF8, 0x3C, 0x1F, 0xC1, 0xE0, 0xFE, 0x0F, 0x07, 0xF0,
  0x78, 0x3F, 0x83, 0xC1, 0xC0, 0x01, 0xC7, 0x3F, 0x3B, 0xFD, 0xFF, 0xFF,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x07,
  0x80, 0x7F, 0x83, 0xFF, 0x0F, 0xBE, 0x78, 0x79, 0xE0, 0xF7, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xE0, 0xF7,
  0x87, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x01, 0x83, 0x9F, 0x8E, 0xFF,
  0x3F, 0x7E, 0xF8, 0x7B, 0xC1, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x8F, 0xBF, 0xFC, 0xFF,
  0xF3, 0xDF, 0x8F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x7E, 0x73, 0xFF, 0xDF, 0xFF,
  0x78, 0x7D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x70, 0x3D, 0xE0, 0xF7, 0x87, 0xCF, 0xFF, 0x3F, 0xFC, 0x7E,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xF3, 0xFB, 0xFD, 0xFF, 0xC7, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00,
  0x0E, 0x07, 0xFD, 0xFF, 0x7C, 0xEF, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x1E, 0x03, 0xF0, 0x7F, 0xFE, 0xFF, 0xDF,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x0F, 0xFF, 0xFF, 0xFE, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0xE7, 0xF1,
  0xF8, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7D,
  0xFF, 0xEF, 0xF7, 0x3F, 0x38, 0xF0, 0x3E, 0xE0, 0x79, 0xE0, 0xF3, 0xC1,
  0xC3, 0x87, 0x87, 0x0F, 0x0F, 0x1C, 0x1E, 0x38, 0x1C, 0xF0, 0x39, 0xE0,
  0x7B, 0x80, 0x77, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0xF0, 0x7C, 0x3D, 0xC1, 0xF0, 0xF7, 0x87, 0xC3, 0xDE, 0x3F, 0x0E,
  0x78, 0xEC, 0x38, 0xE3, 0xB9, 0xE3, 0x8E, 0xE7, 0x8F, 0x73, 0x9C, 0x3D,
  0xCE, 0x70, 0x77, 0x1B, 0xC1, 0xDC, 0x7F, 0x07, 0x71, 0xF8, 0x1D, 0x87,
  0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0,
  0xF8, 0x3D, 0xE1, 0xE3, 0xC7, 0x87, 0x3C, 0x1E, 0xE0, 0x3F, 0x80, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1C, 0xF0, 0xF3,
  0xC3, 0x87, 0x9E, 0x1E, 0xF0, 0x3C, 0xF0, 0x3E, 0xE0, 0x79, 0xE0, 0xF3,
  0xC1, 0xC3, 0x87, 0x87, 0x8F, 0x0F, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x3D,
  0xE0, 0x3B, 0x80, 0x77, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x87, 0xC3, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC7, 0xC7, 0xC3, 0xC1, 0xF8, 0x1C, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xC3, 0xE0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x3E, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x78, 0x1F, 0x83, 0xF0, 0x7C, 0x3F, 0x1E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x3F, 0x0F, 0xC3, 0xC0, 0x18, 0x07,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x81, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 10, 8, 14, 2, -23 },
  { 23, 16, 23, 17, 1, -23 },
  { 69, 13, 26, 16, 1, -24 },
  { 112, 23, 23, 25, 1, -23 },
  { 179, 18, 23, 19, 1, -23 },
  { 231, 4, 8, 7, 2, -23 },
  { 235, 8, 28, 10, 1, -23 },
  { 263, 8, 28, 10, 1, -23 },
  { 291, 13, 13, 15, 1, -24 },
  { 313, 13, 15, 16, 1, -19 },
  { 338, 5, 8, 8, 1, -4 },
  { 343, 8, 3, 10, 1, -10 },
  { 346, 4, 5, 8, 2, -5 },
  { 349, 12, 23, 13, 0, -23 },
  { 384, 13, 23, 16, 1, -23 },
  { 422, 9, 23, 16, 2, -23 },
  { 448, 13, 23, 16, 1, -23 },
  { 486, 13, 23, 16, 1, -23 },
  { 524, 14, 23, 16, 1, -23 },
  { 565, 12, 23, 16, 2, -23 },
  { 600, 13, 23, 16, 1, -23 },
  { 638, 13, 23, 16, 1, -23 },
  { 676, 13, 23, 16, 1, -23 },
  { 714, 13, 23, 16, 1, -23 },
  { 752, 4, 18, 8, 2, -18 },
  { 761, 5, 22, 8, 1, -18 },
  { 775, 14, 15, 16, 1, -19 },
  { 802, 13, 9, 16, 1, -16 },
  { 817, 14, 15, 16, 1, -19 },
  { 844, 12, 23, 12, 0, -23 },
  { 879, 22, 26, 24, 1, -23 },
  { 951, 18, 23, 18, 0, -23 },
  { 1003, 14, 23, 18, 2, -23 },
  { 1044, 14, 23, 17, 2, -23 },
  { 1085, 16, 23, 19, 2, -23 },
  { 1131, 11, 23, 15, 2, -23 },
  { 1163, 11, 23, 14, 2, -23 },
  { 1195, 15, 23, 19, 2, -23 },
  { 1239, 16, 23, 20, 2, -23 },
  { 1285, 8, 23, 10, 1, -23 },
  { 1308, 8, 30, 9, -2, -23 },
  { 1338, 15, 23, 17, 2, -23 },
  { 1382, 11, 23, 14, 2, -23 },
  { 1414, 21, 23, 26, 2, -23 },
  { 1475, 17, 23, 21, 2, -23 },
  { 1524, 17, 23, 20, 2, -23 },
  { 1573, 13, 23, 16, 2, -23 },
  { 1611, 17, 28, 20, 2, -23 },
  { 1671, 15, 23, 17, 2, -23 },
  { 1715, 13, 23, 15, 1, -23 },
  { 1753, 14, 23, 15, 0, -23 },
  { 1794, 15, 23, 20, 2, -23 },
  { 1838, 17, 23, 17, 0, -23 },
  { 1887, 26, 23, 26, 0, -23 },
  { 1962, 16, 23, 16, 0, -23 },
  { 2008, 16, 23, 16, 0, -23 },
  { 2054, 13, 23, 14, 1, -23 },
  { 2092, 7, 28, 10, 2, -23 },
  { 2117, 12, 23, 13, 0, -23 },
  { 2152, 7, 28, 10, 1, -23 },
  { 2177, 15, 14, 17, 1, -23 },
  { 2204, 14, 2, 13, 0, 3 },
  { 2208, 8, 6, 10, 1, -25 },
  { 2214, 13, 18, 16, 1, -18 },
  { 2244, 14, 24, 17, 2, -24 },
  { 2286, 12, 18, 13, 1, -18 },
  { 2313, 14, 24, 17, 1, -24 },
  { 2355, 13, 18, 16, 1, -18 },
  { 2385, 11, 24, 10, 0, -24 },
  { 2418, 14, 26, 17, 1, -18 },
  { 2464, 13, 24, 17, 2, -24 },
  { 2503, 4, 24, 8, 2, -24 },
  { 2515, 7, 32, 8, -1, -24 },
  { 2543, 14, 24, 16, 2, -24 },
  { 2585, 4, 24, 8, 2, -24 },
  { 2597, 21, 18, 25, 2, -18 },
  { 2645, 13, 18, 17, 2, -18 },
  { 2675, 14, 18, 17, 1, -18 },
  { 2707, 14, 26, 17, 2, -18 },
  { 2753, 14, 26, 17, 1, -18 },
  { 2799, 9, 18, 12, 2, -18 },
  { 2820, 11, 18, 13, 1, -18 },
  { 2845, 9, 21, 11, 1, -21 },
  { 2869, 13, 17, 17, 2, -17 },
  { 2897, 15, 17, 15, 0, -17 },
  { 2929, 22, 17, 23, 0, -17 },
  { 2976, 14, 17, 14, 0, -17 },
  { 3006, 15, 25, 15, 0, -17 },
  { 3053, 10, 17, 12, 1, -17 },
  { 3075, 9, 28, 12, 1, -23 },
  { 3107, 3, 31, 15, 6, -24 },
  { 3119, 10, 28, 12, 1, -23 },
  { 3154, 14, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_SemiBold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD32PT7B_H_
