#ifndef _NOTOSANS_CONDENSED_SEMIBOLD17PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xDE, 0xF7, 0x90, 0x1B, 0x09, 0x04, 0x8F, 0xF7,
  0xF9, 0xB0, 0xD9, 0xFE, 0xFF, 0x12, 0x09, 0x0D, 0x80, 0x10, 0x73, 0xF6,
  0xAD, 0x1A, 0x1E, 0x0E, 0x1C, 0x2F, 0x77, 0xC1, 0x02, 0x00, 0xF1, 0x89,
  0x10, 0x93, 0x09, 0x20, 0x96, 0x09, 0x7E, 0xF5, 0xA0, 0xD3, 0x09, 0x31,
  0x92, 0x11, 0xA3, 0x0E, 0x78, 0x36, 0x33, 0x0D, 0x87, 0x83, 0x83, 0xEF,
  0xB6, 0xCF, 0x63, 0x3F, 0xCF, 0x70, 0xFF, 0x36, 0x6C, 0xCC, 0xCC, 0xCC,
  0xCC, 0x66, 0x30, 0xE3, 0x0C, 0x63, 0x08, 0x43, 0x11, 0x8C, 0x62, 0x33,
  0x00, 0x18, 0x31, 0xFF, 0xF3, 0x8D, 0xC9, 0x00, 0x30, 0x60, 0xC7, 0xFF,
  0xE6, 0x0C, 0x18, 0xFE, 0xF8, 0xF0, 0x0E, 0x18, 0x30, 0xC1, 0x82, 0x0C,
  0x18, 0x20, 0xC1, 0x86, 0x00, 0x79, 0xDB, 0x36, 0x6C, 0x78, 0xF1, 0xE3,
  0xCD, 0x9B, 0xF3, 0xC0, 0x19, 0xFE, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x30,
  0xF9, 0xBA, 0x30, 0x60, 0xC3, 0x86, 0x18, 0x61, 0xC3, 0xFF, 0xF0, 0xF9,
  0xB8, 0x30, 0x60, 0xCE, 0x1F, 0x06, 0x0E, 0x1B, 0xF7, 0xC0, 0x0E, 0x0E,
  0x1E, 0x16, 0x36, 0x26, 0x66, 0x46, 0xFF, 0x06, 0x06, 0x06, 0xFD, 0xFB,
  0x06, 0x0F, 0x1F, 0x83, 0x07, 0x0C, 0x1B, 0xF7, 0xC0, 0x3C, 0xEB, 0x06,
  0x0D, 0x9F, 0xB3, 0x63, 0xC7, 0x9B, 0xF3, 0xC0, 0xFF, 0xFF, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x79, 0x9B, 0x36, 0x6F,
  0xCF, 0x1F, 0x66, 0xC7, 0x8F, 0xB3, 0xC0, 0x79, 0xFB, 0x36, 0x2C, 0x79,
  0xFF, 0xB2, 0x0C, 0x1B, 0xE7, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xF8,
  0x06, 0x3D, 0xE7, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x81, 0xC0, 0xE0, 0x71, 0xEF, 0x38, 0x40, 0xF9, 0x70, 0xC3, 0x0C, 0x63,
  0x0C, 0x00, 0x03, 0x0C, 0x1F, 0x86, 0x19, 0x81, 0x67, 0xBD, 0xB3, 0x26,
  0x64, 0xCC, 0x9B, 0x9B, 0x79, 0xBB, 0x00, 0x30, 0x43, 0xF0, 0x1C, 0x0E,
  0x05, 0x86, 0xC3, 0x61, 0x98, 0xCC, 0xFE, 0x7F, 0x30, 0xF8, 0x78, 0x30,
  0xFC, 0xFE, 0xC6, 0xC6, 0xC6, 0xFC, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE, 0xFC,
  0x3E, 0xEF, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0xF9, 0xF0, 0xFC,
  0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF,
  0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0xC3,
  0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x3F, 0x7B, 0x60, 0xC0, 0xC0, 0xCF, 0xCF,
  0xC3, 0xC3, 0xE3, 0x7F, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF6, 0x66, 0x66, 0x66, 0x66, 0xEF, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3B, 0xF0, 0xC7, 0xC6, 0xCC, 0xCC, 0xD8,
  0xF8, 0xF8, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC2, 0xF8, 0xFD, 0x1F, 0xB3,
  0xF6, 0x5E, 0x5B, 0xCF, 0x79, 0xCF, 0x39, 0xE3, 0x30, 0xE1, 0xF8, 0xFC,
  0x7F, 0x3D, 0x9E, 0xCF, 0x37, 0x9B, 0xC7, 0xE3, 0xF0, 0xF8, 0x70, 0x3E,
  0x3B, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0x9F, 0xC7,
  0xC0, 0xFD, 0xFF, 0x1E, 0x3C, 0x79, 0xFF, 0x78, 0xC1, 0x83, 0x06, 0x00,
  0x3E, 0x3B, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0x9F,
  0xC7, 0xC0, 0x60, 0x38, 0x0E, 0xFC, 0xFE, 0xC6, 0xC6, 0xC6, 0xFE, 0xFC,
  0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0x7F, 0xFC, 0x30, 0xE1, 0xC3, 0x83, 0x0E,
  0x3F, 0xFE, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3,
  0x7F, 0x3E, 0xC1, 0xE0, 0x98, 0xCC, 0x66, 0x31, 0x30, 0xD8, 0x6C, 0x36,
  0x0A, 0x07, 0x03, 0x80, 0xC3, 0x1F, 0x0C, 0x66, 0x71, 0x99, 0xE6, 0x67,
  0x99, 0x96, 0xC6, 0xDB, 0x0F, 0x2C, 0x3C, 0xF0, 0xE3, 0xC3, 0x8E, 0x0E,
  0x18, 0xE3, 0x33, 0x0D, 0x86, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x36, 0x33,
  0x18, 0xD8, 0x70, 0xC3, 0x63, 0x66, 0x36, 0x3C, 0x3C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFC, 0x38, 0x61, 0xC3, 0x0C, 0x18, 0x60, 0xC3,
  0xFF, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0xC1,
  0x81, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x3F, 0xF0, 0x08, 0x1C, 0x1C, 0x36, 0x26, 0x63, 0xC3,
  0xFF, 0xFC, 0xC6, 0x30, 0xFD, 0x30, 0xCF, 0xFF, 0x3C, 0xF7, 0xF4, 0xC1,
  0x83, 0x06, 0x0F, 0xDD, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFD, 0xC0, 0x7F,
  0xAC, 0x30, 0xC3, 0x0C, 0x3F, 0x7C, 0x06, 0x0C, 0x18, 0x37, 0xFD, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1F, 0xF7, 0x60, 0x79, 0x9B, 0x17, 0xFF, 0xF8, 0x30,
  0x72, 0x7C, 0x3C, 0xE6, 0x18, 0xF9, 0x86, 0x18, 0x61, 0x86, 0x18, 0x60,
  0x7F, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x76, 0x0C, 0x1F, 0xEF, 0x80,
  0xC1, 0x83, 0x06, 0x0F, 0xDD, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x60,
  0xF4, 0xFF, 0xFF, 0xC0, 0x33, 0x10, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x79, 0xB6, 0x78, 0xF9, 0xB3, 0x36, 0x7C,
  0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0xFD, 0xFD, 0xEF, 0x19, 0xE3, 0x3C, 0x67,
  0x8C, 0xF1, 0x9E, 0x33, 0xC6, 0x60, 0xFD, 0xDF, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC6, 0x7D, 0xDB, 0x1E, 0x3C, 0x78, 0xF1, 0xF6, 0x78, 0xFD, 0xDF,
  0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xDD, 0x83, 0x06, 0x0C, 0x00, 0x7F, 0xDF,
  0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x76, 0x0C, 0x18, 0x30, 0x60, 0xDF, 0xF1,
  0x8C, 0x63, 0x18, 0xC0, 0xFE, 0x71, 0xC7, 0x8C, 0x7F, 0xF0, 0x23, 0x3E,
  0xC6, 0x31, 0x8C, 0x63, 0xCE, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF,
  0x76, 0xC7, 0x66, 0x66, 0x66, 0x6C, 0x3C, 0x3C, 0x38, 0x18, 0xC6, 0x34,
  0x62, 0x6F, 0x66, 0xF6, 0x69, 0x66, 0x94, 0x29, 0x43, 0x9C, 0x39, 0xC0,
  0xE6, 0x6E, 0x3C, 0x38, 0x18, 0x3C, 0x6C, 0x66, 0xE7, 0xC7, 0x66, 0x66,
  0x66, 0x2C, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0x30, 0xF0, 0xE0, 0x7C, 0x31,
  0x86, 0x30, 0xC6, 0x1F, 0xFC, 0x1C, 0xE3, 0x0C, 0x30, 0xC7, 0x38, 0x30,
  0xC3, 0x0C, 0x30, 0xF0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0x18,
  0xC6, 0x31, 0xE7, 0x63, 0x18, 0xC6, 0x72, 0x00, 0xF3, 0x7C,
};

const GFXglyph NotoSans_Condensed_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 9, 12, 9, 0, -12 },
  { 21, 7, 14, 8, 1, -13 },
  { 34, 12, 12, 13, 1, -12 },
  { 52, 9, 12, 10, 1, -12 },
  { 66, 2, 4, 4, 1, -12 },
  { 67, 4, 15, 5, 1, -12 },
  { 75, 5, 15, 5, 0, -12 },
  { 85, 7, 7, 8, 0, -13 },
  { 92, 7, 8, 8, 1, -10 },
  { 99, 2, 4, 4, 1, -2 },
  { 100, 5, 1, 5, 0, -5 },
  { 101, 2, 2, 4, 1, -2 },
  { 102, 7, 12, 7, 0, -12 },
  { 113, 7, 12, 8, 1, -12 },
  { 124, 5, 12, 8, 1, -12 },
  { 132, 7, 12, 8, 1, -12 },
  { 143, 7, 12, 8, 1, -12 },
  { 154, 8, 12, 8, 0, -12 },
  { 166, 7, 12, 8, 1, -12 },
  { 177, 7, 12, 8, 1, -12 },
  { 188, 8, 12, 8, 0, -12 },
  { 200, 7, 12, 8, 1, -12 },
  { 211, 7, 12, 8, 1, -12 },
  { 222, 2, 9, 4, 1, -9 },
  { 225, 2, 11, 4, 1, -9 },
  { 228, 7, 8, 8, 1, -10 },
  { 235, 7, 5, 8, 1, -8 },
  { 240, 7, 8, 8, 1, -10 },
  { 247, 6, 12, 7, 0, -12 },
  { 256, 11, 13, 13, 1, -12 },
  { 274, 9, 12, 9, 0, -12 },
  { 288, 8, 12, 9, 1, -12 },
  { 300, 7, 12, 9, 1, -12 },
  { 311, 8, 12, 10, 1, -12 },
  { 323, 6, 12, 8, 1, -12 },
  { 332, 6, 12, 8, 1, -12 },
  { 341, 8, 12, 10, 1, -12 },
  { 353, 8, 12, 11, 1, -12 },
  { 365, 4, 12, 5, 1, -12 },
  { 371, 4, 15, 5, -1, -12 },
  { 379, 8, 12, 9, 1, -12 },
  { 391, 6, 12, 7, 1, -12 },
  { 400, 11, 12, 14, 1, -12 },
  { 417, 9, 12, 11, 1, -12 },
  { 431, 9, 12, 11, 1, -12 },
  { 445, 7, 12, 9, 1, -12 },
  { 456, 9, 15, 11, 1, -12 },
  { 473, 8, 12, 9, 1, -12 },
  { 485, 6, 12, 8, 1, -12 },
  { 494, 8, 12, 8, 0, -12 },
  { 506, 8, 12, 10, 1, -12 },
  { 518, 9, 12, 9, 0, -12 },
  { 532, 14, 12, 14, 0, -12 },
  { 553, 9, 12, 9, 0, -12 },
  { 567, 8, 12, 8, 0, -12 },
  { 579, 7, 12, 8, 0, -12 },
  { 590, 4, 15, 5, 1, -12 },
  { 598, 7, 12, 7, 0, -12 },
  { 609, 4, 15, 5, 0, -12 },
  { 617, 8, 7, 9, 0, -12 },
  { 624, 7, 2, 7, 0, 1 },
  { 626, 4, 3, 5, 1, -13 },
  { 628, 6, 9, 8, 1, -9 },
  { 635, 7, 13, 9, 1, -13 },
  { 647, 6, 9, 7, 1, -9 },
  { 654, 7, 13, 9, 1, -13 },
  { 666, 7, 9, 8, 1, -9 },
  { 674, 6, 13, 5, 0, -13 },
  { 684, 7, 13, 9, 1, -9 },
  { 696, 7, 13, 9, 1, -13 },
  { 708, 2, 13, 4, 1, -13 },
  { 712, 4, 17, 4, -1, -13 },
  { 721, 7, 13, 8, 1, -13 },
  { 733, 2, 13, 4, 1, -13 },
  { 737, 11, 9, 14, 1, -9 },
  { 750, 7, 9, 9, 1, -9 },
  { 758, 7, 9, 9, 1, -9 },
  { 766, 7, 13, 9, 1, -9 },
  { 778, 7, 13, 9, 1, -9 },
  { 790, 5, 9, 6, 1, -9 },
  { 796, 5, 9, 7, 1, -9 },
  { 802, 5, 11, 6, 0, -11 },
  { 809, 7, 9, 9, 1, -9 },
  { 817, 8, 9, 8, 0, -9 },
  { 826, 12, 9, 12, 0, -9 },
  { 840, 8, 9, 8, 0, -9 },
  { 849, 8, 13, 8, 0, -9 },
  { 862, 6, 9, 7, 0, -9 },
  { 869, 6, 15, 6, 0, -12 },
  { 881, 2, 17, 8, 3, -13 },
  { 886, 5, 15, 6, 1, -12 },
  { 896, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD17PT7B_H_
