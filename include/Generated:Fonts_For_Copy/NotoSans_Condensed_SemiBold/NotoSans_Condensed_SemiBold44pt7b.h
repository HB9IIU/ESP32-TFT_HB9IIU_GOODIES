#ifndef _NOTOSANS_CONDENSED_SEMIBOLD44PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0x9E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0xBF, 0xFF, 0xFF,
  0x80, 0xFC, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC3, 0xC0,
  0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1C, 0x3C, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xF0,
  0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xF1, 0xFB, 0x7C, 0xFC, 0xC1, 0x3E, 0x30, 0x0F, 0x8C,
  0x03, 0xE3, 0x00, 0xFC, 0xC0, 0x1F, 0xB0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xDF, 0x80,
  0x33, 0xE0, 0x0C, 0x7C, 0x03, 0x1F, 0x80, 0xC7, 0xB0, 0x33, 0xEF, 0x8F,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x01,
  0x00, 0x7F, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x78, 0x03, 0xFF, 0x01, 0xE0,
  0x0F, 0x1E, 0x03, 0xC0, 0x1E, 0x3C, 0x07, 0x80, 0x3C, 0x3C, 0x1E, 0x00,
  0x78, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x01, 0xE1, 0xE1, 0xE0, 0x03,
  0xC3, 0xC7, 0x80, 0x07, 0x87, 0x8F, 0x00, 0x0F, 0x0F, 0x1E, 0x00, 0x1E,
  0x1E, 0x78, 0xFC, 0x3C, 0x78, 0xF3, 0xFC, 0x78, 0xF3, 0xC7, 0xFC, 0x7F,
  0xE7, 0x9F, 0x7C, 0xFF, 0x9E, 0x3C, 0x78, 0xFE, 0x3C, 0xF8, 0xF0, 0x78,
  0x79, 0xE1, 0xE0, 0x01, 0xE3, 0xC3, 0xC0, 0x03, 0xC7, 0x87, 0x80, 0x0F,
  0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x3C, 0x00, 0xF0,
  0x78, 0x78, 0x01, 0xE0, 0xF8, 0xF0, 0x07, 0x80, 0xF1, 0xE0, 0x0F, 0x01,
  0xF7, 0xC0, 0x3C, 0x01, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x01,
  0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0x1F, 0xFE, 0x1F, 0x8F, 0xDF, 0x0F,
  0x8F, 0xCF, 0xC7, 0xC7, 0xC3, 0xF7, 0xE3, 0xE0, 0xFF, 0xE3, 0xF0, 0x3F,
  0xF1, 0xF8, 0x1F, 0xF8, 0xFC, 0x07, 0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0x81,
  0xFE, 0x0F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFC, 0xFC, 0x0F, 0xF8, 0x3F, 0xFD, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79,
  0xE7, 0x80, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x41,
  0xE0, 0x9E, 0x79, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x83, 0xF1, 0xF0,
  0x78, 0x78, 0x06, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7C, 0xFB, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xFC, 0x0F, 0x9F,
  0x07, 0xE7, 0xC1, 0xF1, 0xF8, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xE0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF,
  0x7F, 0xFF, 0xDF, 0xF9, 0xF6, 0x1F, 0x21, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1E, 0x0F, 0xC2, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF3, 0x81, 0xF8, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xF0, 0x03,
  0xDF, 0x00, 0x79, 0xF0, 0x07, 0x9F, 0x00, 0xF1, 0xF0, 0x0F, 0x1F, 0x01,
  0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x0F, 0xFC, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF9, 0xFC, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xDF, 0x03, 0xE7, 0xC0,
  0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xF1, 0xF8, 0x7C, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0xF8, 0xF8, 0x3F, 0x1F, 0x87, 0xC1, 0xF9, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F,
  0x0F, 0xE7, 0xC0, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0x07, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFC, 0x3F, 0x1F, 0x03, 0xE3, 0xE0,
  0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xF7, 0xC0,
  0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x7F, 0x7F, 0xBF, 0xE7, 0xFF,
  0x78, 0x7F, 0xEF, 0x07, 0xF9, 0xE0, 0x7C, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7B, 0xEF,
  0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBE, 0xFF, 0xFF, 0xFE, 0x1E, 0x3E, 0x3F, 0x3F, 0x3F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x30, 0x3F, 0x20, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF1, 0xE0, 0x7F,
  0xC7, 0x9F, 0x07, 0xFE, 0x1E, 0xF0, 0x7F, 0xF0, 0xF7, 0x87, 0xC7, 0x87,
  0xBC, 0x3C, 0x3C, 0x3F, 0xC3, 0xC1, 0xE1, 0xFE, 0x1E, 0x0F, 0x0F, 0xF0,
  0xF0, 0x78, 0x7F, 0x87, 0x83, 0xC3, 0xFC, 0x3C, 0x1E, 0x1F, 0xE1, 0xE0,
  0xF0, 0xFF, 0x0F, 0x07, 0x87, 0xF8, 0x78, 0x7C, 0x3F, 0xC3, 0xC3, 0xE3,
  0xDE, 0x1F, 0x3F, 0x9E, 0xF8, 0x7F, 0xDF, 0xE3, 0xC1, 0xFC, 0xFE, 0x1E,
  0x07, 0xC3, 0xE0, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x08, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xC1, 0xFD, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E,
  0x07, 0xEF, 0xC7, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFC, 0x0C, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x21, 0xFE, 0x1E, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xC1, 0xFE, 0x7E, 0x03, 0xF3, 0xF0,
  0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07,
  0xE7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x00, 0xC3, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7C,
  0xFC, 0x01, 0xF3, 0xF8, 0x07, 0xC7, 0xF8, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xEF, 0xFE, 0xFF, 0xCF,
  0xFC, 0xFF, 0x8F, 0xE0, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0x3F, 0x01, 0xF9,
  0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0x9F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E,
  0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7E,
  0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x78, 0x03, 0xFF, 0xFB, 0xC0, 0x1E, 0xFF, 0xDF, 0x00,
  0xF7, 0xFE, 0xF8, 0x0F, 0xBF, 0xF3, 0xC0, 0x7D, 0xFF, 0x9E, 0x03, 0xCF,
  0xFC, 0xF8, 0x1E, 0x7F, 0xE3, 0xC1, 0xF3, 0xFF, 0x1E, 0x0F, 0x1F, 0xF8,
  0xF8, 0x78, 0xFF, 0xC7, 0xC7, 0xC7, 0xFE, 0x1E, 0x3C, 0x3F, 0xF0, 0xF1,
  0xE1, 0xFF, 0x87, 0xDF, 0x0F, 0xFC, 0x1E, 0xF8, 0x7F, 0xE0, 0xF7, 0x83,
  0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFE, 0x07, 0xFE,
  0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07,
  0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xE0, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFB, 0xE0, 0x3F, 0xF7, 0xE0, 0x7F, 0xE7,
  0xC0, 0xFF, 0xCF, 0x81, 0xFF, 0x8F, 0x83, 0xFF, 0x1F, 0x07, 0xFE, 0x1F,
  0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x3E, 0x3F, 0xF0, 0x7C, 0x7F, 0xE0, 0x7C,
  0xFF, 0xC0, 0xF9, 0xFF, 0x81, 0xFB, 0xFF, 0x01, 0xF7, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC3, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x3F, 0xBF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC3, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFC, 0x3F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE0, 0xFC, 0x3E, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7,
  0xF0, 0x73, 0xF0, 0x09, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xB0, 0x0F, 0xDF, 0x0F,
  0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0xE3, 0xFC, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7,
  0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x7D,
  0xF0, 0x07, 0xE0, 0x1F, 0xBE, 0x01, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x80,
  0x7C, 0xF8, 0x07, 0xF0, 0x0F, 0x9F, 0x80, 0xFF, 0x01, 0xF1, 0xF0, 0x3F,
  0xE0, 0x7E, 0x3E, 0x07, 0xBC, 0x0F, 0x87, 0xC0, 0xF7, 0x81, 0xF0, 0xF8,
  0x1E, 0xF0, 0x3E, 0x1F, 0x83, 0xDF, 0x07, 0xC1, 0xF0, 0xFB, 0xE1, 0xF8,
  0x3E, 0x1F, 0x3C, 0x3E, 0x07, 0xC3, 0xC7, 0x87, 0xC0, 0xF8, 0x78, 0xF0,
  0xF8, 0x0F, 0x9F, 0x1F, 0x1F, 0x01, 0xF3, 0xE1, 0xE7, 0xE0, 0x3E, 0x78,
  0x3C, 0xF8, 0x07, 0xCF, 0x07, 0x9F, 0x00, 0xF9, 0xE0, 0xF3, 0xE0, 0x0F,
  0x7C, 0x1F, 0x7C, 0x01, 0xFF, 0x81, 0xEF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0xF8, 0x07,
  0xC3, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x80,
  0xF8, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xFC, 0x03, 0xE1,
  0xF0, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0x7C,
  0x7E, 0x01, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFD,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFC,
  0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC1, 0xE0,
  0x3E, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80,
  0x3C, 0x78, 0x01, 0xF7, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x07, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x0C, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x7F, 0x7F, 0xFF, 0xDF,
  0xFD, 0xF3, 0xFF, 0x3C, 0x7F, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x3F, 0x0F, 0xBF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xCF, 0xF8, 0xF1, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xF0, 0xCF, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x33, 0xFF,
  0xE7, 0xFF, 0xC7, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC3, 0xF9, 0xF1, 0xFF, 0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF,
  0x87, 0xF7, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF,
  0xFF, 0xF3, 0xFF, 0xBC, 0x7F, 0xCF, 0x0F, 0xE3, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x1F, 0x03, 0xE7, 0xC0,
  0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x06, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xF8, 0x00, 0xF0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFF, 0x3F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0x0F, 0xE3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBC, 0xFF, 0xFF,
  0x7E, 0x1F, 0xDF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0x7C, 0x3F, 0x9F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x40, 0x0F, 0xD8, 0x07, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x7F, 0x0F, 0xBF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0xC7, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xC0, 0xF7, 0xFF, 0xFF, 0xB8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x07,
  0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0x7F, 0xBF, 0x04, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFB,
  0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07,
  0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE7, 0xC0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x8F, 0x81, 0xF1, 0xF0, 0x3F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7E, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xFC, 0x1F, 0xC7, 0x9F, 0xF1, 0xFF, 0x3D,
  0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xFE, 0x3F, 0xFE, 0x0F,
  0xE0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F,
  0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF1, 0xFC, 0x3C, 0xFF, 0xCF,
  0x7F, 0xF3, 0xFF, 0xFE, 0xFF, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE1,
  0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F, 0x0F,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0xF1, 0xFC,
  0x3C, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xBF, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xBF, 0xE3, 0xE7, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBC,
  0xFF, 0xFF, 0x7E, 0x1F, 0xDF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD,
  0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0x7C, 0x3F, 0x9F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0xF0, 0xFF, 0x3F, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x1F, 0xF0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xF8, 0x1B, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF1, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x08, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x87,
  0xF7, 0xFF, 0xFB, 0xFF, 0xBC, 0xFF, 0x9E, 0x3F, 0x8F, 0xFC, 0x03, 0xF7,
  0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x79,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0xF8, 0x1F, 0xC0, 0xF9, 0xF0, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0x03,
  0xE7, 0xC0, 0xFE, 0x07, 0xC7, 0xC3, 0xDE, 0x1F, 0x0F, 0x87, 0xBC, 0x3E,
  0x1F, 0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8, 0x3E, 0x3D, 0xE1, 0xE0,
  0x7C, 0xF1, 0xE7, 0xC0, 0xF9, 0xE3, 0xCF, 0x81, 0xF3, 0xC7, 0x9F, 0x01,
  0xE7, 0x8F, 0x3C, 0x03, 0xCF, 0x1E, 0x78, 0x07, 0xFC, 0x1D, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xEF, 0xC0, 0xFC, 0xF8,
  0x1F, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xBF, 0x01, 0xF3,
  0xE0, 0x7C, 0x7E, 0x0F, 0x87, 0xC3, 0xF0, 0xFC, 0x7C, 0x0F, 0x9F, 0x81,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x7D, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF,
  0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0x01, 0xFC,
  0x0F, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x07,
  0xF0, 0x7F, 0x87, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0x00, 0x2F, 0xF8, 0x07, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xA0, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 31, 11, 3, -31 },
  { 25, 15, 11, 19, 2, -31 },
  { 46, 22, 31, 24, 1, -31 },
  { 132, 18, 36, 21, 2, -33 },
  { 213, 31, 32, 34, 2, -32 },
  { 337, 25, 32, 26, 1, -32 },
  { 437, 6, 11, 10, 2, -31 },
  { 446, 11, 39, 14, 2, -32 },
  { 500, 11, 39, 14, 1, -32 },
  { 554, 18, 17, 20, 1, -33 },
  { 593, 19, 21, 21, 1, -26 },
  { 643, 8, 11, 11, 1, -5 },
  { 654, 11, 5, 13, 1, -14 },
  { 661, 7, 6, 11, 2, -6 },
  { 667, 17, 32, 17, 0, -32 },
  { 735, 18, 32, 21, 2, -32 },
  { 807, 12, 31, 21, 3, -31 },
  { 854, 18, 32, 21, 2, -32 },
  { 926, 17, 32, 21, 2, -32 },
  { 994, 20, 32, 21, 1, -32 },
  { 1074, 17, 31, 21, 2, -31 },
  { 1140, 18, 32, 21, 2, -32 },
  { 1212, 19, 31, 21, 1, -31 },
  { 1286, 19, 32, 21, 1, -32 },
  { 1362, 19, 32, 21, 1, -32 },
  { 1438, 6, 24, 11, 3, -24 },
  { 1456, 8, 30, 11, 1, -24 },
  { 1486, 19, 21, 21, 1, -26 },
  { 1536, 19, 13, 21, 1, -22 },
  { 1567, 19, 21, 21, 1, -26 },
  { 1617, 16, 32, 17, 0, -32 },
  { 1681, 29, 36, 33, 2, -32 },
  { 1812, 24, 31, 24, 0, -31 },
  { 1905, 19, 31, 24, 3, -31 },
  { 1979, 20, 32, 23, 2, -32 },
  { 2059, 21, 31, 26, 3, -31 },
  { 2141, 15, 31, 20, 3, -31 },
  { 2200, 15, 31, 20, 3, -31 },
  { 2259, 22, 32, 27, 2, -32 },
  { 2347, 21, 31, 27, 3, -31 },
  { 2429, 12, 31, 14, 1, -31 },
  { 2476, 12, 40, 12, -3, -31 },
  { 2536, 21, 31, 24, 3, -31 },
  { 2618, 15, 31, 19, 3, -31 },
  { 2677, 29, 31, 35, 3, -31 },
  { 2790, 23, 31, 29, 3, -31 },
  { 2880, 24, 32, 28, 2, -32 },
  { 2976, 18, 31, 23, 3, -31 },
  { 3046, 24, 39, 28, 2, -32 },
  { 3163, 20, 31, 24, 3, -31 },
  { 3241, 17, 32, 20, 2, -32 },
  { 3309, 19, 31, 20, 1, -31 },
  { 3383, 21, 31, 27, 3, -31 },
  { 3465, 23, 31, 23, 0, -31 },
  { 3555, 35, 31, 35, 0, -31 },
  { 3691, 22, 31, 22, 0, -31 },
  { 3777, 22, 31, 22, 0, -31 },
  { 3863, 18, 31, 20, 1, -31 },
  { 3933, 10, 39, 14, 3, -32 },
  { 3982, 17, 32, 17, 0, -32 },
  { 4050, 10, 39, 14, 1, -32 },
  { 4099, 21, 18, 23, 1, -31 },
  { 4147, 19, 3, 18, 0, 4 },
  { 4155, 10, 7, 13, 2, -34 },
  { 4164, 18, 24, 21, 1, -24 },
  { 4218, 18, 33, 23, 3, -33 },
  { 4293, 15, 24, 18, 2, -24 },
  { 4338, 18, 33, 23, 2, -33 },
  { 4413, 18, 24, 21, 2, -24 },
  { 4467, 14, 34, 14, 1, -34 },
  { 4527, 18, 35, 23, 2, -24 },
  { 4606, 18, 33, 23, 3, -33 },
  { 4681, 5, 33, 11, 3, -33 },
  { 4702, 9, 44, 11, -1, -33 },
  { 4752, 19, 33, 22, 3, -33 },
  { 4831, 5, 33, 11, 3, -33 },
  { 4852, 29, 24, 35, 3, -24 },
  { 4939, 18, 24, 23, 3, -24 },
  { 4993, 19, 24, 23, 2, -24 },
  { 5050, 18, 35, 23, 3, -24 },
  { 5129, 18, 35, 23, 2, -24 },
  { 5208, 12, 24, 16, 3, -24 },
  { 5244, 14, 24, 18, 2, -24 },
  { 5286, 13, 29, 15, 1, -29 },
  { 5334, 17, 24, 23, 3, -24 },
  { 5385, 20, 24, 20, 0, -24 },
  { 5445, 31, 24, 31, 0, -24 },
  { 5538, 19, 24, 20, 0, -24 },
  { 5595, 20, 35, 20, 0, -24 },
  { 5683, 15, 24, 17, 1, -24 },
  { 5728, 13, 38, 16, 1, -31 },
  { 5790, 4, 44, 20, 8, -34 },
  { 5812, 13, 38, 16, 2, -31 },
  { 5874, 19, 7, 21, 1, -19 },
};

const GFXfont NotoSans_Condensed_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD44PT7B_H_
