#ifndef _NOTOSANS_CONDENSED_SEMIBOLD15PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xF5, 0x20, 0x16, 0x16, 0x14, 0x7F, 0x7F,
  0x24, 0x24, 0xFE, 0x2C, 0x28, 0x68, 0x23, 0xFE, 0xA8, 0xE1, 0xC3, 0x8B,
  0xAF, 0xE2, 0x08, 0x63, 0x28, 0x8B, 0x62, 0xD0, 0xB5, 0xAB, 0xF6, 0xA4,
  0x69, 0x12, 0x4C, 0xB2, 0x18, 0x38, 0x3E, 0x19, 0x0D, 0x83, 0x81, 0xC5,
  0xEC, 0x9E, 0xC6, 0x37, 0x9F, 0xE0, 0xFE, 0x2D, 0x6D, 0x24, 0x9B, 0x26,
  0xC6, 0x23, 0x33, 0x33, 0x33, 0x26, 0xC0, 0x10, 0xAB, 0xF9, 0xC6, 0xC5,
  0x00, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x6D, 0x60, 0xFF, 0xF0, 0x0C,
  0x21, 0x86, 0x10, 0xC2, 0x18, 0x61, 0x0C, 0x00, 0x73, 0xEC, 0xA3, 0x8E,
  0x38, 0xE3, 0xCB, 0x67, 0x00, 0x17, 0xDB, 0x33, 0x33, 0x33, 0x30, 0x73,
  0xE8, 0x82, 0x18, 0x63, 0x18, 0xC3, 0xFF, 0xC0, 0x73, 0xE0, 0x82, 0x19,
  0xC1, 0x83, 0x0E, 0x6F, 0x00, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0x93, 0x7F,
  0xFE, 0x18, 0x30, 0xFB, 0xEC, 0x30, 0xF3, 0xE0, 0xC3, 0x0E, 0x6F, 0x00,
  0x39, 0xEC, 0x20, 0xBB, 0xE8, 0xE3, 0xCF, 0x67, 0x80, 0xFF, 0xFC, 0x10,
  0x60, 0xC1, 0x06, 0x0C, 0x30, 0x61, 0xC0, 0x38, 0xF9, 0x1B, 0x27, 0xC7,
  0x1B, 0x23, 0xC6, 0xCD, 0xF0, 0x38, 0xF9, 0x16, 0x34, 0x6D, 0xDF, 0x82,
  0x0C, 0xB9, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0xA0, 0x02, 0x1C, 0xE7, 0x07,
  0x03, 0x81, 0x80, 0xFC, 0x00, 0x3F, 0x83, 0x07, 0x03, 0x3B, 0x88, 0x00,
  0x77, 0xC2, 0x11, 0x98, 0x84, 0x03, 0x1C, 0x1E, 0x0C, 0xC4, 0x1B, 0x7A,
  0x92, 0xEC, 0xBB, 0x6E, 0xDA, 0x9F, 0xB0, 0x06, 0x10, 0xF8, 0x18, 0x1C,
  0x3C, 0x3C, 0x34, 0x26, 0x66, 0x7E, 0x63, 0xC3, 0xC3, 0xF9, 0xFB, 0x36,
  0x2C, 0xDF, 0x33, 0x63, 0xC7, 0xFB, 0xE0, 0x3D, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0xC1, 0x93, 0xC0, 0xF1, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xFB, 0xE0, 0xFF, 0xF1, 0x8C, 0x7F, 0x18, 0xC7, 0xFE, 0xFF, 0xF1, 0x8C,
  0x7F, 0xF8, 0xC6, 0x30, 0x3C, 0xFF, 0x86, 0x0C, 0x19, 0xF3, 0xE3, 0xC6,
  0xCC, 0xF8, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x18,
  0xF7, 0x22, 0x22, 0x22, 0x22, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xFE, 0xC7, 0x9B, 0x36, 0xCF, 0x1E, 0x3E, 0x6C, 0xCD, 0x9B, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0xF3,
  0xF4, 0xBD, 0x2F, 0x7B, 0xDC, 0xF3, 0x3C, 0xCC, 0xC3, 0xE3, 0xE3, 0xF3,
  0xD3, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0x3C, 0x7E, 0xC6, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC6, 0x6E, 0x3C, 0xF3, 0xFC, 0xF3, 0xCF, 0x7F, 0xB0,
  0xC3, 0x0C, 0x00, 0x3C, 0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6,
  0x6E, 0x3C, 0x0C, 0x06, 0x07, 0xF1, 0xFB, 0x36, 0x6C, 0xDF, 0xBE, 0x6C,
  0xCD, 0x9B, 0x18, 0x7F, 0xF1, 0x0C, 0x38, 0xE3, 0x0F, 0xFC, 0xFF, 0xFC,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0xDD, 0xF0, 0xC3, 0xC3, 0x42, 0x66, 0x66, 0x64,
  0x24, 0x3C, 0x3C, 0x18, 0x18, 0xC6, 0x3C, 0x63, 0xC6, 0x34, 0xF2, 0x6F,
  0x66, 0xF6, 0x69, 0x62, 0x94, 0x39, 0xC3, 0x9C, 0x30, 0xC0, 0xC6, 0x66,
  0x6C, 0x3C, 0x38, 0x18, 0x38, 0x3C, 0x6C, 0x66, 0xC7, 0xC6, 0x8D, 0x93,
  0x63, 0xC7, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xF0, 0xC6, 0x18, 0xC3,
  0x18, 0x63, 0xFF, 0xC0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6E, 0xC1, 0x06, 0x18,
  0x20, 0xC3, 0x04, 0x18, 0x20, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xF0, 0x10, 0x30, 0xE1, 0x66, 0x48, 0xF0, 0x80, 0xFC, 0xCC, 0xFC, 0xC2,
  0xFC, 0xC7, 0x7D, 0xC3, 0x0C, 0x3E, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0x80,
  0x7E, 0x71, 0x08, 0x63, 0x2F, 0x0C, 0x30, 0xDF, 0xCF, 0x38, 0xE3, 0xCF,
  0x77, 0xC0, 0x7B, 0x28, 0xFF, 0x83, 0x0C, 0x9E, 0x3B, 0x19, 0xF6, 0x31,
  0x8C, 0x63, 0x18, 0x7F, 0x3C, 0xE3, 0x8F, 0x3D, 0xDF, 0x0C, 0x3F, 0x98,
  0xC3, 0x0C, 0x3E, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0xF3, 0xFF, 0xFC,
  0x6C, 0x36, 0xDB, 0x6D, 0xB7, 0xA0, 0xC3, 0x0C, 0x33, 0xDB, 0xCF, 0x34,
  0xDB, 0x3C, 0xC0, 0xFF, 0xFF, 0xFC, 0xBB, 0xB3, 0x3C, 0xCF, 0x33, 0xCC,
  0xF3, 0x3C, 0xCF, 0x33, 0xBB, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x7B, 0x3C,
  0xE3, 0x8F, 0x3C, 0xDE, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xFE, 0xC3, 0x0C,
  0x30, 0x7F, 0x3C, 0xE3, 0x8F, 0x3D, 0xDF, 0x0C, 0x30, 0xC3, 0xBF, 0xCC,
  0xCC, 0xCC, 0xF4, 0xA1, 0xC3, 0x0E, 0xDE, 0x23, 0x3E, 0xC6, 0x31, 0x8C,
  0x69, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x3D, 0xDD, 0xC6, 0x89, 0xB3, 0x66,
  0x85, 0x0E, 0x18, 0xCC, 0x53, 0xB4, 0xAD, 0xAB, 0x7A, 0x9C, 0xA3, 0x38,
  0xCE, 0xCE, 0xD8, 0xE1, 0xC3, 0x8D, 0x1B, 0x63, 0xC6, 0x89, 0xB3, 0x62,
  0x85, 0x0E, 0x1C, 0x30, 0x63, 0x86, 0x00, 0x78, 0xC6, 0x62, 0x31, 0x1F,
  0x19, 0xCC, 0x63, 0x1B, 0x9C, 0x31, 0x8C, 0x63, 0x80, 0xFF, 0xFE, 0x8C,
  0x44, 0x46, 0x37, 0x64, 0x44, 0xC0, 0xFF, 0x18,
};

const GFXglyph NotoSans_Condensed_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 6, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 12, 7, 1, -11 },
  { 27, 10, 11, 12, 1, -11 },
  { 41, 9, 11, 9, 0, -11 },
  { 54, 2, 4, 3, 1, -11 },
  { 55, 3, 13, 5, 1, -11 },
  { 60, 4, 13, 5, 0, -11 },
  { 67, 7, 6, 7, 0, -11 },
  { 73, 6, 7, 7, 1, -9 },
  { 79, 3, 4, 4, 0, -2 },
  { 81, 4, 2, 5, 0, -5 },
  { 82, 2, 2, 4, 1, -2 },
  { 83, 6, 11, 6, 0, -11 },
  { 92, 6, 11, 7, 1, -11 },
  { 101, 4, 11, 7, 1, -11 },
  { 107, 6, 11, 7, 1, -11 },
  { 116, 6, 11, 7, 1, -11 },
  { 125, 7, 11, 7, 0, -11 },
  { 135, 6, 11, 7, 1, -11 },
  { 144, 6, 11, 7, 1, -11 },
  { 153, 7, 11, 7, 0, -11 },
  { 163, 7, 11, 7, 0, -11 },
  { 173, 7, 11, 7, 0, -11 },
  { 183, 2, 8, 4, 1, -8 },
  { 185, 2, 10, 4, 1, -8 },
  { 188, 7, 7, 7, 0, -9 },
  { 195, 6, 4, 7, 1, -7 },
  { 198, 6, 7, 7, 1, -9 },
  { 204, 5, 11, 6, 0, -11 },
  { 211, 10, 12, 11, 1, -11 },
  { 226, 8, 11, 8, 0, -11 },
  { 237, 7, 11, 8, 1, -11 },
  { 247, 6, 11, 8, 1, -11 },
  { 256, 7, 11, 9, 1, -11 },
  { 266, 5, 11, 7, 1, -11 },
  { 273, 5, 11, 7, 1, -11 },
  { 280, 7, 11, 9, 1, -11 },
  { 290, 7, 11, 9, 1, -11 },
  { 300, 4, 11, 5, 0, -11 },
  { 306, 4, 14, 4, -1, -11 },
  { 313, 7, 11, 8, 1, -11 },
  { 323, 5, 11, 7, 1, -11 },
  { 330, 10, 11, 12, 1, -11 },
  { 344, 8, 11, 10, 1, -11 },
  { 355, 8, 11, 10, 1, -11 },
  { 366, 6, 11, 8, 1, -11 },
  { 375, 8, 14, 10, 1, -11 },
  { 389, 7, 11, 8, 1, -11 },
  { 399, 5, 11, 7, 1, -11 },
  { 406, 7, 11, 7, 0, -11 },
  { 416, 7, 11, 9, 1, -11 },
  { 426, 8, 11, 8, 0, -11 },
  { 437, 12, 11, 12, 0, -11 },
  { 454, 8, 11, 8, 0, -11 },
  { 465, 7, 11, 7, 0, -11 },
  { 475, 6, 11, 7, 0, -11 },
  { 484, 3, 13, 5, 1, -11 },
  { 489, 6, 11, 6, 0, -11 },
  { 498, 4, 13, 5, 0, -11 },
  { 505, 7, 7, 8, 0, -11 },
  { 512, 6, 1, 6, 0, 1 },
  { 513, 3, 2, 5, 1, -11 },
  { 514, 5, 8, 7, 1, -8 },
  { 519, 6, 11, 8, 1, -11 },
  { 528, 5, 8, 6, 1, -8 },
  { 533, 6, 11, 8, 1, -11 },
  { 542, 6, 8, 7, 1, -8 },
  { 548, 5, 11, 5, 0, -11 },
  { 555, 6, 12, 8, 1, -8 },
  { 564, 6, 11, 8, 1, -11 },
  { 573, 2, 11, 4, 1, -11 },
  { 576, 3, 15, 4, 0, -11 },
  { 582, 6, 11, 7, 1, -11 },
  { 591, 2, 11, 4, 1, -11 },
  { 594, 10, 8, 12, 1, -8 },
  { 604, 6, 8, 8, 1, -8 },
  { 610, 6, 8, 8, 1, -8 },
  { 616, 6, 12, 8, 1, -8 },
  { 625, 6, 12, 8, 1, -8 },
  { 634, 4, 8, 5, 1, -8 },
  { 638, 5, 8, 6, 1, -8 },
  { 643, 5, 10, 5, 0, -10 },
  { 650, 6, 8, 8, 1, -8 },
  { 656, 7, 8, 7, 0, -8 },
  { 663, 10, 8, 11, 0, -8 },
  { 673, 7, 8, 7, 0, -8 },
  { 680, 7, 12, 7, 0, -8 },
  { 691, 5, 8, 6, 0, -8 },
  { 696, 5, 13, 5, 0, -11 },
  { 705, 1, 15, 7, 3, -11 },
  { 707, 4, 13, 5, 1, -11 },
  { 714, 7, 2, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD15PT7B_H_
