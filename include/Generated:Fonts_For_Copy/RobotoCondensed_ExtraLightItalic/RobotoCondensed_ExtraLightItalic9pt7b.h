#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC9PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x08, 0x80, 0x21, 0xCC, 0xA6, 0x38, 0x00, 0x07, 0x44, 0x21,
  0x9E, 0x00, 0xCD, 0xE4, 0x7B, 0x30, 0x75, 0x64, 0xA9, 0xF0, 0x00, 0x29,
  0x49, 0x24, 0x00, 0x04, 0x92, 0x4A, 0x00, 0x4D, 0x40, 0x26, 0x20, 0x80,
  0x00, 0x80, 0x04, 0xA5, 0x20, 0x75, 0x99, 0x99, 0xE0, 0x55, 0x50, 0x71,
  0x12, 0x24, 0xC0, 0x71, 0x12, 0x19, 0xE0, 0x13, 0x55, 0xE2, 0x20, 0x52,
  0x72, 0x70, 0x24, 0x79, 0x99, 0x60, 0x64, 0xA5, 0x00, 0x75, 0x57, 0x99,
  0xE0, 0xF6, 0xDE, 0x70, 0x08, 0x08, 0x34, 0x42, 0x26, 0x42, 0x2C, 0xE4,
  0xA8, 0x00, 0x3C, 0x85, 0x6D, 0x5A, 0xB7, 0xA0, 0x30, 0x22, 0x55, 0xB9,
  0x00, 0x75, 0x57, 0x89, 0xF0, 0x79, 0x88, 0x88, 0xE0, 0x52, 0x52, 0x98,
  0xCA, 0x80, 0x52, 0x10, 0xC8, 0x42, 0x80, 0x52, 0x10, 0xC8, 0x42, 0x00,
  0x78, 0x88, 0x89, 0xE0, 0x42, 0x52, 0xD8, 0xC6, 0x00, 0x55, 0xA0, 0x01,
  0x11, 0x19, 0xE0, 0x4A, 0x98, 0x8A, 0x4A, 0x40, 0x49, 0x29, 0x20, 0x41,
  0x14, 0xD3, 0xB6, 0xDA, 0x00, 0x42, 0x5A, 0xD9, 0xCA, 0x40, 0x3A, 0x63,
  0x18, 0xC9, 0xC0, 0x72, 0x52, 0xE8, 0x42, 0x00, 0x3A, 0x63, 0x18, 0xC9,
  0xC2, 0x72, 0x52, 0xE8, 0x4A, 0x40, 0x72, 0x10, 0x41, 0x4B, 0xC0, 0x64,
  0x44, 0x44, 0x00, 0x89, 0x99, 0x9A, 0xE0, 0x19, 0xAA, 0xC4, 0x00, 0x02,
  0x9A, 0x76, 0xDA, 0x49, 0x00, 0x0A, 0x88, 0x46, 0x2A, 0x40, 0x1A, 0xAC,
  0x44, 0x00, 0x38, 0x88, 0x44, 0x43, 0x80, 0x49, 0x49, 0x20, 0x7E, 0x24,
  0x94, 0x92, 0x4C, 0x80, 0x40, 0x80, 0x71, 0x59, 0xE0, 0x44, 0x79, 0x99,
  0xE0, 0x79, 0x88, 0xE0, 0x01, 0x79, 0x99, 0xA0, 0x7B, 0x88, 0xE0, 0x2A,
  0xA0, 0x79, 0x99, 0xA2, 0xE0, 0x44, 0x79, 0x99, 0x80, 0x42, 0xA8, 0x20,
  0x24, 0x92, 0x00, 0x44, 0x4A, 0xCA, 0x80, 0x55, 0xA8, 0x7E, 0x59, 0x65,
  0x84, 0x79, 0x99, 0x80, 0x79, 0x99, 0xA0, 0x79, 0x99, 0xE8, 0x00, 0x79,
  0x99, 0xA2, 0x00, 0x52, 0x48, 0x48, 0x62, 0xE0, 0x55, 0x80, 0x09, 0x99,
  0xE0, 0x3B, 0x48, 0x0E, 0xAD, 0x4A, 0x00, 0x06, 0x44, 0xA0, 0x1A, 0x64,
  0x44, 0x80, 0x12, 0x44, 0xC0, 0x29, 0x20, 0x14, 0x00, 0x56, 0xAA, 0x04,
  0x92, 0x12, 0x00, 0x97,
};

const GFXglyph RobotoCondensed_ExtraLightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 2, 1, -7 },
  { 4, 5, 7, 4, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 4, 7, 6, 1, -7 },
  { 18, 4, 7, 5, 0, -7 },
  { 22, 1, 2, 1, 1, -7 },
  { 23, 3, 9, 2, 0, -7 },
  { 27, 3, 9, 2, -1, -7 },
  { 31, 3, 4, 4, 1, -7 },
  { 33, 4, 4, 4, 0, -5 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 2, 1, 2, 0, -4 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 3, 8, 3, 0, -7 },
  { 41, 4, 7, 4, 0, -7 },
  { 45, 2, 7, 4, 1, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 3, 7, 4, 1, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 3, 7, 4, 1, -7 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 3, 7, 4, 1, -7 },
  { 76, 1, 5, 2, 0, -5 },
  { 77, 1, 6, 2, 0, -5 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 4, 2, 4, 0, -4 },
  { 81, 4, 4, 4, 0, -5 },
  { 83, 3, 7, 3, 1, -7 },
  { 86, 7, 8, 7, 0, -6 },
  { 93, 4, 7, 5, 0, -7 },
  { 97, 4, 7, 5, 0, -7 },
  { 101, 4, 7, 5, 1, -7 },
  { 105, 5, 7, 5, 0, -7 },
  { 110, 5, 7, 4, 0, -7 },
  { 115, 5, 7, 4, 0, -7 },
  { 120, 4, 7, 5, 1, -7 },
  { 124, 5, 7, 5, 0, -7 },
  { 129, 2, 7, 2, 0, -7 },
  { 131, 4, 7, 4, 0, -7 },
  { 135, 5, 7, 5, 0, -7 },
  { 140, 3, 7, 4, 0, -7 },
  { 143, 6, 7, 7, 0, -7 },
  { 149, 5, 7, 5, 0, -7 },
  { 154, 5, 7, 5, 0, -7 },
  { 159, 5, 7, 5, 0, -7 },
  { 164, 5, 8, 5, 0, -7 },
  { 169, 5, 7, 5, 0, -7 },
  { 174, 5, 7, 5, 0, -7 },
  { 179, 4, 7, 5, 1, -7 },
  { 183, 4, 7, 5, 1, -7 },
  { 187, 4, 7, 5, 1, -7 },
  { 191, 6, 7, 7, 1, -7 },
  { 197, 5, 7, 5, 0, -7 },
  { 202, 4, 7, 5, 1, -7 },
  { 206, 5, 7, 5, 0, -7 },
  { 211, 3, 8, 2, 0, -7 },
  { 214, 1, 8, 3, 1, -7 },
  { 215, 3, 8, 2, -1, -7 },
  { 218, 3, 3, 3, 0, -7 },
  { 220, 3, 1, 3, 0, 0 },
  { 221, 1, 2, 2, 1, -8 },
  { 222, 4, 5, 4, 0, -5 },
  { 225, 4, 7, 4, 0, -7 },
  { 229, 4, 5, 4, 0, -5 },
  { 232, 4, 7, 4, 0, -7 },
  { 236, 4, 5, 4, 0, -5 },
  { 239, 2, 7, 3, 1, -7 },
  { 241, 4, 7, 4, 0, -5 },
  { 245, 4, 7, 4, 0, -7 },
  { 249, 2, 7, 2, 0, -7 },
  { 251, 3, 9, 2, -1, -7 },
  { 255, 4, 7, 4, 0, -7 },
  { 259, 2, 7, 2, 0, -7 },
  { 261, 6, 5, 7, 0, -5 },
  { 265, 4, 5, 4, 0, -5 },
  { 268, 4, 5, 4, 0, -5 },
  { 271, 4, 7, 4, 0, -5 },
  { 275, 4, 7, 4, 0, -5 },
  { 279, 3, 5, 3, 0, -5 },
  { 281, 4, 5, 4, 0, -5 },
  { 284, 2, 6, 3, 0, -6 },
  { 286, 4, 5, 4, 0, -5 },
  { 289, 3, 5, 4, 1, -5 },
  { 291, 5, 5, 6, 1, -5 },
  { 295, 4, 5, 4, 0, -5 },
  { 298, 4, 7, 4, 0, -5 },
  { 302, 4, 5, 4, 0, -5 },
  { 305, 3, 9, 3, 0, -7 },
  { 309, 2, 8, 2, 0, -7 },
  { 311, 3, 9, 3, -1, -7 },
  { 315, 4, 2, 5, 1, -4 },
};

const GFXfont RobotoCondensed_ExtraLightItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC9PT7B_H_
