#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC7PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0x00, 0x07, 0x6E, 0x00, 0x0A, 0x23, 0xC0, 0x99, 0x76, 0x6D,
  0x5E, 0x00, 0x1A, 0xA8, 0x15, 0x68, 0x0A, 0x00, 0x09, 0x20, 0x80, 0x00,
  0x00, 0x09, 0x40, 0x76, 0xDE, 0xF8, 0x24, 0xAC, 0x25, 0x1E, 0x25, 0xF0,
  0x48, 0x96, 0x5A, 0xDE, 0x56, 0x00, 0x75, 0x5E, 0x76, 0xB4, 0x00, 0x10,
  0x39, 0x00, 0x1C, 0x07, 0x00, 0x58, 0x00, 0x3B, 0x67, 0xBD, 0x41, 0x00,
  0x2D, 0xF0, 0x75, 0xDE, 0x79, 0x88, 0xE0, 0x29, 0x99, 0xE0, 0x28, 0x68,
  0xC0, 0x28, 0x68, 0x80, 0x78, 0x88, 0xF0, 0x09, 0x79, 0x80, 0x78, 0x04,
  0x9E, 0x0A, 0x4A, 0x80, 0x12, 0x4C, 0x4A, 0x77, 0xDA, 0x00, 0x4D, 0xBB,
  0xA0, 0x79, 0x99, 0xE0, 0x79, 0xA8, 0x80, 0x79, 0x99, 0xE0, 0x79, 0x8A,
  0x80, 0x48, 0x42, 0xE0, 0x4A, 0x48, 0x09, 0x99, 0xE0, 0x37, 0x48, 0x06,
  0xAD, 0x42, 0x00, 0x06, 0x46, 0x80, 0x3A, 0x48, 0x32, 0x44, 0xC0, 0x5A,
  0xA0, 0x78, 0x7E, 0x58, 0x00, 0x80, 0x66, 0xC0, 0x0E, 0xDE, 0x72, 0x60,
  0x0E, 0xDA, 0x7E, 0x40, 0x5A, 0x48, 0x56, 0xD4, 0x0E, 0xD8, 0x38, 0x05,
  0x50, 0x15, 0x68, 0x78, 0x7D, 0x6A, 0x00, 0x76, 0xC0, 0x76, 0xD0, 0x76,
  0xF0, 0x56, 0xD0, 0x6A, 0x51, 0xF0, 0x3A, 0x80, 0x16, 0xE0, 0x97, 0x20,
  0x5E, 0x80, 0x29, 0x40, 0x97, 0x28, 0x00, 0x69, 0x00, 0x50, 0x80, 0x78,
  0x10, 0xA0, 0x52,
};

const GFXglyph RobotoCondensed_ExtraLightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 1, 1, 2, 1, -5 },
  { 3, 4, 5, 3, 0, -5 },
  { 6, 3, 7, 3, 0, -6 },
  { 9, 3, 5, 4, 1, -5 },
  { 11, 3, 5, 4, 0, -5 },
  { 13, 1, 1, 1, 0, -5 },
  { 14, 2, 8, 2, 0, -6 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 3, 3, 3, 0, -5 },
  { 20, 3, 4, 3, 0, -4 },
  { 22, 1, 2, 1, 0, -1 },
  { 23, 2, 1, 2, 0, -3 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 3, 5, 2, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 1, 5, 3, 1, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 2, 5, 3, 1, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 1, 4, 1, 0, -4 },
  { 47, 1, 5, 1, 0, -4 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 2, 5, 3, 1, -5 },
  { 55, 5, 7, 5, 0, -5 },
  { 60, 3, 5, 4, 0, -5 },
  { 62, 3, 5, 4, 0, -5 },
  { 64, 4, 5, 4, 0, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 4, 5, 3, 0, -5 },
  { 73, 4, 5, 3, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 1, 5, 2, 0, -5 },
  { 83, 3, 5, 3, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 3, 5, 3, 0, -5 },
  { 90, 5, 5, 5, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 6, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 3, 5, 4, 1, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 3, 5, 4, 1, -5 },
  { 119, 5, 5, 5, 1, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 3, 5, 4, 1, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 2, 7, 1, 0, -6 },
  { 133, 1, 5, 2, 1, -5 },
  { 134, 1, 7, 1, 0, -6 },
  { 135, 2, 3, 3, 0, -5 },
  { 136, 2, 1, 3, 0, 0 },
  { 137, 1, 1, 2, 1, -5 },
  { 138, 3, 4, 3, 0, -4 },
  { 140, 3, 5, 3, 0, -5 },
  { 142, 3, 4, 3, 0, -4 },
  { 144, 3, 5, 3, 0, -5 },
  { 146, 3, 4, 3, 0, -4 },
  { 148, 3, 5, 2, 0, -5 },
  { 150, 3, 5, 3, 0, -4 },
  { 152, 3, 5, 3, 0, -5 },
  { 154, 1, 5, 1, 0, -5 },
  { 155, 2, 7, 1, -1, -5 },
  { 157, 3, 5, 3, 0, -5 },
  { 159, 1, 5, 1, 0, -5 },
  { 160, 5, 4, 5, 0, -4 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 3, 5, 3, 0, -4 },
  { 169, 3, 5, 3, 0, -4 },
  { 171, 2, 4, 2, 0, -4 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 2, 5, 2, 0, -5 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 3, 4, 4, 1, -4 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 3, 6, 3, 0, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 2, 6, 2, 0, -5 },
  { 191, 1, 6, 1, 0, -5 },
  { 192, 2, 6, 2, 0, -5 },
  { 194, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_ExtraLightItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC7PT7B_H_
