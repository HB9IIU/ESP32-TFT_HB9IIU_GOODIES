#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC32PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x21, 0x08, 0x46, 0x31, 0x08, 0x42, 0x11, 0x08, 0x40,
  0x00, 0x00, 0x42, 0x00, 0x65, 0x14, 0xD2, 0x49, 0x24, 0x80, 0x00, 0x86,
  0x00, 0x84, 0x01, 0x84, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08, 0x02, 0x08,
  0x3F, 0xFF, 0x02, 0x10, 0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20,
  0x08, 0x40, 0x08, 0x40, 0xFF, 0xF8, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80,
  0x21, 0x00, 0x21, 0x00, 0x41, 0x00, 0x43, 0x00, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x07, 0xC0, 0x63, 0x04, 0x0C, 0x60, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x00, 0x20, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0D, 0x00, 0x28, 0x03, 0x60, 0x11, 0x00, 0x88, 0x08, 0x31,
  0xC0, 0xF8, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x44, 0x01,
  0x08, 0x02, 0x10, 0x68, 0x20, 0x90, 0x42, 0x20, 0x8C, 0x41, 0x10, 0x86,
  0x40, 0x99, 0x01, 0xE2, 0x00, 0x08, 0x00, 0x23, 0x80, 0xC8, 0x81, 0x20,
  0x84, 0x41, 0x10, 0x82, 0x23, 0x04, 0x84, 0x12, 0x08, 0x24, 0x08, 0x40,
  0x11, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x18, 0x80, 0x43, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x80, 0x82, 0x02, 0x10, 0x09, 0x80, 0x1C, 0x00, 0x60, 0x02,
  0x80, 0x13, 0x00, 0x84, 0x14, 0x18, 0x50, 0x23, 0x80, 0xCA, 0x01, 0x68,
  0x03, 0x30, 0x08, 0x40, 0x51, 0x86, 0x61, 0xF0, 0x80, 0x49, 0x25, 0xA0,
  0x01, 0x03, 0x06, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04,
  0x06, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x00, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x82, 0x1F, 0x6E, 0x1F, 0x80, 0x60, 0x0A, 0x01, 0x30, 0x31,
  0x06, 0x18, 0x40, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x32, 0x22, 0x64, 0x80,
  0xFC, 0xF0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x00, 0x07, 0xC0, 0xC6, 0x18, 0x23,
  0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0x80, 0x48,
  0x08, 0xC1, 0x86, 0x30, 0x3C, 0x00, 0x02, 0x3D, 0xCE, 0x10, 0x60, 0x81,
  0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81,
  0x06, 0x08, 0x00, 0x03, 0xE0, 0x61, 0x82, 0x04, 0x20, 0x33, 0x00, 0x90,
  0x04, 0x80, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x61, 0x82, 0x06, 0x20, 0x13,
  0x00, 0x90, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x38, 0x0F,
  0x00, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09,
  0x80, 0x44, 0x04, 0x18, 0xC0, 0x7C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x1C,
  0x00, 0xA0, 0x09, 0x00, 0xD8, 0x04, 0xC0, 0x44, 0x06, 0x20, 0x21, 0x02,
  0x08, 0x20, 0xC3, 0x04, 0x10, 0x21, 0x01, 0x18, 0x08, 0xFF, 0xF8, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xF8, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x2F, 0x81,
  0xC6, 0x08, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x24, 0x01, 0x20, 0x11, 0x00, 0x84, 0x08, 0x30, 0xC0, 0x78, 0x00, 0x00,
  0xE0, 0x60, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x4F, 0x8B,
  0x1B, 0x81, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x40, 0x6C, 0x08, 0xC6, 0x0F, 0x80, 0xFF, 0xF0, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x18, 0xC0, 0x81, 0x86,
  0x02, 0x10, 0x08, 0x40, 0x23, 0x00, 0x8C, 0x02, 0x10, 0x18, 0x40, 0xC0,
  0x86, 0x03, 0xE0, 0x10, 0x60, 0x80, 0x84, 0x01, 0x30, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x03, 0x20, 0x08, 0x40, 0x41, 0x86, 0x01, 0xF0, 0x00, 0x07,
  0x81, 0x86, 0x10, 0x22, 0x03, 0x60, 0x14, 0x01, 0x40, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x34, 0x06, 0x40, 0xE3, 0x1A, 0x1E, 0x20, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0xC0, 0x70, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x20, 0x86, 0x10,
  0x80, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x20, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0x80, 0x00, 0x1E, 0x18, 0x98, 0x28, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x01, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x81, 0x80,
  0x18, 0x01, 0x00, 0xC0, 0x02, 0x06, 0x00, 0x08, 0x30, 0x00, 0x10, 0x80,
  0x00, 0x44, 0x07, 0x81, 0x10, 0x21, 0x04, 0x81, 0x04, 0x12, 0x08, 0x10,
  0x50, 0x60, 0x41, 0x41, 0x02, 0x05, 0x04, 0x08, 0x14, 0x20, 0x20, 0xA0,
  0x81, 0x82, 0x82, 0x04, 0x0A, 0x08, 0x10, 0x68, 0x20, 0xC1, 0x20, 0x85,
  0x0C, 0x83, 0x34, 0x62, 0x07, 0x0F, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x06, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0xE0, 0x02, 0x40, 0x04, 0x80,
  0x19, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x06, 0x10, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x07, 0xFE, 0x10, 0x04, 0x20, 0x0C,
  0x80, 0x09, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70, 0x00, 0x80, 0x0F, 0xF0,
  0x10, 0x30, 0x20, 0x30, 0xC0, 0x21, 0x80, 0x42, 0x00, 0x84, 0x01, 0x08,
  0x02, 0x10, 0x0C, 0x60, 0x30, 0x80, 0xC1, 0xFF, 0x02, 0x03, 0x04, 0x03,
  0x08, 0x02, 0x30, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x84,
  0x03, 0x18, 0x0C, 0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10,
  0x80, 0x23, 0x00, 0x64, 0x00, 0x58, 0x00, 0xA0, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x46, 0x00, 0x84, 0x02, 0x06, 0x18, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x08, 0x18, 0x08, 0x04, 0x18, 0x06, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x03, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60, 0x04, 0x40, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0x40, 0x10, 0x40, 0x30, 0xC0, 0xC0, 0xFF, 0x00,
  0x0F, 0xFE, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x3F, 0xF0,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x0C, 0x38,
  0x30, 0x10, 0xC0, 0x31, 0x00, 0x24, 0x00, 0x48, 0x00, 0xB0, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x0F, 0xD8, 0x00, 0xA0, 0x01,
  0x40, 0x06, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x22, 0x00, 0x46, 0x01, 0x86,
  0x1C, 0x07, 0xE0, 0x00, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x08, 0x60,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x61, 0x00, 0x18, 0x40, 0x04, 0x10, 0x01,
  0x0C, 0x00, 0x42, 0x00, 0x10, 0xFF, 0xFC, 0x20, 0x03, 0x08, 0x00, 0x82,
  0x00, 0x21, 0x80, 0x08, 0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x04, 0x30, 0x01, 0x08, 0x00, 0x40, 0x18, 0x84, 0x21, 0x08,
  0xC4, 0x21, 0x08, 0xC6, 0x21, 0x08, 0x46, 0x31, 0x08, 0x42, 0x00, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x80, 0x22, 0x01, 0x88, 0x04, 0x20, 0x30, 0xC0, 0x81,
  0x8C, 0x03, 0xE0, 0x00, 0x08, 0x01, 0x04, 0x01, 0x82, 0x01, 0x83, 0x01,
  0x81, 0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x11, 0x80, 0x19,
  0x80, 0x09, 0x80, 0x05, 0xE0, 0x03, 0x90, 0x01, 0x8C, 0x00, 0x82, 0x00,
  0xC1, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x08, 0x06, 0x04, 0x01,
  0x06, 0x00, 0xC2, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x3F,
  0xF8, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x87, 0x00, 0x0E,
  0x14, 0x00, 0x28, 0x58, 0x01, 0xA1, 0x20, 0x05, 0x84, 0x80, 0x26, 0x12,
  0x00, 0x90, 0xC8, 0x04, 0x42, 0x20, 0x11, 0x08, 0x40, 0x84, 0x21, 0x02,
  0x30, 0x84, 0x10, 0x82, 0x10, 0x42, 0x18, 0x42, 0x08, 0x41, 0x08, 0x21,
  0x02, 0x40, 0x84, 0x09, 0x06, 0x10, 0x28, 0x10, 0x40, 0xA0, 0x43, 0x03,
  0x01, 0x08, 0x0C, 0x04, 0x00, 0x08, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x08,
  0x78, 0x02, 0x1A, 0x00, 0x84, 0x80, 0x21, 0x30, 0x18, 0x44, 0x06, 0x11,
  0x01, 0x0C, 0x20, 0x43, 0x08, 0x10, 0x83, 0x04, 0x20, 0x43, 0x08, 0x10,
  0x82, 0x06, 0x21, 0x80, 0x88, 0x40, 0x22, 0x10, 0x04, 0x84, 0x01, 0x61,
  0x00, 0x70, 0x40, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC0, 0x03, 0xF0, 0x0C,
  0x30, 0x20, 0x10, 0x80, 0x33, 0x00, 0x24, 0x00, 0x58, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x66, 0x00, 0x84, 0x02,
  0x06, 0x18, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x10, 0x18, 0x20, 0x18, 0xC0,
  0x11, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x06, 0x60, 0x08,
  0x80, 0x31, 0x01, 0xC3, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x00, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x33, 0x00, 0x24, 0x00,
  0x58, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x1E, 0x00, 0x28,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x66, 0x00, 0x84, 0x02, 0x06, 0x18, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x0F, 0xF0, 0x10, 0x18, 0x20, 0x18, 0xC0, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x06, 0x60, 0x08, 0x80,
  0x21, 0x01, 0x83, 0xFE, 0x04, 0x08, 0x08, 0x18, 0x30, 0x10, 0x40, 0x20,
  0x80, 0x41, 0x00, 0x42, 0x00, 0x8C, 0x01, 0x18, 0x03, 0x20, 0x02, 0x00,
  0x01, 0xF0, 0x0C, 0x38, 0x20, 0x10, 0xC0, 0x31, 0x00, 0x26, 0x00, 0x4C,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x26,
  0x00, 0x84, 0x03, 0x06, 0x1C, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0xC0, 0x30, 0x40, 0x60, 0x70, 0xC0,
  0x1F, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x36, 0x00, 0x4C, 0x00, 0x88,
  0x02, 0x10, 0x04, 0x20, 0x18, 0x40, 0x20, 0x80, 0xC1, 0x81, 0x01, 0x06,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x64, 0x00,
  0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xB0, 0x14, 0x02, 0xC0, 0x50, 0x1B,
  0x03, 0x40, 0x44, 0x09, 0x01, 0x10, 0x24, 0x0C, 0x41, 0x18, 0x21, 0x04,
  0x20, 0x84, 0x30, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08, 0xC1, 0x10, 0x22,
  0x04, 0x40, 0x88, 0x13, 0x02, 0x60, 0x48, 0x09, 0x01, 0x20, 0x24, 0x05,
  0x00, 0xB0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x10, 0x06, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x84, 0x00, 0x83, 0x00, 0xC0, 0x80, 0xC0, 0x40,
  0x40, 0x10, 0x40, 0x08, 0x60, 0x06, 0x20, 0x01, 0x20, 0x00, 0xB0, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x14, 0x00, 0x1A, 0x00, 0x09, 0x80, 0x08, 0x40,
  0x0C, 0x20, 0x0C, 0x18, 0x04, 0x04, 0x04, 0x03, 0x06, 0x00, 0x82, 0x00,
  0x42, 0x00, 0x30, 0xC0, 0x07, 0x80, 0x09, 0x00, 0x22, 0x00, 0xC6, 0x01,
  0x04, 0x04, 0x08, 0x18, 0x18, 0x20, 0x10, 0x80, 0x23, 0x00, 0x44, 0x00,
  0x50, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0x82, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0xC0, 0xC6,
  0x10, 0x84, 0x21, 0x08, 0x61, 0x08, 0x42, 0x10, 0x86, 0x10, 0x84, 0x21,
  0x08, 0x61, 0x08, 0x07, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x83, 0xC0, 0x06, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x23, 0x21, 0x41, 0xC1,
  0x81, 0x7F, 0xF0, 0x46, 0x23, 0x03, 0xE0, 0x71, 0x86, 0x04, 0x20, 0x33,
  0x01, 0x80, 0x08, 0x00, 0x40, 0xFE, 0x18, 0x11, 0x00, 0x98, 0x0C, 0x80,
  0x44, 0x02, 0x20, 0x31, 0x02, 0x8C, 0x64, 0x3E, 0x20, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x3C, 0x3C, 0x33, 0x81,
  0x30, 0x12, 0x01, 0x20, 0x12, 0x01, 0x60, 0x14, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x34, 0x02, 0xC0, 0x6C, 0x04, 0xB1, 0x89, 0xF0, 0x07, 0xC1, 0x86,
  0x30, 0x22, 0x01, 0x60, 0x14, 0x01, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x02, 0x80, 0x48, 0x04, 0x40, 0x86, 0x18, 0x3E, 0x00, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81,
  0xE2, 0x18, 0x48, 0x40, 0xE2, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x44,
  0x01, 0x10, 0x0C, 0xC0, 0x23, 0x00, 0x88, 0x02, 0x20, 0x08, 0xC0, 0x61,
  0x03, 0x86, 0x14, 0x0F, 0x90, 0x07, 0xC1, 0x86, 0x30, 0x22, 0x01, 0x60,
  0x14, 0x01, 0x40, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x46, 0x18, 0x1F, 0x00, 0x03, 0xC1, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x03, 0xF8, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x03, 0xC4, 0x30, 0x90, 0x81, 0xC4, 0x02, 0x10, 0x08, 0x80, 0x22,
  0x00, 0x88, 0x02, 0x20, 0x19, 0x80, 0x46, 0x01, 0x10, 0x04, 0x60, 0x11,
  0x80, 0xC2, 0x07, 0x0C, 0x28, 0x1F, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x43, 0x03, 0x06, 0x18, 0x0F, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x3C, 0x34, 0x22, 0x83, 0x30, 0x13,
  0x01, 0x20, 0x12, 0x01, 0x60, 0x34, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x02, 0xC0, 0x68, 0x04, 0x80, 0x48, 0x04, 0x08, 0xC0, 0x00, 0x00, 0x42,
  0x31, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x42, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x38, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x02, 0x30, 0x21, 0x02, 0x08, 0x20, 0x42, 0x02, 0x60, 0x16, 0x01, 0xE0,
  0x0E, 0x80, 0x64, 0x02, 0x10, 0x10, 0x80, 0x82, 0x0C, 0x10, 0x40, 0x42,
  0x02, 0x10, 0x08, 0x08, 0x42, 0x31, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10,
  0x8C, 0x42, 0x10, 0x84, 0x62, 0x10, 0x33, 0xC1, 0xE1, 0x21, 0x18, 0x8A,
  0x0D, 0x02, 0x60, 0x30, 0x12, 0x01, 0x80, 0x90, 0x08, 0x05, 0x80, 0x40,
  0x28, 0x06, 0x01, 0x40, 0x20, 0x1A, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80,
  0x40, 0x2C, 0x02, 0x01, 0x40, 0x30, 0x0A, 0x01, 0x00, 0xD0, 0x08, 0x04,
  0x80, 0x40, 0x20, 0x13, 0xC3, 0x62, 0x28, 0x33, 0x01, 0x30, 0x12, 0x01,
  0x20, 0x16, 0x03, 0x40, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40, 0x2C, 0x06,
  0x80, 0x48, 0x04, 0x80, 0x40, 0x07, 0xC0, 0x63, 0x04, 0x0C, 0x40, 0x22,
  0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x16, 0x00, 0xA0, 0x05, 0x00,
  0x6C, 0x02, 0x20, 0x31, 0x01, 0x04, 0x30, 0x1F, 0x00, 0x09, 0xE0, 0xF0,
  0x86, 0x02, 0x30, 0x11, 0x00, 0x88, 0x04, 0x40, 0x26, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x02, 0x40, 0x32, 0x01, 0x30, 0x19, 0x80, 0x8B, 0x18, 0x4F,
  0x82, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x07, 0x88, 0xC2, 0x44, 0x0E, 0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x02, 0x40, 0x36, 0x01, 0x30, 0x09, 0x00, 0x4C, 0x02, 0x60, 0x31, 0x03,
  0x8C, 0x38, 0x3E, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x13, 0x9E, 0x0A, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x00, 0x0F,
  0x83, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x28, 0x05, 0x00, 0xA0, 0x23, 0x1C, 0x3E, 0x00, 0x10,
  0x20, 0x40, 0x8F, 0xE6, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10,
  0x20, 0xC1, 0x02, 0x06, 0x07, 0x00, 0x20, 0x16, 0x03, 0x40, 0x24, 0x02,
  0x40, 0x24, 0x02, 0xC0, 0x2C, 0x06, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04,
  0x80, 0xC8, 0x0C, 0x81, 0x8C, 0x28, 0x7C, 0x80, 0x80, 0x28, 0x02, 0xC0,
  0x44, 0x04, 0x40, 0x84, 0x08, 0x41, 0x84, 0x10, 0x43, 0x06, 0x20, 0x22,
  0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x03, 0x00, 0x10, 0x00, 0x80, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x50, 0x70, 0x28, 0x28, 0x34, 0x14, 0x12, 0x13,
  0x19, 0x08, 0x88, 0x88, 0x44, 0x44, 0x26, 0x26, 0x12, 0x12, 0x0B, 0x0B,
  0x05, 0x05, 0x02, 0x83, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x00, 0x08,
  0x0C, 0x20, 0x20, 0xC1, 0x01, 0x0C, 0x06, 0x20, 0x09, 0x00, 0x2C, 0x00,
  0x60, 0x01, 0x00, 0x0E, 0x00, 0x68, 0x03, 0x20, 0x08, 0x40, 0x41, 0x03,
  0x06, 0x08, 0x08, 0x40, 0x30, 0x10, 0x04, 0x30, 0x08, 0x60, 0x30, 0x40,
  0x40, 0x81, 0x81, 0x02, 0x02, 0x0C, 0x04, 0x10, 0x08, 0x60, 0x18, 0x80,
  0x11, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0x60, 0x30, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x01, 0x80, 0xC0, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x08, 0x46,
  0x21, 0x08, 0x42, 0x31, 0x88, 0x42, 0x10, 0x8C, 0x42, 0x10, 0x84, 0x62,
  0x10, 0x84, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x40, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x0C, 0x06, 0x02, 0x00, 0x3C, 0x02, 0xCC, 0x09, 0x0C,
  0x14, 0x0C, 0x48, 0x07, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 6, 1, -23 },
  { 16, 6, 7, 8, 3, -24 },
  { 22, 16, 23, 15, 1, -23 },
  { 68, 13, 29, 15, 1, -26 },
  { 116, 15, 23, 20, 3, -23 },
  { 160, 14, 23, 17, 1, -23 },
  { 201, 3, 7, 5, 3, -24 },
  { 204, 8, 32, 9, 2, -25 },
  { 236, 9, 32, 9, -2, -25 },
  { 272, 12, 13, 13, 2, -23 },
  { 292, 13, 17, 15, 1, -19 },
  { 320, 4, 7, 6, -1, -3 },
  { 324, 6, 1, 8, 1, -11 },
  { 325, 2, 2, 7, 1, -2 },
  { 326, 13, 25, 11, -1, -23 },
  { 367, 12, 23, 15, 2, -23 },
  { 402, 7, 23, 15, 4, -23 },
  { 423, 13, 23, 15, 1, -23 },
  { 461, 13, 23, 15, 1, -23 },
  { 499, 13, 23, 15, 1, -23 },
  { 537, 13, 23, 15, 2, -23 },
  { 575, 11, 23, 15, 2, -23 },
  { 607, 12, 23, 15, 3, -23 },
  { 642, 14, 23, 15, 1, -23 },
  { 683, 12, 23, 15, 2, -23 },
  { 718, 5, 17, 6, 0, -17 },
  { 729, 6, 21, 6, -1, -17 },
  { 745, 12, 13, 14, 1, -17 },
  { 765, 12, 7, 15, 2, -14 },
  { 776, 12, 13, 14, 1, -17 },
  { 796, 9, 23, 12, 3, -23 },
  { 822, 22, 29, 25, 1, -22 },
  { 902, 15, 23, 17, -1, -23 },
  { 946, 15, 23, 17, 1, -23 },
  { 990, 15, 23, 18, 2, -23 },
  { 1034, 16, 23, 18, 1, -23 },
  { 1080, 16, 23, 16, 1, -23 },
  { 1126, 16, 23, 15, 1, -23 },
  { 1172, 15, 23, 19, 2, -23 },
  { 1216, 18, 23, 19, 1, -23 },
  { 1268, 5, 23, 8, 2, -23 },
  { 1283, 14, 23, 15, 1, -23 },
  { 1324, 17, 23, 17, 1, -23 },
  { 1373, 11, 23, 14, 1, -23 },
  { 1405, 22, 23, 23, 1, -23 },
  { 1469, 18, 23, 19, 1, -23 },
  { 1521, 15, 23, 18, 2, -23 },
  { 1565, 15, 23, 17, 1, -23 },
  { 1609, 15, 27, 18, 2, -23 },
  { 1660, 15, 23, 17, 1, -23 },
  { 1704, 15, 23, 16, 1, -23 },
  { 1748, 15, 23, 16, 3, -23 },
  { 1792, 16, 23, 18, 2, -23 },
  { 1838, 15, 23, 17, 3, -23 },
  { 1882, 22, 23, 24, 3, -23 },
  { 1946, 17, 23, 16, 0, -23 },
  { 1995, 15, 23, 16, 3, -23 },
  { 2039, 17, 23, 16, 0, -23 },
  { 2088, 9, 31, 7, 0, -26 },
  { 2123, 5, 25, 11, 3, -23 },
  { 2139, 9, 31, 7, -2, -26 },
  { 2174, 8, 11, 12, 2, -23 },
  { 2185, 12, 1, 12, -2, 0 },
  { 2187, 4, 4, 8, 4, -24 },
  { 2189, 13, 17, 15, 0, -17 },
  { 2217, 12, 24, 15, 1, -24 },
  { 2253, 12, 17, 14, 1, -17 },
  { 2279, 14, 24, 15, 1, -24 },
  { 2321, 12, 17, 14, 1, -17 },
  { 2347, 10, 24, 9, 2, -24 },
  { 2377, 14, 24, 15, 0, -17 },
  { 2419, 12, 24, 15, 1, -24 },
  { 2455, 5, 23, 6, 1, -23 },
  { 2470, 10, 30, 6, -4, -23 },
  { 2508, 13, 24, 13, 1, -24 },
  { 2547, 5, 24, 6, 1, -24 },
  { 2562, 21, 17, 24, 1, -17 },
  { 2607, 12, 17, 15, 1, -17 },
  { 2633, 13, 17, 15, 1, -17 },
  { 2661, 13, 24, 15, 0, -17 },
  { 2700, 13, 24, 15, 1, -17 },
  { 2739, 9, 17, 9, 1, -17 },
  { 2759, 11, 17, 14, 1, -17 },
  { 2783, 7, 21, 9, 2, -21 },
  { 2802, 12, 17, 15, 2, -17 },
  { 2828, 12, 17, 13, 2, -17 },
  { 2854, 17, 17, 20, 3, -17 },
  { 2891, 14, 17, 13, -1, -17 },
  { 2921, 15, 24, 13, -1, -17 },
  { 2966, 13, 17, 13, 0, -17 },
  { 2994, 10, 32, 9, 1, -25 },
  { 3034, 5, 27, 6, 1, -23 },
  { 3051, 10, 32, 9, -2, -25 },
  { 3091, 15, 5, 19, 2, -12 },
};

const GFXfont RobotoCondensed_ExtraLightItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC32PT7B_H_
