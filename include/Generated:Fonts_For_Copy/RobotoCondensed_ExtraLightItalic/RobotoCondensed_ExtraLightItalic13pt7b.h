#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC13PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x15, 0x40, 0x80, 0x36, 0x00, 0x00, 0x28, 0x79, 0x22, 0x85, 0x17,
  0x28, 0x10, 0x00, 0xE4, 0x51, 0x40, 0xC0, 0x82, 0x89, 0x42, 0x00, 0x62,
  0x5A, 0xAC, 0x10, 0xB5, 0x45, 0x14, 0x18, 0xA2, 0x8C, 0x21, 0x48, 0xE2,
  0x74, 0x60, 0x29, 0x49, 0x24, 0x92, 0x40, 0x21, 0x11, 0x11, 0x11, 0x22,
  0x24, 0x80, 0x21, 0x3C, 0xC9, 0x00, 0x21, 0x1C, 0x44, 0x20, 0xE0, 0x40,
  0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x40, 0x00, 0x74, 0x63, 0x18,
  0xC6, 0x52, 0xE0, 0x65, 0x24, 0x92, 0x00, 0x39, 0x14, 0x42, 0x08, 0x42,
  0x10, 0xF0, 0x39, 0x14, 0x41, 0x38, 0x28, 0xA2, 0x70, 0x00, 0x21, 0x8A,
  0x29, 0x2E, 0x84, 0x00, 0x72, 0x10, 0xE0, 0x84, 0x32, 0xE0, 0x34, 0x8F,
  0x99, 0x99, 0xE0, 0x78, 0x44, 0x22, 0x11, 0x08, 0x80, 0x39, 0x14, 0x51,
  0x39, 0x28, 0x62, 0x70, 0x74, 0x63, 0x19, 0x38, 0x42, 0xE0, 0x40, 0x08,
  0x40, 0x0A, 0x80, 0x16, 0x84, 0x30, 0x73, 0x00, 0x60, 0x82, 0x6C, 0x00,
  0x79, 0x12, 0x44, 0x00, 0x80, 0x0F, 0x08, 0x48, 0x29, 0xD5, 0x2C, 0x96,
  0x4B, 0x49, 0x9B, 0x40, 0x10, 0x07, 0x80, 0x08, 0x61, 0x8A, 0x29, 0xD4,
  0x61, 0x84, 0x3C, 0x94, 0x51, 0x59, 0x14, 0x61, 0x38, 0x39, 0x18, 0x60,
  0x82, 0x08, 0x22, 0x70, 0x1C, 0x45, 0x0A, 0x14, 0x28, 0x51, 0x42, 0x38,
  0x1C, 0x41, 0x02, 0x05, 0x08, 0x10, 0x40, 0x30, 0x1C, 0x41, 0x02, 0x07,
  0x08, 0x10, 0x40, 0x00, 0x39, 0x18, 0x20, 0x8A, 0x08, 0x62, 0x70, 0x00,
  0x21, 0x42, 0x42, 0x5A, 0x42, 0x42, 0x84, 0x00, 0x56, 0xAA, 0x00, 0x04,
  0x10, 0x41, 0x08, 0x28, 0xA2, 0x70, 0x02, 0x49, 0x22, 0x87, 0x0A, 0x12,
  0x44, 0x04, 0x01, 0x10, 0x84, 0x21, 0x10, 0x30, 0x20, 0x90, 0x58, 0x6A,
  0x55, 0x2A, 0xA5, 0x55, 0x32, 0x09, 0x00, 0x21, 0x21, 0x52, 0x52, 0x4A,
  0x4A, 0x4A, 0x84, 0x84, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x3C,
  0x45, 0x0A, 0x27, 0x88, 0x10, 0x40, 0x00, 0x39, 0x18, 0x61, 0x86, 0x18,
  0xA2, 0x70, 0x40, 0x80, 0x3C, 0x45, 0x0A, 0x27, 0x89, 0x12, 0x42, 0x04,
  0x3C, 0x85, 0x03, 0x01, 0x80, 0xA1, 0x42, 0x78, 0x78, 0x82, 0x08, 0x20,
  0x82, 0x10, 0x40, 0x02, 0x18, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x86, 0x18,
  0xA2, 0x51, 0x46, 0x18, 0x40, 0x88, 0xC4, 0x65, 0x32, 0xAA, 0x55, 0x32,
  0x98, 0x88, 0x44, 0x00, 0x42, 0x48, 0xA0, 0x81, 0x06, 0x12, 0x24, 0x84,
  0x86, 0x24, 0x94, 0x60, 0x82, 0x10, 0x40, 0x1E, 0x08, 0x20, 0x41, 0x04,
  0x10, 0x20, 0xF0, 0x22, 0x44, 0x44, 0x44, 0x48, 0x88, 0x80, 0xA9, 0x55,
  0x40, 0x11, 0x12, 0x22, 0x22, 0x22, 0x44, 0x40, 0x2D, 0xD0, 0x70, 0xC0,
  0x3A, 0x42, 0xF8, 0xC5, 0xA0, 0x02, 0x10, 0xF4, 0xA5, 0x31, 0x8F, 0x80,
  0x3A, 0x21, 0x08, 0x45, 0xC0, 0x00, 0x42, 0xF9, 0x4A, 0x52, 0x97, 0x80,
  0x3A, 0x6F, 0x08, 0x41, 0xC0, 0x34, 0x44, 0x88, 0x88, 0x80, 0x3D, 0x24,
  0xA2, 0x8A, 0x27, 0x82, 0x13, 0x80, 0x02, 0x10, 0xF4, 0xA5, 0x31, 0x8C,
  0x40, 0x20, 0x24, 0x92, 0x90, 0x08, 0x00, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x4C, 0x00, 0x01, 0x04, 0x12, 0x51, 0x86, 0x24, 0x92, 0x20, 0x05, 0x24,
  0x92, 0x90, 0x7B, 0xA2, 0x52, 0x29, 0x18, 0x8C, 0x46, 0x20, 0x7A, 0x52,
  0x98, 0xC6, 0x20, 0x39, 0x14, 0x61, 0x8A, 0x27, 0x00, 0x7A, 0x52, 0x98,
  0xC7, 0xD0, 0x80, 0x00, 0x7C, 0xA5, 0x29, 0x4B, 0xC2, 0x10, 0x00, 0x64,
  0x44, 0x88, 0x80, 0x3A, 0x10, 0x60, 0xC5, 0xC0, 0x4A, 0x49, 0x24, 0x80,
  0x8C, 0x65, 0x29, 0x4B, 0xC0, 0x0C, 0xA5, 0x4A, 0x61, 0x00, 0x93, 0x26,
  0xCD, 0xAC, 0x99, 0x22, 0x00, 0x4A, 0x4C, 0x45, 0x2A, 0x40, 0x02, 0x48,
  0x91, 0x42, 0x86, 0x04, 0x10, 0x20, 0x80, 0x38, 0x44, 0x44, 0x23, 0x80,
  0x12, 0x22, 0x22, 0x44, 0x44, 0x44, 0x20, 0x15, 0x55, 0xA8, 0x21, 0x11,
  0x11, 0x12, 0x22, 0x24, 0x80, 0xE4, 0x60,
};

const GFXglyph RobotoCondensed_ExtraLightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 2, 0, -9 },
  { 4, 3, 3, 3, 1, -10 },
  { 6, 7, 9, 6, 0, -9 },
  { 14, 6, 11, 6, 0, -10 },
  { 23, 6, 9, 8, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 1, 3, 2, 1, -10 },
  { 38, 3, 13, 4, 1, -10 },
  { 43, 4, 13, 4, -1, -10 },
  { 50, 5, 5, 5, 1, -9 },
  { 54, 5, 6, 6, 1, -7 },
  { 58, 1, 3, 2, 0, -1 },
  { 59, 3, 1, 3, 0, -5 },
  { 60, 1, 1, 3, 0, -1 },
  { 61, 6, 10, 4, -1, -9 },
  { 69, 5, 9, 6, 1, -9 },
  { 75, 3, 9, 6, 2, -9 },
  { 79, 6, 9, 6, 0, -9 },
  { 86, 6, 9, 6, 0, -9 },
  { 93, 6, 9, 6, 0, -9 },
  { 100, 5, 9, 6, 1, -9 },
  { 106, 4, 9, 6, 1, -9 },
  { 111, 5, 9, 6, 1, -9 },
  { 117, 6, 9, 6, 0, -9 },
  { 124, 5, 9, 6, 1, -9 },
  { 130, 2, 7, 2, 0, -7 },
  { 132, 2, 9, 2, 0, -7 },
  { 135, 4, 5, 6, 1, -7 },
  { 138, 5, 2, 6, 1, -5 },
  { 140, 5, 5, 6, 0, -7 },
  { 144, 4, 9, 5, 1, -9 },
  { 149, 9, 12, 10, 0, -9 },
  { 163, 6, 9, 7, 0, -9 },
  { 170, 6, 9, 7, 0, -9 },
  { 177, 6, 9, 7, 1, -9 },
  { 184, 7, 9, 7, 0, -9 },
  { 192, 7, 9, 6, 0, -9 },
  { 200, 7, 9, 6, 0, -9 },
  { 208, 6, 9, 8, 1, -9 },
  { 215, 8, 9, 8, 0, -9 },
  { 224, 2, 9, 3, 1, -9 },
  { 227, 6, 9, 6, 0, -9 },
  { 234, 7, 9, 7, 0, -9 },
  { 242, 5, 9, 6, 0, -9 },
  { 248, 9, 9, 9, 0, -9 },
  { 259, 8, 9, 8, 0, -9 },
  { 268, 6, 9, 7, 1, -9 },
  { 275, 7, 9, 7, 0, -9 },
  { 283, 6, 11, 7, 1, -9 },
  { 292, 7, 9, 7, 0, -9 },
  { 300, 7, 9, 7, 0, -9 },
  { 308, 6, 9, 7, 1, -9 },
  { 315, 6, 9, 7, 1, -9 },
  { 322, 6, 9, 7, 1, -9 },
  { 329, 9, 9, 10, 1, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 6, 9, 7, 1, -9 },
  { 355, 7, 9, 7, 0, -9 },
  { 363, 4, 13, 3, 0, -11 },
  { 370, 2, 10, 4, 1, -9 },
  { 373, 4, 13, 3, -1, -11 },
  { 380, 3, 5, 5, 1, -9 },
  { 382, 5, 1, 5, -1, 0 },
  { 383, 1, 2, 3, 2, -10 },
  { 384, 5, 7, 6, 0, -7 },
  { 389, 5, 10, 6, 0, -10 },
  { 396, 5, 7, 6, 0, -7 },
  { 401, 5, 10, 6, 1, -10 },
  { 408, 5, 7, 6, 0, -7 },
  { 413, 4, 10, 4, 1, -10 },
  { 418, 6, 10, 6, 0, -7 },
  { 426, 5, 10, 6, 0, -10 },
  { 433, 3, 10, 3, 0, -10 },
  { 437, 5, 13, 3, -2, -10 },
  { 446, 6, 10, 5, 0, -10 },
  { 454, 3, 10, 3, 0, -10 },
  { 458, 9, 7, 10, 0, -7 },
  { 466, 5, 7, 6, 0, -7 },
  { 471, 6, 7, 6, 0, -7 },
  { 477, 5, 10, 6, 0, -7 },
  { 484, 5, 10, 6, 1, -7 },
  { 491, 4, 7, 4, 0, -7 },
  { 495, 5, 7, 6, 0, -7 },
  { 500, 3, 9, 4, 1, -9 },
  { 504, 5, 7, 6, 1, -7 },
  { 509, 5, 7, 5, 1, -7 },
  { 514, 7, 7, 8, 1, -7 },
  { 521, 5, 7, 5, 0, -7 },
  { 526, 7, 10, 5, -1, -7 },
  { 535, 5, 7, 5, 0, -7 },
  { 540, 4, 13, 4, 0, -10 },
  { 547, 2, 11, 3, 0, -9 },
  { 550, 4, 13, 4, -1, -10 },
  { 557, 6, 2, 8, 1, -5 },
};

const GFXfont RobotoCondensed_ExtraLightItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC13PT7B_H_
