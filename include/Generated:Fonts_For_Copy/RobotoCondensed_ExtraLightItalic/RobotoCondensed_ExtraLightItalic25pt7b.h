#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC25PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x40, 0x00, 0x88, 0x99, 0x9A,
  0xA0, 0x02, 0x20, 0x22, 0x04, 0x20, 0x44, 0x04, 0x43, 0xFF, 0x08, 0x80,
  0x88, 0x10, 0x81, 0x10, 0x11, 0x01, 0x10, 0xFF, 0xC2, 0x20, 0x22, 0x04,
  0x40, 0x44, 0x04, 0x40, 0x01, 0x00, 0x80, 0x78, 0x63, 0x30, 0x48, 0x12,
  0x04, 0x80, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x0A, 0x02,
  0x80, 0xA0, 0x44, 0x30, 0xF0, 0x10, 0x04, 0x00, 0x38, 0x04, 0x40, 0x44,
  0x28, 0x44, 0x84, 0x48, 0x48, 0x49, 0x07, 0x10, 0x02, 0x00, 0x40, 0x04,
  0xE0, 0x91, 0x12, 0x12, 0x21, 0x22, 0x14, 0x22, 0x02, 0x20, 0x1C, 0x07,
  0x01, 0x10, 0x42, 0x08, 0x41, 0x08, 0x22, 0x04, 0x80, 0xA0, 0x18, 0x04,
  0x81, 0x10, 0xA1, 0x18, 0x25, 0x02, 0xA0, 0x64, 0x0C, 0x42, 0x87, 0x88,
  0x55, 0x40, 0x02, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x84, 0x10, 0x42, 0x10, 0x82, 0x00, 0x04, 0x01, 0x00,
  0x41, 0x11, 0x37, 0x83, 0x01, 0xC0, 0x48, 0x22, 0x10, 0x40, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x24, 0xA8, 0xF8, 0xC0, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x07, 0x06, 0x21, 0x04,
  0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x50, 0x18, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x11, 0x04, 0x42, 0x0F, 0x00, 0x0C, 0xDC, 0x82, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x80, 0x0F, 0x04, 0x22,
  0x04, 0x81, 0x40, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x3F, 0xE0, 0x0F, 0x04, 0x22, 0x04,
  0x81, 0x40, 0x40, 0x10, 0x08, 0x04, 0x0E, 0x00, 0x40, 0x08, 0x02, 0x00,
  0xA0, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00, 0x00, 0xC0, 0x60, 0x18, 0x0A,
  0x04, 0x81, 0x20, 0x88, 0x44, 0x21, 0x08, 0x44, 0x12, 0x04, 0xFF, 0xC0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x05, 0xE1, 0x8C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x20, 0x48,
  0x12, 0x08, 0xC6, 0x1E, 0x00, 0x03, 0x82, 0x02, 0x02, 0x02, 0x01, 0x01,
  0x3C, 0xE3, 0x40, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x82, 0x62,
  0x1E, 0x00, 0x7F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x00, 0x0F, 0x86, 0x32, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0xC6, 0x1E,
  0x08, 0x44, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00,
  0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x91,
  0xC7, 0x20, 0x10, 0x10, 0x08, 0x08, 0x18, 0x70, 0x00, 0x13, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x11, 0x88, 0x80, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x40,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x00, 0x1C,
  0x62, 0x41, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x41,
  0x00, 0x21, 0x00, 0x09, 0x07, 0x84, 0x84, 0x22, 0x84, 0x21, 0x42, 0x10,
  0xA2, 0x08, 0x61, 0x04, 0x30, 0x84, 0x18, 0x82, 0x14, 0x41, 0x0A, 0x21,
  0x89, 0x11, 0x44, 0x87, 0x1C, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x82, 0x00, 0x3E, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x14,
  0x01, 0x40, 0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x82, 0x08, 0x21, 0x02,
  0x1F, 0xE2, 0x01, 0x20, 0x14, 0x01, 0x40, 0x1C, 0x01, 0x1F, 0x82, 0x08,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x06, 0x7F, 0x08, 0x11, 0x01,
  0x20, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x04, 0x81, 0x9F, 0xC0, 0x07, 0xC0,
  0x82, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x24, 0x02, 0x40, 0x44, 0x0C, 0x21, 0x81,
  0xE0, 0x1F, 0x81, 0x06, 0x20, 0x22, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x80, 0x48,
  0x08, 0x81, 0x0F, 0xE0, 0x1F, 0xF1, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x7F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xF1, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x7F, 0x84, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0x81,
  0x86, 0x20, 0x22, 0x02, 0x40, 0x14, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x83, 0xE8, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x41, 0x83,
  0xE0, 0x10, 0x04, 0x40, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22,
  0x01, 0x08, 0x04, 0x7F, 0xF1, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x21,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x80, 0x11, 0x11, 0x22,
  0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x81, 0x10, 0x22, 0x08, 0x42, 0x07, 0x80, 0x10, 0x18, 0x81, 0x88, 0x18,
  0x41, 0x82, 0x18, 0x10, 0x80, 0x88, 0x04, 0x80, 0x4C, 0x02, 0xA0, 0x19,
  0x80, 0x84, 0x04, 0x30, 0x20, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02,
  0x00, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFF, 0x10, 0x01, 0x88, 0x00, 0xCA,
  0x00, 0xC5, 0x00, 0x62, 0x80, 0x51, 0x40, 0x28, 0xA0, 0x24, 0x48, 0x12,
  0x44, 0x12, 0x22, 0x09, 0x11, 0x08, 0x88, 0x84, 0x44, 0x44, 0x22, 0x12,
  0x12, 0x0A, 0x11, 0x06, 0x08, 0x83, 0x04, 0x41, 0x02, 0x00, 0x10, 0x04,
  0x40, 0x23, 0x80, 0x8A, 0x02, 0x24, 0x08, 0x90, 0x22, 0x40, 0x88, 0x84,
  0x42, 0x11, 0x08, 0x44, 0x11, 0x10, 0x44, 0x40, 0x91, 0x02, 0x88, 0x0A,
  0x20, 0x18, 0x80, 0x62, 0x01, 0x80, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x02,
  0x80, 0x28, 0x02, 0x40, 0x44, 0x04, 0x21, 0x81, 0xE0, 0x1F, 0xC1, 0x06,
  0x20, 0x22, 0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40, 0x64, 0x0C,
  0x7F, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x18, 0x02, 0x80, 0x28, 0x02, 0x40, 0x44, 0x04,
  0x21, 0x81, 0xF0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x1F, 0xC1, 0x06, 0x20,
  0x22, 0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40, 0xC7, 0xF0, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x08, 0x80, 0x88, 0x08, 0x80, 0x48, 0x04, 0x07,
  0x81, 0x86, 0x20, 0x22, 0x02, 0x20, 0x22, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x48, 0x04, 0x80, 0x48, 0x08, 0x41,
  0x03, 0xE0, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x02, 0x40, 0x11, 0x01, 0x08, 0x18, 0x61, 0x80, 0xF0, 0x00, 0x80,
  0x18, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x0C, 0x40, 0x84, 0x08, 0x41,
  0x02, 0x10, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x18,
  0x01, 0x00, 0x80, 0xC0, 0x50, 0x30, 0x24, 0x0C, 0x09, 0x05, 0x06, 0x41,
  0x41, 0x10, 0x90, 0x44, 0x24, 0x21, 0x09, 0x08, 0x44, 0x42, 0x11, 0x11,
  0x04, 0x82, 0x41, 0x20, 0x90, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81,
  0x40, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x00, 0x10, 0x08, 0x40, 0x60, 0x81,
  0x02, 0x08, 0x08, 0x40, 0x11, 0x00, 0x48, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x50, 0x02, 0x40, 0x08, 0x80, 0x42, 0x02, 0x04, 0x18, 0x10, 0x40,
  0x42, 0x00, 0x80, 0xC0, 0x14, 0x02, 0x40, 0x44, 0x04, 0x20, 0x82, 0x10,
  0x21, 0x01, 0x20, 0x16, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x07, 0xFE, 0x00,
  0x0E, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x70, 0x92, 0x49, 0x22,
  0x49, 0x24, 0x89, 0x24, 0x90, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x38, 0x04, 0x18, 0x30, 0xA1, 0x44, 0x48, 0xA1, 0x42, 0xFF, 0x80,
  0x48, 0x80, 0x0F, 0x84, 0x32, 0x04, 0x81, 0x00, 0x40, 0x11, 0xF8, 0x82,
  0x40, 0x90, 0x28, 0x19, 0x0A, 0x3C, 0x80, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0xF1, 0x42, 0x60, 0x90, 0x14, 0x05, 0x02, 0x40, 0xA0,
  0x28, 0x0A, 0x02, 0x81, 0x30, 0x8B, 0xC0, 0x1E, 0x10, 0x90, 0x28, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0xA0, 0x58, 0x47, 0xC0, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x87, 0x91, 0x0A, 0x40, 0x88, 0x11,
  0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x44, 0x08, 0x81, 0x08, 0x60, 0xF4,
  0x00, 0x1F, 0x10, 0xD0, 0x28, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x43, 0xC0, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10, 0x7C, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x0F,
  0x22, 0x14, 0x81, 0x90, 0x22, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88,
  0x11, 0x02, 0x10, 0xC3, 0xE8, 0x01, 0x00, 0x40, 0x08, 0xC2, 0x07, 0x80,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0xBC, 0x61, 0x60, 0xB0, 0x50,
  0x28, 0x14, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x40, 0x03, 0x00,
  0x02, 0x22, 0x44, 0x44, 0x48, 0x88, 0x88, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x30, 0xE0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x08, 0x84, 0x42, 0x11, 0x04, 0x81, 0x40, 0x70, 0x12, 0x08,
  0x82, 0x10, 0x84, 0x20, 0x88, 0x20, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44,
  0x44, 0x88, 0x88, 0x80, 0x17, 0x8F, 0x14, 0x28, 0x4C, 0x18, 0x26, 0x0C,
  0x12, 0x04, 0x09, 0x02, 0x04, 0x81, 0x02, 0x80, 0x81, 0x40, 0x80, 0xA0,
  0x40, 0x90, 0x20, 0x48, 0x10, 0x24, 0x08, 0x10, 0x2F, 0x18, 0x58, 0x2C,
  0x14, 0x0A, 0x05, 0x02, 0x81, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x10, 0x0F,
  0x0C, 0x26, 0x09, 0x01, 0x40, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x28,
  0x11, 0x08, 0x3C, 0x00, 0x17, 0x83, 0x08, 0xC1, 0x10, 0x12, 0x02, 0x40,
  0x88, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x30, 0x85, 0xE1, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x00, 0x1E, 0x48, 0x54, 0x09, 0x02, 0x40, 0xA0,
  0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x11, 0x0C, 0x7D, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x2E, 0x61, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x00, 0x0F, 0x04, 0x22, 0x04, 0x81, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x24, 0x11, 0x0C, 0x3E, 0x00, 0x10, 0x41, 0x04,
  0xFC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x10, 0x70, 0x20, 0x48,
  0x14, 0x09, 0x02, 0x40, 0x90, 0x24, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x31,
  0x1C, 0x79, 0x00, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44, 0x21, 0x10, 0x90,
  0x48, 0x28, 0x14, 0x0C, 0x02, 0x00, 0x82, 0x06, 0x08, 0x28, 0x50, 0xA1,
  0x46, 0x89, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x41, 0x85, 0x06,
  0x14, 0x10, 0x20, 0x40, 0x80, 0x20, 0x4C, 0x21, 0x10, 0x44, 0x0A, 0x03,
  0x00, 0xC0, 0x30, 0x12, 0x08, 0x86, 0x21, 0x04, 0x81, 0x00, 0x10, 0x21,
  0x02, 0x10, 0x61, 0x04, 0x10, 0xC1, 0x08, 0x08, 0x80, 0x90, 0x09, 0x00,
  0xA0, 0x0A, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x0E,
  0x00, 0x3F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x01, 0x00, 0xFF, 0x00, 0x03, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x60, 0x80, 0x40, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x10, 0x08, 0x84, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x00, 0x08, 0x04, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x02, 0x01, 0x06, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x38, 0x14, 0x41,
  0x42, 0x28, 0x1C,
};

const GFXglyph RobotoCondensed_ExtraLightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 18, 5, 1, -18 },
  { 10, 4, 5, 7, 3, -19 },
  { 13, 12, 18, 12, 1, -18 },
  { 40, 10, 22, 12, 1, -20 },
  { 68, 12, 18, 16, 2, -18 },
  { 95, 11, 18, 13, 1, -18 },
  { 120, 2, 5, 4, 2, -19 },
  { 122, 7, 26, 7, 1, -20 },
  { 145, 6, 26, 7, -1, -20 },
  { 165, 10, 10, 10, 1, -18 },
  { 178, 10, 13, 12, 1, -15 },
  { 195, 3, 5, 5, -1, -2 },
  { 197, 5, 1, 6, 1, -9 },
  { 198, 1, 2, 5, 1, -2 },
  { 199, 10, 20, 8, -1, -18 },
  { 224, 10, 18, 12, 1, -18 },
  { 247, 6, 18, 12, 3, -18 },
  { 261, 10, 18, 12, 1, -18 },
  { 284, 10, 18, 12, 1, -18 },
  { 307, 10, 18, 12, 1, -18 },
  { 330, 10, 18, 12, 2, -18 },
  { 353, 9, 18, 12, 1, -18 },
  { 374, 10, 18, 12, 2, -18 },
  { 397, 10, 18, 12, 1, -18 },
  { 420, 9, 18, 12, 2, -18 },
  { 441, 4, 14, 5, 0, -14 },
  { 448, 5, 17, 4, -1, -14 },
  { 459, 9, 10, 11, 1, -13 },
  { 471, 10, 6, 12, 1, -11 },
  { 479, 9, 10, 11, 1, -13 },
  { 491, 8, 18, 10, 2, -18 },
  { 509, 17, 23, 19, 1, -17 },
  { 558, 12, 18, 13, -1, -18 },
  { 585, 11, 18, 13, 1, -18 },
  { 610, 12, 18, 14, 1, -18 },
  { 637, 12, 18, 14, 1, -18 },
  { 664, 12, 18, 12, 1, -18 },
  { 691, 12, 18, 12, 1, -18 },
  { 718, 12, 18, 15, 2, -18 },
  { 745, 14, 18, 15, 1, -18 },
  { 777, 4, 18, 6, 1, -18 },
  { 786, 11, 18, 12, 0, -18 },
  { 811, 13, 18, 13, 1, -18 },
  { 841, 8, 18, 11, 1, -18 },
  { 859, 17, 18, 18, 1, -18 },
  { 898, 14, 18, 15, 1, -18 },
  { 930, 12, 18, 14, 1, -18 },
  { 957, 12, 18, 13, 1, -18 },
  { 984, 12, 21, 14, 1, -18 },
  { 1016, 12, 18, 14, 1, -18 },
  { 1043, 12, 18, 13, 1, -18 },
  { 1070, 12, 18, 13, 2, -18 },
  { 1097, 13, 18, 14, 1, -18 },
  { 1127, 12, 18, 13, 2, -18 },
  { 1154, 18, 18, 19, 2, -18 },
  { 1195, 14, 18, 13, 0, -18 },
  { 1227, 12, 18, 13, 2, -18 },
  { 1254, 13, 18, 13, 0, -18 },
  { 1284, 7, 24, 5, 0, -20 },
  { 1305, 3, 20, 8, 3, -18 },
  { 1313, 7, 24, 5, -2, -20 },
  { 1334, 7, 9, 9, 1, -18 },
  { 1342, 9, 1, 9, -1, 0 },
  { 1344, 3, 3, 7, 3, -18 },
  { 1346, 10, 13, 11, 0, -13 },
  { 1363, 10, 19, 12, 1, -19 },
  { 1387, 9, 13, 11, 1, -13 },
  { 1402, 11, 19, 12, 1, -19 },
  { 1429, 9, 13, 11, 1, -13 },
  { 1444, 8, 19, 7, 1, -19 },
  { 1463, 11, 18, 12, 0, -13 },
  { 1488, 9, 19, 12, 1, -19 },
  { 1510, 4, 18, 5, 1, -18 },
  { 1519, 8, 23, 5, -3, -18 },
  { 1542, 10, 19, 10, 1, -19 },
  { 1566, 4, 19, 5, 1, -19 },
  { 1576, 17, 13, 19, 0, -13 },
  { 1604, 9, 13, 12, 1, -13 },
  { 1619, 10, 13, 12, 1, -13 },
  { 1636, 11, 18, 12, 0, -13 },
  { 1661, 10, 18, 12, 1, -13 },
  { 1684, 7, 13, 7, 1, -13 },
  { 1696, 10, 13, 11, 0, -13 },
  { 1713, 6, 17, 7, 1, -17 },
  { 1726, 10, 13, 12, 1, -13 },
  { 1743, 9, 13, 10, 2, -13 },
  { 1758, 14, 13, 16, 2, -13 },
  { 1781, 10, 13, 10, 0, -13 },
  { 1798, 12, 18, 10, -1, -13 },
  { 1825, 10, 13, 10, 0, -13 },
  { 1842, 8, 25, 7, 1, -20 },
  { 1867, 5, 21, 5, 0, -18 },
  { 1881, 8, 24, 7, -2, -19 },
  { 1905, 12, 4, 15, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraLightItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC25PT7B_H_
