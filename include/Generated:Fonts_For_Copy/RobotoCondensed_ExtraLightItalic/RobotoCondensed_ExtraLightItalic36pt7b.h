#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC36PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x0C, 0x30, 0x82,
  0x08, 0x21, 0x86, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x45, 0x14, 0xD3,
  0xCB, 0x28, 0xA2, 0x00, 0x61, 0x80, 0x10, 0x40, 0x04, 0x10, 0x03, 0x0C,
  0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x10, 0x1F, 0xFF, 0xC0,
  0xC3, 0x00, 0x20, 0x80, 0x08, 0x20, 0x06, 0x18, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x10, 0x40, 0x08, 0x20, 0x3F, 0xFF, 0x80, 0x82, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x04, 0x10, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0F, 0x80, 0x31, 0xC0,
  0xC0, 0x83, 0x01, 0x84, 0x01, 0x18, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x98, 0x01, 0x30, 0x02, 0x60, 0x04, 0x40,
  0x18, 0x80, 0x21, 0x80, 0xC1, 0xC7, 0x00, 0xF8, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x1E, 0x00, 0x19, 0x80, 0x08, 0x40, 0x08, 0x10, 0x04, 0x08,
  0x22, 0x04, 0x33, 0x06, 0x11, 0x82, 0x10, 0xC1, 0x18, 0x21, 0x98, 0x19,
  0x88, 0x07, 0x88, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x38, 0x06, 0x22,
  0x02, 0x20, 0x82, 0x30, 0x43, 0x10, 0x21, 0x08, 0x11, 0x04, 0x09, 0x02,
  0x0D, 0x81, 0x04, 0x00, 0x86, 0x00, 0x66, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x03, 0x18, 0x06, 0x08, 0x04, 0x08, 0x04, 0x08, 0x0C, 0x08, 0x0C, 0x18,
  0x0C, 0x10, 0x04, 0x20, 0x04, 0x40, 0x07, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0D, 0x00, 0x19, 0x81, 0x30, 0x83, 0x60, 0xC2, 0x40, 0x62, 0xC0, 0x26,
  0xC0, 0x34, 0xC0, 0x1C, 0xC0, 0x18, 0x40, 0x18, 0x60, 0x2C, 0x30, 0xC4,
  0x1F, 0x06, 0x5F, 0xA8, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x00, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x07, 0x8C,
  0x73, 0xFE, 0x01, 0xE0, 0x07, 0x00, 0x36, 0x01, 0x88, 0x0C, 0x30, 0x60,
  0x41, 0x01, 0x00, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x33, 0x32, 0x26, 0xC8, 0xFE, 0xF0, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x18, 0xC0,
  0xC1, 0x86, 0x02, 0x10, 0x0C, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x60, 0x05,
  0x00, 0x34, 0x00, 0xD0, 0x03, 0x40, 0x0B, 0x00, 0x2C, 0x00, 0xA0, 0x06,
  0x80, 0x1A, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x8C, 0x04,
  0x10, 0x30, 0x73, 0x80, 0xF8, 0x00, 0x03, 0x0E, 0x7A, 0xC2, 0x02, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x01, 0xF0, 0x0E, 0x30,
  0x30, 0x30, 0x40, 0x21, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x0E,
  0x30, 0x30, 0x30, 0x40, 0x31, 0x80, 0x62, 0x00, 0x44, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x3C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x26, 0x00, 0x4C, 0x00,
  0x98, 0x03, 0x10, 0x0C, 0x30, 0x10, 0x38, 0xC0, 0x3F, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x50, 0x01, 0xE0, 0x02, 0xC0, 0x09, 0x00, 0x32, 0x00,
  0xC4, 0x01, 0x08, 0x06, 0x30, 0x18, 0x60, 0x20, 0x80, 0x81, 0x03, 0x02,
  0x04, 0x0C, 0x10, 0x18, 0x60, 0x31, 0x80, 0x43, 0xFF, 0xF8, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x07,
  0xFE, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x2F, 0x80, 0xF1, 0x81, 0x81, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x66, 0x00,
  0x8C, 0x01, 0x18, 0x06, 0x10, 0x08, 0x30, 0x30, 0x31, 0xC0, 0x3E, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x03, 0x3E, 0x13, 0x18, 0xA0, 0x66, 0x01, 0x60, 0x0F, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x28, 0x01, 0x60, 0x1B,
  0x01, 0x8C, 0x08, 0x31, 0x80, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x38, 0x10, 0x10, 0x60,
  0x31, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x06, 0x30, 0x18,
  0x20, 0x20, 0x71, 0x80, 0x7C, 0x03, 0x06, 0x0C, 0x06, 0x30, 0x04, 0x40,
  0x09, 0x80, 0x1B, 0x00, 0x34, 0x00, 0x48, 0x00, 0x98, 0x03, 0x30, 0x04,
  0x30, 0x10, 0x30, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0xE3, 0x0C, 0x0C, 0x40,
  0x26, 0x01, 0x20, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x28, 0x03, 0x60, 0x39, 0x03, 0x4E, 0x76, 0x3E, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x1C, 0x07, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x30,
  0x40, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x10, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x20, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x02, 0x00, 0x00, 0x0F, 0x83, 0x18, 0x81, 0x30, 0x34, 0x07, 0x80,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x18,
  0x01, 0x00, 0x30, 0x00, 0x40, 0x30, 0x00, 0x30, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x04, 0x18, 0x0F, 0x01, 0x08, 0x18, 0xC0, 0x88, 0x18, 0x20, 0x44,
  0x08, 0x10, 0x26, 0x08, 0x08, 0x12, 0x0C, 0x0C, 0x09, 0x04, 0x04, 0x05,
  0x02, 0x02, 0x02, 0x83, 0x01, 0x03, 0x41, 0x01, 0x81, 0x20, 0x80, 0x80,
  0xB0, 0x40, 0x40, 0x58, 0x20, 0x20, 0x48, 0x10, 0x30, 0x24, 0x08, 0x28,
  0x32, 0x04, 0x14, 0x11, 0x83, 0x33, 0x30, 0xC0, 0xF0, 0xF0, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x05, 0x00, 0x02, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x01, 0x18, 0x00, 0x8C, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x60, 0x80,
  0x20, 0x40, 0x30, 0x20, 0x10, 0x10, 0x18, 0x0C, 0x08, 0x06, 0x0C, 0x01,
  0x07, 0xFF, 0x86, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11, 0x00, 0x0C, 0x80,
  0x06, 0xC0, 0x03, 0x40, 0x00, 0xE0, 0x00, 0x40, 0x07, 0xF8, 0x06, 0x07,
  0x03, 0x00, 0xC1, 0x00, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04, 0x30,
  0x02, 0x18, 0x03, 0x08, 0x01, 0x04, 0x01, 0x82, 0x03, 0x01, 0xFF, 0x01,
  0x80, 0x60, 0xC0, 0x10, 0x40, 0x0C, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x8C, 0x00, 0x46, 0x00, 0x62, 0x00, 0x21, 0x00, 0x30, 0x80, 0x30, 0xC0,
  0x70, 0x7F, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xC7, 0x01, 0x80, 0xC1, 0x00,
  0x21, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x02, 0x40, 0x01, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x98, 0x00, 0xCC, 0x00,
  0x42, 0x00, 0x61, 0x00, 0x20, 0xC0, 0x30, 0x38, 0x60, 0x07, 0xE0, 0x00,
  0x07, 0xF8, 0x03, 0x03, 0x80, 0xC0, 0x30, 0x20, 0x06, 0x08, 0x00, 0x82,
  0x00, 0x20, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x31, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x18, 0x80, 0x06,
  0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x31, 0x80, 0x08, 0x60, 0x06, 0x10,
  0x01, 0x04, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0xE0, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x1F, 0xFC, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC3, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xFC, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xE1, 0xC0, 0x60, 0x10, 0x30, 0x06, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00,
  0x08, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x07, 0xF1, 0x00, 0x04, 0x40, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x86, 0x00,
  0x60, 0xC0, 0x30, 0x1C, 0x78, 0x03, 0xF8, 0x00, 0x04, 0x00, 0x10, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08,
  0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x04, 0x10, 0x00, 0x41,
  0x00, 0x04, 0x1F, 0xFF, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x08,
  0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x84, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x82,
  0x18, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x00, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x80,
  0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x60, 0xC0, 0xC0, 0x71, 0x80, 0x3F,
  0x00, 0x04, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06, 0x04, 0x01, 0x80, 0x80,
  0x60, 0x10, 0x18, 0x02, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x02, 0x18,
  0x00, 0x46, 0x00, 0x09, 0x80, 0x01, 0x78, 0x00, 0x7B, 0x00, 0x0E, 0x30,
  0x01, 0x86, 0x00, 0x20, 0x60, 0x04, 0x04, 0x00, 0x80, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x80, 0x10, 0x10, 0x03, 0x02, 0x00, 0x20, 0xC0, 0x06,
  0x18, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01,
  0x83, 0x80, 0x01, 0xC1, 0x40, 0x00, 0xA0, 0xA0, 0x00, 0xD0, 0x50, 0x00,
  0x58, 0x2C, 0x00, 0x6C, 0x36, 0x00, 0x24, 0x19, 0x00, 0x32, 0x08, 0x80,
  0x11, 0x04, 0x40, 0x19, 0x82, 0x20, 0x08, 0xC1, 0x18, 0x0C, 0x61, 0x84,
  0x04, 0x20, 0xC2, 0x06, 0x10, 0x41, 0x02, 0x08, 0x20, 0x83, 0x0C, 0x10,
  0x41, 0x06, 0x08, 0x31, 0x83, 0x0C, 0x08, 0x81, 0x06, 0x04, 0xC0, 0x82,
  0x02, 0x40, 0x41, 0x01, 0x60, 0x60, 0x80, 0xA0, 0x30, 0xC0, 0x70, 0x10,
  0x60, 0x10, 0x08, 0x00, 0x04, 0x00, 0x10, 0xE0, 0x03, 0x0E, 0x00, 0x30,
  0xE0, 0x03, 0x0B, 0x00, 0x20, 0x90, 0x02, 0x09, 0x00, 0x21, 0x98, 0x06,
  0x18, 0x80, 0x61, 0x0C, 0x06, 0x10, 0x40, 0x41, 0x04, 0x04, 0x10, 0x60,
  0x43, 0x02, 0x0C, 0x30, 0x20, 0xC2, 0x03, 0x0C, 0x20, 0x10, 0x82, 0x01,
  0x88, 0x20, 0x08, 0x86, 0x00, 0x98, 0x60, 0x0D, 0x84, 0x00, 0x50, 0x40,
  0x05, 0x04, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0xFC, 0x01,
  0xC7, 0x01, 0x80, 0xC1, 0x80, 0x21, 0x80, 0x18, 0x80, 0x04, 0xC0, 0x02,
  0x40, 0x01, 0x20, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x34, 0x00,
  0x1A, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x02, 0x80, 0x01, 0x40, 0x01, 0xA0,
  0x00, 0x90, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x21, 0x00, 0x20, 0xC0, 0x30,
  0x38, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x03, 0x01, 0xC0, 0xC0, 0x10,
  0x20, 0x06, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02, 0x18,
  0x00, 0x84, 0x00, 0x61, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x06, 0x0C, 0x07,
  0x03, 0xFF, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xC7, 0x01, 0x80, 0xC1, 0x00,
  0x21, 0x80, 0x18, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x01, 0x60, 0x00, 0xB0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0B, 0x00, 0x05,
  0x80, 0x02, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x4C, 0x00,
  0x66, 0x00, 0x21, 0x00, 0x20, 0xC0, 0x30, 0x38, 0xE0, 0x07, 0xF0, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x07, 0xFC,
  0x06, 0x03, 0x03, 0x00, 0xC1, 0x00, 0x30, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x63,
  0x00, 0x61, 0x80, 0xE0, 0xFF, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08,
  0x18, 0x06, 0x0C, 0x03, 0x04, 0x00, 0x82, 0x00, 0x61, 0x00, 0x30, 0x80,
  0x08, 0xC0, 0x06, 0x60, 0x03, 0x00, 0x00, 0xFC, 0x01, 0xC7, 0x01, 0x80,
  0xC1, 0x80, 0x21, 0x80, 0x18, 0x80, 0x0C, 0x40, 0x06, 0x20, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x20, 0x00, 0x90, 0x00,
  0xC8, 0x00, 0x66, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x30, 0x38, 0x70, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x46, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x23,
  0x00, 0x08, 0xC0, 0x06, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00, 0x11, 0x80,
  0x04, 0x60, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x08, 0x40, 0x02,
  0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x04,
  0x00, 0x81, 0x80, 0xC0, 0x38, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0xE0,
  0x00, 0xD0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10,
  0xC0, 0x18, 0x60, 0x08, 0x10, 0x0C, 0x08, 0x04, 0x04, 0x02, 0x02, 0x03,
  0x01, 0x01, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x04,
  0x60, 0x02, 0x20, 0x01, 0x10, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x04, 0x80, 0xC8, 0x0C, 0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0xC1,
  0x0C, 0x18, 0xC1, 0x0C, 0x10, 0xC3, 0x04, 0x10, 0xC2, 0x04, 0x30, 0xC2,
  0x04, 0x20, 0xC6, 0x04, 0x60, 0x44, 0x04, 0x40, 0x4C, 0x04, 0x40, 0x48,
  0x04, 0xC0, 0x48, 0x04, 0x80, 0x58, 0x04, 0x80, 0x50, 0x05, 0x80, 0x50,
  0x07, 0x00, 0x60, 0x07, 0x00, 0x60, 0x07, 0x00, 0x60, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x30, 0x01, 0x00, 0x80, 0x18, 0x06, 0x01, 0x80, 0x10, 0x08,
  0x00, 0x80, 0xC0, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00, 0xC6, 0x00, 0x02,
  0x60, 0x00, 0x12, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x40, 0x00, 0x13, 0x00, 0x01, 0x88, 0x00, 0x18, 0x40, 0x00, 0x83,
  0x00, 0x0C, 0x08, 0x00, 0xC0, 0x60, 0x04, 0x03, 0x00, 0x60, 0x08, 0x06,
  0x00, 0x60, 0x20, 0x01, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xA0, 0x00,
  0x98, 0x00, 0xCC, 0x00, 0xC2, 0x00, 0x41, 0x80, 0x60, 0xC0, 0x60, 0x20,
  0x20, 0x10, 0x30, 0x0C, 0x30, 0x02, 0x10, 0x01, 0x18, 0x00, 0xC8, 0x00,
  0x28, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xC1, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x3E,
  0x00, 0x84, 0x21, 0x0C, 0x61, 0x08, 0x42, 0x10, 0xC6, 0x10, 0x84, 0x21,
  0x0C, 0x61, 0x08, 0x42, 0x10, 0xC6, 0x10, 0x07, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x3C, 0x00, 0x03, 0x00, 0xC0, 0x50, 0x14, 0x09, 0x02, 0x41, 0x18, 0x46,
  0x20, 0x88, 0x26, 0x09, 0x02, 0xC0, 0xC0, 0xFF, 0xF8, 0xC4, 0x62, 0x30,
  0x03, 0xE0, 0x71, 0x86, 0x06, 0x60, 0x12, 0x00, 0x90, 0x04, 0x00, 0x20,
  0x03, 0x0F, 0xF9, 0xC0, 0x98, 0x05, 0x80, 0x28, 0x01, 0x40, 0x1A, 0x00,
  0xD0, 0x0C, 0xC0, 0xA3, 0x19, 0x0F, 0x88, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x11, 0xF0, 0x5C,
  0x61, 0xC0, 0xC6, 0x03, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x05, 0x80, 0x36, 0x00, 0xD0, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x30,
  0x04, 0xE0, 0x22, 0x63, 0x08, 0xF8, 0x00, 0x03, 0xE0, 0x38, 0xC1, 0x81,
  0x8C, 0x02, 0x20, 0x09, 0x80, 0x34, 0x00, 0xD0, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x4C, 0x01, 0x10, 0x08, 0x60,
  0x60, 0xC7, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x03, 0xC6, 0x0E,
  0x76, 0x18, 0x14, 0x10, 0x0C, 0x20, 0x04, 0x20, 0x0C, 0x60, 0x0C, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0xC0, 0x18, 0x40,
  0x10, 0x40, 0x10, 0x40, 0x30, 0x60, 0x50, 0x31, 0xB0, 0x1F, 0x30, 0x03,
  0xE0, 0x38, 0xC1, 0x81, 0x8C, 0x02, 0x20, 0x09, 0x80, 0x24, 0x00, 0x90,
  0x02, 0x7F, 0xFB, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x20, 0xC3, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x60,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x7F, 0x82, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x01,
  0xE3, 0x07, 0x3A, 0x0C, 0x0A, 0x08, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30,
  0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x08, 0x20, 0x08, 0x20, 0x18, 0x30, 0x28, 0x18, 0xD8, 0x0F,
  0x98, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0xC0, 0x60, 0x71,
  0xC0, 0x1F, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x11, 0xF0, 0x4C, 0x61, 0x40, 0x86, 0x03,
  0x38, 0x0C, 0xC0, 0x32, 0x00, 0xC8, 0x02, 0x20, 0x09, 0x80, 0x26, 0x00,
  0x90, 0x06, 0x40, 0x19, 0x00, 0x44, 0x01, 0x30, 0x04, 0xC0, 0x12, 0x00,
  0xC8, 0x03, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x06, 0x10, 0x41, 0x04,
  0x30, 0xC2, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xF0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x0C, 0x40, 0x61, 0x03, 0x04, 0x18, 0x30, 0xC0,
  0xC6, 0x02, 0x30, 0x09, 0x80, 0x2C, 0x01, 0xF8, 0x06, 0x20, 0x10, 0xC0,
  0x41, 0x01, 0x06, 0x04, 0x08, 0x30, 0x30, 0xC0, 0x42, 0x01, 0x88, 0x02,
  0x00, 0x04, 0x30, 0xC2, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x10, 0xC3,
  0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x00, 0x11, 0xF0,
  0x7C, 0x13, 0x18, 0xC6, 0x14, 0x09, 0x03, 0x38, 0x0A, 0x03, 0x30, 0x0E,
  0x01, 0x30, 0x0C, 0x01, 0x20, 0x0C, 0x03, 0x20, 0x08, 0x03, 0x20, 0x08,
  0x02, 0x60, 0x08, 0x02, 0x60, 0x18, 0x02, 0x40, 0x18, 0x02, 0x40, 0x10,
  0x06, 0x40, 0x10, 0x06, 0xC0, 0x10, 0x04, 0xC0, 0x10, 0x04, 0xC0, 0x30,
  0x04, 0x80, 0x30, 0x04, 0x80, 0x20, 0x0C, 0x11, 0xF0, 0x4C, 0x61, 0x40,
  0x86, 0x03, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0xC8, 0x02, 0x20, 0x09, 0x80,
  0x26, 0x00, 0x90, 0x06, 0x40, 0x19, 0x00, 0x44, 0x01, 0x30, 0x04, 0xC0,
  0x12, 0x00, 0xC8, 0x03, 0x00, 0x03, 0xE0, 0x38, 0xE1, 0x80, 0x84, 0x03,
  0x30, 0x04, 0x80, 0x16, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00,
  0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x24, 0x01, 0x10, 0x0C, 0x60, 0x60, 0xC3,
  0x01, 0xF8, 0x00, 0x08, 0xF8, 0x17, 0x18, 0x38, 0x18, 0xC0, 0x31, 0x80,
  0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x60, 0x0C, 0xC0, 0x19,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x02, 0x30, 0x0C, 0x70, 0x10, 0x98,
  0xC1, 0x1F, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x00, 0x03, 0xC6, 0x1C, 0xE8, 0x60, 0x70, 0x80, 0x63,
  0x00, 0x44, 0x01, 0x98, 0x03, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x22, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x10, 0x04, 0x20, 0x18, 0x60, 0x70,
  0x63, 0xE0, 0x7C, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x11, 0xC5, 0xC1, 0x40, 0x60, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x00, 0x07, 0xC0, 0x73, 0x84, 0x04, 0x60, 0x32,
  0x00, 0x90, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x12, 0x00, 0x90, 0x04, 0xC0, 0x43, 0x9E, 0x07, 0xC0,
  0x08, 0x08, 0x08, 0x18, 0x18, 0xFF, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x60, 0x78,
  0x20, 0x0C, 0x80, 0x22, 0x00, 0x98, 0x02, 0x60, 0x09, 0x00, 0x64, 0x01,
  0x90, 0x04, 0x40, 0x13, 0x00, 0x4C, 0x01, 0x20, 0x0C, 0x80, 0x32, 0x00,
  0x88, 0x06, 0x20, 0x18, 0xC0, 0xE1, 0x8D, 0x83, 0xE4, 0x00, 0xC0, 0x0E,
  0x00, 0xD0, 0x04, 0x80, 0x64, 0x02, 0x20, 0x31, 0x81, 0x0C, 0x18, 0x20,
  0x81, 0x0C, 0x08, 0x40, 0x42, 0x02, 0x20, 0x19, 0x00, 0x50, 0x02, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x60, 0x38, 0x06, 0x02, 0x80, 0xE0,
  0x68, 0x0A, 0x06, 0x81, 0xA0, 0x4C, 0x12, 0x0C, 0xC3, 0x20, 0x8C, 0x22,
  0x18, 0xC2, 0x21, 0x0C, 0x42, 0x10, 0x44, 0x23, 0x04, 0xC2, 0x20, 0x48,
  0x36, 0x05, 0x83, 0x40, 0x50, 0x14, 0x05, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x00, 0x08, 0x03, 0x0C, 0x06, 0x04, 0x0C, 0x06,
  0x08, 0x02, 0x18, 0x02, 0x30, 0x03, 0x20, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x0C, 0x60, 0x08, 0x20, 0x18,
  0x30, 0x30, 0x10, 0x60, 0x18, 0x40, 0x18, 0x18, 0x01, 0x08, 0x03, 0x08,
  0x02, 0x08, 0x06, 0x08, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x0C, 0x18, 0x04,
  0x10, 0x04, 0x30, 0x04, 0x20, 0x04, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x02,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x20, 0x1C, 0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x70, 0x18, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x0C, 0x30, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x30, 0xC3, 0x08,
  0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x08, 0x00,
  0x04, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x1C, 0x01, 0x80, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x40, 0x00, 0x1E, 0x01, 0x99, 0x80, 0x98, 0x60, 0x48, 0x18, 0x6C, 0x06,
  0x64, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 7, 1, -26 },
  { 21, 6, 8, 9, 4, -27 },
  { 27, 18, 26, 17, 1, -26 },
  { 86, 15, 32, 17, 1, -29 },
  { 146, 17, 26, 23, 3, -26 },
  { 202, 16, 26, 19, 1, -26 },
  { 254, 2, 7, 6, 4, -27 },
  { 256, 10, 37, 10, 2, -29 },
  { 303, 10, 37, 10, -2, -29 },
  { 350, 14, 14, 15, 2, -26 },
  { 375, 14, 19, 17, 2, -21 },
  { 409, 4, 8, 7, -1, -3 },
  { 413, 7, 1, 9, 1, -12 },
  { 414, 2, 2, 8, 1, -2 },
  { 415, 14, 28, 12, -1, -26 },
  { 464, 14, 26, 17, 2, -26 },
  { 510, 8, 26, 17, 5, -26 },
  { 536, 15, 26, 17, 1, -26 },
  { 585, 15, 26, 17, 1, -26 },
  { 634, 15, 26, 17, 1, -26 },
  { 683, 15, 26, 17, 2, -26 },
  { 732, 13, 26, 17, 2, -26 },
  { 775, 14, 26, 17, 3, -26 },
  { 821, 15, 26, 17, 1, -26 },
  { 870, 13, 26, 17, 3, -26 },
  { 913, 6, 19, 7, 0, -19 },
  { 928, 7, 24, 6, -1, -19 },
  { 949, 13, 15, 16, 2, -19 },
  { 974, 13, 8, 17, 2, -16 },
  { 987, 13, 15, 16, 1, -19 },
  { 1012, 11, 26, 14, 3, -26 },
  { 1048, 25, 33, 28, 1, -25 },
  { 1152, 17, 26, 19, -1, -26 },
  { 1208, 17, 26, 19, 1, -26 },
  { 1264, 17, 26, 20, 2, -26 },
  { 1320, 18, 26, 20, 1, -26 },
  { 1379, 18, 26, 17, 1, -26 },
  { 1438, 18, 26, 17, 1, -26 },
  { 1497, 18, 26, 21, 2, -26 },
  { 1556, 20, 26, 21, 1, -26 },
  { 1621, 6, 26, 8, 2, -26 },
  { 1641, 16, 26, 17, 1, -26 },
  { 1693, 19, 26, 19, 1, -26 },
  { 1755, 12, 26, 16, 1, -26 },
  { 1794, 25, 26, 26, 1, -26 },
  { 1876, 20, 26, 22, 1, -26 },
  { 1941, 17, 26, 20, 2, -26 },
  { 1997, 18, 26, 19, 1, -26 },
  { 2056, 17, 31, 20, 2, -26 },
  { 2122, 17, 26, 20, 1, -26 },
  { 2178, 17, 26, 18, 1, -26 },
  { 2234, 17, 26, 18, 3, -26 },
  { 2290, 18, 26, 20, 2, -26 },
  { 2349, 17, 26, 19, 3, -26 },
  { 2405, 24, 26, 27, 4, -26 },
  { 2483, 21, 26, 19, -1, -26 },
  { 2552, 17, 26, 18, 3, -26 },
  { 2608, 19, 26, 18, 0, -26 },
  { 2670, 10, 34, 7, 0, -29 },
  { 2713, 5, 28, 12, 4, -26 },
  { 2731, 10, 34, 7, -2, -29 },
  { 2774, 10, 13, 13, 2, -26 },
  { 2791, 13, 1, 13, -2, 0 },
  { 2793, 4, 5, 10, 5, -27 },
  { 2796, 13, 19, 16, 1, -19 },
  { 2827, 14, 27, 17, 1, -27 },
  { 2875, 14, 19, 16, 1, -19 },
  { 2909, 16, 27, 17, 1, -27 },
  { 2963, 14, 19, 16, 1, -19 },
  { 2997, 11, 27, 10, 2, -27 },
  { 3035, 16, 26, 17, 0, -19 },
  { 3087, 14, 27, 17, 1, -27 },
  { 3135, 6, 26, 7, 1, -26 },
  { 3155, 12, 33, 7, -5, -26 },
  { 3205, 14, 27, 15, 1, -27 },
  { 3253, 6, 27, 7, 1, -27 },
  { 3274, 24, 19, 27, 1, -19 },
  { 3331, 14, 19, 17, 1, -19 },
  { 3365, 14, 19, 17, 1, -19 },
  { 3399, 15, 26, 17, 0, -19 },
  { 3448, 15, 26, 17, 1, -19 },
  { 3497, 10, 19, 11, 1, -19 },
  { 3521, 13, 19, 16, 1, -19 },
  { 3552, 8, 24, 10, 2, -24 },
  { 3576, 14, 19, 17, 2, -19 },
  { 3610, 13, 19, 15, 2, -19 },
  { 3641, 20, 19, 23, 3, -19 },
  { 3689, 16, 19, 15, -1, -19 },
  { 3727, 16, 26, 15, -1, -19 },
  { 3779, 15, 19, 15, 0, -19 },
  { 3815, 11, 35, 10, 1, -28 },
  { 3864, 6, 31, 7, 1, -26 },
  { 3888, 11, 36, 10, -2, -28 },
  { 3938, 17, 6, 21, 2, -14 },
};

const GFXfont RobotoCondensed_ExtraLightItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC36PT7B_H_
