#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC67PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x38, 0x73, 0x87,
  0x38, 0x63, 0x06, 0x30, 0x63, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xC6, 0x0C,
  0x60, 0xC6, 0x1C, 0xE1, 0xCC, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x04, 0x38, 0x01,
  0x80, 0x1C, 0x60, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x00, 0xE1, 0x80, 0x0C,
  0x03, 0x83, 0x00, 0x38, 0x06, 0x0E, 0x00, 0x60, 0x18, 0x1C, 0x00, 0xC0,
  0x70, 0x38, 0x01, 0x80, 0xC0, 0x70, 0x07, 0x03, 0x00, 0x60, 0x0C, 0x0E,
  0x00, 0xC0, 0x38, 0x18, 0x01, 0xC0, 0xE0, 0x60, 0x01, 0xC3, 0x81, 0xC0,
  0x03, 0xFE, 0x03, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0x00,
  0x01, 0x81, 0xFF, 0x00, 0x06, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x06, 0x00,
  0x70, 0x30, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x03, 0x81, 0x80, 0x18, 0x0E,
  0x03, 0x00, 0x30, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x18, 0x00, 0xC1, 0xC0,
  0x30, 0x01, 0x83, 0x00, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0x0E, 0x38, 0x01,
  0x80, 0x18, 0x60, 0x03, 0x00, 0x31, 0x80, 0x06, 0x00, 0x61, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x37, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x1C, 0x38, 0x06,
  0x00, 0x61, 0xC0, 0x1C, 0x01, 0x8E, 0x00, 0x30, 0x06, 0x38, 0x00, 0xE0,
  0x39, 0xC0, 0x01, 0xC0, 0xC7, 0x00, 0x07, 0x03, 0x18, 0x00, 0x0E, 0x1C,
  0xE0, 0x00, 0x38, 0x63, 0x80, 0x00, 0x73, 0x8E, 0x00, 0x01, 0xCC, 0x38,
  0x00, 0x03, 0xF0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1D, 0xC0, 0xE0, 0x01,
  0xE7, 0x01, 0xE0, 0x0E, 0x0E, 0x03, 0xFF, 0xF0, 0x38, 0x07, 0xFF, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x00, 0x31, 0x8C, 0x67, 0x39, 0x8C, 0x67, 0x39,
  0x8C, 0x60, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x40, 0x0C, 0x00, 0xBC, 0x03, 0x01, 0xEF, 0xE0,
  0xC1, 0xF8, 0x7E, 0x33, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x04,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x06,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x40,
  0xFF, 0xFF, 0xFF, 0xC0, 0x13, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x03, 0x80,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x61, 0xF9, 0xCF, 0xC3, 0xBC, 0x07,
  0x60, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x60, 0x07,
  0x00, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x1F, 0x80, 0x00, 0xEF,
  0xFE, 0x00, 0x0D, 0xFB, 0xF8, 0x00, 0xF8, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x07, 0xE0, 0x07, 0x0F, 0xFC, 0x03, 0x1F, 0x1F, 0x81, 0x9C,
  0x01, 0xC1, 0xDC, 0x00, 0x70, 0xF8, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x3C,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x1E,
  0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0x60, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0x70, 0x00,
  0x6E, 0x38, 0x00, 0xEC, 0x3C, 0x03, 0xCC, 0x1F, 0x9F, 0x9C, 0x0F, 0xFE,
  0x1C, 0x03, 0xF8, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0x00, 0xF0, 0x7C, 0x0F, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x01,
  0x80, 0x00, 0x20, 0x03, 0x80, 0x3E, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x08,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xF0, 0x1C, 0x1C, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0x67, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xFF, 0xC0,
  0x03, 0x03, 0x80, 0x07, 0x87, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x07, 0x00,
  0x30, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0xC1, 0x80, 0x0E, 0x00, 0x30, 0x03,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x30, 0x01, 0x80, 0x06, 0x00, 0x31,
  0xC0, 0x0E, 0x00, 0x18, 0x00, 0xC7, 0x00, 0x30, 0x00, 0x60, 0x03, 0x18,
  0x01, 0xC0, 0x03, 0x80, 0x0C, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x33, 0x80,
  0x18, 0x00, 0x30, 0x00, 0xCC, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x30, 0x03,
  0x00, 0x07, 0x00, 0x1D, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x67, 0x00, 0x70,
  0x00, 0x60, 0x01, 0x98, 0x01, 0x80, 0x01, 0x80, 0x06, 0x60, 0x06, 0x00,
  0x0E, 0x00, 0x39, 0x80, 0x18, 0x00, 0x30, 0x00, 0xC6, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x18, 0x03, 0x80, 0x07, 0x00, 0x0C, 0xE0, 0x0E, 0x00, 0x1C,
  0x00, 0x63, 0x80, 0x30, 0x00, 0x60, 0x01, 0x8E, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x38, 0x03, 0x00, 0x1E, 0x00, 0x30, 0xE0, 0x0C, 0x00, 0x78, 0x01,
  0xC3, 0x80, 0x38, 0x03, 0x60, 0x06, 0x0E, 0x00, 0x60, 0x19, 0xC0, 0x30,
  0x38, 0x01, 0xC0, 0xC3, 0x03, 0x80, 0x60, 0x07, 0xFE, 0x0F, 0x3C, 0x01,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x06, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x07, 0x80,
  0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x07, 0x80, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x06, 0x00,
  0x01, 0xE0, 0x0C, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xF8, 0x00, 0x18,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x06,
  0x00, 0x07, 0xC0, 0x03, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0x70, 0x00, 0xFF, 0xFC,
  0x70, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x60, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x30, 0x07, 0x80, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x1E, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x06, 0x1E, 0x00, 0x00, 0x00,
  0x63, 0xF0, 0x00, 0x00, 0x0E, 0x73, 0x00, 0x00, 0x00, 0xEE, 0x38, 0x00,
  0x00, 0x0F, 0xC1, 0x80, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0x80, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xD8, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x1D, 0x80, 0x00,
  0x00, 0x1B, 0x80, 0x76, 0x00, 0x00, 0x00, 0xEC, 0x01, 0x98, 0x00, 0x00,
  0x03, 0x30, 0x06, 0x70, 0x00, 0x00, 0x1C, 0xC0, 0x19, 0xC0, 0x00, 0x00,
  0x67, 0x00, 0x67, 0x00, 0x00, 0x03, 0x9C, 0x03, 0x8C, 0x00, 0x00, 0x0C,
  0x70, 0x0E, 0x30, 0x00, 0x00, 0x71, 0x80, 0x38, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0,
  0x0C, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x70, 0x60, 0x00, 0x06, 0x0E, 0x01,
  0xC1, 0x80, 0x00, 0x38, 0x30, 0x07, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x18,
  0x1C, 0x00, 0x07, 0x03, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C, 0x01, 0x80,
  0xC0, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0x03, 0x01, 0x80, 0x38, 0x0C,
  0x00, 0x1C, 0x06, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x0C, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x00, 0x60, 0x07, 0x01, 0x80,
  0x1C, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x30, 0x01,
  0xC0, 0x38, 0x00, 0xC1, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x06, 0x00, 0x18,
  0x03, 0x80, 0x0E, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x38, 0xC0, 0x03, 0x80,
  0x30, 0x00, 0x67, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x98, 0x00, 0x38, 0x07,
  0x00, 0x06, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x1B, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x7C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x6C, 0x00,
  0x00, 0x18, 0x07, 0x70, 0x00, 0x00, 0xC0, 0x3B, 0x80, 0x00, 0x0E, 0x01,
  0xCC, 0x00, 0x00, 0x70, 0x0E, 0x70, 0x00, 0x03, 0x80, 0x61, 0x80, 0x00,
  0x1C, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x70, 0x00, 0x06, 0x01, 0xC1,
  0x80, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x70, 0x00, 0x1C,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x30,
  0x00, 0x30, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x30, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x0E, 0x00,
  0x30, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x06, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x30,
  0x0E, 0x00, 0x06, 0x01, 0x80, 0x70, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x1C, 0x00, 0x06, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x38, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x70, 0x00, 0x06, 0x0C, 0x03, 0x80, 0x00, 0x38,
  0xE0, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0xE0, 0x00, 0x07, 0x38, 0x06, 0x00,
  0x00, 0x39, 0xC0, 0x30, 0x00, 0x00, 0xCC, 0x03, 0x80, 0x00, 0x07, 0x60,
  0x1C, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00,
  0x07, 0xC0, 0x30, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x9C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x03, 0xF0,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x33, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0xB8, 0x00, 0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x18, 0xE0,
  0x00, 0x39, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x70, 0xE0, 0x00,
  0x61, 0x80, 0x01, 0x83, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x0E, 0x00, 0x0C,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x70, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x81,
  0x80, 0x07, 0x01, 0x80, 0x06, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x1C,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x70, 0x03, 0x80, 0x60, 0x07, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x1C, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x70, 0x01,
  0xC0, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x18, 0x00, 0x38, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x80, 0x00, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01,
  0xB8, 0x00, 0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x80, 0x0E, 0x60, 0x03, 0x18,
  0x01, 0xC6, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0C, 0x1C, 0x07, 0x07, 0x01,
  0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x1C, 0x03, 0x06, 0x00, 0xE3, 0x80,
  0x38, 0xC0, 0x06, 0x70, 0x01, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C,
  0x0C, 0x0E, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0x00, 0x30, 0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x0F,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E,
  0x18, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0xC1, 0x80, 0x03, 0xF0, 0x70,
  0x01, 0xDC, 0x0E, 0x01, 0xE7, 0x03, 0xFF, 0xF1, 0xC0, 0x3F, 0xF0, 0x70,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x1E, 0x00, 0x0C, 0x3F, 0xF0, 0x07, 0x1F, 0xFE, 0x01,
  0xDE, 0x01, 0xC0, 0x6E, 0x00, 0x38, 0x1F, 0x00, 0x0E, 0x07, 0x80, 0x01,
  0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x07,
  0x18, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0xE0, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x07, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x30, 0xF0, 0x00, 0x1C, 0x3E, 0x00, 0x0E, 0x0E, 0xC0, 0x07,
  0x83, 0x1C, 0x03, 0xC0, 0xC3, 0xFF, 0xE0, 0x30, 0x7F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3C, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38, 0x18, 0x00, 0x0C,
  0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x03, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x7C, 0x03, 0x00, 0x0F, 0xFC, 0x18, 0x01, 0xFF, 0xF0, 0xC0,
  0x1E, 0x01, 0xCE, 0x01, 0xE0, 0x03, 0x70, 0x1E, 0x00, 0x1B, 0x80, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0xE0,
  0x07, 0x00, 0xF7, 0x00, 0x1F, 0xFF, 0x30, 0x00, 0x7F, 0xE1, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x18, 0x00,
  0x0C, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x98,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x20, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0xC0, 0x0F, 0xFF, 0x86, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x00,
  0x3B, 0x80, 0xF0, 0x00, 0xDC, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01,
  0x80, 0x01, 0xE0, 0x0E, 0x00, 0x3F, 0x00, 0x38, 0x07, 0xB8, 0x00, 0xFF,
  0xF9, 0xC0, 0x03, 0xFF, 0x0C, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xE1, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x07, 0xC0, 0x06, 0x0F, 0xF8, 0x07,
  0x1F, 0xFE, 0x03, 0x9C, 0x03, 0x81, 0xDC, 0x00, 0xC0, 0xDC, 0x00, 0x70,
  0x6C, 0x00, 0x38, 0x3C, 0x00, 0x0C, 0x3C, 0x00, 0x06, 0x1E, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0x9E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x01,
  0x81, 0xE0, 0x00, 0x30, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x39, 0xE0, 0x00, 0x06, 0x78, 0x00, 0x00, 0xDF, 0x80, 0x00, 0x1F,
  0x30, 0x00, 0x07, 0xC7, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00,
  0x30, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x1C, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xE3, 0xFF, 0xC0,
  0x7F, 0xF8, 0x06, 0x38, 0x0F, 0x0F, 0x00, 0xE0, 0x33, 0x00, 0x38, 0x70,
  0x03, 0x01, 0xB0, 0x00, 0xE6, 0x00, 0x1C, 0x1F, 0x00, 0x07, 0x60, 0x00,
  0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x18,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x87, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x87, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0x83, 0xFE, 0x01, 0xC7, 0xFF, 0x80, 0xE7, 0x00, 0xE0, 0x77, 0x00, 0x30,
  0x37, 0x00, 0x1C, 0x1B, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x0F, 0x00, 0x01,
  0x87, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3C,
  0x03, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x98, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0x0F, 0xFC, 0x00, 0x39, 0xFF, 0xF0, 0x01, 0xDE, 0x01, 0xC0,
  0x0D, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0xE0, 0x00, 0xE0, 0x1D, 0x80, 0x0F, 0x00, 0xEF, 0x00, 0xF0,
  0x06, 0x3F, 0xFF, 0x00, 0x30, 0x7F, 0xE0, 0x01, 0x80, 0x78, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x30, 0x1F, 0xFF, 0x0C, 0x0F, 0x00, 0xE7,
  0x07, 0x80, 0x0D, 0xC3, 0xC0, 0x01, 0x60, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x01, 0xE0, 0x70, 0x01, 0xF8, 0x0E, 0x01,
  0xEE, 0x01, 0xFF, 0xF3, 0x00, 0x3F, 0xF0, 0xC0, 0x01, 0xE0, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x61, 0xFC, 0x1C,
  0xFF, 0x83, 0xBC, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x70,
  0x18, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8E,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x3C,
  0x00, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30,
  0x00, 0x07, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x87,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x78, 0x18,
  0x00, 0x1E, 0x07, 0x00, 0x0F, 0x81, 0xC0, 0x06, 0xE0, 0x3C, 0x07, 0xB0,
  0x07, 0xFF, 0x8C, 0x00, 0xFF, 0xC3, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x38, 0x00,
  0xC0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x0E,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1F,
  0x80, 0x01, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x00, 0x03, 0x98, 0x00, 0x3C,
  0x00, 0x0C, 0x60, 0x00, 0xF0, 0x00, 0x71, 0x80, 0x07, 0xE0, 0x01, 0x86,
  0x00, 0x1B, 0x80, 0x0E, 0x18, 0x00, 0x6E, 0x00, 0x38, 0x60, 0x03, 0xB8,
  0x00, 0xC1, 0x80, 0x0C, 0x60, 0x07, 0x06, 0x00, 0x71, 0x80, 0x18, 0x18,
  0x01, 0x86, 0x00, 0xE0, 0x70, 0x0E, 0x18, 0x03, 0x81, 0xC0, 0x30, 0x60,
  0x1C, 0x07, 0x01, 0xC1, 0x80, 0x70, 0x1C, 0x06, 0x06, 0x01, 0x80, 0x70,
  0x18, 0x18, 0x0E, 0x01, 0xC0, 0xE0, 0x70, 0x30, 0x03, 0x03, 0x01, 0xC1,
  0xC0, 0x0C, 0x1C, 0x07, 0x07, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x00, 0xC3,
  0x80, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x03, 0x1C,
  0x00, 0x31, 0x80, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x03, 0x38,
  0x00, 0xCE, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x37, 0x00, 0x0D, 0xC0,
  0x00, 0xD8, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x70, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0C, 0x7F, 0xF0, 0x00, 0x39, 0xC0, 0x70, 0x00, 0x63, 0x00, 0x70,
  0x00, 0xCE, 0x00, 0x70, 0x03, 0x98, 0x00, 0x70, 0x0E, 0x30, 0x00, 0x70,
  0x38, 0xE0, 0x00, 0x7D, 0xF1, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E,
  0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 49, 13, 1, -48 },
  { 69, 12, 14, 18, 7, -50 },
  { 90, 34, 48, 32, 1, -48 },
  { 294, 28, 62, 32, 2, -55 },
  { 511, 31, 50, 42, 6, -49 },
  { 705, 30, 50, 35, 2, -49 },
  { 893, 5, 14, 11, 7, -50 },
  { 902, 19, 68, 18, 3, -53 },
  { 1064, 19, 68, 19, -4, -53 },
  { 1226, 26, 26, 27, 4, -48 },
  { 1311, 27, 34, 32, 3, -39 },
  { 1426, 8, 14, 12, -2, -6 },
  { 1440, 13, 2, 17, 2, -22 },
  { 1444, 5, 5, 15, 1, -4 },
  { 1448, 28, 52, 23, -3, -48 },
  { 1630, 27, 50, 32, 3, -49 },
  { 1799, 15, 48, 32, 9, -48 },
  { 1889, 28, 49, 32, 1, -49 },
  { 2061, 28, 50, 32, 2, -49 },
  { 2236, 28, 48, 32, 1, -48 },
  { 2404, 28, 49, 32, 4, -48 },
  { 2576, 25, 49, 32, 3, -48 },
  { 2730, 26, 48, 32, 6, -48 },
  { 2886, 28, 50, 32, 2, -49 },
  { 3061, 24, 49, 32, 5, -49 },
  { 3208, 10, 36, 12, 1, -35 },
  { 3253, 13, 43, 12, -2, -35 },
  { 3323, 25, 27, 29, 3, -35 },
  { 3408, 25, 15, 32, 4, -29 },
  { 3455, 25, 27, 30, 2, -35 },
  { 3540, 20, 50, 26, 6, -49 },
  { 3665, 46, 61, 52, 2, -46 },
  { 4016, 32, 48, 35, -2, -48 },
  { 4208, 31, 48, 35, 2, -48 },
  { 4394, 32, 50, 37, 4, -49 },
  { 4594, 33, 48, 37, 2, -48 },
  { 4792, 33, 48, 32, 2, -48 },
  { 4990, 33, 48, 32, 2, -48 },
  { 5188, 32, 50, 39, 4, -49 },
  { 5388, 37, 48, 40, 2, -48 },
  { 5610, 11, 48, 16, 3, -48 },
  { 5676, 30, 49, 31, 1, -48 },
  { 5860, 36, 48, 36, 2, -48 },
  { 6076, 23, 48, 30, 2, -48 },
  { 6214, 46, 48, 49, 2, -48 },
  { 6490, 37, 48, 40, 2, -48 },
  { 6712, 32, 50, 38, 4, -49 },
  { 6912, 32, 48, 35, 2, -48 },
  { 7104, 33, 58, 38, 3, -49 },
  { 7344, 32, 48, 37, 2, -48 },
  { 7536, 32, 50, 34, 2, -49 },
  { 7736, 31, 48, 34, 6, -48 },
  { 7922, 33, 49, 38, 4, -48 },
  { 8125, 32, 48, 35, 6, -48 },
  { 8317, 46, 48, 51, 7, -48 },
  { 8593, 37, 48, 34, -1, -48 },
  { 8815, 32, 48, 34, 6, -48 },
  { 9007, 35, 48, 34, 0, -48 },
  { 9217, 18, 64, 14, 1, -54 },
  { 9361, 10, 52, 22, 7, -48 },
  { 9426, 18, 64, 14, -4, -54 },
  { 9570, 18, 24, 24, 4, -48 },
  { 9624, 23, 2, 24, -3, 0 },
  { 9630, 8, 9, 18, 9, -50 },
  { 9639, 26, 37, 30, 1, -36 },
  { 9760, 26, 51, 32, 2, -50 },
  { 9926, 25, 37, 29, 2, -36 },
  { 10042, 29, 51, 32, 3, -50 },
  { 10227, 25, 37, 30, 2, -36 },
  { 10343, 20, 51, 19, 4, -51 },
  { 10471, 29, 50, 32, 0, -36 },
  { 10653, 25, 50, 31, 2, -50 },
  { 10810, 11, 48, 13, 2, -48 },
  { 10876, 21, 62, 13, -8, -48 },
  { 11039, 27, 50, 28, 2, -50 },
  { 11208, 11, 50, 13, 2, -50 },
  { 11277, 45, 36, 50, 1, -36 },
  { 11480, 25, 36, 31, 2, -36 },
  { 11593, 25, 37, 32, 3, -36 },
  { 11709, 29, 50, 32, -1, -36 },
  { 11891, 26, 50, 32, 3, -36 },
  { 12054, 19, 36, 20, 2, -36 },
  { 12140, 25, 37, 29, 1, -36 },
  { 12256, 14, 46, 19, 4, -45 },
  { 12337, 26, 36, 31, 3, -35 },
  { 12454, 24, 35, 28, 4, -35 },
  { 12559, 38, 35, 43, 5, -35 },
  { 12726, 29, 35, 28, -1, -35 },
  { 12853, 32, 49, 27, -3, -35 },
  { 13049, 27, 35, 28, 0, -35 },
  { 13168, 21, 66, 19, 2, -52 },
  { 13342, 12, 57, 14, 1, -48 },
  { 13428, 21, 66, 19, -4, -52 },
  { 13602, 31, 11, 39, 4, -25 },
};

const GFXfont RobotoCondensed_ExtraLightItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC67PT7B_H_
