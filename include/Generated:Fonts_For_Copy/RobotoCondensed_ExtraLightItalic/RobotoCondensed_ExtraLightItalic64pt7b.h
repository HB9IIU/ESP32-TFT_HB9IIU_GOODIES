#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC64PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x01, 0xE0, 0x18, 0x00, 0x30, 0x66, 0x1C, 0xC3, 0x98, 0x67,
  0x0C, 0xE1, 0x98, 0x33, 0x0E, 0x61, 0x9C, 0x33, 0x06, 0x60, 0xCC, 0x18,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x07, 0xF7, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x07, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x18, 0x60, 0x06, 0x00,
  0xC3, 0x80, 0x18, 0x07, 0x0C, 0x00, 0x60, 0x18, 0x30, 0x01, 0x80, 0xC0,
  0xC0, 0x0C, 0x07, 0x03, 0x00, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x30,
  0x06, 0x07, 0x00, 0xE0, 0x18, 0x18, 0x01, 0x80, 0xC0, 0xC0, 0x07, 0x07,
  0x07, 0x00, 0x0F, 0xF8, 0x18, 0x00, 0x1F, 0x80, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x03, 0xF0,
  0x00, 0x18, 0x1F, 0xF0, 0x00, 0xC0, 0xE0, 0xC0, 0x07, 0x07, 0x01, 0x80,
  0x18, 0x18, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x07, 0x03, 0x00, 0x60, 0x18,
  0x1C, 0x00, 0xC0, 0xC0, 0x60, 0x07, 0x07, 0x01, 0x80, 0x18, 0x18, 0x06,
  0x00, 0x60, 0xC0, 0x18, 0x01, 0x86, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80,
  0x18, 0xC0, 0x06, 0x00, 0xC2, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0xC0, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x63, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xE0, 0x70, 0x03, 0x1C, 0x03, 0x80, 0x31, 0x80, 0x38, 0x07,
  0x38, 0x01, 0xC0, 0x73, 0x00, 0x0C, 0x06, 0x70, 0x00, 0xE0, 0x66, 0x00,
  0x06, 0x0E, 0xE0, 0x00, 0x70, 0xCE, 0x00, 0x03, 0x1C, 0xE0, 0x00, 0x39,
  0x8E, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x3B, 0x03, 0x80, 0x07,
  0x38, 0x3C, 0x01, 0xE1, 0x81, 0xFF, 0xF8, 0x1C, 0x07, 0xFF, 0x00, 0xE0,
  0x1F, 0x80, 0x00, 0x19, 0xCE, 0x63, 0x18, 0xCE, 0x63, 0x18, 0xCE, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x1C,
  0x03, 0xF8, 0x18, 0x1F, 0x7E, 0x18, 0xFE, 0x1F, 0xDB, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0x8E, 0x00, 0x03, 0x07, 0x00, 0x07, 0x03, 0x00, 0x0E, 0x03,
  0x80, 0x1C, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x20, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x1C, 0x38,
  0x70, 0xE1, 0x87, 0x0E, 0x38, 0x71, 0xC7, 0x04, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x73, 0xDE, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0E, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x07,
  0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x30, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x78, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x1F, 0x81, 0xF6,
  0x3F, 0x1B, 0xF0, 0xEE, 0x03, 0xA0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x0E,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00,
  0x06, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x87, 0xF0, 0x00, 0x33, 0xFF, 0x00, 0x07, 0xF1, 0xF8,
  0x01, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x70, 0x02, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x18,
  0x7F, 0xE0, 0x19, 0xF0, 0xF8, 0x3B, 0x80, 0x38, 0x37, 0x00, 0x1C, 0x3E,
  0x00, 0x0C, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0x60,
  0x00, 0x1C, 0x60, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x60, 0x3C, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x0F, 0xDF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x60,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x3C, 0xC0, 0x00, 0xF9, 0xC0, 0x03, 0xE3, 0x80,
  0x0E, 0xC3, 0x80, 0x39, 0x83, 0xC3, 0xE7, 0x03, 0xFF, 0x0C, 0x01, 0xF8,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x83, 0xC1,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0x60, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0,
  0x3F, 0xFC, 0x0F, 0x01, 0xC3, 0xC0, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x33,
  0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x03, 0x80, 0x07, 0xFC, 0x00, 0x30,
  0x30, 0x00, 0xF0, 0xF0, 0x03, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x30, 0x60,
  0x03, 0x80, 0x30, 0x03, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x31, 0xC0, 0x1C, 0x00,
  0x60, 0x03, 0x18, 0x01, 0x80, 0x06, 0x00, 0x31, 0x80, 0x38, 0x00, 0x60,
  0x03, 0x30, 0x03, 0x00, 0x06, 0x00, 0x33, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x30, 0x07, 0x00, 0x0C, 0x00, 0x37, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x60,
  0x06, 0x00, 0x0C, 0x00, 0x66, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x60, 0x0E,
  0x00, 0x18, 0x00, 0x66, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x60, 0x0C, 0x00,
  0x18, 0x00, 0xCE, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0xC0, 0x0C, 0x00, 0x30,
  0x01, 0xCC, 0x00, 0xC0, 0x07, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0x70, 0x01,
  0x8C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x0C,
  0x00, 0xC0, 0x1B, 0x00, 0x60, 0xC0, 0x0C, 0x03, 0x30, 0x0C, 0x0E, 0x00,
  0xE0, 0x63, 0x81, 0xC0, 0x60, 0x07, 0xBC, 0x1C, 0x78, 0x06, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x30, 0x03, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x01, 0x80, 0x00, 0xF0, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0x03, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0x80, 0x03, 0xE0, 0x0C, 0x00,
  0x07, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x0F, 0x00, 0xC0, 0x03, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x3C,
  0x01, 0x80, 0x01, 0xE0, 0x03, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xC3,
  0x00, 0x0F, 0xFF, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0xE0, 0x0C,
  0x00, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x00,
  0xE7, 0xE0, 0x00, 0x00, 0x33, 0x9C, 0x00, 0x00, 0x0D, 0xC7, 0x00, 0x00,
  0x03, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x1B, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xB0,
  0x00, 0x00, 0x06, 0xC0, 0x1B, 0x80, 0x00, 0x00, 0xEC, 0x01, 0xB8, 0x00,
  0x00, 0x0C, 0xC0, 0x39, 0x80, 0x00, 0x01, 0xCC, 0x03, 0x98, 0x00, 0x00,
  0x19, 0xC0, 0x31, 0x80, 0x00, 0x03, 0x9C, 0x03, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x31, 0xC0, 0x00, 0x07, 0x18, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x70, 0xC0, 0x00, 0x0E, 0x18, 0x07, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x60,
  0xC0, 0x00, 0x1C, 0x38, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x60, 0xE0,
  0x00, 0x38, 0x30, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x00,
  0x70, 0x70, 0x0E, 0x06, 0x00, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x00, 0xE0,
  0x70, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0x60,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x18, 0x03,
  0x80, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x81,
  0xC0, 0x0C, 0x03, 0x80, 0x18, 0x18, 0x01, 0xC0, 0x38, 0x01, 0x83, 0x80,
  0x1C, 0x03, 0x00, 0x18, 0x30, 0x01, 0xC0, 0x30, 0x01, 0xC7, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x60, 0x01, 0x80, 0x30, 0x00, 0xCE, 0x00, 0x18, 0x07,
  0x00, 0x0C, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xDC, 0x00, 0x38, 0x06, 0x00,
  0x0D, 0x80, 0x03, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x30, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x00,
  0xE0, 0x1F, 0x80, 0x00, 0x0E, 0x01, 0xD8, 0x00, 0x00, 0xC0, 0x19, 0x80,
  0x00, 0x0C, 0x01, 0x9C, 0x00, 0x00, 0xC0, 0x38, 0xC0, 0x00, 0x1C, 0x03,
  0x8C, 0x00, 0x01, 0xC0, 0x38, 0xE0, 0x00, 0x1C, 0x03, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x70, 0x00, 0x18, 0x03, 0x03, 0x00, 0x01, 0x80, 0x70, 0x30,
  0x00, 0x38, 0x07, 0x03, 0x80, 0x03, 0x80, 0x70, 0x18, 0x00, 0x38, 0x06,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x0C, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x18, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x18, 0x00, 0x0C, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0xC0, 0x18, 0x00, 0x0E, 0x0C, 0x03, 0x80, 0x00, 0x61, 0xC0, 0x38,
  0x00, 0x06, 0x1C, 0x03, 0x80, 0x00, 0x71, 0xC0, 0x30, 0x00, 0x03, 0x18,
  0x03, 0x00, 0x00, 0x39, 0x80, 0x30, 0x00, 0x01, 0xB8, 0x07, 0x00, 0x00,
  0x1B, 0x80, 0x70, 0x00, 0x01, 0xF8, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x60,
  0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x1F, 0x80, 0x06,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x06, 0x00, 0x03, 0xE0, 0x0C, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xE0, 0x06, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x70, 0x07, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x38, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xC0, 0x00, 0x1D,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x30,
  0x00, 0x0D, 0x80, 0x00, 0x71, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x0C, 0x00,
  0x07, 0x60, 0x00, 0x38, 0x60, 0x00, 0x33, 0x00, 0x01, 0xC3, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x18, 0x00, 0x18, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xC3,
  0x00, 0x06, 0x06, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x38, 0x00, 0x60, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x30, 0x01,
  0xC0, 0x70, 0x01, 0x81, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x60,
  0x1C, 0x00, 0xC0, 0x60, 0x07, 0x00, 0xE0, 0x06, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x70, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x06,
  0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xC3, 0x80,
  0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80,
  0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x70, 0x0C, 0x0C,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x87,
  0x00, 0x61, 0x80, 0x18, 0xE0, 0x06, 0x30, 0x01, 0x9C, 0x00, 0x66, 0x00,
  0x1C, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x70, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x06, 0x07, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x60, 0x18, 0x00, 0x38, 0x1C, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01,
  0xF8, 0x03, 0x81, 0xE0, 0x01, 0xC1, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x61,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03,
  0xC3, 0x80, 0x03, 0xE0, 0xE0, 0x07, 0x70, 0x78, 0x07, 0x38, 0x1F, 0xFF,
  0x1C, 0x07, 0xFE, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x38, 0xFF, 0xC0, 0x0C, 0x7F, 0xF8,
  0x03, 0x38, 0x07, 0x00, 0xD8, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00,
  0x06, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x18, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x07, 0x80, 0x01, 0xC1, 0xF0, 0x00, 0x60, 0x6E, 0x00, 0x38, 0x19, 0xC0,
  0x3C, 0x06, 0x3F, 0x7E, 0x01, 0x83, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x1C,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x70, 0x00, 0x60, 0x38, 0x00, 0xE0,
  0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x3C, 0x03, 0x00,
  0x3F, 0xF0, 0x60, 0x0F, 0xDF, 0x1C, 0x03, 0x80, 0x73, 0x80, 0xE0, 0x03,
  0x60, 0x38, 0x00, 0x2C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x07, 0x06, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x80, 0x01,
  0xC0, 0x30, 0x00, 0x78, 0x07, 0x00, 0x1F, 0x00, 0x70, 0x0E, 0xE0, 0x0F,
  0xFF, 0x98, 0x00, 0xFF, 0xC3, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x20, 0x38, 0x00, 0x70, 0x1C, 0x01,
  0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0x83, 0x00, 0x3F, 0x7C, 0x70, 0x07, 0x00, 0xE7, 0x00, 0xE0, 0x03,
  0x60, 0x1C, 0x00, 0x36, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xE0, 0x0F,
  0x00, 0xEE, 0x00, 0x7F, 0xFC, 0xC0, 0x03, 0xFF, 0x0C, 0x00, 0x07, 0xC0,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xE0, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x0F, 0x80, 0x0E, 0x1F, 0xF0, 0x06, 0x3F, 0xFC, 0x03, 0x38, 0x07,
  0x01, 0x98, 0x01, 0x80, 0xD8, 0x00, 0xE0, 0xF8, 0x00, 0x70, 0x78, 0x00,
  0x18, 0x3C, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03,
  0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x8F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x01, 0x80, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0C,
  0xF0, 0x00, 0x03, 0x7C, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x7C, 0xE0, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x38,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x80, 0x60, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x60, 0xFF, 0x80, 0x3F, 0xE0, 0x0C, 0x7F, 0xF8,
  0x1F, 0xBE, 0x01, 0x9C, 0x03, 0x87, 0x00, 0xE0, 0x77, 0x00, 0x71, 0xC0,
  0x0C, 0x0F, 0xC0, 0x07, 0x70, 0x01, 0xC1, 0xF0, 0x00, 0xEC, 0x00, 0x18,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x60, 0x00, 0x18, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE1, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x80,
  0x00, 0x61, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x86, 0x00, 0x01, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x60, 0x00, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xC3,
  0xFE, 0x00, 0xC3, 0xFF, 0x80, 0x67, 0x00, 0xE0, 0x33, 0x00, 0x30, 0x1B,
  0x00, 0x1C, 0x1F, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x07, 0x80, 0x01, 0x83,
  0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00,
  0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x3C, 0x03, 0xC0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x87, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0C, 0x3F, 0xF0, 0x00, 0xC7, 0xFF,
  0x80, 0x0C, 0xE0, 0x1C, 0x00, 0xD8, 0x00, 0xE0, 0x0F, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30,
  0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x70, 0x1F,
  0x00, 0x06, 0x01, 0xB0, 0x00, 0xE0, 0x19, 0xC0, 0x3C, 0x01, 0x8F, 0xDF,
  0x80, 0x18, 0x7F, 0xE0, 0x03, 0x80, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0xC0, 0x7F, 0xF8, 0xE0,
  0x70, 0x0E, 0x70, 0x70, 0x01, 0xB0, 0x70, 0x00, 0x58, 0x70, 0x00, 0x3C,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x38, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30,
  0x00, 0x0E, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x03, 0xC0, 0xE0, 0x03, 0xE0, 0x78, 0x07, 0x70, 0x1F, 0xFF, 0x30,
  0x07, 0xFE, 0x18, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x71,
  0xFC, 0x0C, 0x7F, 0x81, 0x9C, 0x00, 0x36, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0xFF,
  0xFF, 0xFE, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x86,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30,
  0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x70, 0x00,
  0x0C, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x0F, 0x03, 0x00, 0x0F, 0x81, 0xC0, 0x0F, 0xC0, 0x70, 0x0E, 0xC0,
  0x3F, 0xFE, 0x60, 0x0F, 0xFC, 0x30, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x73, 0x00, 0x00, 0xE6, 0x00, 0x01,
  0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60,
  0xE0, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x83,
  0x00, 0x07, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0,
  0x00, 0x33, 0x80, 0x00, 0x66, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x06, 0xE0, 0x00, 0xE0,
  0x00, 0xEE, 0x00, 0x1E, 0x00, 0x0C, 0xE0, 0x01, 0xE0, 0x01, 0xCE, 0x00,
  0x3E, 0x00, 0x1C, 0xE0, 0x03, 0x60, 0x01, 0x86, 0x00, 0x37, 0x00, 0x38,
  0x60, 0x06, 0x70, 0x03, 0x06, 0x00, 0x67, 0x00, 0x70, 0x60, 0x0E, 0x30,
  0x07, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x1C, 0x30, 0x0E, 0x06, 0x01,
  0x83, 0x00, 0xC0, 0x60, 0x18, 0x30, 0x1C, 0x06, 0x03, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x30, 0x18, 0x07, 0x07, 0x03, 0x03, 0x80, 0x70, 0x60, 0x38,
  0x30, 0x07, 0x0E, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x18, 0x60, 0x07, 0x1C,
  0x01, 0x86, 0x00, 0x31, 0x80, 0x18, 0xE0, 0x03, 0x18, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x01, 0x98, 0x00, 0x37, 0x00, 0x19,
  0x80, 0x03, 0x60, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x01, 0xB0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x00, 0xE0,
  0x00, 0x70, 0x18, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x60, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xC7, 0x9F, 0x00, 0x06, 0x70, 0x38,
  0x00, 0x33, 0x00, 0xE0, 0x03, 0x30, 0x03, 0x80, 0x19, 0x80, 0x0E, 0x01,
  0xDC, 0x00, 0x38, 0x1C, 0xC0, 0x00, 0xF3, 0xC6, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 47, 12, 1, -46 },
  { 66, 11, 13, 17, 7, -48 },
  { 84, 32, 46, 31, 1, -46 },
  { 268, 27, 60, 30, 2, -53 },
  { 471, 30, 48, 40, 6, -47 },
  { 651, 28, 48, 33, 2, -47 },
  { 819, 5, 13, 10, 6, -48 },
  { 828, 18, 66, 17, 3, -51 },
  { 977, 18, 66, 18, -4, -51 },
  { 1126, 24, 25, 26, 4, -46 },
  { 1201, 26, 32, 31, 3, -37 },
  { 1305, 7, 13, 12, -2, -5 },
  { 1317, 13, 2, 16, 2, -21 },
  { 1321, 5, 4, 14, 1, -3 },
  { 1324, 26, 50, 22, -2, -46 },
  { 1487, 25, 48, 30, 3, -47 },
  { 1637, 14, 46, 30, 9, -46 },
  { 1718, 27, 47, 30, 1, -47 },
  { 1877, 26, 48, 30, 2, -47 },
  { 2033, 27, 46, 30, 1, -46 },
  { 2189, 27, 47, 30, 4, -46 },
  { 2348, 24, 47, 30, 3, -46 },
  { 2489, 26, 46, 30, 5, -46 },
  { 2639, 27, 48, 30, 2, -47 },
  { 2801, 23, 47, 30, 5, -47 },
  { 2937, 9, 33, 12, 1, -32 },
  { 2975, 12, 40, 11, -2, -32 },
  { 3035, 24, 26, 28, 3, -34 },
  { 3113, 25, 14, 30, 3, -28 },
  { 3157, 24, 26, 28, 2, -34 },
  { 3235, 19, 48, 25, 6, -47 },
  { 3349, 44, 58, 49, 2, -44 },
  { 3668, 31, 46, 33, -2, -46 },
  { 3847, 29, 46, 33, 2, -46 },
  { 4014, 30, 48, 35, 4, -47 },
  { 4194, 31, 46, 36, 2, -46 },
  { 4373, 31, 46, 31, 2, -46 },
  { 4552, 31, 46, 31, 2, -46 },
  { 4731, 31, 48, 37, 4, -47 },
  { 4917, 35, 46, 38, 2, -46 },
  { 5119, 10, 46, 15, 3, -46 },
  { 5177, 28, 47, 30, 1, -46 },
  { 5342, 34, 46, 34, 2, -46 },
  { 5538, 22, 46, 29, 2, -46 },
  { 5665, 44, 46, 46, 2, -46 },
  { 5918, 36, 46, 38, 2, -46 },
  { 6125, 31, 48, 36, 3, -47 },
  { 6311, 31, 46, 33, 2, -46 },
  { 6490, 31, 55, 36, 3, -47 },
  { 6704, 31, 46, 35, 2, -46 },
  { 6883, 30, 48, 32, 2, -47 },
  { 7063, 29, 46, 33, 6, -46 },
  { 7230, 32, 47, 36, 4, -46 },
  { 7418, 30, 46, 33, 6, -46 },
  { 7591, 45, 46, 48, 6, -46 },
  { 7850, 36, 46, 33, -1, -46 },
  { 8057, 30, 46, 33, 6, -46 },
  { 8230, 33, 46, 33, 0, -46 },
  { 8420, 18, 62, 13, 0, -52 },
  { 8560, 9, 50, 21, 7, -46 },
  { 8617, 18, 62, 13, -4, -52 },
  { 8757, 18, 23, 23, 3, -46 },
  { 8809, 23, 2, 23, -3, 0 },
  { 8815, 8, 8, 17, 8, -48 },
  { 8823, 25, 36, 29, 1, -35 },
  { 8936, 26, 49, 30, 1, -48 },
  { 9096, 24, 36, 28, 2, -35 },
  { 9204, 27, 49, 30, 3, -48 },
  { 9370, 24, 36, 28, 2, -35 },
  { 9478, 19, 49, 18, 4, -49 },
  { 9595, 28, 48, 30, 0, -35 },
  { 9763, 25, 48, 30, 1, -48 },
  { 9913, 11, 46, 13, 2, -46 },
  { 9977, 21, 59, 13, -8, -46 },
  { 10132, 26, 48, 26, 1, -48 },
  { 10288, 11, 48, 13, 2, -48 },
  { 10354, 43, 35, 48, 1, -35 },
  { 10543, 25, 35, 30, 1, -35 },
  { 10653, 25, 36, 30, 2, -35 },
  { 10766, 28, 48, 30, -1, -35 },
  { 10934, 25, 48, 30, 3, -35 },
  { 11084, 19, 35, 19, 1, -35 },
  { 11168, 24, 36, 28, 1, -35 },
  { 11276, 13, 44, 18, 4, -43 },
  { 11348, 25, 35, 30, 3, -34 },
  { 11458, 23, 34, 26, 4, -34 },
  { 11556, 36, 34, 41, 5, -34 },
  { 11709, 27, 34, 26, -1, -34 },
  { 11824, 30, 47, 26, -3, -34 },
  { 12001, 26, 34, 26, 0, -34 },
  { 12112, 20, 63, 18, 2, -50 },
  { 12270, 11, 54, 13, 1, -46 },
  { 12345, 20, 63, 18, -4, -50 },
  { 12503, 29, 11, 37, 4, -25 },
};

const GFXfont RobotoCondensed_ExtraLightItalic64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC64PT7B_H_
