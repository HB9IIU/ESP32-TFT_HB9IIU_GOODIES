#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC26PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x40, 0x00, 0x08, 0x80, 0x59,
  0x99, 0xA0, 0x02, 0x10, 0x11, 0x00, 0x88, 0x08, 0x40, 0x44, 0x1F, 0xFC,
  0x21, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x22, 0x01, 0x10, 0x7F,
  0xE0, 0x88, 0x04, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x01, 0x00, 0x20,
  0x1E, 0x0C, 0x61, 0x04, 0x40, 0x48, 0x09, 0x01, 0x20, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x00, 0x24, 0x04, 0x80, 0x90, 0x13, 0x06, 0x21,
  0x83, 0xE0, 0x10, 0x04, 0x00, 0x18, 0x01, 0x20, 0x10, 0x80, 0x84, 0x48,
  0x44, 0x42, 0x22, 0x12, 0x09, 0x20, 0x79, 0x00, 0x10, 0x01, 0x38, 0x0A,
  0x20, 0x91, 0x08, 0x84, 0x48, 0x44, 0x42, 0x42, 0x10, 0x09, 0x00, 0x30,
  0x07, 0x01, 0x10, 0x42, 0x08, 0x41, 0x08, 0x23, 0x04, 0xC0, 0xB0, 0x08,
  0x03, 0x80, 0x90, 0x21, 0x1C, 0x23, 0x02, 0x60, 0x54, 0x06, 0x80, 0x88,
  0x68, 0xF1, 0x00, 0xF8, 0x02, 0x04, 0x10, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x40, 0x40, 0x10, 0x10, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x10, 0x41, 0x02, 0x00, 0x04, 0x02, 0x02, 0x11, 0x16, 0xF0, 0xC0, 0x60,
  0x48, 0x46, 0x41, 0x00, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x3F, 0xF8, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x24, 0xA8,
  0xF8, 0xC0, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x00, 0x07, 0x81, 0x18, 0x41, 0x10,
  0x22, 0x04, 0x40, 0x50, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x40, 0x28,
  0x09, 0x01, 0x20, 0x24, 0x08, 0x41, 0x08, 0x40, 0xF0, 0x00, 0x04, 0xF4,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x00, 0x0F, 0x84, 0x32, 0x04, 0x81, 0x40, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0F,
  0xF8, 0x07, 0x83, 0x18, 0xC1, 0x10, 0x22, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x01, 0x81, 0xC0, 0x04, 0x00, 0x40, 0x08, 0x01, 0x20, 0x24, 0x04, 0x81,
  0x08, 0x60, 0xF0, 0x00, 0x00, 0x40, 0x30, 0x14, 0x06, 0x02, 0x81, 0x20,
  0x88, 0x22, 0x10, 0x88, 0x42, 0x11, 0x04, 0x81, 0x3F, 0xF0, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x1F, 0xC2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0xF0, 0x61, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x20,
  0x44, 0x08, 0x83, 0x18, 0x40, 0xF0, 0x00, 0x01, 0xC1, 0x80, 0x80, 0x40,
  0x30, 0x08, 0x02, 0x01, 0x3C, 0x50, 0x98, 0x24, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x09, 0x02, 0x41, 0x18, 0xC3, 0xC0, 0x7F, 0xE0, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x00, 0x07, 0x83,
  0x08, 0x41, 0x10, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x10, 0x83, 0xE0,
  0x84, 0x20, 0x48, 0x09, 0x00, 0xA0, 0x24, 0x04, 0x81, 0x88, 0x60, 0xF0,
  0x00, 0x1E, 0x18, 0x98, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x68, 0x53, 0xD0, 0x08, 0x08, 0x04, 0x04, 0x0C, 0x38, 0x00, 0x13,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x11, 0x88, 0x80, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x10, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x04, 0x0C,
  0x18, 0x30, 0x30, 0x20, 0x00, 0x1E, 0x22, 0x41, 0x41, 0x81, 0x01, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x00, 0x00, 0x00, 0x40, 0x40,
  0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x10, 0x20, 0x02, 0x10, 0x00, 0x84,
  0x1C, 0x12, 0x18, 0x84, 0x84, 0x21, 0x42, 0x08, 0x50, 0x84, 0x14, 0x41,
  0x06, 0x10, 0x42, 0x84, 0x10, 0xA1, 0x08, 0x28, 0x82, 0x0A, 0x21, 0x84,
  0x84, 0xA2, 0x21, 0xC7, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x04, 0x00, 0x3E, 0x00, 0x00, 0x40, 0x06, 0x00, 0x28, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x04, 0x20, 0x21, 0x02, 0x04,
  0x10, 0x21, 0xFF, 0x08, 0x08, 0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0xB0,
  0x02, 0x1F, 0x81, 0x06, 0x10, 0x21, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22,
  0x06, 0x20, 0xC7, 0xF0, 0x40, 0xC4, 0x04, 0x40, 0x24, 0x02, 0x40, 0x68,
  0x04, 0x80, 0xC8, 0x18, 0xFE, 0x00, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x20,
  0x32, 0x00, 0x90, 0x04, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x07,
  0xC0, 0x1F, 0xC0, 0x83, 0x04, 0x0C, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11,
  0x00, 0x90, 0x08, 0x80, 0xC4, 0x0C, 0x3F, 0x80, 0x1F, 0xF1, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x07, 0xFC, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0xFE, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x07, 0xC1, 0x82, 0x30,
  0x12, 0x01, 0x40, 0x14, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x83,
  0xE8, 0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0xC0, 0x46, 0x18, 0x3E,
  0x00, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22,
  0x00, 0x88, 0x02, 0x20, 0x09, 0xFF, 0xE4, 0x01, 0x10, 0x04, 0x40, 0x11,
  0x00, 0x44, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x00, 0x11,
  0x11, 0x13, 0x22, 0x22, 0x26, 0x44, 0x44, 0x48, 0x80, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x40, 0x84, 0x08, 0x41, 0x06, 0x30,
  0x3E, 0x00, 0x10, 0x08, 0x40, 0x41, 0x02, 0x08, 0x10, 0x20, 0x80, 0x84,
  0x02, 0x20, 0x09, 0x80, 0x2C, 0x01, 0x70, 0x07, 0x60, 0x18, 0x80, 0x43,
  0x01, 0x04, 0x04, 0x18, 0x20, 0x20, 0x80, 0xC2, 0x01, 0x08, 0x06, 0x00,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x3F, 0xE0, 0x10, 0x00,
  0x86, 0x00, 0x61, 0x80, 0x18, 0xA0, 0x0A, 0x28, 0x02, 0x8A, 0x01, 0x22,
  0x40, 0x50, 0x90, 0x24, 0x24, 0x09, 0x11, 0x04, 0x44, 0x41, 0x11, 0x10,
  0x84, 0x42, 0x22, 0x10, 0x90, 0x84, 0x24, 0x22, 0x0A, 0x08, 0x82, 0x82,
  0x20, 0xC0, 0x88, 0x10, 0x40, 0x10, 0x04, 0x60, 0x11, 0x80, 0x4E, 0x01,
  0x24, 0x0C, 0x90, 0x22, 0x40, 0x88, 0x82, 0x22, 0x09, 0x84, 0x24, 0x11,
  0x90, 0x44, 0x40, 0x91, 0x02, 0x44, 0x09, 0x30, 0x14, 0x80, 0x72, 0x00,
  0x88, 0x02, 0x00, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x20, 0x12, 0x00, 0x90,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01,
  0x40, 0x09, 0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x07, 0xC0, 0x1F, 0xC1,
  0x02, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x24,
  0x04, 0x7F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x20, 0x12, 0x00, 0x90,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x07, 0xC0, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x1F, 0xC1, 0x02, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x03, 0x20, 0x24, 0x04, 0x7F, 0x84, 0x10, 0x41, 0x04, 0x08,
  0x40, 0x88, 0x08, 0x80, 0x48, 0x04, 0x80, 0x40, 0x07, 0xC1, 0x82, 0x10,
  0x32, 0x01, 0x20, 0x12, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x70, 0x01,
  0x80, 0x04, 0x00, 0x48, 0x02, 0x80, 0x48, 0x04, 0x80, 0xC6, 0x18, 0x3E,
  0x00, 0x7F, 0xF0, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x02, 0x20, 0x11, 0x00, 0x88, 0x0C, 0x40, 0x41, 0x0C, 0x07,
  0xC0, 0x80, 0x16, 0x00, 0x90, 0x08, 0x80, 0x44, 0x06, 0x20, 0x21, 0x01,
  0x08, 0x10, 0x40, 0x81, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00,
  0x90, 0x04, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x80, 0xA0, 0x20,
  0x28, 0x18, 0x0A, 0x06, 0x04, 0x82, 0x81, 0x20, 0x90, 0x48, 0x24, 0x22,
  0x11, 0x08, 0x84, 0x46, 0x22, 0x11, 0x08, 0x84, 0x42, 0x21, 0x20, 0x90,
  0x48, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x10, 0x08,
  0x04, 0x02, 0x00, 0x10, 0x04, 0x40, 0x20, 0x81, 0x02, 0x0C, 0x0C, 0x20,
  0x11, 0x00, 0x4C, 0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x40,
  0x08, 0x80, 0x62, 0x01, 0x04, 0x08, 0x10, 0x60, 0x41, 0x00, 0x88, 0x02,
  0x00, 0x40, 0x12, 0x01, 0x90, 0x08, 0xC0, 0x82, 0x04, 0x10, 0x40, 0x84,
  0x02, 0x20, 0x12, 0x00, 0xA0, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x1F, 0xFC, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x0F, 0xFE, 0x00, 0x0E, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x40, 0xF0, 0x92, 0x49, 0x12, 0x49, 0x24, 0x89, 0x24, 0x92,
  0x0E, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xF0, 0x04, 0x18, 0x30, 0x91, 0x24, 0x48, 0xA1, 0x42, 0xFF, 0x80, 0x4C,
  0x80, 0x07, 0x86, 0x13, 0x04, 0x81, 0x00, 0x40, 0x10, 0xFC, 0xC1, 0x40,
  0x90, 0x28, 0x09, 0x06, 0x42, 0x8F, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0xF0, 0xC2, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x50,
  0x18, 0x0A, 0x02, 0x80, 0xA0, 0x4C, 0x32, 0x70, 0x0F, 0x0C, 0x26, 0x09,
  0x02, 0x40, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x12, 0x04, 0x42,
  0x0F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x83, 0x91,
  0x8E, 0x20, 0xC8, 0x09, 0x01, 0x20, 0x48, 0x09, 0x01, 0x20, 0x24, 0x04,
  0x80, 0x90, 0x21, 0x0C, 0x1E, 0x80, 0x0F, 0x0C, 0x26, 0x09, 0x02, 0x40,
  0x60, 0x2F, 0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x43, 0x0F, 0x00,
  0x07, 0x08, 0x08, 0x10, 0x10, 0x10, 0x7E, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x0F, 0x23, 0x1C, 0x41,
  0x90, 0x12, 0x02, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20,
  0x42, 0x18, 0x3D, 0x00, 0x20, 0x04, 0x01, 0x08, 0x40, 0xF0, 0x00, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x70, 0xE2, 0x20, 0x98, 0x14,
  0x05, 0x02, 0x40, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04,
  0x11, 0x00, 0x02, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x80, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0xE0, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0C, 0x86, 0x23, 0x11, 0x84, 0xC1,
  0x60, 0x70, 0x12, 0x04, 0x82, 0x10, 0x84, 0x20, 0x88, 0x22, 0x04, 0x11,
  0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x88, 0x2F, 0x0F, 0x18,
  0x48, 0xD8, 0x28, 0x2C, 0x08, 0x14, 0x04, 0x0A, 0x04, 0x05, 0x02, 0x02,
  0x81, 0x02, 0x80, 0x81, 0x40, 0x40, 0xA0, 0x20, 0x50, 0x20, 0x28, 0x10,
  0x14, 0x08, 0x10, 0x27, 0x0E, 0x22, 0x09, 0x81, 0x40, 0x50, 0x24, 0x09,
  0x02, 0x40, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x40, 0x0F, 0x0C, 0x22,
  0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x04,
  0x43, 0x0F, 0x00, 0x17, 0x83, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x46, 0x18, 0xBC, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x0E, 0x4C, 0x72, 0x0D, 0x01, 0x40,
  0x50, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x43, 0x0F, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x2E, 0x60, 0x83, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x00, 0x0F, 0x84, 0x32, 0x04, 0x81,
  0x20, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x24, 0x09, 0x02, 0x41, 0x0F,
  0x80, 0x10, 0x41, 0x1F, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x10, 0x70, 0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x50, 0x24, 0x09, 0x02,
  0x80, 0xA0, 0x28, 0x1A, 0x04, 0x43, 0x0F, 0x40, 0x80, 0xC0, 0xA0, 0x50,
  0x48, 0x24, 0x11, 0x10, 0x88, 0x48, 0x24, 0x14, 0x0A, 0x02, 0x01, 0x00,
  0x81, 0x05, 0x06, 0x0A, 0x0C, 0x14, 0x28, 0x48, 0x50, 0x91, 0x22, 0x22,
  0x44, 0x24, 0x88, 0x51, 0x20, 0xA1, 0x41, 0x83, 0x03, 0x06, 0x04, 0x0C,
  0x08, 0x10, 0x00, 0x20, 0x42, 0x08, 0x42, 0x08, 0x80, 0xB0, 0x14, 0x01,
  0x00, 0x60, 0x0C, 0x02, 0x40, 0x88, 0x30, 0x84, 0x11, 0x03, 0x00, 0x10,
  0x11, 0x02, 0x10, 0x21, 0x04, 0x10, 0x41, 0x0C, 0x08, 0x80, 0x98, 0x09,
  0x00, 0x90, 0x0A, 0x00, 0xA0, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x03, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0xFF, 0x00,
  0x01, 0x06, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x60,
  0x80, 0x40, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x44, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42,
  0x10, 0x84, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0xC0, 0x00, 0x78, 0x2C, 0xC2, 0x86,
  0x28, 0x3C,
};

const GFXglyph RobotoCondensed_ExtraLightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 19, 5, 1, -19 },
  { 11, 4, 5, 7, 3, -20 },
  { 14, 13, 19, 13, 1, -19 },
  { 45, 11, 23, 12, 1, -21 },
  { 77, 13, 19, 16, 2, -19 },
  { 108, 11, 19, 14, 1, -19 },
  { 135, 1, 5, 4, 3, -20 },
  { 136, 7, 27, 7, 1, -21 },
  { 160, 7, 27, 7, -1, -21 },
  { 184, 9, 10, 11, 2, -19 },
  { 196, 11, 13, 12, 1, -15 },
  { 214, 3, 5, 5, -1, -2 },
  { 216, 5, 1, 7, 1, -9 },
  { 217, 1, 2, 6, 1, -2 },
  { 218, 11, 21, 9, -1, -19 },
  { 247, 11, 19, 12, 1, -19 },
  { 274, 6, 19, 12, 3, -19 },
  { 289, 10, 19, 12, 1, -19 },
  { 313, 11, 19, 12, 1, -19 },
  { 340, 10, 19, 12, 1, -19 },
  { 364, 11, 19, 12, 2, -19 },
  { 391, 10, 19, 12, 1, -19 },
  { 415, 11, 19, 12, 2, -19 },
  { 442, 11, 19, 12, 1, -19 },
  { 469, 9, 19, 12, 2, -19 },
  { 491, 4, 14, 5, 0, -14 },
  { 498, 5, 17, 5, -1, -14 },
  { 509, 10, 11, 11, 1, -14 },
  { 523, 10, 7, 12, 1, -12 },
  { 532, 9, 11, 11, 1, -14 },
  { 545, 8, 19, 10, 2, -19 },
  { 564, 18, 24, 20, 1, -18 },
  { 618, 13, 19, 14, -1, -19 },
  { 649, 12, 19, 13, 1, -19 },
  { 678, 13, 19, 14, 1, -19 },
  { 709, 13, 19, 14, 1, -19 },
  { 740, 12, 19, 13, 1, -19 },
  { 769, 13, 19, 13, 1, -19 },
  { 800, 12, 19, 15, 2, -19 },
  { 829, 14, 19, 16, 1, -19 },
  { 863, 4, 19, 6, 1, -19 },
  { 873, 12, 19, 12, 0, -19 },
  { 902, 14, 19, 14, 1, -19 },
  { 936, 9, 19, 12, 1, -19 },
  { 958, 18, 19, 19, 1, -19 },
  { 1001, 14, 19, 16, 1, -19 },
  { 1035, 13, 19, 15, 1, -19 },
  { 1066, 12, 19, 13, 1, -19 },
  { 1095, 13, 22, 15, 1, -19 },
  { 1131, 12, 19, 14, 1, -19 },
  { 1160, 12, 19, 13, 1, -19 },
  { 1189, 12, 19, 13, 2, -19 },
  { 1218, 13, 19, 15, 1, -19 },
  { 1249, 13, 19, 13, 2, -19 },
  { 1280, 18, 19, 20, 3, -19 },
  { 1323, 14, 19, 13, 0, -19 },
  { 1357, 13, 19, 13, 2, -19 },
  { 1388, 14, 19, 13, 0, -19 },
  { 1422, 7, 25, 5, 0, -21 },
  { 1444, 3, 21, 9, 3, -19 },
  { 1452, 8, 25, 5, -2, -21 },
  { 1477, 7, 9, 9, 1, -19 },
  { 1485, 9, 1, 9, -1, 0 },
  { 1487, 3, 3, 7, 3, -19 },
  { 1489, 10, 14, 12, 0, -14 },
  { 1507, 10, 20, 12, 1, -20 },
  { 1532, 10, 14, 11, 1, -14 },
  { 1550, 11, 20, 12, 1, -20 },
  { 1578, 10, 14, 11, 1, -14 },
  { 1596, 8, 20, 7, 1, -20 },
  { 1616, 11, 19, 12, 0, -14 },
  { 1643, 10, 20, 12, 1, -20 },
  { 1668, 4, 19, 5, 1, -19 },
  { 1678, 8, 24, 5, -3, -19 },
  { 1702, 10, 20, 11, 1, -20 },
  { 1727, 4, 20, 5, 1, -20 },
  { 1737, 17, 14, 19, 1, -14 },
  { 1767, 10, 14, 12, 1, -14 },
  { 1785, 10, 14, 12, 1, -14 },
  { 1803, 11, 19, 12, 0, -14 },
  { 1830, 10, 19, 12, 1, -14 },
  { 1854, 7, 14, 8, 1, -14 },
  { 1867, 10, 14, 11, 0, -14 },
  { 1885, 6, 17, 7, 1, -17 },
  { 1898, 10, 14, 12, 1, -14 },
  { 1916, 9, 14, 11, 2, -14 },
  { 1932, 15, 14, 17, 2, -14 },
  { 1959, 11, 14, 11, 0, -14 },
  { 1979, 12, 19, 11, -1, -14 },
  { 2008, 11, 14, 11, 0, -14 },
  { 2028, 8, 25, 7, 1, -20 },
  { 2053, 5, 22, 5, 0, -19 },
  { 2067, 9, 25, 7, -2, -20 },
  { 2096, 12, 4, 15, 2, -10 },
};

const GFXfont RobotoCondensed_ExtraLightItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC26PT7B_H_
