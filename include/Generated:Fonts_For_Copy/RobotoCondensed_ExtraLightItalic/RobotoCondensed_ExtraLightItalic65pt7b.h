#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC65PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x66, 0x0C, 0xC1, 0x98, 0x73,
  0x0E, 0xE1, 0x9C, 0x33, 0x06, 0x60, 0xCC, 0x39, 0x86, 0x70, 0xCC, 0x19,
  0x83, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0xF0, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x80, 0x0E,
  0x00, 0x78, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x02, 0x18, 0x01, 0x80, 0x1C, 0x60, 0x06, 0x00, 0x61, 0x80, 0x18, 0x03,
  0x0E, 0x00, 0x60, 0x1C, 0x30, 0x01, 0x80, 0x60, 0xC0, 0x06, 0x03, 0x03,
  0x00, 0x38, 0x1C, 0x0C, 0x00, 0xC0, 0xE0, 0x30, 0x03, 0x03, 0x00, 0xC0,
  0x1C, 0x18, 0x01, 0x80, 0x60, 0xE0, 0x06, 0x03, 0x83, 0x00, 0x1C, 0x1C,
  0x18, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x7F, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x7E, 0x00, 0x03, 0x07, 0xFC, 0x00, 0x18, 0x38, 0x38,
  0x00, 0xE0, 0xC0, 0x60, 0x07, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00,
  0xC0, 0xC0, 0x0C, 0x07, 0x03, 0x00, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0xC0,
  0x70, 0x03, 0x07, 0x01, 0x80, 0x0C, 0x18, 0x06, 0x00, 0x30, 0xC0, 0x18,
  0x01, 0xC7, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x06, 0x00,
  0x61, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x0F, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x06, 0x00, 0x71, 0xC0, 0x38, 0x03, 0x0E, 0x00, 0xC0, 0x18,
  0xE0, 0x07, 0x00, 0xC6, 0x00, 0x1C, 0x0E, 0x70, 0x00, 0xE0, 0x63, 0x00,
  0x03, 0x83, 0x18, 0x00, 0x0C, 0x39, 0xC0, 0x00, 0x71, 0x8E, 0x00, 0x01,
  0x9C, 0x70, 0x00, 0x0E, 0xC3, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0,
  0x60, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF8, 0x1C, 0x00, 0x0E, 0xE0, 0x70,
  0x00, 0xE3, 0x03, 0xC0, 0x1E, 0x1C, 0x07, 0xFF, 0xC0, 0x60, 0x1F, 0xFC,
  0x03, 0x80, 0x1F, 0x00, 0x00, 0x18, 0xCE, 0x73, 0x98, 0xC6, 0x73, 0x98,
  0xC6, 0x30, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x03, 0x7C, 0x0E, 0x0F, 0xDF,
  0x86, 0x1F, 0x81, 0xFB, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x70, 0xC3,
  0x8E, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xDE, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x38, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x18, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70,
  0x1C, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x07,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xF6, 0x3F, 0x1B, 0xF0, 0x6E, 0x03, 0xA0,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x78, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x0C, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x1E,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x60, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x1C, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC7, 0xF0, 0x00,
  0x33, 0xFF, 0x80, 0x07, 0xF9, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0x70, 0x02, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x18, 0x7F, 0xF0, 0x18, 0xF0, 0xF8, 0x3B,
  0xC0, 0x3C, 0x3F, 0x00, 0x1C, 0x36, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38,
  0x00, 0x06, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0x30, 0x00, 0x30, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x1E,
  0x03, 0xC0, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x70, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xF0, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x0C,
  0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0x60, 0x00, 0x7C, 0x70,
  0x00, 0xFC, 0x38, 0x01, 0xDC, 0x38, 0x03, 0x98, 0x1F, 0x1F, 0x18, 0x0F,
  0xFE, 0x38, 0x03, 0xF0, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0x81, 0xF0, 0x78, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x18, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x01, 0xC1, 0xC0, 0x1C, 0x70,
  0x01, 0x8C, 0x00, 0x3B, 0x80, 0x07, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x18,
  0x06, 0x00, 0x0F, 0xF8, 0x00, 0x40, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0x03,
  0x00, 0x1C, 0x03, 0x80, 0x18, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xC1, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0x8E, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x60, 0x07, 0x00,
  0x0C, 0x00, 0x63, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x38, 0x03, 0x80, 0x06,
  0x00, 0x19, 0x80, 0x18, 0x00, 0x30, 0x01, 0xCC, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x60, 0x0E, 0x00, 0x1C, 0x00, 0x67, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x30, 0x03, 0x00, 0x06, 0x00, 0x19, 0x80, 0x18, 0x00, 0x30, 0x01, 0xCC,
  0x01, 0xC0, 0x03, 0x80, 0x0C, 0x60, 0x0C, 0x00, 0x18, 0x00, 0x63, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x38, 0x03, 0x00, 0x06, 0x00, 0x31, 0xC0, 0x18,
  0x00, 0x70, 0x01, 0x8C, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x60, 0x06, 0x00,
  0x38, 0x00, 0xC3, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x18, 0x01, 0x80, 0x1E,
  0x00, 0x60, 0xC0, 0x0C, 0x01, 0xB0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0xC0,
  0x30, 0x38, 0x03, 0x81, 0xC6, 0x07, 0x00, 0xC0, 0x0F, 0xFC, 0x3C, 0xF0,
  0x06, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0xFC, 0x00,
  0x30, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01,
  0x80, 0x01, 0xE0, 0x06, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x06, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70,
  0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xC0, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x60, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x03,
  0xFF, 0xE3, 0x00, 0x0F, 0xFF, 0xC6, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x07, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x03, 0x07, 0x80, 0x00,
  0x00, 0x61, 0xE0, 0x00, 0x00, 0x0C, 0x7C, 0x00, 0x00, 0x03, 0x9F, 0x80,
  0x00, 0x00, 0x77, 0x38, 0x00, 0x00, 0x0D, 0xC3, 0x00, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x00, 0x3C, 0x06, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xB8, 0x00, 0x00, 0x07, 0x60, 0x1B, 0x80, 0x00, 0x00, 0x66, 0x01, 0x98,
  0x00, 0x00, 0x0E, 0xE0, 0x19, 0x80, 0x00, 0x00, 0xCE, 0x03, 0x98, 0x00,
  0x00, 0x1C, 0xC0, 0x39, 0x80, 0x00, 0x01, 0x8C, 0x03, 0x1C, 0x00, 0x00,
  0x38, 0xC0, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x03, 0x0C, 0x00, 0x00, 0x71,
  0xC0, 0x30, 0xC0, 0x00, 0x06, 0x1C, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80,
  0x70, 0xE0, 0x00, 0x0C, 0x18, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x60,
  0x60, 0x00, 0x18, 0x38, 0x06, 0x06, 0x00, 0x03, 0x83, 0x80, 0x60, 0x60,
  0x00, 0x30, 0x38, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0xE0, 0x70, 0x00,
  0x60, 0x30, 0x0C, 0x03, 0x00, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x70, 0x0C, 0x03, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x18, 0x01,
  0x80, 0xC0, 0x0E, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0x38, 0x01, 0xC1,
  0x80, 0x0C, 0x03, 0x80, 0x1C, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC3, 0x00,
  0x1C, 0x03, 0x00, 0x0C, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xC6, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xEC, 0x00, 0x18, 0x07,
  0x00, 0x07, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x78, 0x00, 0x38, 0x06, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xF0, 0x00,
  0x00, 0x60, 0x1F, 0x80, 0x00, 0x06, 0x01, 0xD8, 0x00, 0x00, 0x60, 0x1D,
  0xC0, 0x00, 0x0E, 0x01, 0x8C, 0x00, 0x00, 0xE0, 0x18, 0xC0, 0x00, 0x0C,
  0x03, 0x8E, 0x00, 0x00, 0xC0, 0x38, 0x60, 0x00, 0x0C, 0x03, 0x86, 0x00,
  0x01, 0xC0, 0x30, 0x70, 0x00, 0x1C, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x30,
  0x38, 0x00, 0x18, 0x07, 0x01, 0x80, 0x01, 0x80, 0x70, 0x18, 0x00, 0x18,
  0x07, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x38, 0x06, 0x00, 0xC0,
  0x03, 0x80, 0x60, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x03, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x70,
  0x0C, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x1C, 0x00, 0x1C,
  0x06, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x1C, 0x00, 0x0C, 0x0E, 0x01, 0x80,
  0x00, 0xE0, 0xE0, 0x18, 0x00, 0x06, 0x0E, 0x03, 0x80, 0x00, 0x60, 0xC0,
  0x38, 0x00, 0x07, 0x0C, 0x03, 0x80, 0x00, 0x31, 0xC0, 0x30, 0x00, 0x03,
  0x9C, 0x03, 0x00, 0x00, 0x19, 0xC0, 0x30, 0x00, 0x01, 0x98, 0x07, 0x00,
  0x00, 0x1D, 0x80, 0x70, 0x00, 0x00, 0xD8, 0x07, 0x00, 0x00, 0x0F, 0x80,
  0x60, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x01, 0xE0, 0x0C, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3E, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x1F, 0xC0, 0x06, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0xF0, 0x07, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x80,
  0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x30, 0x00, 0x06, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x39, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x70, 0xE0, 0x00,
  0xC3, 0x00, 0x03, 0x07, 0x00, 0x06, 0x18, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xC0, 0x01, 0x81, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x80, 0x0C, 0x06,
  0x00, 0x30, 0x1C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x01,
  0x83, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x61,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xE0,
  0x00, 0x33, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x06, 0x70, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x03, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x01,
  0x80, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00,
  0x1D, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00, 0xC7, 0x00, 0x70, 0xC0, 0x18,
  0x30, 0x0E, 0x0C, 0x03, 0x03, 0x01, 0xC0, 0xC0, 0x60, 0x38, 0x38, 0x0E,
  0x0C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x06, 0x30, 0x01, 0xDC,
  0x00, 0x76, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC1,
  0xC1, 0x83, 0x83, 0x07, 0x06, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x1C, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFC, 0x01, 0x81, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x70, 0x00, 0x06, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0x87, 0x00, 0x03, 0xC1, 0x80, 0x03, 0x60, 0xE0, 0x03, 0xB0, 0x78, 0x07,
  0x98, 0x1F, 0xFF, 0x0C, 0x07, 0xFE, 0x06, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x1F, 0x00,
  0x0E, 0x1F, 0xF8, 0x03, 0x1F, 0xFF, 0x00, 0xCE, 0x01, 0xC0, 0x36, 0x00,
  0x38, 0x0F, 0x00, 0x06, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x30, 0x7C, 0x00,
  0x1C, 0x19, 0x80, 0x0E, 0x06, 0x70, 0x0F, 0x01, 0x8F, 0xFF, 0x80, 0x60,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0x30, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x83, 0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0x01, 0x80, 0x0F, 0xFC, 0x18, 0x01, 0xFF, 0xE1, 0x80, 0x3C,
  0x03, 0x18, 0x07, 0x00, 0x1B, 0x80, 0xE0, 0x00, 0xF8, 0x0C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0xF0,
  0x07, 0x00, 0x1B, 0x00, 0x38, 0x07, 0x30, 0x03, 0xFF, 0xE7, 0x00, 0x1F,
  0xF8, 0x70, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x30, 0x38, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0x83, 0x00, 0x3F, 0xFC, 0x30, 0x07, 0x80,
  0x63, 0x00, 0xE0, 0x03, 0x70, 0x1C, 0x00, 0x1F, 0x01, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x1E, 0x00,
  0xE0, 0x03, 0x60, 0x07, 0x00, 0xE6, 0x00, 0x7F, 0xFC, 0xE0, 0x03, 0xFF,
  0x8E, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x1F,
  0xF8, 0x07, 0x1F, 0xFE, 0x03, 0x1C, 0x07, 0x01, 0x98, 0x01, 0xC0, 0xD8,
  0x00, 0xE0, 0xF8, 0x00, 0x30, 0x78, 0x00, 0x18, 0x3C, 0x00, 0x0C, 0x1C,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x3C,
  0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x8F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00,
  0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x38,
  0x00, 0x01, 0x9E, 0x00, 0x00, 0x6F, 0xC0, 0x00, 0x3E, 0x30, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x80, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0xE0,
  0x00, 0xC0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x38, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x33, 0x80, 0x70, 0xF0, 0x1E, 0x03, 0x70,
  0x03, 0x8C, 0x00, 0xE0, 0x76, 0x00, 0x39, 0x80, 0x06, 0x07, 0xC0, 0x01,
  0xB0, 0x00, 0x70, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0x87, 0xFE, 0x01, 0xC7, 0xFF, 0x80, 0xC7,
  0x01, 0xC0, 0x66, 0x00, 0x70, 0x36, 0x00, 0x38, 0x3E, 0x00, 0x0C, 0x1F,
  0x00, 0x06, 0x0F, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0C,
  0x30, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x30,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x98,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0E, 0x1F, 0xF0, 0x00, 0xC7, 0xFF, 0xC0, 0x0C,
  0xE0, 0x1C, 0x00, 0xD8, 0x00, 0xE0, 0x0F, 0x00, 0x06, 0x01, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x30, 0x1F, 0x00, 0x07,
  0x01, 0xB8, 0x00, 0xE0, 0x19, 0xC0, 0x3C, 0x01, 0x8F, 0xFF, 0x80, 0x18,
  0x3F, 0xF0, 0x03, 0x80, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0xC0, 0x7F, 0xFC, 0x60, 0x78, 0x06,
  0x30, 0x70, 0x01, 0xB8, 0x70, 0x00, 0x7C, 0x30, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x03, 0x81, 0x80, 0x03,
  0xC0, 0xE0, 0x03, 0x60, 0x38, 0x07, 0x30, 0x1F, 0xFF, 0x38, 0x07, 0xFF,
  0x1C, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0xE3, 0xF8, 0x1C,
  0xFF, 0x03, 0x38, 0x00, 0x6E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFC, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x38,
  0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x3C, 0x03, 0xE0, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x87, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x06, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x81, 0xC0, 0x0E, 0xC0,
  0x70, 0x0E, 0xE0, 0x3F, 0xFE, 0x70, 0x0F, 0xFC, 0x30, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0x60, 0x00,
  0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x70, 0x00,
  0x30, 0x70, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x00,
  0xC0, 0x30, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x6E, 0x00, 0x0F, 0x00,
  0x0E, 0xE0, 0x01, 0xB0, 0x00, 0xEE, 0x00, 0x1B, 0x00, 0x0C, 0x60, 0x03,
  0xB0, 0x01, 0xC6, 0x00, 0x33, 0x00, 0x18, 0x60, 0x07, 0x30, 0x03, 0x86,
  0x00, 0x63, 0x00, 0x38, 0x60, 0x06, 0x30, 0x03, 0x06, 0x00, 0xC3, 0x00,
  0x70, 0x60, 0x0C, 0x30, 0x06, 0x06, 0x01, 0xC3, 0x00, 0xE0, 0x60, 0x18,
  0x38, 0x0C, 0x07, 0x03, 0x83, 0x81, 0xC0, 0x70, 0x30, 0x18, 0x1C, 0x07,
  0x07, 0x01, 0x81, 0x80, 0x70, 0x60, 0x18, 0x38, 0x07, 0x06, 0x01, 0x83,
  0x00, 0x70, 0xC0, 0x18, 0x70, 0x03, 0x0C, 0x01, 0x87, 0x00, 0x31, 0xC0,
  0x18, 0x60, 0x03, 0x18, 0x01, 0x8E, 0x00, 0x33, 0x80, 0x18, 0xC0, 0x03,
  0x30, 0x01, 0xDC, 0x00, 0x33, 0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x38, 0x70, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x20, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x31, 0xF7,
  0xC0, 0x01, 0xCE, 0x07, 0x80, 0x06, 0x30, 0x0F, 0x00, 0x19, 0xC0, 0x1C,
  0x00, 0xE6, 0x00, 0x38, 0x03, 0x38, 0x00, 0x70, 0x18, 0xC0, 0x00, 0xF3,
  0xE3, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 47, 12, 1, -46 },
  { 66, 11, 14, 17, 7, -49 },
  { 86, 33, 46, 31, 1, -46 },
  { 276, 27, 60, 31, 2, -53 },
  { 479, 30, 48, 41, 6, -47 },
  { 659, 29, 48, 34, 2, -47 },
  { 833, 5, 14, 11, 6, -49 },
  { 842, 18, 67, 18, 3, -52 },
  { 993, 18, 67, 18, -4, -52 },
  { 1144, 25, 25, 27, 4, -46 },
  { 1223, 26, 34, 31, 3, -38 },
  { 1334, 7, 14, 12, -2, -5 },
  { 1347, 13, 2, 17, 2, -22 },
  { 1351, 5, 4, 14, 1, -3 },
  { 1354, 27, 50, 22, -3, -46 },
  { 1523, 26, 48, 31, 3, -47 },
  { 1679, 14, 46, 31, 9, -46 },
  { 1760, 28, 47, 31, 1, -47 },
  { 1925, 27, 48, 31, 2, -47 },
  { 2087, 27, 46, 31, 1, -46 },
  { 2243, 27, 47, 31, 4, -46 },
  { 2402, 24, 47, 31, 3, -46 },
  { 2543, 26, 46, 31, 5, -46 },
  { 2693, 28, 48, 31, 2, -47 },
  { 2861, 24, 47, 31, 5, -47 },
  { 3002, 10, 34, 12, 1, -33 },
  { 3045, 12, 42, 11, -2, -33 },
  { 3108, 24, 26, 29, 3, -34 },
  { 3186, 25, 15, 31, 3, -29 },
  { 3233, 24, 26, 29, 2, -34 },
  { 3311, 19, 48, 25, 6, -47 },
  { 3425, 45, 59, 50, 2, -45 },
  { 3757, 31, 46, 34, -2, -46 },
  { 3936, 30, 46, 34, 2, -46 },
  { 4109, 30, 48, 36, 4, -47 },
  { 4289, 32, 46, 36, 2, -46 },
  { 4473, 32, 46, 32, 2, -46 },
  { 4657, 32, 46, 31, 2, -46 },
  { 4841, 31, 48, 38, 4, -47 },
  { 5027, 36, 46, 39, 2, -46 },
  { 5234, 11, 46, 15, 3, -46 },
  { 5298, 29, 47, 31, 1, -46 },
  { 5469, 35, 46, 35, 2, -46 },
  { 5671, 22, 46, 29, 2, -46 },
  { 5798, 44, 46, 47, 2, -46 },
  { 6051, 36, 46, 39, 2, -46 },
  { 6258, 32, 48, 37, 3, -47 },
  { 6450, 31, 46, 34, 2, -46 },
  { 6629, 32, 55, 37, 3, -47 },
  { 6849, 31, 46, 35, 2, -46 },
  { 7028, 31, 48, 33, 2, -47 },
  { 7214, 30, 46, 33, 6, -46 },
  { 7387, 32, 47, 36, 4, -46 },
  { 7575, 30, 46, 34, 6, -46 },
  { 7748, 45, 46, 49, 6, -46 },
  { 8007, 36, 46, 33, -1, -46 },
  { 8214, 30, 46, 33, 6, -46 },
  { 8387, 34, 46, 33, 0, -46 },
  { 8583, 17, 63, 13, 1, -53 },
  { 8717, 9, 50, 22, 7, -46 },
  { 8774, 18, 63, 13, -4, -53 },
  { 8916, 18, 23, 23, 3, -46 },
  { 8968, 23, 2, 24, -3, 0 },
  { 8974, 7, 9, 17, 9, -49 },
  { 8982, 25, 36, 30, 1, -35 },
  { 9095, 26, 50, 31, 1, -49 },
  { 9258, 25, 36, 28, 2, -35 },
  { 9371, 28, 50, 31, 3, -49 },
  { 9546, 24, 36, 29, 2, -35 },
  { 9654, 20, 50, 18, 4, -50 },
  { 9779, 28, 48, 31, 0, -35 },
  { 9947, 25, 49, 30, 2, -49 },
  { 10101, 11, 46, 13, 2, -46 },
  { 10165, 21, 59, 13, -8, -46 },
  { 10320, 26, 49, 27, 2, -49 },
  { 10480, 11, 49, 13, 2, -49 },
  { 10548, 44, 35, 49, 1, -35 },
  { 10741, 25, 35, 30, 2, -35 },
  { 10851, 26, 36, 31, 2, -35 },
  { 10968, 28, 48, 31, -1, -35 },
  { 11136, 25, 48, 31, 3, -35 },
  { 11286, 19, 35, 19, 2, -35 },
  { 11370, 24, 36, 28, 1, -35 },
  { 11478, 14, 44, 18, 4, -43 },
  { 11555, 25, 35, 30, 3, -34 },
  { 11665, 24, 34, 27, 4, -34 },
  { 11767, 36, 34, 41, 5, -34 },
  { 11920, 28, 34, 27, -1, -34 },
  { 12039, 31, 47, 27, -3, -34 },
  { 12222, 26, 34, 27, 0, -34 },
  { 12333, 20, 65, 19, 2, -51 },
  { 12496, 11, 55, 13, 1, -46 },
  { 12572, 20, 65, 19, -4, -51 },
  { 12735, 30, 11, 38, 4, -25 },
};

const GFXfont RobotoCondensed_ExtraLightItalic65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC65PT7B_H_
