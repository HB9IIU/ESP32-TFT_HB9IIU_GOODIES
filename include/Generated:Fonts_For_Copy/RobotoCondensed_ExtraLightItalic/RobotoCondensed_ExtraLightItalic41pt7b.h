#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC41PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x02, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x06, 0x0C, 0x00, 0x22, 0x22, 0x62, 0x66, 0x66, 0x46, 0x44, 0x44, 0xC4,
  0x00, 0x10, 0x20, 0x03, 0x06, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x60,
  0xC0, 0x06, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x01, 0xFF,
  0xFF, 0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x03,
  0x04, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x60, 0x80, 0x04, 0x08, 0x0F,
  0xFF, 0xF8, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08, 0x30, 0x01, 0x82, 0x00,
  0x10, 0x20, 0x01, 0x06, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0xF8, 0x03,
  0xDC, 0x06, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x08, 0xC0,
  0x18, 0x60, 0x30, 0x39, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0E, 0x00, 0x07, 0x60, 0x01, 0x82, 0x00, 0x20, 0x40,
  0x04, 0x08, 0x09, 0x81, 0x03, 0x20, 0x20, 0xC4, 0x04, 0x10, 0x80, 0x84,
  0x10, 0x31, 0x82, 0x04, 0x60, 0x61, 0x88, 0x06, 0x63, 0x00, 0x78, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x3C, 0x01, 0x8C, 0xC0, 0x62, 0x08, 0x08, 0xC1,
  0x82, 0x10, 0x30, 0xC2, 0x06, 0x10, 0xC0, 0xC4, 0x18, 0x19, 0x83, 0x02,
  0x60, 0x60, 0x48, 0x0C, 0x18, 0x00, 0x82, 0x00, 0x19, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x7F, 0x00, 0x10, 0x60, 0x0C, 0x08, 0x02, 0x02, 0x01,
  0x80, 0x80, 0x60, 0x20, 0x18, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x23,
  0x00, 0x0D, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x33, 0x00,
  0x18, 0x40, 0x4C, 0x18, 0x12, 0x03, 0x0D, 0x80, 0xC2, 0x40, 0x18, 0xB0,
  0x02, 0x6C, 0x00, 0xF3, 0x00, 0x1C, 0x40, 0x06, 0x18, 0x03, 0x87, 0x01,
  0xB0, 0xF3, 0x86, 0x0F, 0xC1, 0x80, 0x6D, 0xB4, 0xB6, 0xC0, 0x00, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x40, 0x83, 0xF8, 0x8F, 0x1F, 0xF8, 0x03, 0xC0,
  0x03, 0x80, 0x06, 0xC0, 0x0C, 0x40, 0x08, 0x60, 0x18, 0x30, 0x30, 0x30,
  0x20, 0x10, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x11, 0x33,
  0x36, 0x6C, 0x80, 0xFF, 0x5F, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0xDC, 0x06, 0x06, 0x0C, 0x02, 0x08, 0x03, 0x18, 0x03,
  0x10, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x40, 0x03, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18,
  0xC0, 0x18, 0x40, 0x30, 0x60, 0x60, 0x39, 0xC0, 0x1F, 0x00, 0x00, 0x83,
  0xC7, 0xAE, 0x34, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x00, 0xFC, 0x01, 0xEF, 0x01,
  0xC0, 0xC0, 0x80, 0x20, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x20, 0x03,
  0x10, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0xE7, 0x01, 0xC0, 0xC0, 0xC0, 0x30, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x02,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x26, 0x00, 0x13, 0x00, 0x19, 0x80, 0x0C,
  0x40, 0x04, 0x30, 0x06, 0x0C, 0x06, 0x03, 0xDE, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0x90,
  0x00, 0xC8, 0x00, 0xC4, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x61, 0x80, 0x60,
  0x80, 0x20, 0x40, 0x30, 0x20, 0x30, 0x30, 0x30, 0x18, 0x10, 0x0C, 0x18,
  0x04, 0x18, 0x02, 0x18, 0x01, 0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0xFF, 0xC1, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x9F, 0x00, 0x5F, 0xE0, 0x18, 0x0C, 0x04, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x10, 0x01, 0x84, 0x00, 0x41, 0x00, 0x30, 0x40, 0x08, 0x18, 0x06, 0x03,
  0x03, 0x00, 0x7B, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x87, 0xC1, 0x3B, 0xC6, 0x80, 0xCE, 0x01, 0x98, 0x01, 0xB0,
  0x03, 0x40, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xB0, 0x03, 0x60, 0x06, 0x40, 0x18, 0xC0, 0x30, 0xC0, 0xC1, 0xEF, 0x00,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7B, 0xC0, 0x30, 0x30, 0x18,
  0x06, 0x0C, 0x00, 0x83, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02, 0x18, 0x00,
  0x86, 0x00, 0x60, 0x80, 0x10, 0x30, 0x0C, 0x0C, 0x06, 0x01, 0xEF, 0x00,
  0x7F, 0x00, 0x30, 0x70, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x21, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x04,
  0x18, 0x03, 0x07, 0x01, 0x80, 0xF3, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x1E, 0xF0, 0x70, 0x30, 0x80, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xB0, 0x07, 0x20, 0x0A, 0x60, 0x6C, 0x7B, 0x98, 0x7C, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0xC3, 0x00, 0x02, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60,
  0xC0, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x10, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x10, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x0F, 0x81, 0xDC, 0x30, 0x66, 0x02, 0xC0, 0x3C, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x10, 0x60, 0x0F, 0x00, 0x82, 0x01,
  0xCC, 0x06, 0x30, 0x18, 0x10, 0x31, 0x01, 0x81, 0x81, 0x98, 0x18, 0x0C,
  0x0C, 0xC0, 0x80, 0x40, 0x44, 0x0C, 0x02, 0x02, 0x60, 0x60, 0x30, 0x13,
  0x02, 0x01, 0x80, 0x90, 0x30, 0x08, 0x0C, 0x81, 0x80, 0x40, 0x64, 0x08,
  0x06, 0x02, 0x20, 0x40, 0x30, 0x13, 0x02, 0x03, 0x01, 0x98, 0x10, 0x18,
  0x08, 0xC0, 0x81, 0x40, 0xC6, 0x04, 0x1A, 0x0C, 0x10, 0x3B, 0x98, 0xC0,
  0x80, 0xF0, 0x78, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0x90, 0x00, 0x32, 0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x21, 0x80, 0x0C,
  0x30, 0x01, 0x06, 0x00, 0x60, 0x40, 0x08, 0x08, 0x03, 0x01, 0x00, 0x40,
  0x20, 0x18, 0x04, 0x02, 0x00, 0xC0, 0xC0, 0x18, 0x10, 0x03, 0x06, 0x00,
  0x20, 0xFF, 0xFC, 0x30, 0x00, 0x86, 0x00, 0x11, 0x80, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x07, 0xFE,
  0x00, 0xC1, 0xF0, 0x18, 0x03, 0x02, 0x00, 0x20, 0x40, 0x06, 0x08, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x00, 0x08, 0x20, 0x03,
  0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x3C, 0x07, 0xFF, 0x00, 0x80, 0x38,
  0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x02, 0x18, 0x00, 0x42, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61,
  0x00, 0x38, 0x20, 0x3E, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x78,
  0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x60, 0x80, 0x02, 0x18, 0x00,
  0x21, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x8C,
  0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x10, 0x60, 0x03, 0x02, 0x00, 0x60,
  0x30, 0x0C, 0x01, 0xE7, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x60,
  0xF8, 0x06, 0x00, 0xC0, 0x40, 0x06, 0x04, 0x00, 0x20, 0x40, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x11,
  0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x31, 0x00, 0x02,
  0x10, 0x00, 0x23, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00,
  0x42, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00,
  0x60, 0x40, 0x0C, 0x04, 0x1F, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3D, 0xF0, 0x1C, 0x07, 0x06, 0x00, 0x60, 0x80, 0x06, 0x30,
  0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x7F, 0xD8, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x19, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x0C, 0x00,
  0x60, 0xC0, 0x38, 0x0F, 0x7E, 0x00, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x20, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x07, 0xFF, 0xFC, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x00,
  0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x00, 0x04, 0x08, 0x10, 0x60,
  0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60,
  0x81, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x20, 0x03, 0x08,
  0x00, 0xC2, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x0C, 0x06, 0x06, 0x00, 0xF7,
  0x00, 0x1F, 0x80, 0x00, 0x06, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60, 0x07,
  0x01, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x03,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x60, 0x00, 0x83, 0x00, 0x06, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x3C, 0x00, 0x05, 0x98, 0x00,
  0x1C, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x20,
  0x18, 0x00, 0x80, 0x30, 0x02, 0x00, 0x40, 0x18, 0x01, 0x80, 0x60, 0x02,
  0x01, 0x80, 0x0C, 0x04, 0x00, 0x10, 0x10, 0x00, 0x60, 0x40, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x7F, 0xFC, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0x50, 0x00, 0x0F, 0x05, 0x00, 0x00, 0xA0, 0x50, 0x00, 0x1A,
  0x0D, 0x80, 0x01, 0x20, 0xD8, 0x00, 0x36, 0x08, 0x80, 0x02, 0x60, 0x88,
  0x00, 0x66, 0x08, 0x80, 0x04, 0x41, 0x8C, 0x00, 0xC4, 0x18, 0xC0, 0x08,
  0xC1, 0x8C, 0x01, 0x8C, 0x18, 0x40, 0x30, 0xC1, 0x04, 0x03, 0x08, 0x10,
  0x40, 0x60, 0x83, 0x06, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x08,
  0x18, 0x20, 0x21, 0x81, 0x82, 0x02, 0x10, 0x10, 0x20, 0x23, 0x01, 0x06,
  0x03, 0x20, 0x10, 0x60, 0x36, 0x03, 0x06, 0x01, 0x40, 0x30, 0x40, 0x1C,
  0x03, 0x04, 0x01, 0x80, 0x20, 0x40, 0x18, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x28, 0x00, 0x20, 0x58, 0x00, 0x40,
  0x90, 0x00, 0x83, 0x20, 0x03, 0x06, 0x60, 0x06, 0x0C, 0x40, 0x0C, 0x10,
  0xC0, 0x10, 0x21, 0x80, 0x20, 0xC1, 0x00, 0xC1, 0x83, 0x01, 0x83, 0x02,
  0x03, 0x06, 0x06, 0x06, 0x08, 0x0C, 0x08, 0x10, 0x08, 0x10, 0x60, 0x18,
  0x60, 0xC0, 0x10, 0xC1, 0x80, 0x21, 0x83, 0x00, 0x62, 0x04, 0x00, 0x44,
  0x08, 0x00, 0xC8, 0x30, 0x01, 0xB0, 0x60, 0x01, 0x60, 0xC0, 0x03, 0xC1,
  0x00, 0x03, 0x02, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x20, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00,
  0x32, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00,
  0x06, 0x40, 0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x84, 0x00, 0x18, 0x60, 0x03, 0x06,
  0x00, 0x60, 0x30, 0x0C, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x60, 0x7C, 0x06, 0x00, 0xE0, 0x40, 0x06, 0x04, 0x00, 0x30, 0x40,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08,
  0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x03, 0x81,
  0x01, 0xF0, 0x1F, 0xFC, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x20,
  0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x20, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00,
  0x24, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00,
  0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x84, 0x00, 0x18, 0x60,
  0x03, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x07, 0xFF, 0x00, 0x60, 0x78, 0x06, 0x00, 0xC0, 0x40, 0x06, 0x04, 0x00,
  0x20, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x30, 0x80,
  0x02, 0x08, 0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x10,
  0x01, 0x81, 0x01, 0xE0, 0x1F, 0xF8, 0x03, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x04, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x20,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x01, 0x04, 0x00, 0x18, 0xC0, 0x01,
  0x80, 0x00, 0x7E, 0x00, 0x1F, 0x78, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C,
  0x00, 0x60, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0x40, 0x03, 0x06, 0x00, 0x70, 0x30, 0x0E, 0x01, 0xEF, 0x80, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x18, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x21, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80,
  0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x20,
  0x80, 0x01, 0x0C, 0x00, 0x08, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00,
  0x30, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x08,
  0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x3C, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0B, 0x00, 0x03, 0x60,
  0x00, 0x4C, 0x00, 0x19, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x18, 0x40,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x01, 0x01, 0x80, 0x30, 0x20, 0x06, 0x0C, 0x00, 0xC1,
  0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x23, 0x00, 0x04, 0x60, 0x00, 0xC8,
  0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xC0, 0x0E, 0x00, 0x3C,
  0x00, 0xA0, 0x02, 0xC0, 0x0A, 0x00, 0x6C, 0x01, 0xA0, 0x04, 0xC0, 0x13,
  0x00, 0xCC, 0x03, 0x30, 0x0C, 0x40, 0x33, 0x00, 0x84, 0x02, 0x30, 0x18,
  0x40, 0x61, 0x01, 0x84, 0x04, 0x10, 0x10, 0x40, 0xC1, 0x03, 0x04, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x06, 0x06, 0x18, 0x10, 0x60, 0x61, 0x01, 0x04,
  0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x20, 0x18, 0x80, 0x66,
  0x01, 0x98, 0x06, 0x40, 0x19, 0x00, 0x6C, 0x00, 0x90, 0x06, 0xC0, 0x0B,
  0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0x41, 0x80, 0x00, 0xC2, 0x00,
  0x00, 0x8C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x88, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x20, 0x00, 0x60, 0x60, 0x01, 0x80,
  0x40, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x03,
  0x03, 0x00, 0x02, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x19,
  0x00, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0x40, 0x04, 0x0C, 0x01, 0x81,
  0x80, 0x60, 0x30, 0x08, 0x02, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x00,
  0x86, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x2C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xF8, 0x00, 0xC3, 0x04, 0x10, 0x41,
  0x06, 0x18, 0x60, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x10, 0x41, 0x04, 0x18,
  0x61, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x30, 0x41, 0x01, 0xF0, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x7C, 0x00, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x40, 0x6C, 0x09, 0x83, 0x30, 0x42, 0x18, 0x42, 0x08, 0xC1, 0x90, 0x36,
  0x06, 0x80, 0x70, 0x08, 0xFF, 0xFC, 0x63, 0x0C, 0x21, 0x80, 0x01, 0xF0,
  0x0F, 0x78, 0x30, 0x18, 0xC0, 0x31, 0x00, 0x26, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x1F, 0xF0, 0xF8, 0x23, 0x00, 0x4C, 0x01,
  0xB0, 0x03, 0x60, 0x06, 0x80, 0x09, 0x00, 0x32, 0x00, 0xE6, 0x03, 0xC7,
  0x79, 0x87, 0xE3, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0xF8,
  0x1B, 0xDE, 0x1E, 0x06, 0x1C, 0x03, 0x18, 0x03, 0x10, 0x01, 0x10, 0x01,
  0x30, 0x01, 0x30, 0x01, 0x30, 0x03, 0x20, 0x03, 0x20, 0x03, 0x20, 0x03,
  0x60, 0x02, 0x60, 0x02, 0x60, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x60, 0x0C,
  0xD0, 0x18, 0xDE, 0xF0, 0x87, 0xC0, 0x01, 0xF0, 0x07, 0xBC, 0x0C, 0x06,
  0x18, 0x06, 0x10, 0x02, 0x30, 0x02, 0x20, 0x03, 0x60, 0x03, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x04, 0xC0, 0x0C, 0x40, 0x08, 0x60, 0x18, 0x60, 0x30, 0x3D, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0xF8,
  0xC0, 0xF7, 0x30, 0x60, 0x2C, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x18, 0x40, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x10, 0xC0,
  0x0C, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02,
  0x08, 0x01, 0x83, 0x00, 0xE0, 0x40, 0x78, 0x1E, 0xF4, 0x01, 0xF1, 0x00,
  0x01, 0xF0, 0x07, 0xBC, 0x0C, 0x06, 0x18, 0x06, 0x10, 0x02, 0x30, 0x02,
  0x20, 0x03, 0x60, 0x03, 0x60, 0x02, 0x40, 0x02, 0x7F, 0xFE, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x08, 0x30, 0x18, 0x3C, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0E, 0xC0,
  0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x03, 0xFE,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00,
  0xF8, 0xC0, 0xF7, 0x30, 0x60, 0x28, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x18, 0x40, 0x06, 0x30, 0x01, 0x0C, 0x00, 0x43, 0x00, 0x10,
  0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x08, 0x20,
  0x02, 0x08, 0x01, 0x83, 0x00, 0xE0, 0x60, 0x78, 0x1E, 0xF4, 0x01, 0xF1,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x04, 0x01, 0x81,
  0x80, 0xC0, 0x39, 0xE0, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x78, 0x19, 0xDE, 0x1B, 0x06, 0x1C, 0x02, 0x14, 0x03, 0x18,
  0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20,
  0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40,
  0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x30,
  0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x0B, 0x80,
  0x78, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x01, 0x86,
  0x01, 0x83, 0x01, 0x81, 0x81, 0x80, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80,
  0x31, 0x80, 0x19, 0x80, 0x0D, 0x80, 0x05, 0xE0, 0x03, 0xB0, 0x01, 0x8C,
  0x01, 0x86, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x06, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x06, 0x0C, 0x18, 0x20,
  0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x00,
  0x18, 0xF8, 0x0F, 0x83, 0x3B, 0x87, 0xB8, 0x68, 0x19, 0x81, 0x8E, 0x01,
  0x60, 0x31, 0x80, 0x38, 0x02, 0x30, 0x06, 0x00, 0x4C, 0x00, 0xC0, 0x09,
  0x80, 0x18, 0x01, 0x30, 0x02, 0x00, 0x26, 0x00, 0x40, 0x0C, 0x80, 0x18,
  0x01, 0x90, 0x03, 0x00, 0x36, 0x00, 0x60, 0x04, 0xC0, 0x0C, 0x00, 0x98,
  0x01, 0x00, 0x12, 0x00, 0x20, 0x06, 0x40, 0x0C, 0x00, 0xC8, 0x01, 0x80,
  0x1B, 0x00, 0x30, 0x02, 0x60, 0x04, 0x00, 0x4C, 0x00, 0x80, 0x09, 0x00,
  0x10, 0x03, 0x00, 0x08, 0x78, 0x19, 0xDE, 0x1B, 0x06, 0x1C, 0x02, 0x14,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20,
  0x02, 0x20, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x04, 0x40,
  0x04, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0x03,
  0xF0, 0x1E, 0x70, 0x70, 0x30, 0x80, 0x33, 0x00, 0x6C, 0x00, 0x58, 0x00,
  0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x40, 0x06, 0x80, 0x09, 0x80, 0x33, 0x00, 0x43, 0x03,
  0x83, 0x9E, 0x03, 0xF0, 0x00, 0x02, 0x3E, 0x01, 0xBD, 0xE0, 0x78, 0x18,
  0x1C, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x10, 0x40, 0x04, 0x30, 0x01, 0x0C,
  0x00, 0x43, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0xC6, 0x00,
  0x21, 0x80, 0x08, 0x60, 0x06, 0x10, 0x01, 0x06, 0x00, 0xC3, 0x80, 0x20,
  0xF0, 0x18, 0x37, 0xBC, 0x08, 0x7C, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x00, 0x03, 0xE3, 0x0F, 0x73, 0x18, 0x0A, 0x30, 0x06, 0x30, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0,
  0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x18, 0xC0, 0x38, 0x40, 0x78, 0x7B, 0xD0, 0x1F, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x08, 0xF1, 0xBF, 0x1A, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0xF0,
  0x1F, 0x70, 0x70, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x04, 0x80, 0x09, 0x80, 0x33, 0x00, 0x43, 0x01, 0x83,
  0xBE, 0x03, 0xF0, 0x00, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFC, 0x20,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x60, 0x3E, 0x0F, 0x00, 0x10,
  0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20,
  0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x38, 0x60, 0x58, 0x7B, 0x90, 0x1F, 0x10, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xB0, 0x06, 0xC0, 0x13, 0x00, 0xC4, 0x02, 0x10, 0x18, 0x40, 0x41, 0x03,
  0x06, 0x0C, 0x18, 0x20, 0x61, 0x80, 0x84, 0x02, 0x30, 0x08, 0x80, 0x36,
  0x00, 0xD0, 0x03, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x10,
  0x07, 0x80, 0x60, 0x0F, 0x00, 0xE0, 0x36, 0x03, 0xC0, 0x64, 0x07, 0x80,
  0x88, 0x0B, 0x03, 0x10, 0x36, 0x06, 0x20, 0x44, 0x18, 0x41, 0x88, 0x30,
  0x82, 0x10, 0x41, 0x0C, 0x21, 0x82, 0x18, 0x43, 0x06, 0x20, 0x8C, 0x0C,
  0xC1, 0x18, 0x19, 0x03, 0x20, 0x36, 0x06, 0xC0, 0x68, 0x0D, 0x00, 0xD0,
  0x1A, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0xC1, 0x00, 0x60, 0x60, 0x30, 0x18, 0x08, 0x03,
  0x06, 0x00, 0xC3, 0x00, 0x10, 0x80, 0x06, 0x60, 0x00, 0xB0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0xC8, 0x00, 0x23, 0x00,
  0x18, 0x40, 0x0C, 0x18, 0x02, 0x06, 0x01, 0x80, 0x80, 0xC0, 0x30, 0x60,
  0x04, 0x18, 0x01, 0x80, 0x04, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0x40,
  0x60, 0x0C, 0x06, 0x00, 0x80, 0x60, 0x18, 0x02, 0x01, 0x00, 0x20, 0x30,
  0x02, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x0C,
  0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x13, 0x00, 0x01, 0xB0, 0x00, 0x1A,
  0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0xB8, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x08, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x70, 0x03, 0x80, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x0E, 0x00,
  0x40, 0x00, 0x0F, 0x00, 0x23, 0xF0, 0x04, 0xC3, 0x01, 0xB0, 0x30, 0x24,
  0x03, 0x0C, 0x80, 0x3F, 0x30, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 8, 1, -29 },
  { 27, 8, 9, 11, 4, -31 },
  { 36, 20, 29, 20, 1, -29 },
  { 109, 16, 37, 19, 2, -33 },
  { 183, 19, 29, 26, 4, -29 },
  { 252, 18, 29, 21, 1, -29 },
  { 318, 3, 9, 7, 4, -31 },
  { 322, 11, 42, 11, 2, -33 },
  { 380, 11, 42, 11, -2, -33 },
  { 438, 16, 16, 17, 2, -29 },
  { 470, 16, 22, 20, 2, -25 },
  { 514, 4, 9, 8, -1, -3 },
  { 519, 8, 1, 11, 1, -13 },
  { 520, 3, 3, 9, 1, -3 },
  { 522, 17, 31, 14, -2, -29 },
  { 588, 16, 29, 19, 2, -29 },
  { 646, 9, 29, 19, 5, -29 },
  { 679, 17, 29, 19, 1, -29 },
  { 741, 17, 29, 19, 1, -29 },
  { 803, 17, 29, 19, 1, -29 },
  { 865, 18, 29, 19, 2, -29 },
  { 931, 15, 29, 19, 2, -29 },
  { 986, 17, 29, 19, 3, -29 },
  { 1048, 18, 29, 19, 1, -29 },
  { 1114, 15, 29, 19, 3, -29 },
  { 1169, 6, 22, 8, 1, -22 },
  { 1186, 8, 28, 7, -1, -22 },
  { 1214, 15, 17, 18, 2, -22 },
  { 1246, 16, 9, 19, 2, -18 },
  { 1264, 16, 17, 18, 1, -22 },
  { 1298, 12, 29, 16, 4, -29 },
  { 1342, 29, 37, 32, 1, -28 },
  { 1477, 19, 29, 21, -1, -29 },
  { 1546, 19, 29, 21, 1, -29 },
  { 1615, 20, 29, 23, 2, -29 },
  { 1688, 20, 29, 23, 1, -29 },
  { 1761, 20, 29, 20, 1, -29 },
  { 1834, 20, 29, 20, 1, -29 },
  { 1907, 19, 29, 24, 3, -29 },
  { 1976, 23, 29, 24, 1, -29 },
  { 2060, 7, 29, 10, 2, -29 },
  { 2086, 18, 29, 19, 1, -29 },
  { 2152, 22, 29, 22, 1, -29 },
  { 2232, 14, 29, 18, 1, -29 },
  { 2283, 28, 29, 30, 1, -29 },
  { 2385, 23, 29, 25, 1, -29 },
  { 2469, 20, 29, 23, 2, -29 },
  { 2542, 20, 29, 21, 1, -29 },
  { 2615, 20, 34, 23, 2, -29 },
  { 2700, 20, 29, 22, 1, -29 },
  { 2773, 20, 29, 21, 1, -29 },
  { 2846, 19, 29, 21, 4, -29 },
  { 2915, 21, 29, 23, 2, -29 },
  { 2992, 19, 29, 21, 4, -29 },
  { 3061, 28, 29, 31, 4, -29 },
  { 3163, 23, 29, 21, -1, -29 },
  { 3247, 19, 29, 21, 4, -29 },
  { 3316, 21, 29, 21, 0, -29 },
  { 3393, 12, 39, 8, 0, -33 },
  { 3452, 6, 32, 14, 4, -29 },
  { 3476, 12, 39, 8, -3, -33 },
  { 3535, 11, 15, 15, 2, -29 },
  { 3556, 15, 1, 15, -2, 0 },
  { 3558, 5, 5, 11, 5, -30 },
  { 3562, 15, 22, 19, 1, -22 },
  { 3604, 16, 31, 19, 1, -31 },
  { 3666, 16, 22, 18, 1, -22 },
  { 3710, 18, 31, 19, 2, -31 },
  { 3780, 16, 22, 18, 1, -22 },
  { 3824, 13, 31, 12, 2, -31 },
  { 3875, 18, 30, 19, 0, -22 },
  { 3943, 16, 31, 19, 1, -31 },
  { 4005, 7, 30, 8, 1, -30 },
  { 4032, 13, 38, 8, -5, -30 },
  { 4094, 17, 31, 17, 1, -31 },
  { 4160, 7, 31, 8, 1, -31 },
  { 4188, 27, 22, 31, 1, -22 },
  { 4263, 16, 22, 19, 1, -22 },
  { 4307, 15, 22, 19, 2, -22 },
  { 4349, 18, 30, 19, -1, -22 },
  { 4417, 16, 30, 19, 2, -22 },
  { 4477, 12, 22, 12, 1, -22 },
  { 4510, 15, 22, 18, 1, -22 },
  { 4552, 9, 27, 11, 2, -27 },
  { 4583, 16, 22, 19, 2, -22 },
  { 4627, 14, 22, 17, 3, -22 },
  { 4666, 23, 22, 26, 3, -22 },
  { 4730, 18, 22, 17, -1, -22 },
  { 4780, 20, 30, 17, -2, -22 },
  { 4855, 17, 22, 17, 0, -22 },
  { 4902, 13, 41, 12, 1, -32 },
  { 4969, 7, 34, 8, 1, -29 },
  { 4999, 13, 41, 12, -3, -32 },
  { 5066, 19, 7, 24, 2, -16 },
};

const GFXfont RobotoCondensed_ExtraLightItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC41PT7B_H_
