#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC18PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x48, 0x08, 0xB6, 0xD0, 0x04, 0x82, 0x42, 0x47,
  0xF0, 0x90, 0x90, 0x48, 0x24, 0x24, 0x7F, 0x89, 0x09, 0x04, 0x80, 0x08,
  0x10, 0x71, 0x14, 0x28, 0x50, 0x10, 0x10, 0x18, 0x14, 0x28, 0x50, 0x9E,
  0x10, 0x20, 0x60, 0x90, 0x92, 0x94, 0x94, 0xE8, 0x10, 0x16, 0x29, 0x49,
  0x49, 0x89, 0x0E, 0x1C, 0x24, 0x24, 0x44, 0x28, 0x30, 0x30, 0x51, 0x8A,
  0x8A, 0x84, 0x8C, 0x72, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x42, 0x00, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x84, 0x44, 0x00, 0x10, 0x22, 0x5B, 0xC3, 0x09, 0x22, 0x00,
  0x08, 0x20, 0x40, 0x8F, 0xE2, 0x08, 0x10, 0x20, 0x29, 0x40, 0xE0, 0xC0,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x14,
  0x47, 0x00, 0x17, 0x11, 0x11, 0x22, 0x22, 0x22, 0x40, 0x1E, 0x21, 0x21,
  0x41, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x1C, 0x45,
  0x0A, 0x10, 0x20, 0x8E, 0x02, 0x05, 0x0A, 0x14, 0x27, 0x80, 0x01, 0x02,
  0x06, 0x0A, 0x0A, 0x12, 0x22, 0x22, 0x44, 0x7F, 0x04, 0x04, 0x04, 0x3F,
  0x20, 0x20, 0x40, 0x40, 0x78, 0x44, 0x02, 0x02, 0x82, 0x84, 0x84, 0x78,
  0x0C, 0x42, 0x10, 0x79, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x7F, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x0E,
  0x11, 0x21, 0x21, 0x21, 0x22, 0x1C, 0x22, 0x42, 0x82, 0x82, 0x42, 0x3C,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xA2, 0x7C, 0x08, 0x20, 0x86, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x02, 0x44, 0x80, 0x04, 0x66,
  0x20, 0x40, 0xC0, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x30, 0x10,
  0x10, 0xC6, 0x10, 0x00, 0x74, 0x62, 0x10, 0x88, 0x88, 0x40, 0x00, 0x08,
  0x00, 0x07, 0xC1, 0x82, 0x20, 0x12, 0x01, 0x47, 0x18, 0x89, 0x88, 0x99,
  0x11, 0x91, 0x19, 0x12, 0x92, 0x29, 0xDC, 0x80, 0x08, 0x00, 0x40, 0x03,
  0xC0, 0x02, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x1F, 0x10,
  0x50, 0x28, 0x14, 0x08, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x82,
  0x82, 0x82, 0x82, 0x84, 0xF8, 0x1E, 0x10, 0x90, 0x28, 0x14, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0xA0, 0x90, 0x47, 0xC0, 0x3E, 0x41, 0x41, 0x41,
  0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0x3F, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x7E, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x3F, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x7E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E,
  0x10, 0x90, 0x28, 0x14, 0x02, 0x02, 0x01, 0x1E, 0x81, 0x40, 0xA0, 0x48,
  0x43, 0xC0, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0xFD, 0x02, 0x81,
  0x40, 0xA0, 0x50, 0x28, 0x10, 0x25, 0x24, 0x92, 0x92, 0x48, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x82, 0x84, 0x44, 0x78, 0x20,
  0xA0, 0x90, 0x88, 0x84, 0x82, 0x81, 0xC0, 0x90, 0x88, 0x42, 0x21, 0x10,
  0x48, 0x20, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0xFC,
  0x20, 0x12, 0x03, 0x60, 0x55, 0x06, 0x50, 0xA5, 0x0A, 0x51, 0x29, 0x12,
  0x92, 0x28, 0xA4, 0x8C, 0x48, 0xC4, 0x88, 0x40, 0x20, 0x48, 0x25, 0x09,
  0x42, 0x50, 0x92, 0x24, 0x8A, 0x24, 0x85, 0x21, 0x48, 0x32, 0x0C, 0x82,
  0x00, 0x1E, 0x10, 0x90, 0x28, 0x14, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x90, 0x47, 0xC0, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0x7C,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x10, 0x90, 0x28, 0x14, 0x0C, 0x06,
  0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x47, 0xC0, 0x20, 0x08, 0x3E, 0x41,
  0x41, 0x41, 0x41, 0x42, 0x7C, 0x84, 0x84, 0x84, 0x84, 0x82, 0x82, 0x0F,
  0x08, 0x48, 0x24, 0x12, 0x00, 0x80, 0x30, 0x04, 0x01, 0x40, 0xA0, 0x48,
  0x43, 0xC0, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x12, 0x0A, 0x05, 0x02,
  0x81, 0x40, 0xA0, 0x90, 0x87, 0x80, 0x81, 0x81, 0x82, 0x82, 0x84, 0x84,
  0x88, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x84, 0x18, 0x41, 0x86, 0x28,
  0xA2, 0x8A, 0x29, 0x24, 0x92, 0x49, 0x24, 0xA2, 0x8A, 0x28, 0xC2, 0x8C,
  0x10, 0x81, 0x00, 0x20, 0x48, 0x21, 0x10, 0x48, 0x0A, 0x03, 0x00, 0x80,
  0x50, 0x14, 0x08, 0x84, 0x21, 0x08, 0x81, 0x00, 0x81, 0x82, 0x82, 0x44,
  0x48, 0x48, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x3F, 0x80, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x0F, 0xF0,
  0x19, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10, 0x86, 0x00,
  0xAA, 0xA5, 0x55, 0x50, 0x18, 0x42, 0x21, 0x08, 0x42, 0x10, 0x88, 0x42,
  0x10, 0x84, 0x26, 0x00, 0x11, 0x8C, 0x94, 0xC4, 0xFC, 0x50, 0x1C, 0x45,
  0x08, 0x13, 0xE8, 0x60, 0xC2, 0x8C, 0xE8, 0x20, 0x20, 0x20, 0x20, 0x3E,
  0x22, 0x41, 0x41, 0x41, 0x42, 0x42, 0x42, 0x44, 0xB8, 0x39, 0x18, 0x60,
  0x82, 0x08, 0x21, 0x89, 0xC0, 0x01, 0x02, 0x02, 0x02, 0x3A, 0x46, 0x84,
  0x84, 0x84, 0x84, 0x84, 0x84, 0x88, 0x78, 0x39, 0x18, 0x61, 0xFE, 0x08,
  0x20, 0x81, 0xE0, 0x18, 0x82, 0x08, 0xF1, 0x04, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x00, 0x1D, 0x23, 0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x44, 0x3A,
  0x04, 0x04, 0x84, 0x78, 0x10, 0x40, 0x81, 0x03, 0xE4, 0x48, 0xA1, 0x42,
  0x85, 0x0A, 0x14, 0x30, 0x80, 0x60, 0x24, 0xA4, 0x92, 0x48, 0x0C, 0x00,
  0x02, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0xC0, 0x10,
  0x20, 0x20, 0x20, 0x22, 0x24, 0x48, 0x50, 0x70, 0x50, 0x48, 0x48, 0x84,
  0x84, 0x29, 0x24, 0x94, 0x92, 0x49, 0x00, 0x3E, 0xF2, 0x31, 0x21, 0x14,
  0x21, 0x42, 0x14, 0x21, 0x42, 0x14, 0x21, 0x82, 0x18, 0x41, 0x3E, 0x44,
  0x8A, 0x14, 0x28, 0x50, 0xA1, 0x83, 0x08, 0x3C, 0x8A, 0x0C, 0x18, 0x30,
  0x61, 0x42, 0x88, 0xE0, 0x3E, 0x22, 0x41, 0x41, 0x41, 0x42, 0x42, 0x42,
  0x44, 0xB8, 0x80, 0x80, 0x80, 0x80, 0x3A, 0x8E, 0x14, 0x28, 0x50, 0xA1,
  0x42, 0x88, 0xF0, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x82, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x00, 0x1C, 0x45, 0x0A, 0x03, 0x01, 0x01, 0x42, 0x84, 0xF0,
  0x22, 0xF4, 0x44, 0x44, 0x88, 0x84, 0x42, 0x86, 0x0C, 0x28, 0x50, 0xA1,
  0x42, 0x88, 0xF0, 0x83, 0x0A, 0x14, 0x44, 0x8A, 0x14, 0x30, 0x60, 0x80,
  0x84, 0x61, 0x18, 0xC6, 0x32, 0x54, 0x95, 0x46, 0x51, 0x8C, 0x42, 0x10,
  0x80, 0x42, 0x44, 0x90, 0xC1, 0x02, 0x0A, 0x24, 0x45, 0x08, 0x20, 0x90,
  0x88, 0x44, 0x41, 0x20, 0xA0, 0x50, 0x30, 0x18, 0x08, 0x04, 0x02, 0x02,
  0x06, 0x00, 0x3E, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0xF8, 0x08,
  0x88, 0x42, 0x10, 0x88, 0x84, 0x10, 0x84, 0x42, 0x10, 0x41, 0x00, 0x24,
  0x92, 0x52, 0x49, 0x25, 0x20, 0x30, 0x40, 0x82, 0x08, 0x41, 0x04, 0x08,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x42, 0x00, 0x71, 0x89, 0x86,
};

const GFXglyph RobotoCondensed_ExtraLightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 3, 0, -13 },
  { 6, 3, 4, 5, 2, -14 },
  { 8, 9, 13, 9, 0, -13 },
  { 23, 7, 17, 8, 1, -15 },
  { 38, 8, 13, 11, 2, -13 },
  { 51, 8, 13, 9, 1, -13 },
  { 64, 1, 4, 3, 2, -14 },
  { 65, 5, 18, 5, 1, -14 },
  { 77, 5, 18, 5, -1, -14 },
  { 89, 7, 7, 7, 1, -13 },
  { 96, 7, 9, 9, 1, -11 },
  { 104, 3, 4, 3, -1, -2 },
  { 106, 3, 1, 5, 1, -6 },
  { 107, 2, 1, 4, 0, -1 },
  { 108, 8, 14, 6, -1, -13 },
  { 122, 7, 13, 8, 1, -13 },
  { 134, 4, 13, 8, 2, -13 },
  { 141, 8, 13, 8, 0, -13 },
  { 154, 7, 13, 8, 1, -13 },
  { 166, 8, 13, 8, 0, -13 },
  { 179, 8, 13, 8, 1, -13 },
  { 192, 6, 13, 8, 1, -13 },
  { 202, 8, 13, 8, 1, -13 },
  { 215, 8, 13, 8, 0, -13 },
  { 228, 7, 13, 8, 1, -13 },
  { 240, 3, 9, 3, 0, -9 },
  { 244, 4, 11, 3, -1, -9 },
  { 250, 6, 7, 8, 1, -9 },
  { 256, 7, 5, 9, 1, -8 },
  { 261, 7, 7, 8, 0, -9 },
  { 268, 5, 13, 7, 2, -13 },
  { 277, 12, 16, 14, 1, -12 },
  { 301, 9, 13, 9, -1, -13 },
  { 316, 8, 13, 9, 1, -13 },
  { 329, 9, 13, 10, 1, -13 },
  { 344, 8, 13, 10, 1, -13 },
  { 357, 8, 13, 9, 1, -13 },
  { 370, 8, 13, 9, 1, -13 },
  { 383, 9, 13, 10, 1, -13 },
  { 398, 9, 13, 11, 1, -13 },
  { 413, 3, 13, 4, 1, -13 },
  { 418, 8, 13, 8, 0, -13 },
  { 431, 9, 13, 10, 1, -13 },
  { 446, 6, 13, 8, 1, -13 },
  { 456, 12, 13, 13, 1, -13 },
  { 476, 10, 13, 11, 1, -13 },
  { 493, 9, 13, 10, 1, -13 },
  { 508, 8, 13, 9, 1, -13 },
  { 521, 9, 15, 10, 1, -13 },
  { 538, 8, 13, 10, 1, -13 },
  { 551, 9, 13, 9, 0, -13 },
  { 566, 8, 13, 9, 2, -13 },
  { 579, 9, 13, 10, 1, -13 },
  { 594, 8, 13, 9, 2, -13 },
  { 607, 12, 13, 14, 2, -13 },
  { 627, 10, 13, 9, 0, -13 },
  { 644, 8, 13, 9, 2, -13 },
  { 657, 9, 13, 9, 0, -13 },
  { 672, 5, 18, 4, 0, -15 },
  { 684, 2, 14, 6, 2, -13 },
  { 688, 5, 18, 4, -1, -15 },
  { 700, 5, 6, 6, 1, -13 },
  { 704, 7, 1, 7, -1, 0 },
  { 705, 2, 2, 5, 2, -13 },
  { 706, 7, 10, 8, 0, -10 },
  { 715, 8, 14, 8, 0, -14 },
  { 729, 6, 10, 8, 1, -10 },
  { 737, 8, 14, 8, 1, -14 },
  { 751, 6, 10, 8, 1, -10 },
  { 759, 6, 14, 5, 1, -14 },
  { 770, 8, 14, 8, 0, -10 },
  { 784, 7, 14, 8, 0, -14 },
  { 797, 3, 13, 4, 1, -13 },
  { 802, 6, 17, 4, -2, -13 },
  { 815, 8, 14, 7, 0, -14 },
  { 829, 3, 14, 4, 1, -14 },
  { 835, 12, 10, 13, 0, -10 },
  { 850, 7, 10, 8, 0, -10 },
  { 859, 7, 10, 9, 1, -10 },
  { 868, 8, 14, 8, 0, -10 },
  { 882, 7, 14, 8, 1, -10 },
  { 895, 6, 10, 5, 0, -10 },
  { 903, 7, 10, 8, 0, -10 },
  { 912, 4, 12, 5, 1, -12 },
  { 918, 7, 10, 8, 1, -10 },
  { 927, 7, 10, 7, 1, -10 },
  { 936, 10, 10, 11, 1, -10 },
  { 949, 7, 10, 7, 0, -10 },
  { 958, 9, 14, 7, -1, -10 },
  { 974, 7, 10, 7, 0, -10 },
  { 983, 5, 18, 5, 1, -14 },
  { 995, 3, 15, 4, 0, -13 },
  { 1001, 6, 18, 5, -1, -14 },
  { 1015, 8, 3, 10, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraLightItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC18PT7B_H_
