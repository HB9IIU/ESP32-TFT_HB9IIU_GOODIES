#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC46PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xC0, 0x63, 0x63,
  0x63, 0x62, 0x62, 0x46, 0xC6, 0xC6, 0xC4, 0xC4, 0x00, 0x0C, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00, 0x02,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x20, 0x60, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10,
  0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x02, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x04, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x20,
  0x20, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x00, 0x02, 0x02, 0x00, 0x04, 0x0C,
  0x00, 0x18, 0x10, 0x00, 0x20, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xE0, 0x60,
  0x30, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x01, 0x0C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x8C, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0,
  0x06, 0x0C, 0x01, 0x80, 0xC0, 0x70, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0x04, 0x00, 0x08, 0x18, 0x00, 0x60, 0x20, 0x11, 0x00,
  0x80, 0xC4, 0x06, 0x06, 0x10, 0x18, 0x30, 0xC0, 0x60, 0x83, 0x01, 0x06,
  0x0C, 0x04, 0x30, 0x10, 0x30, 0x80, 0x61, 0x86, 0x00, 0xFC, 0x30, 0x01,
  0xE0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x1E, 0x00, 0x30, 0xFC, 0x01, 0x86, 0x18, 0x04, 0x30, 0x20, 0x30, 0x80,
  0x81, 0x86, 0x03, 0x04, 0x18, 0x08, 0x20, 0x60, 0x21, 0x81, 0x00, 0x8C,
  0x04, 0x06, 0x20, 0x10, 0x18, 0x80, 0x60, 0x40, 0x01, 0x83, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x30, 0x60,
  0x03, 0x03, 0x00, 0x10, 0x08, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x60,
  0x30, 0x02, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00,
  0x11, 0x80, 0x00, 0xD8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x60,
  0x00, 0x33, 0x00, 0x03, 0x0C, 0x06, 0x30, 0x60, 0x23, 0x01, 0x81, 0x18,
  0x0C, 0x19, 0x80, 0x30, 0xCC, 0x00, 0x8C, 0x40, 0x06, 0x62, 0x00, 0x1E,
  0x10, 0x00, 0xF0, 0x80, 0x03, 0x06, 0x00, 0x38, 0x30, 0x03, 0x60, 0xE0,
  0x33, 0x03, 0xFF, 0x0C, 0x07, 0xE0, 0x60, 0x6D, 0xA5, 0xB6, 0x90, 0x00,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x03,
  0x03, 0x07, 0xF1, 0x1F, 0x1E, 0xFC, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xD8,
  0x00, 0x66, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x18, 0x20,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x18,
  0xC4, 0x63, 0x19, 0x8C, 0xC4, 0x00, 0x7F, 0xDF, 0xE0, 0x7F, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x38, 0x18, 0x18, 0x06, 0x06, 0x00,
  0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x01, 0x18, 0x00, 0x44, 0x00, 0x13,
  0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x26, 0x00, 0x19, 0x00, 0x06, 0x40, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x8C,
  0x00, 0x61, 0x00, 0x10, 0x60, 0x0C, 0x18, 0x06, 0x03, 0x03, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x40, 0xF0, 0xFD, 0xE3, 0xE0, 0xA0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF0, 0x0E, 0x07, 0x01, 0x80, 0x60, 0x60, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x06, 0x07,
  0x01, 0x80, 0x60, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x08, 0x40, 0x01,
  0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0xC0, 0x00, 0x98, 0x00, 0x31, 0x00, 0x06, 0x30, 0x01, 0x86,
  0x00, 0x30, 0x60, 0x0C, 0x0E, 0x03, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x6C,
  0x00, 0x09, 0x80, 0x03, 0x20, 0x00, 0xC4, 0x00, 0x11, 0x80, 0x06, 0x30,
  0x01, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x03, 0x02, 0x00, 0xC0, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x60, 0x08, 0x0C, 0x01, 0x03,
  0x00, 0x60, 0xC0, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x1F, 0x00, 0x2F, 0xF8, 0x0F, 0x03, 0x81, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x80, 0x03, 0x18, 0x00, 0x43, 0x00, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x1C, 0x0E, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x1F, 0x03, 0x3F, 0xE1, 0xB0, 0x30, 0xA0, 0x0C, 0xE0, 0x06,
  0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x34, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x60, 0x01, 0x90, 0x00, 0xCC,
  0x00, 0xC6, 0x00, 0x61, 0x80, 0x60, 0xE0, 0x60, 0x3F, 0xE0, 0x07, 0xC0,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0xC0,
  0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00,
  0xC0, 0x60, 0x18, 0x07, 0x03, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xE0,
  0x60, 0x1C, 0x03, 0x03, 0x00, 0x18, 0x30, 0x01, 0x86, 0x00, 0x0C, 0x60,
  0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x84,
  0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x60, 0x38, 0x1C, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0x81, 0x81, 0x80, 0x61,
  0x80, 0x11, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03, 0x60, 0x01, 0xB0, 0x00,
  0xD0, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x80,
  0x07, 0x60, 0x03, 0x30, 0x03, 0x98, 0x03, 0xC6, 0x07, 0x61, 0xFF, 0x20,
  0x7E, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x38, 0x60, 0x01,
  0x81, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x02, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF3, 0xFF, 0xFC, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xC1,
  0x81, 0x8C, 0x06, 0x60, 0x09, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x78, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x03, 0xC0,
  0x08, 0xC0, 0x1F, 0xE0, 0x11, 0x80, 0x60, 0x60, 0x22, 0x01, 0x80, 0xC0,
  0x4C, 0x06, 0x01, 0x00, 0x90, 0x08, 0x02, 0x01, 0x60, 0x30, 0x0C, 0x02,
  0xC0, 0x40, 0x18, 0x0D, 0x01, 0x80, 0x20, 0x1A, 0x03, 0x00, 0x40, 0x3C,
  0x04, 0x01, 0x80, 0x58, 0x18, 0x03, 0x00, 0xB0, 0x30, 0x04, 0x03, 0x40,
  0x60, 0x08, 0x06, 0x80, 0x80, 0x30, 0x09, 0x01, 0x00, 0x60, 0x32, 0x02,
  0x01, 0xC0, 0x64, 0x04, 0x07, 0x01, 0x88, 0x08, 0x0B, 0x02, 0x10, 0x18,
  0x26, 0x0C, 0x20, 0x1F, 0x87, 0xF0, 0x60, 0x1E, 0x07, 0x80, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x10, 0x00,
  0x18, 0x40, 0x00, 0x61, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x08, 0x00, 0x80, 0x20,
  0x06, 0x00, 0x80, 0x10, 0x03, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0C, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x06, 0x00, 0xE0, 0x40, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x03, 0x81, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x00, 0x0C, 0x20, 0x00,
  0x42, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00,
  0x0C, 0x40, 0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0,
  0x0E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0xE0, 0x18, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x0C, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x46, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x30, 0x30,
  0x03, 0x80, 0xE0, 0x38, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x60, 0x0E, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20,
  0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x21, 0x80, 0x00, 0x84, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00, 0x0C,
  0x10, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x1C, 0x07, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x7F, 0xC4, 0x01, 0xFF, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x80, 0x78, 0x03, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x04, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x10, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x10,
  0x00, 0x04, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0x80, 0x00, 0x20, 0x00, 0x03, 0x02,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20,
  0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x06, 0x01, 0x80, 0x70, 0x38,
  0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x08, 0x0E, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x36, 0x60, 0x00,
  0x3C, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x18, 0x00, 0x20, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x03, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE0, 0xD0, 0x00, 0x03, 0xC1, 0xA0, 0x00, 0x05, 0x83, 0x60,
  0x00, 0x1B, 0x06, 0xC0, 0x00, 0x64, 0x09, 0x80, 0x00, 0xC8, 0x11, 0x00,
  0x03, 0x30, 0x62, 0x00, 0x06, 0x60, 0xC6, 0x00, 0x18, 0xC1, 0x8C, 0x00,
  0x31, 0x83, 0x18, 0x00, 0xC2, 0x04, 0x30, 0x01, 0x84, 0x08, 0x20, 0x06,
  0x18, 0x30, 0x40, 0x0C, 0x30, 0x60, 0xC0, 0x30, 0x60, 0xC1, 0x80, 0x60,
  0xC1, 0x83, 0x01, 0x81, 0x02, 0x06, 0x03, 0x02, 0x04, 0x04, 0x0C, 0x0C,
  0x18, 0x08, 0x10, 0x18, 0x30, 0x18, 0x60, 0x30, 0x60, 0x30, 0x80, 0x60,
  0xC0, 0x63, 0x00, 0x81, 0x00, 0x44, 0x03, 0x02, 0x00, 0x98, 0x06, 0x0C,
  0x01, 0x20, 0x0C, 0x18, 0x03, 0xC0, 0x18, 0x30, 0x07, 0x00, 0x30, 0x60,
  0x0E, 0x00, 0x40, 0x80, 0x08, 0x01, 0x80, 0x06, 0x00, 0x01, 0x83, 0x80,
  0x00, 0xC1, 0xC0, 0x00, 0x60, 0xA0, 0x00, 0x20, 0xD8, 0x00, 0x30, 0x6C,
  0x00, 0x18, 0x32, 0x00, 0x0C, 0x19, 0x80, 0x06, 0x0C, 0xC0, 0x03, 0x04,
  0x30, 0x01, 0x06, 0x18, 0x01, 0x83, 0x04, 0x00, 0xC1, 0x83, 0x00, 0x60,
  0xC1, 0x80, 0x30, 0x60, 0x40, 0x18, 0x20, 0x30, 0x08, 0x30, 0x18, 0x0C,
  0x18, 0x06, 0x06, 0x0C, 0x03, 0x03, 0x06, 0x00, 0x81, 0x83, 0x00, 0x60,
  0x81, 0x00, 0x30, 0x41, 0x80, 0x08, 0x60, 0xC0, 0x06, 0x30, 0x60, 0x03,
  0x18, 0x30, 0x00, 0xCC, 0x18, 0x00, 0x64, 0x08, 0x00, 0x16, 0x0C, 0x00,
  0x0F, 0x06, 0x00, 0x07, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x04,
  0x00, 0x02, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x19, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x10, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x30, 0x80, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x07, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x60, 0x07, 0x01, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x02,
  0x0C, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x04, 0x00, 0x38, 0x30, 0x01,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xC0, 0x07, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x40, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00, 0x46, 0x00,
  0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00, 0x03,
  0x10, 0x00, 0x06, 0x20, 0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00, 0x41,
  0x80, 0x01, 0x83, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x07,
  0x01, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x40, 0x07, 0x01, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x02,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x10, 0x60, 0x00, 0xC1, 0x00, 0x06, 0x04, 0x00, 0x38, 0x30, 0x01,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC0, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x80, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x30, 0x00, 0x08, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x80, 0x70, 0x03, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x10, 0x00,
  0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x02, 0x08, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00,
  0x00, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x0C, 0x03, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0x90, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x02, 0x02, 0x00, 0x18,
  0x08, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0x40, 0x30, 0x01, 0x00, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x02, 0x18, 0x00,
  0x08, 0x60, 0x00, 0x23, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x34, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x14, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xD8, 0x01, 0xB0, 0x01,
  0x30, 0x03, 0x60, 0x06, 0x60, 0x04, 0xC0, 0x0C, 0xC0, 0x18, 0x80, 0x31,
  0x80, 0x21, 0x00, 0x63, 0x00, 0xC2, 0x00, 0xC6, 0x01, 0x84, 0x03, 0x0C,
  0x02, 0x08, 0x06, 0x18, 0x0C, 0x10, 0x08, 0x30, 0x18, 0x30, 0x30, 0x60,
  0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0x80, 0x81, 0x01, 0x83, 0x01, 0x06,
  0x03, 0x06, 0x02, 0x0C, 0x06, 0x18, 0x04, 0x30, 0x04, 0x30, 0x0C, 0x60,
  0x08, 0x60, 0x18, 0x80, 0x11, 0x80, 0x33, 0x00, 0x23, 0x00, 0x66, 0x00,
  0x44, 0x00, 0xD8, 0x00, 0x98, 0x01, 0xB0, 0x01, 0xB0, 0x03, 0x40, 0x03,
  0x40, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x08, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x83, 0x0C, 0x30, 0xC3, 0x04,
  0x10, 0x61, 0x86, 0x18, 0x60, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x41,
  0x86, 0x18, 0x61, 0x82, 0x08, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x01, 0xF8,
  0x0F, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x78, 0x03, 0xC0, 0x36, 0x01, 0x90, 0x18, 0x80, 0x84, 0x0C,
  0x30, 0x41, 0x86, 0x0C, 0x20, 0x63, 0x01, 0x10, 0x09, 0x80, 0x68, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x0C, 0x61, 0x8C, 0x00, 0xFC, 0x01, 0xFF,
  0x81, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xFF, 0xC1, 0xFF, 0xE3, 0x80, 0x31,
  0x80, 0x19, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x01, 0xCC, 0x01, 0xE3, 0x03, 0xB1, 0xFF, 0x18, 0x3E, 0x0C, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x31, 0xF8, 0x0C, 0xFF, 0x02, 0xE0, 0x60, 0xE0, 0x0C, 0x70, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xC8, 0x00, 0x26, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x40, 0x18, 0xD8,
  0x0C, 0x33, 0xFE, 0x0C, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x60,
  0x30, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x23, 0x00, 0x0C, 0xC0, 0x03,
  0x20, 0x00, 0xD8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x40, 0x03, 0x10, 0x00, 0xC4, 0x00,
  0x21, 0x80, 0x18, 0x60, 0x0C, 0x0C, 0x06, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x1F, 0x0C, 0x07, 0xFC, 0xC0, 0xE0, 0x6C, 0x18,
  0x02, 0x83, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x18, 0x60, 0x01, 0x86,
  0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x04, 0x01, 0xC0, 0x60, 0x34, 0x03, 0xFE,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x60, 0x30, 0x30,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x23, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x27, 0xFF, 0xF9, 0xFF, 0xFE, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x04, 0x0E, 0x03, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x7C,
  0x07, 0xE0, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7C, 0x30, 0x1F, 0xF3, 0x03, 0x01, 0xB0, 0x60, 0x0A, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x08, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00,
  0x04, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83,
  0x00, 0x38, 0x10, 0x07, 0x81, 0x80, 0xD0, 0x0F, 0xFB, 0x00, 0x7E, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0xC0, 0x70, 0x18, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0xF8, 0x0C, 0xFF, 0x02, 0x60, 0x60, 0xB0, 0x18, 0x68, 0x03, 0x1C,
  0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0x8C, 0x00,
  0x23, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x88, 0x00, 0x62, 0x00, 0x11,
  0x80, 0x04, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x08, 0xC0,
  0x02, 0x30, 0x01, 0x8C, 0x00, 0x60, 0x03, 0x07, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x60, 0xC0, 0x18, 0x10, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x18, 0x03, 0x06, 0x00, 0x61, 0x80, 0x08, 0x60, 0x01, 0x18, 0x00,
  0x66, 0x00, 0x0D, 0xE0, 0x01, 0xEC, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x00,
  0x81, 0x80, 0x30, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x02,
  0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18, 0x00, 0x03, 0x03,
  0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x0C, 0x3E, 0x01,
  0xF0, 0x19, 0xFE, 0x0F, 0xF0, 0x26, 0x06, 0x30, 0x30, 0xD8, 0x0C, 0xC0,
  0x21, 0xE0, 0x0F, 0x00, 0x63, 0x80, 0x1C, 0x00, 0xC6, 0x00, 0x30, 0x01,
  0x8C, 0x00, 0x60, 0x03, 0x18, 0x00, 0xC0, 0x06, 0x60, 0x01, 0x00, 0x0C,
  0xC0, 0x06, 0x00, 0x11, 0x80, 0x0C, 0x00, 0x63, 0x00, 0x18, 0x00, 0xC4,
  0x00, 0x30, 0x01, 0x88, 0x00, 0x40, 0x03, 0x30, 0x00, 0x80, 0x04, 0x60,
  0x03, 0x00, 0x08, 0xC0, 0x06, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x62, 0x00,
  0x18, 0x00, 0xC4, 0x00, 0x20, 0x01, 0x98, 0x00, 0x40, 0x02, 0x30, 0x01,
  0x80, 0x04, 0x60, 0x03, 0x00, 0x18, 0x0C, 0x3E, 0x03, 0x3F, 0xC0, 0xD8,
  0x18, 0x2C, 0x06, 0x1A, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0xC4, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x62, 0x00, 0x18, 0x80, 0x04, 0x60, 0x01, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0xE0, 0x30, 0x70, 0x0E, 0x18, 0x01, 0x8C,
  0x00, 0x62, 0x00, 0x09, 0x80, 0x02, 0x60, 0x00, 0x90, 0x00, 0x2C, 0x00,
  0x0B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04,
  0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0x60, 0x0C, 0x1C,
  0x0E, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0x1F, 0x80, 0x33, 0xFC, 0x02,
  0xC0, 0x60, 0x38, 0x03, 0x07, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x10,
  0x60, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x1C, 0x01, 0x83, 0x60,
  0x30, 0x33, 0xFE, 0x03, 0x0F, 0xC0, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0xC1, 0xFF, 0x30, 0xE0, 0x6C,
  0x60, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x62, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0x90, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0x40, 0x1C, 0x18, 0x0D, 0x03, 0xFE, 0xC0, 0x7E, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x78, 0x33, 0xE0,
  0xD8, 0x02, 0x80, 0x1E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x00, 0x61, 0x80,
  0x18, 0x80, 0x0C, 0x40, 0x06, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x8C, 0x00, 0xC3, 0x81,
  0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x61, 0xFF, 0xFF, 0x8C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0xE0, 0xF0, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0x40,
  0x02, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x01,
  0x88, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC4,
  0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE1, 0x00,
  0x38, 0x60, 0x14, 0x1C, 0x0D, 0x03, 0xFE, 0xC0, 0x7E, 0x30, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0x98, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x61, 0x80,
  0x20, 0xC0, 0x30, 0x60, 0x10, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x0C, 0x02,
  0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x08, 0x80,
  0x04, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x10,
  0x00, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xD8, 0x07,
  0x80, 0x6C, 0x02, 0xC0, 0x26, 0x03, 0x60, 0x33, 0x01, 0x30, 0x19, 0x81,
  0x98, 0x18, 0xC0, 0xCC, 0x0C, 0x60, 0xC6, 0x04, 0x30, 0x61, 0x06, 0x18,
  0x20, 0x83, 0x0C, 0x30, 0x43, 0x02, 0x10, 0x21, 0x81, 0x18, 0x10, 0x80,
  0x88, 0x0C, 0xC0, 0x4C, 0x06, 0x40, 0x26, 0x03, 0x60, 0x12, 0x01, 0xB0,
  0x0B, 0x00, 0xD0, 0x05, 0x00, 0x78, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0xC0,
  0x30, 0x18, 0x03, 0x01, 0x80, 0x18, 0x30, 0x01, 0x86, 0x00, 0x08, 0x40,
  0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0x90, 0x00, 0x11, 0x80, 0x03, 0x08, 0x00, 0x60,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x30, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x00, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x10, 0x18, 0x00, 0x40,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00,
  0x00, 0x8C, 0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x08, 0x00, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x01, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFC, 0x00, 0xD8, 0x30, 0x06, 0xC0, 0xC0, 0x2C, 0x03, 0x03,
  0x60, 0x1C, 0x32, 0x00, 0x7F, 0x00, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 33, 9, 1, -33 },
  { 34, 8, 10, 12, 5, -35 },
  { 44, 23, 33, 22, 1, -33 },
  { 139, 19, 41, 22, 2, -37 },
  { 237, 22, 33, 29, 4, -33 },
  { 328, 21, 33, 24, 1, -33 },
  { 415, 3, 10, 8, 5, -35 },
  { 419, 13, 48, 13, 2, -37 },
  { 497, 13, 48, 13, -3, -37 },
  { 575, 17, 18, 19, 3, -33 },
  { 614, 19, 24, 22, 2, -27 },
  { 671, 5, 10, 8, -1, -4 },
  { 678, 10, 2, 12, 1, -16 },
  { 681, 3, 3, 10, 1, -3 },
  { 683, 19, 36, 16, -2, -33 },
  { 769, 18, 33, 22, 2, -33 },
  { 844, 10, 33, 22, 6, -33 },
  { 886, 19, 33, 22, 1, -33 },
  { 965, 19, 33, 22, 1, -33 },
  { 1044, 19, 33, 22, 1, -33 },
  { 1123, 19, 33, 22, 3, -33 },
  { 1202, 17, 33, 22, 2, -33 },
  { 1273, 18, 33, 22, 4, -33 },
  { 1348, 20, 33, 22, 1, -33 },
  { 1431, 17, 33, 22, 3, -33 },
  { 1502, 7, 24, 8, 1, -24 },
  { 1523, 9, 30, 8, -2, -24 },
  { 1557, 17, 18, 20, 2, -24 },
  { 1596, 18, 12, 22, 2, -21 },
  { 1623, 18, 18, 20, 1, -24 },
  { 1664, 14, 33, 18, 4, -33 },
  { 1722, 31, 42, 36, 2, -32 },
  { 1885, 22, 33, 24, -1, -33 },
  { 1976, 20, 33, 24, 2, -33 },
  { 2059, 21, 33, 25, 3, -33 },
  { 2146, 22, 33, 26, 2, -33 },
  { 2237, 22, 33, 22, 2, -33 },
  { 2328, 22, 33, 22, 2, -33 },
  { 2419, 22, 33, 27, 3, -33 },
  { 2510, 25, 33, 27, 2, -33 },
  { 2614, 8, 33, 11, 2, -33 },
  { 2647, 20, 33, 22, 1, -33 },
  { 2730, 24, 33, 25, 2, -33 },
  { 2829, 15, 33, 21, 2, -33 },
  { 2891, 31, 33, 33, 2, -33 },
  { 3019, 25, 33, 28, 2, -33 },
  { 3123, 23, 33, 26, 2, -33 },
  { 3218, 22, 33, 24, 2, -33 },
  { 3309, 23, 39, 26, 2, -33 },
  { 3422, 22, 33, 25, 2, -33 },
  { 3513, 22, 33, 23, 1, -33 },
  { 3604, 21, 33, 23, 4, -33 },
  { 3691, 23, 33, 26, 3, -33 },
  { 3786, 22, 33, 24, 4, -33 },
  { 3877, 31, 33, 35, 5, -33 },
  { 4005, 26, 33, 24, -1, -33 },
  { 4113, 22, 33, 23, 4, -33 },
  { 4204, 24, 33, 23, 0, -33 },
  { 4303, 13, 44, 9, 0, -37 },
  { 4375, 6, 36, 15, 5, -33 },
  { 4402, 13, 44, 9, -3, -37 },
  { 4474, 13, 16, 17, 2, -33 },
  { 4500, 16, 2, 17, -2, 0 },
  { 4504, 5, 6, 12, 6, -34 },
  { 4508, 17, 24, 21, 1, -24 },
  { 4559, 18, 35, 22, 1, -35 },
  { 4638, 18, 24, 20, 1, -24 },
  { 4692, 20, 35, 22, 2, -35 },
  { 4780, 18, 24, 20, 1, -24 },
  { 4834, 14, 35, 13, 3, -35 },
  { 4896, 20, 33, 22, 0, -24 },
  { 4979, 18, 35, 22, 1, -35 },
  { 5058, 8, 33, 9, 1, -33 },
  { 5091, 15, 42, 9, -6, -33 },
  { 5170, 19, 35, 19, 1, -35 },
  { 5254, 8, 35, 9, 1, -35 },
  { 5289, 31, 24, 34, 1, -24 },
  { 5382, 18, 24, 22, 1, -24 },
  { 5436, 18, 24, 22, 2, -24 },
  { 5490, 20, 33, 22, -1, -24 },
  { 5573, 18, 33, 22, 2, -24 },
  { 5648, 14, 24, 14, 1, -24 },
  { 5690, 17, 24, 20, 1, -24 },
  { 5741, 9, 31, 13, 3, -31 },
  { 5776, 18, 24, 22, 2, -24 },
  { 5830, 17, 24, 19, 3, -24 },
  { 5881, 25, 24, 29, 4, -24 },
  { 5956, 20, 24, 19, -1, -24 },
  { 6016, 22, 33, 19, -2, -24 },
  { 6107, 19, 24, 19, 0, -24 },
  { 6164, 14, 46, 13, 2, -36 },
  { 6245, 8, 39, 9, 1, -33 },
  { 6284, 15, 46, 13, -3, -36 },
  { 6371, 21, 8, 27, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLightItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC46PT7B_H_
