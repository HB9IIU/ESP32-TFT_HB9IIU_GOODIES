#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC53PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x01, 0x00, 0x61, 0xB0, 0xD8,
  0x6C, 0x66, 0x33, 0x1B, 0x0D, 0x86, 0xC2, 0x63, 0x21, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x08, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xFC, 0x00, 0x3E, 0x78, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x30,
  0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x70, 0x03, 0x80,
  0xE0, 0x1C, 0x01, 0xE3, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x00, 0x80, 0x21, 0x80, 0x40, 0x30, 0x80,
  0x20, 0x18, 0xC0, 0x10, 0x18, 0x60, 0x18, 0x18, 0x30, 0x0C, 0x0C, 0x18,
  0x06, 0x0C, 0x0C, 0x03, 0x0C, 0x06, 0x03, 0x06, 0x03, 0x01, 0x86, 0x00,
  0xC1, 0x86, 0x00, 0x71, 0x83, 0x00, 0x1F, 0x83, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x83,
  0xF0, 0x00, 0xC3, 0x8C, 0x00, 0xC3, 0x03, 0x00, 0x41, 0x81, 0x80, 0x61,
  0x80, 0x40, 0x60, 0xC0, 0x20, 0x60, 0x40, 0x10, 0x30, 0x60, 0x08, 0x30,
  0x30, 0x0C, 0x30, 0x18, 0x06, 0x18, 0x0C, 0x03, 0x18, 0x06, 0x01, 0x98,
  0x03, 0x01, 0x84, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xEF, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0xE0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0x63,
  0x80, 0x00, 0xCE, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x77, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x0E, 0x01,
  0x8C, 0x0C, 0x03, 0x30, 0x0C, 0x06, 0xC0, 0x18, 0x19, 0x80, 0x18, 0x36,
  0x00, 0x30, 0x6C, 0x00, 0x31, 0x98, 0x00, 0x73, 0x30, 0x00, 0x6C, 0x60,
  0x00, 0xF8, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x83, 0x00,
  0x1D, 0x87, 0x00, 0x63, 0x07, 0xC7, 0x83, 0x03, 0xFC, 0x07, 0x00, 0xC0,
  0x00, 0x33, 0x33, 0x66, 0x66, 0x64, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x06, 0x02, 0x07, 0xF8, 0x61, 0xF1, 0xF6,
  0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x03,
  0x18, 0x00, 0x61, 0x80, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x06, 0x07,
  0x00, 0x60, 0x20, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x30,
  0xC3, 0x1C, 0x61, 0x8C, 0x71, 0x84, 0x00, 0xFF, 0xFF, 0xF0, 0x6F, 0xF4,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7C,
  0xF0, 0x07, 0x01, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00,
  0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x38, 0x01,
  0x80, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1E, 0x3C, 0x00, 0x7F, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x0E, 0x07, 0xE1, 0xE6, 0xF8, 0x6E, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x9F, 0x00, 0x70, 0x0E, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x60, 0x70, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x1E, 0x00, 0x70, 0x1C, 0x03, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0x78, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x38,
  0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x06,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC7, 0xC0, 0x06, 0xFF, 0xC0, 0x1F, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x80, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x10,
  0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x0E, 0x03, 0x00, 0x70, 0x0E, 0x03,
  0x80, 0x1F, 0x3C, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x61, 0xF8, 0x0C, 0xFF, 0xC1, 0xB8, 0x1C,
  0x6C, 0x01, 0x8F, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00, 0x76, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x66,
  0x00, 0x0C, 0xE0, 0x03, 0x8C, 0x00, 0x61, 0xC0, 0x18, 0x1C, 0x07, 0x01,
  0xE7, 0xC0, 0x1F, 0xE0, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF3,
  0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x01,
  0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x20, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03,
  0x80, 0x1C, 0x03, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x00,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x03,
  0x80, 0x78, 0x03, 0xE3, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0xC0, 0x0F, 0x3E, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x30,
  0x01, 0x8E, 0x00, 0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xE6, 0x00,
  0x3C, 0xC0, 0x05, 0x9C, 0x03, 0xB1, 0xC0, 0xE6, 0x1F, 0xF1, 0x80, 0xFC,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x06, 0x0F, 0x0E, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x00,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0x3C,
  0x18, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x60, 0x01, 0xF0, 0x03, 0x06, 0x00, 0x7F, 0x80,
  0x30, 0xC0, 0x0C, 0x0C, 0x03, 0x0C, 0x01, 0x80, 0x60, 0x11, 0x80, 0x30,
  0x0C, 0x01, 0x18, 0x06, 0x00, 0xC0, 0x11, 0x00, 0x60, 0x0C, 0x01, 0x30,
  0x0C, 0x00, 0xC0, 0x33, 0x00, 0xC0, 0x08, 0x03, 0x20, 0x18, 0x01, 0x80,
  0x36, 0x01, 0x80, 0x18, 0x03, 0x60, 0x18, 0x01, 0x80, 0x36, 0x03, 0x00,
  0x10, 0x03, 0x40, 0x30, 0x03, 0x00, 0x2C, 0x03, 0x00, 0x30, 0x06, 0xC0,
  0x30, 0x03, 0x00, 0x6C, 0x06, 0x00, 0x20, 0x04, 0xC0, 0x60, 0x06, 0x00,
  0xCC, 0x06, 0x00, 0x60, 0x0C, 0xC0, 0x60, 0x0E, 0x00, 0x8C, 0x06, 0x00,
  0xE0, 0x18, 0xC0, 0x60, 0x1E, 0x01, 0x0C, 0x06, 0x03, 0x60, 0x30, 0xC0,
  0x30, 0x66, 0x06, 0x0C, 0x03, 0x8C, 0x31, 0xC0, 0xC0, 0x1F, 0x81, 0xF8,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1C,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x03, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0C,
  0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x18, 0x00, 0xE0, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0x3F, 0x00, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38,
  0x30, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x1C,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x1C, 0x03, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xC7, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00,
  0xE0, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x01, 0xFF, 0xC6, 0x00, 0x7F, 0xF1, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x00, 0x03, 0x03, 0x03,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x06,
  0x01, 0x80, 0x1C, 0x01, 0x80, 0x70, 0x03, 0xE7, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00,
  0x60, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x19, 0xF0, 0x00, 0x01, 0xBB,
  0x80, 0x00, 0x1F, 0x18, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x1E, 0x02, 0xC0, 0x00, 0x01, 0xE0, 0x6C, 0x00, 0x00, 0x36, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x6C, 0x00, 0x00, 0x64, 0x06, 0x40, 0x00, 0x06, 0xC0,
  0x66, 0x00, 0x00, 0xCC, 0x04, 0x60, 0x00, 0x0C, 0xC0, 0xC6, 0x00, 0x01,
  0x8C, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0xC6, 0x00, 0x03, 0x18, 0x0C, 0x30,
  0x00, 0x71, 0x80, 0xC3, 0x00, 0x06, 0x18, 0x0C, 0x30, 0x00, 0xC1, 0x81,
  0x83, 0x00, 0x0C, 0x18, 0x18, 0x30, 0x01, 0x81, 0x81, 0x81, 0x00, 0x18,
  0x30, 0x18, 0x18, 0x03, 0x03, 0x01, 0x81, 0x80, 0x30, 0x30, 0x18, 0x18,
  0x06, 0x03, 0x03, 0x01, 0x80, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x03, 0x03,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x18, 0x06, 0x03, 0x00, 0xC1, 0x80,
  0x60, 0x60, 0x0C, 0x30, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x0C,
  0x60, 0x0C, 0x06, 0x00, 0x46, 0x00, 0xC0, 0x60, 0x06, 0xC0, 0x0C, 0x06,
  0x00, 0x6C, 0x00, 0xC0, 0xC0, 0x07, 0x80, 0x0C, 0x0C, 0x00, 0x78, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x80,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x07, 0x80, 0x00,
  0x70, 0x3C, 0x00, 0x03, 0x03, 0xE0, 0x00, 0x18, 0x19, 0x80, 0x00, 0xC0,
  0xCC, 0x00, 0x06, 0x06, 0x30, 0x00, 0x30, 0x31, 0x80, 0x03, 0x01, 0x8C,
  0x00, 0x18, 0x18, 0x30, 0x00, 0xC0, 0xC1, 0x80, 0x06, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x30, 0x01, 0x81, 0x81, 0x80, 0x18, 0x0C, 0x06, 0x00, 0xC0,
  0xC0, 0x30, 0x06, 0x06, 0x01, 0x80, 0x30, 0x30, 0x06, 0x01, 0x81, 0x80,
  0x30, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0xE0, 0x06, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x30, 0x00, 0xC1, 0x81, 0x80, 0x06, 0x0C, 0x0C, 0x00, 0x30, 0xE0,
  0x60, 0x00, 0xC6, 0x07, 0x00, 0x06, 0x30, 0x30, 0x00, 0x31, 0x81, 0x80,
  0x00, 0xCC, 0x0C, 0x00, 0x06, 0x60, 0x60, 0x00, 0x1F, 0x03, 0x00, 0x00,
  0xF0, 0x30, 0x00, 0x07, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xCF, 0xC0, 0x03, 0x80, 0x38, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x03,
  0x80, 0x1C, 0x03, 0xC0, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xC0, 0x07, 0x80,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x0E, 0x03, 0x00, 0x1E, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x1C,
  0x01, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x1C,
  0x00, 0x1C, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xC0, 0x07, 0x00, 0x60,
  0x00, 0xC0, 0x70, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x0E,
  0x03, 0x00, 0x0E, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE7, 0xC0, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x03, 0xE3, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x1F, 0x9F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x07, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01, 0xB0, 0x00, 0x1C, 0x00, 0x0D,
  0x80, 0x01, 0xE0, 0x00, 0x6E, 0x00, 0x0F, 0x00, 0x06, 0x30, 0x00, 0xD8,
  0x00, 0x31, 0x80, 0x06, 0xC0, 0x03, 0x8C, 0x00, 0x26, 0x00, 0x18, 0x60,
  0x03, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x80, 0x0C, 0x18, 0x01, 0x84, 0x00,
  0x60, 0xC0, 0x0C, 0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x30, 0x30, 0x06,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x18, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x06, 0x00, 0x81, 0x80, 0x30,
  0x30, 0x04, 0x0C, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x05, 0x80, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30,
  0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x03, 0x98,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x70,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x2C, 0x01,
  0xB0, 0x04, 0xC0, 0x33, 0x00, 0x8C, 0x06, 0x10, 0x10, 0x60, 0xC1, 0x83,
  0x06, 0x18, 0x18, 0x60, 0x63, 0x00, 0x8C, 0x03, 0x60, 0x0D, 0x80, 0x3C,
  0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0x87, 0x0C, 0x18, 0x60,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xE3, 0xC0, 0x70, 0x0E, 0x06,
  0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFE,
  0x07, 0xFF, 0xE0, 0xE0, 0x06, 0x38, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00,
  0x38, 0xC0, 0x03, 0x8E, 0x00, 0xF8, 0x60, 0x1D, 0x87, 0xCF, 0x18, 0x1F,
  0xE1, 0x80, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00,
  0x63, 0xFC, 0x03, 0x3C, 0xF0, 0x1F, 0x01, 0xC1, 0xA0, 0x06, 0x0E, 0x00,
  0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC4, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x63, 0x00, 0x03, 0x1C, 0x00, 0x30,
  0xE0, 0x01, 0x87, 0x80, 0x18, 0x36, 0x01, 0xC3, 0x1E, 0x7C, 0x18, 0x7F,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xC7, 0x80,
  0x60, 0x0C, 0x0C, 0x00, 0xE1, 0x80, 0x06, 0x18, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x70, 0x0E, 0x03,
  0xE7, 0xC0, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1F, 0xE1, 0x80, 0x78, 0xE3, 0x01,
  0xC0, 0x66, 0x06, 0x00, 0x6C, 0x1C, 0x00, 0x70, 0x30, 0x00, 0x60, 0xE0,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x78, 0x06, 0x01, 0xB0, 0x0F, 0x9E, 0x60, 0x0F,
  0xF0, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xE3,
  0xC0, 0x38, 0x0E, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x18, 0x03,
  0x81, 0xF1, 0xF0, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0xF1, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x7F, 0xF8,
  0x7F, 0xF0, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0C,
  0x03, 0xC7, 0x18, 0x0E, 0x03, 0x30, 0x30, 0x03, 0x60, 0xE0, 0x03, 0x81,
  0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x03, 0xC0, 0x70, 0x0D, 0x80,
  0x7C, 0xF3, 0x00, 0x7F, 0x86, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x18, 0x06, 0x00, 0x70, 0x07, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x61, 0xFC, 0x03,
  0x3C, 0xF0, 0x1B, 0x01, 0xC1, 0xB0, 0x06, 0x0D, 0x00, 0x30, 0x78, 0x00,
  0xC3, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x30, 0x03, 0x07,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1C, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x38, 0x18, 0x01, 0xC0,
  0x60, 0x0E, 0x03, 0x00, 0x70, 0x0C, 0x03, 0x80, 0x30, 0x1C, 0x00, 0xC0,
  0xE0, 0x03, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x61, 0xC0, 0x01, 0x8E, 0x00,
  0x06, 0x70, 0x00, 0x1B, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xE6, 0x00, 0x0E,
  0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x20, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x18, 0x01, 0x80,
  0x60, 0x07, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x38, 0x30, 0x00, 0x60, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x63, 0xFC, 0x07, 0xF8,
  0x06, 0x71, 0xE0, 0xF3, 0xC0, 0xCC, 0x07, 0x18, 0x0E, 0x0D, 0x80, 0x33,
  0x00, 0x60, 0xF0, 0x03, 0x60, 0x06, 0x0E, 0x00, 0x34, 0x00, 0x30, 0xE0,
  0x01, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x31, 0xC0, 0x03, 0x80, 0x03,
  0x18, 0x00, 0x30, 0x00, 0x71, 0x80, 0x03, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x63, 0x00,
  0x02, 0x00, 0x06, 0x30, 0x00, 0x60, 0x00, 0xE3, 0x00, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00, 0x18,
  0xC0, 0x00, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0xFE, 0x01, 0x9E, 0x78, 0x0D, 0x80,
  0xE0, 0xD8, 0x03, 0x06, 0x80, 0x18, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x03, 0xE7, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x18, 0x00,
  0x33, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x87, 0x00, 0x30,
  0x38, 0x0E, 0x01, 0xE3, 0xC0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x03, 0x1F, 0xE0, 0x06, 0x71, 0xE0, 0x0F, 0x80, 0xE0, 0x3C, 0x00,
  0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x3C, 0x00,
  0xC0, 0x6C, 0x03, 0x80, 0x8F, 0x3E, 0x03, 0x0F, 0xF0, 0x06, 0x02, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xC0, 0xF1,
  0xE6, 0x0E, 0x03, 0x30, 0xE0, 0x0D, 0x8E, 0x00, 0x38, 0x60, 0x00, 0xC7,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0,
  0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00,
  0x3C, 0x1C, 0x03, 0x60, 0x7C, 0xF3, 0x01, 0xFE, 0x30, 0x00, 0x81, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x3F, 0x06, 0x78, 0x06, 0xC0, 0x0D, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xE7, 0xC0, 0x70, 0x0C, 0x0E, 0x00,
  0x60, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x03, 0x86, 0x00, 0x30, 0x70, 0x0E, 0x03, 0xE7, 0xC0, 0x0F, 0xF8,
  0x00, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x87, 0xFF, 0xFF, 0xE1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0E, 0x40, 0xF8, 0x04, 0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x33, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30,
  0xC0, 0x07, 0x0C, 0x00, 0x70, 0xE0, 0x0F, 0x06, 0x01, 0xB0, 0x78, 0xF2,
  0x03, 0xFC, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00,
  0x18, 0x30, 0x07, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x04, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x03, 0x60,
  0x00, 0x68, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0x70, 0x01,
  0xB0, 0x01, 0xC0, 0x0C, 0xC0, 0x0F, 0x00, 0x31, 0x00, 0x3C, 0x01, 0xC6,
  0x01, 0xB0, 0x06, 0x18, 0x06, 0x40, 0x18, 0x60, 0x31, 0x80, 0xC1, 0x80,
  0xC6, 0x03, 0x06, 0x06, 0x18, 0x1C, 0x18, 0x18, 0x60, 0x60, 0x60, 0x61,
  0x81, 0x81, 0x83, 0x06, 0x0C, 0x06, 0x0C, 0x18, 0x30, 0x18, 0x60, 0x61,
  0x80, 0x61, 0x81, 0x86, 0x01, 0x8C, 0x02, 0x18, 0x06, 0x30, 0x08, 0xC0,
  0x18, 0x80, 0x23, 0x00, 0x26, 0x00, 0xD8, 0x00, 0x98, 0x03, 0x60, 0x02,
  0xC0, 0x0D, 0x80, 0x0B, 0x00, 0x3C, 0x00, 0x28, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x0E, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x18, 0x07,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x63, 0x80,
  0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x60, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x01,
  0x81, 0xC0, 0x03, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x80,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x8E, 0x1C, 0x00, 0xC6, 0x07, 0x00, 0x66, 0x01, 0xC0, 0x33, 0x00, 0x70,
  0x33, 0x00, 0x1C, 0x31, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 39, 10, 1, -38 },
  { 45, 9, 11, 14, 6, -40 },
  { 58, 27, 38, 26, 1, -38 },
  { 187, 22, 50, 25, 2, -44 },
  { 325, 25, 40, 33, 5, -39 },
  { 450, 23, 40, 28, 2, -39 },
  { 565, 4, 11, 9, 5, -40 },
  { 571, 14, 54, 14, 3, -42 },
  { 666, 15, 54, 15, -3, -42 },
  { 768, 20, 21, 22, 3, -38 },
  { 821, 22, 28, 25, 2, -32 },
  { 898, 6, 11, 10, -2, -4 },
  { 907, 10, 2, 14, 2, -18 },
  { 910, 4, 4, 12, 1, -3 },
  { 912, 22, 41, 18, -2, -38 },
  { 1025, 21, 40, 25, 3, -39 },
  { 1130, 12, 38, 25, 7, -38 },
  { 1187, 22, 39, 25, 1, -39 },
  { 1295, 22, 40, 25, 2, -39 },
  { 1405, 22, 38, 25, 1, -38 },
  { 1510, 22, 39, 25, 3, -38 },
  { 1618, 19, 39, 25, 3, -38 },
  { 1711, 22, 38, 25, 4, -38 },
  { 1816, 23, 40, 25, 1, -39 },
  { 1931, 19, 39, 25, 4, -39 },
  { 2024, 8, 28, 10, 1, -27 },
  { 2052, 11, 34, 9, -2, -27 },
  { 2099, 20, 21, 23, 2, -28 },
  { 2152, 20, 13, 25, 3, -24 },
  { 2185, 20, 21, 23, 1, -28 },
  { 2238, 16, 40, 20, 5, -39 },
  { 2318, 36, 49, 41, 2, -37 },
  { 2539, 26, 38, 28, -2, -38 },
  { 2663, 24, 38, 27, 2, -38 },
  { 2777, 25, 40, 29, 3, -39 },
  { 2902, 26, 38, 29, 2, -38 },
  { 3026, 25, 38, 26, 2, -38 },
  { 3145, 26, 38, 26, 2, -38 },
  { 3269, 26, 40, 31, 3, -39 },
  { 3399, 29, 38, 32, 2, -38 },
  { 3537, 8, 38, 12, 3, -38 },
  { 3575, 23, 39, 25, 1, -38 },
  { 3688, 28, 38, 28, 2, -38 },
  { 3821, 18, 38, 24, 2, -38 },
  { 3907, 36, 38, 38, 2, -38 },
  { 4078, 29, 38, 32, 2, -38 },
  { 4216, 26, 40, 30, 3, -39 },
  { 4346, 25, 38, 27, 2, -38 },
  { 4465, 25, 46, 30, 3, -39 },
  { 4609, 25, 38, 29, 2, -38 },
  { 4728, 26, 40, 27, 1, -39 },
  { 4858, 24, 38, 27, 5, -38 },
  { 4972, 26, 39, 30, 3, -38 },
  { 5099, 25, 38, 27, 5, -38 },
  { 5218, 37, 38, 40, 5, -38 },
  { 5394, 30, 38, 27, -1, -38 },
  { 5537, 25, 38, 27, 5, -38 },
  { 5656, 28, 38, 27, 0, -38 },
  { 5789, 15, 51, 11, 0, -43 },
  { 5885, 8, 41, 18, 5, -38 },
  { 5926, 14, 51, 11, -3, -43 },
  { 6016, 14, 19, 19, 3, -38 },
  { 6050, 19, 2, 19, -3, 0 },
  { 6055, 6, 7, 14, 7, -40 },
  { 6061, 20, 30, 24, 1, -29 },
  { 6136, 21, 41, 25, 1, -40 },
  { 6244, 20, 30, 23, 2, -29 },
  { 6319, 23, 41, 25, 2, -40 },
  { 6437, 20, 30, 23, 1, -29 },
  { 6512, 16, 41, 15, 3, -41 },
  { 6594, 23, 40, 25, 0, -29 },
  { 6709, 21, 40, 25, 1, -40 },
  { 6814, 8, 38, 10, 2, -38 },
  { 6852, 17, 49, 11, -7, -38 },
  { 6957, 22, 40, 22, 1, -40 },
  { 7067, 8, 40, 10, 2, -40 },
  { 7107, 36, 29, 40, 1, -29 },
  { 7238, 21, 29, 25, 1, -29 },
  { 7315, 20, 30, 25, 2, -29 },
  { 7390, 23, 40, 25, -1, -29 },
  { 7505, 21, 40, 25, 2, -29 },
  { 7610, 16, 29, 16, 1, -29 },
  { 7668, 20, 30, 23, 1, -29 },
  { 7743, 11, 36, 15, 3, -35 },
  { 7793, 20, 29, 25, 3, -28 },
  { 7866, 19, 28, 22, 3, -28 },
  { 7933, 30, 28, 34, 4, -28 },
  { 8038, 23, 28, 22, -1, -28 },
  { 8119, 25, 39, 22, -2, -28 },
  { 8241, 21, 28, 22, 0, -28 },
  { 8315, 16, 52, 15, 2, -41 },
  { 8419, 9, 45, 11, 1, -38 },
  { 8470, 16, 52, 15, -3, -41 },
  { 8574, 25, 9, 31, 3, -20 },
};

const GFXfont RobotoCondensed_ExtraLightItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC53PT7B_H_
