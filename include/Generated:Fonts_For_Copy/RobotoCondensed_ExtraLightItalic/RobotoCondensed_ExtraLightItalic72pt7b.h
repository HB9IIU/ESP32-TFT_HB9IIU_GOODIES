#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC72PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x60,
  0x00, 0x38, 0x33, 0x87, 0x30, 0x73, 0x07, 0x30, 0x77, 0x06, 0x70, 0x67,
  0x0E, 0x60, 0xE6, 0x0E, 0x60, 0xCE, 0x0C, 0xE0, 0xCC, 0x1C, 0xC1, 0xC0,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x18, 0x60, 0x03, 0x80, 0x0C, 0x30, 0x01, 0xC0, 0x0C, 0x38, 0x00,
  0xC0, 0x0E, 0x1C, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x30, 0x06, 0x06, 0x00,
  0x18, 0x07, 0x03, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00, 0xC0,
  0x06, 0x03, 0x80, 0x60, 0x03, 0x03, 0x80, 0x38, 0x03, 0x81, 0x80, 0x1C,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x81, 0xC0, 0x03, 0xC3, 0xC0, 0xC0, 0x00,
  0xFF, 0xC0, 0xC0, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0x38, 0x1F,
  0xF8, 0x00, 0x18, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x0C,
  0x01, 0x80, 0x0C, 0x0E, 0x00, 0xE0, 0x0C, 0x06, 0x00, 0x30, 0x0E, 0x07,
  0x00, 0x18, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x06, 0x07, 0x00,
  0xC0, 0x03, 0x07, 0x00, 0x60, 0x03, 0x83, 0x00, 0x70, 0x01, 0xC3, 0x80,
  0x38, 0x00, 0xC3, 0x80, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x00, 0x31, 0xC0,
  0x07, 0x00, 0x38, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x00, 0x60, 0x07, 0x80,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x07,
  0x0E, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0x70, 0x06,
  0x38, 0x00, 0x38, 0x0E, 0x38, 0x00, 0x38, 0x0E, 0x70, 0x00, 0x1C, 0x0C,
  0x70, 0x00, 0x1C, 0x1C, 0x60, 0x00, 0x0E, 0x1C, 0x60, 0x00, 0x0E, 0x38,
  0xE0, 0x00, 0x07, 0x38, 0xE0, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x03, 0xE0,
  0x60, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x0E, 0x70, 0x3C, 0x00, 0x3C, 0x70,
  0x1F, 0x00, 0xF8, 0x38, 0x0F, 0xFF, 0xE0, 0x1C, 0x03, 0xFF, 0x80, 0x1C,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0xCE, 0x73, 0x9C, 0xC6, 0x73, 0x9C, 0xC6,
  0x73, 0x80, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x70, 0x07,
  0x78, 0x07, 0x03, 0xF7, 0xF0, 0x60, 0xFE, 0x1F, 0xC6, 0x7F, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0x40, 0x7F, 0xFF, 0xFF,
  0xF0, 0x77, 0xBD, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x03,
  0xE0, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x1F, 0xF0, 0xFC, 0xEF,
  0xE1, 0xBE, 0x03, 0x70, 0x06, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x03,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x7F, 0x00, 0x00, 0x63,
  0xFF, 0x80, 0x00, 0xDF, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x1F, 0xC0, 0x06, 0x0F, 0xFE, 0x01, 0xC7,
  0xFF, 0xE0, 0x39, 0xE0, 0x1E, 0x06, 0x70, 0x01, 0xE0, 0xDC, 0x00, 0x1C,
  0x3F, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x07,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x03, 0xCC, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x1E, 0x38, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xF8, 0x70, 0x00, 0x77, 0x0F,
  0x00, 0x1C, 0xC0, 0xF0, 0x0F, 0x38, 0x0F, 0xFF, 0xC7, 0x00, 0xFF, 0xE0,
  0xE0, 0x07, 0xF0, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x3C, 0x0F,
  0x00, 0x70, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x06, 0x38, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xFE, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0x7C, 0xFC, 0x00, 0x70, 0x38, 0x00, 0x38, 0x07, 0x80,
  0x0C, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xC1, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xC7, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x31, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x1C, 0x60, 0x03, 0x80, 0x03, 0x80, 0x07, 0x18, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xCE, 0x00, 0x30, 0x00, 0x30, 0x00, 0x63, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x18, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x06, 0x30, 0x01,
  0x80, 0x01, 0xC0, 0x03, 0x9C, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xE7, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x60,
  0x03, 0x00, 0x03, 0x80, 0x07, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC6,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x61, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x60, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x18, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x06, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0x7C, 0x00,
  0x60, 0x60, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x0D, 0xC0,
  0x1C, 0x06, 0x00, 0x38, 0x06, 0x30, 0x0E, 0x01, 0x80, 0x0E, 0x07, 0x0E,
  0x07, 0x00, 0x60, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x18, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x07, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x07, 0xC0, 0x0C, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x18, 0x00, 0x1F, 0xFF, 0x86,
  0x00, 0x07, 0xFF, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x78, 0x01, 0x80,
  0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x00, 0x0E,
  0x3F, 0x00, 0x00, 0x00, 0x73, 0xBC, 0x00, 0x00, 0x03, 0x38, 0xE0, 0x00,
  0x00, 0x1B, 0x87, 0x80, 0x00, 0x01, 0xF8, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x70, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x36, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x76, 0x01, 0xD8, 0x00, 0x00, 0x00,
  0x6E, 0x01, 0x98, 0x00, 0x00, 0x00, 0xEE, 0x01, 0x9C, 0x00, 0x00, 0x00,
  0xCE, 0x01, 0x9C, 0x00, 0x00, 0x01, 0xCC, 0x03, 0x9C, 0x00, 0x00, 0x01,
  0x8C, 0x03, 0x8C, 0x00, 0x00, 0x03, 0x9C, 0x03, 0x8C, 0x00, 0x00, 0x07,
  0x1C, 0x03, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x03, 0x0E, 0x00, 0x00, 0x0E,
  0x1C, 0x03, 0x0E, 0x00, 0x00, 0x0E, 0x18, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x18, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x07, 0x06, 0x00, 0x00, 0x38,
  0x38, 0x06, 0x07, 0x00, 0x00, 0x38, 0x38, 0x06, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x30, 0x0E, 0x03, 0x00, 0x00, 0xE0,
  0x70, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x0E, 0x03, 0x00, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x0E, 0x00,
  0xE0, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x38, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x38, 0x01,
  0xC0, 0x38, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x01,
  0xC0, 0x30, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0xE0, 0x01,
  0x80, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x61, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0x63, 0x80, 0x03, 0x80, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x80, 0x60, 0x00, 0x77, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x76, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x01,
  0x80, 0x77, 0x00, 0x00, 0x07, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x01, 0xCC,
  0x00, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x00, 0x38, 0x06, 0x38, 0x00, 0x00,
  0x60, 0x1C, 0x30, 0x00, 0x01, 0xC0, 0x38, 0x70, 0x00, 0x03, 0x80, 0x70,
  0x60, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x07, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x07, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x06, 0x01,
  0xC0, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x38, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x30, 0x00, 0x0E, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x38, 0x07, 0x00, 0x00, 0x30, 0x70,
  0x0C, 0x00, 0x00, 0x70, 0xE0, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x70, 0x00,
  0x00, 0xC7, 0x00, 0xE0, 0x00, 0x01, 0xCE, 0x01, 0xC0, 0x00, 0x01, 0x9C,
  0x03, 0x80, 0x00, 0x03, 0xB8, 0x06, 0x00, 0x00, 0x07, 0x70, 0x1C, 0x00,
  0x00, 0x06, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x1F,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00,
  0xF8, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3E, 0x00, 0xC0,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x71, 0x80, 0x00, 0x19, 0x80, 0x00, 0x38, 0x60, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x71, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC1, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x07, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x0C, 0x00,
  0x70, 0x07, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x0E,
  0x00, 0xC0, 0x03, 0x00, 0x70, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x18, 0x00,
  0xE0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x60, 0x30, 0x00, 0x38, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0E,
  0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x06, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x76, 0x00, 0x0C, 0xC0, 0x03,
  0x98, 0x00, 0x63, 0x00, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x18,
  0x18, 0x07, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0xC1, 0xC0,
  0x38, 0x30, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00,
  0x3B, 0x80, 0x07, 0x60, 0x00, 0xFC, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x1C, 0x07, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x1E,
  0x00, 0x01, 0x83, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x1F, 0x06, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x77, 0x07, 0x80, 0x1E, 0x70,
  0x3C, 0x07, 0xC7, 0x01, 0xFF, 0xF0, 0x70, 0x0F, 0xFE, 0x07, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x0F, 0x80, 0x03, 0x87,
  0xFF, 0x00, 0x38, 0xFF, 0xF8, 0x03, 0x3C, 0x03, 0xC0, 0x37, 0x00, 0x1E,
  0x07, 0xE0, 0x00, 0xE0, 0x7C, 0x00, 0x06, 0x07, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0xC0, 0x01, 0xE0, 0xEE, 0x00, 0x3C,
  0x0E, 0x78, 0x07, 0x80, 0xC3, 0xFF, 0xF0, 0x0C, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x3F, 0xF0, 0x30,
  0x01, 0xFF, 0xF8, 0x60, 0x07, 0xC0, 0x79, 0xC0, 0x1E, 0x00, 0x33, 0x80,
  0x78, 0x00, 0x37, 0x00, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0xB8, 0x01,
  0xF0, 0x1E, 0x60, 0x01, 0xFF, 0xF8, 0xC0, 0x01, 0xFF, 0xC3, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x03,
  0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x80, 0xE0,
  0x00, 0x30, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x0C, 0x00,
  0x7F, 0xFE, 0x18, 0x01, 0xF0, 0x1E, 0x70, 0x07, 0x80, 0x0C, 0xE0, 0x1E,
  0x00, 0x0D, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x3F, 0x00, 0x38, 0x00, 0xEE, 0x00, 0x7C,
  0x07, 0x98, 0x00, 0x7F, 0xFE, 0x30, 0x00, 0x7F, 0xF0, 0xE0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x03, 0xE0, 0x03, 0x83, 0xFF, 0x00, 0x71, 0xFF, 0xF0, 0x0C, 0x78,
  0x0F, 0x01, 0x9C, 0x00, 0xE0, 0x77, 0x00, 0x0E, 0x0E, 0xC0, 0x01, 0xC1,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x07, 0x80, 0x00, 0x60, 0xE0, 0x00,
  0x0C, 0x3C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x1C, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x30, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x01,
  0x8F, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x61, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x31, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x39, 0xC0, 0x0E,
  0x1C, 0x00, 0x70, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x38, 0x0F, 0xC0, 0x01,
  0xDC, 0x00, 0x0C, 0x07, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x70,
  0x7F, 0xE0, 0x0E, 0x3F, 0xFE, 0x01, 0x8F, 0x01, 0xE0, 0x33, 0x80, 0x1C,
  0x0E, 0x60, 0x01, 0xC1, 0xD8, 0x00, 0x38, 0x3E, 0x00, 0x07, 0x07, 0xC0,
  0x00, 0x60, 0xF0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x87, 0x80, 0x00, 0x30,
  0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xE1, 0xFF, 0xC0, 0x01,
  0xC7, 0xFF, 0xC0, 0x03, 0x3C, 0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x1F,
  0x80, 0x03, 0x80, 0x3E, 0x00, 0x03, 0x00, 0x78, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0x80, 0x76, 0x00, 0x0F, 0x00, 0xEE, 0x00, 0x3C, 0x01, 0xCF,
  0x00, 0xF0, 0x03, 0x8F, 0xFF, 0xC0, 0x06, 0x07, 0xFE, 0x00, 0x0C, 0x03,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xFF, 0x03, 0x00, 0xFF, 0xFC, 0x30, 0x1F, 0x01, 0xE7, 0x03,
  0xC0, 0x06, 0x70, 0x78, 0x00, 0x37, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3E, 0x03,
  0x80, 0x0E, 0xE0, 0x3C, 0x03, 0xCC, 0x01, 0xFF, 0xF8, 0xC0, 0x0F, 0xFE,
  0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x1C, 0x3F, 0xC0,
  0xE3, 0xFC, 0x06, 0x7C, 0x00, 0x33, 0x80, 0x03, 0xB0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x1E,
  0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x18, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x30, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x1B,
  0x81, 0xC0, 0x07, 0x60, 0x3E, 0x03, 0xCC, 0x03, 0xFF, 0xF3, 0x80, 0x3F,
  0xF8, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x70,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0xE0, 0x00, 0xD8,
  0x00, 0x38, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0xE0, 0x01, 0x9C, 0x00, 0x30,
  0xE0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x03,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x60, 0x06, 0x0C, 0x00,
  0xC0, 0x60, 0x0E, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0xC0, 0x60,
  0x1C, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x0C, 0x03, 0x80, 0x70, 0x38, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x0E, 0x07, 0x00, 0x70, 0x30, 0x0E, 0x06, 0x00,
  0x70, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x0E, 0x0E, 0x00, 0x70, 0xE0,
  0x06, 0x1C, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0x71, 0xC0, 0x06, 0x18,
  0x00, 0x71, 0xC0, 0x06, 0x38, 0x00, 0x71, 0x80, 0x06, 0x38, 0x00, 0x33,
  0x80, 0x06, 0x70, 0x00, 0x33, 0x00, 0x06, 0x70, 0x00, 0x37, 0x00, 0x06,
  0x60, 0x00, 0x36, 0x00, 0x07, 0xE0, 0x00, 0x36, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xC3, 0xFF, 0xC0, 0x00, 0x63, 0xC0,
  0xF0, 0x00, 0x33, 0xC0, 0x38, 0x00, 0x39, 0xC0, 0x0E, 0x00, 0x19, 0xC0,
  0x03, 0x80, 0x1C, 0xE0, 0x01, 0xE0, 0x1C, 0x60, 0x00, 0x78, 0x1E, 0x30,
  0x00, 0x1F, 0xFE, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 52, 14, 2, -51 },
  { 73, 12, 15, 19, 8, -54 },
  { 96, 36, 51, 35, 2, -51 },
  { 326, 29, 67, 34, 3, -59 },
  { 569, 33, 53, 45, 7, -52 },
  { 788, 32, 53, 38, 2, -52 },
  { 1000, 5, 15, 12, 7, -54 },
  { 1010, 19, 73, 20, 4, -57 },
  { 1184, 20, 74, 20, -4, -57 },
  { 1369, 28, 28, 29, 4, -51 },
  { 1467, 29, 37, 35, 3, -43 },
  { 1602, 8, 15, 13, -2, -6 },
  { 1617, 14, 2, 19, 2, -24 },
  { 1621, 5, 5, 16, 2, -4 },
  { 1625, 30, 55, 24, -3, -51 },
  { 1832, 28, 53, 34, 4, -52 },
  { 2018, 15, 51, 34, 10, -51 },
  { 2114, 30, 52, 34, 2, -52 },
  { 2309, 30, 53, 34, 2, -52 },
  { 2508, 29, 51, 34, 2, -51 },
  { 2693, 31, 52, 34, 4, -51 },
  { 2895, 27, 52, 34, 3, -51 },
  { 3071, 29, 51, 34, 6, -51 },
  { 3256, 31, 53, 34, 2, -52 },
  { 3462, 27, 52, 34, 5, -52 },
  { 3638, 11, 38, 13, 1, -37 },
  { 3691, 15, 46, 13, -3, -37 },
  { 3778, 27, 29, 32, 3, -38 },
  { 3876, 27, 17, 34, 4, -32 },
  { 3934, 27, 29, 32, 2, -38 },
  { 4032, 22, 53, 28, 6, -52 },
  { 4178, 50, 66, 56, 2, -50 },
  { 4591, 34, 51, 37, -2, -51 },
  { 4808, 32, 51, 37, 3, -51 },
  { 5012, 34, 53, 40, 4, -52 },
  { 5238, 35, 51, 40, 3, -51 },
  { 5462, 34, 51, 35, 3, -51 },
  { 5679, 34, 51, 35, 3, -51 },
  { 5896, 34, 53, 42, 5, -52 },
  { 6122, 39, 51, 43, 3, -51 },
  { 6371, 12, 51, 17, 3, -51 },
  { 6448, 32, 52, 34, 1, -51 },
  { 6656, 37, 51, 39, 3, -51 },
  { 6892, 24, 51, 32, 3, -51 },
  { 7045, 48, 51, 52, 3, -51 },
  { 7351, 39, 51, 43, 3, -51 },
  { 7600, 35, 53, 41, 4, -52 },
  { 7832, 34, 51, 37, 3, -51 },
  { 8049, 35, 61, 41, 4, -52 },
  { 8316, 35, 51, 39, 2, -51 },
  { 8540, 34, 53, 36, 2, -52 },
  { 8766, 33, 51, 37, 7, -51 },
  { 8977, 36, 52, 40, 4, -51 },
  { 9211, 34, 51, 37, 6, -51 },
  { 9428, 50, 51, 55, 7, -51 },
  { 9747, 40, 51, 37, -1, -51 },
  { 10002, 33, 51, 37, 7, -51 },
  { 10213, 38, 51, 37, 0, -51 },
  { 10456, 19, 70, 15, 1, -59 },
  { 10623, 11, 55, 24, 7, -51 },
  { 10699, 19, 70, 15, -4, -59 },
  { 10866, 19, 26, 26, 4, -51 },
  { 10928, 25, 3, 26, -3, 0 },
  { 10938, 9, 10, 19, 9, -54 },
  { 10950, 28, 40, 33, 1, -39 },
  { 11090, 28, 55, 34, 2, -54 },
  { 11283, 27, 40, 32, 2, -39 },
  { 11418, 31, 55, 34, 3, -54 },
  { 11632, 27, 40, 32, 2, -39 },
  { 11767, 22, 55, 20, 4, -55 },
  { 11919, 31, 54, 34, 0, -39 },
  { 12129, 27, 54, 34, 2, -54 },
  { 12312, 12, 52, 14, 2, -52 },
  { 12390, 23, 67, 14, -9, -52 },
  { 12583, 29, 54, 30, 2, -54 },
  { 12779, 12, 54, 14, 2, -54 },
  { 12860, 49, 39, 54, 1, -39 },
  { 13099, 27, 39, 34, 2, -39 },
  { 13231, 28, 40, 34, 3, -39 },
  { 13371, 31, 54, 34, -1, -39 },
  { 13581, 28, 54, 34, 3, -39 },
  { 13770, 21, 39, 21, 2, -39 },
  { 13873, 27, 40, 31, 1, -39 },
  { 14008, 16, 49, 20, 4, -48 },
  { 14106, 27, 39, 34, 4, -38 },
  { 14238, 27, 38, 30, 4, -38 },
  { 14367, 40, 38, 46, 6, -38 },
  { 14557, 31, 38, 30, -1, -38 },
  { 14705, 34, 53, 29, -3, -38 },
  { 14931, 29, 38, 30, 0, -38 },
  { 15069, 23, 71, 21, 2, -56 },
  { 15274, 12, 61, 15, 1, -51 },
  { 15366, 22, 71, 21, -4, -56 },
  { 15562, 33, 12, 42, 4, -27 },
};

const GFXfont RobotoCondensed_ExtraLightItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC72PT7B_H_
