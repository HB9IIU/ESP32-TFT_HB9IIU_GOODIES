#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC8PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0x00, 0x23, 0x56, 0x70, 0x22, 0x54, 0x29, 0xA4, 0x9E, 0xBE,
  0xC0, 0x25, 0x65, 0xAE, 0x00, 0x0A, 0x49, 0x20, 0x15, 0x58, 0x03, 0x40,
  0x02, 0xF0, 0x80, 0xC0, 0x00, 0x05, 0x28, 0x00, 0x25, 0x99, 0xAE, 0x55,
  0x80, 0x61, 0x12, 0x4C, 0x21, 0x16, 0x9E, 0x02, 0x62, 0x62, 0x74, 0x61,
  0x9E, 0x29, 0xDB, 0xC0, 0xE5, 0x28, 0x00, 0x25, 0x5A, 0x9E, 0xD6, 0xE5,
  0x80, 0x00, 0x10, 0x71, 0x80, 0x68, 0x47, 0x00, 0xD4, 0x00, 0x39, 0x16,
  0x69, 0xD7, 0xE8, 0x18, 0x22, 0x65, 0x91, 0x65, 0x5A, 0x9E, 0x34, 0x88,
  0x9F, 0x65, 0x59, 0x9E, 0x74, 0x48, 0x8C, 0x74, 0x48, 0x88, 0x72, 0x7B,
  0xC0, 0x4A, 0x53, 0x69, 0x48, 0x56, 0xA0, 0x11, 0x12, 0x2E, 0x42, 0x99,
  0x0A, 0x40, 0x49, 0x49, 0x80, 0x45, 0x24, 0xAE, 0xAA, 0xA0, 0x4A, 0x53,
  0x6B, 0x48, 0x35, 0x99, 0x9F, 0x65, 0x56, 0x88, 0x35, 0x99, 0x9F, 0x00,
  0x65, 0x56, 0xA8, 0x24, 0x42, 0x9E, 0xE9, 0x28, 0x00, 0x05, 0x99, 0x9F,
  0x16, 0xED, 0x00, 0x25, 0x7B, 0x69, 0x40, 0x05, 0x24, 0x68, 0x17, 0x48,
  0x00, 0x71, 0x24, 0x4C, 0x56, 0xA8, 0x78, 0x24, 0x94, 0x92, 0x08, 0x00,
  0x00, 0x80, 0x2E, 0xF0, 0x0A, 0xDB, 0xC0, 0xD2, 0x70, 0x17, 0x99, 0xAA,
  0xFE, 0x70, 0x09, 0x28, 0x00, 0xF9, 0xAA, 0x2C, 0x0A, 0xDB, 0x00, 0x42,
  0xA0, 0x20, 0x24, 0x94, 0x0A, 0xAD, 0x40, 0x1A, 0xA0, 0x7E, 0x5A, 0x60,
  0x76, 0xC0, 0xF6, 0xD0, 0x76, 0xF8, 0x00, 0xF6, 0xD2, 0x40, 0x92, 0x40,
  0xC8, 0xF0, 0x1A, 0x00, 0x16, 0xF0, 0x15, 0x20, 0x5A, 0xA2, 0x29, 0x40,
  0x15, 0x25, 0x00, 0x29, 0x60, 0x09, 0x01, 0x22, 0x16, 0xA8, 0x04, 0x90,
  0x90, 0x60,
};

const GFXglyph RobotoCondensed_ExtraLightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 3, 6, 5, 1, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 1, -6 },
  { 17, 3, 8, 2, 0, -6 },
  { 20, 2, 8, 2, 0, -6 },
  { 22, 4, 3, 3, 0, -6 },
  { 24, 4, 4, 4, 0, -5 },
  { 26, 1, 2, 1, 0, -1 },
  { 27, 2, 1, 2, 0, -3 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 6, 3, 0, -6 },
  { 32, 4, 6, 4, 0, -6 },
  { 35, 2, 6, 4, 1, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 3, 6, 4, 0, -6 },
  { 52, 3, 6, 4, 1, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 3, 6, 4, 1, -6 },
  { 61, 1, 4, 1, 0, -4 },
  { 62, 1, 5, 1, 0, -4 },
  { 63, 3, 3, 4, 0, -4 },
  { 65, 3, 2, 4, 0, -4 },
  { 66, 3, 3, 4, 0, -4 },
  { 68, 2, 6, 3, 1, -6 },
  { 70, 6, 8, 6, 0, -6 },
  { 76, 4, 6, 4, 0, -6 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 2, 6, 2, 0, -6 },
  { 103, 4, 6, 4, 0, -6 },
  { 106, 5, 6, 4, 0, -6 },
  { 110, 3, 6, 4, 0, -6 },
  { 113, 6, 6, 6, 0, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 4, 6, 5, 0, -6 },
  { 125, 4, 6, 4, 0, -6 },
  { 128, 4, 7, 5, 0, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 4, 6, 4, 0, -6 },
  { 138, 3, 6, 4, 1, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 3, 6, 4, 1, -6 },
  { 147, 5, 6, 6, 1, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 3, 6, 4, 1, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 2, 8, 2, 0, -7 },
  { 162, 1, 6, 3, 1, -6 },
  { 163, 3, 8, 2, -1, -7 },
  { 166, 3, 3, 3, 0, -6 },
  { 168, 2, 1, 3, 0, 0 },
  { 169, 1, 1, 2, 1, -6 },
  { 170, 3, 4, 4, 0, -4 },
  { 172, 3, 6, 4, 0, -6 },
  { 175, 3, 4, 4, 0, -4 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 3, 4, 4, 0, -4 },
  { 182, 3, 6, 2, 0, -6 },
  { 185, 4, 6, 4, 0, -4 },
  { 188, 3, 6, 4, 0, -6 },
  { 191, 2, 6, 2, 0, -6 },
  { 193, 3, 8, 2, -1, -6 },
  { 196, 3, 6, 3, 0, -6 },
  { 199, 2, 6, 2, 0, -6 },
  { 201, 6, 4, 6, 0, -4 },
  { 204, 3, 4, 4, 0, -4 },
  { 206, 3, 4, 4, 0, -4 },
  { 208, 3, 6, 4, 0, -4 },
  { 211, 3, 6, 4, 0, -4 },
  { 214, 3, 4, 2, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 2, 5, 2, 0, -5 },
  { 220, 3, 4, 4, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 4, 4, 5, 1, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 3, 6, 3, 0, -4 },
  { 231, 3, 4, 3, 0, -4 },
  { 233, 3, 8, 2, 0, -6 },
  { 236, 2, 7, 2, 0, -6 },
  { 238, 3, 8, 2, -1, -6 },
  { 241, 4, 1, 5, 0, -3 },
};

const GFXfont RobotoCondensed_ExtraLightItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC8PT7B_H_
