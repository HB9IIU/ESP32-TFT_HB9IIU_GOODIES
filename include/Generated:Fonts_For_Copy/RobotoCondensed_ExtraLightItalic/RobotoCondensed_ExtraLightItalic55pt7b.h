#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC55PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x80, 0x31, 0x98,
  0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xC6, 0xC3, 0x61, 0xB0, 0xD8, 0x40,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x08, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0x00,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x04, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xE0, 0x38, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x30, 0x00, 0x70,
  0x60, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x1E, 0x00, 0xF9, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x86, 0x01, 0x80, 0x31, 0x80, 0x60, 0x18, 0x40, 0x18,
  0x0C, 0x30, 0x06, 0x06, 0x0C, 0x01, 0x81, 0x83, 0x00, 0x40, 0xC0, 0xC0,
  0x30, 0x60, 0x30, 0x0C, 0x18, 0x04, 0x06, 0x0C, 0x01, 0x83, 0x86, 0x00,
  0x71, 0xC1, 0x80, 0x0F, 0xE0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00,
  0xC1, 0xF8, 0x00, 0x60, 0xE3, 0x00, 0x30, 0x60, 0x60, 0x0C, 0x30, 0x18,
  0x06, 0x0C, 0x02, 0x03, 0x02, 0x00, 0x80, 0xC1, 0x80, 0x30, 0x60, 0x60,
  0x08, 0x30, 0x18, 0x02, 0x0C, 0x06, 0x01, 0x86, 0x01, 0x80, 0x63, 0x00,
  0x60, 0x18, 0x80, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x00,
  0xC0, 0x03, 0x81, 0x80, 0x01, 0x87, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xB0,
  0x00, 0x07, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x1C, 0x03, 0x38, 0x0C,
  0x03, 0x30, 0x0E, 0x02, 0x60, 0x06, 0x06, 0x60, 0x07, 0x06, 0xE0, 0x03,
  0x0E, 0xC0, 0x01, 0x8C, 0xC0, 0x01, 0x8C, 0xC0, 0x00, 0xD8, 0xC0, 0x00,
  0xF8, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x70, 0x01,
  0xB8, 0x38, 0x07, 0x18, 0x1F, 0x3E, 0x0C, 0x0F, 0xF8, 0x0C, 0x00, 0x80,
  0x00, 0x33, 0x33, 0x33, 0x66, 0x66, 0x40, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x04, 0x00, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x08,
  0x06, 0x03, 0xF8, 0x30, 0x79, 0xF1, 0x9F, 0x03, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x0C, 0x00, 0x70, 0x70, 0x07, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x00, 0x30,
  0x10, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x1C, 0x30, 0xE1, 0x82, 0x00, 0xFF,
  0xFF, 0xF8, 0x6F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3C,
  0xF8, 0x03, 0x80, 0xC0, 0x38, 0x03, 0x03, 0x80, 0x18, 0x18, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03,
  0x30, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x18, 0x0E, 0x00, 0xF9, 0xE0, 0x01,
  0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF1, 0xF3, 0x7C,
  0x37, 0x06, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xF7,
  0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x03,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0x9F, 0x00, 0x70, 0x0E, 0x03, 0x80,
  0x18, 0x1C, 0x00, 0x70, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x31, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8E, 0x00, 0x0C, 0x18,
  0x00, 0x70, 0x70, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0xF3, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0xE0, 0x70, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0E, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x1F, 0x80, 0x06, 0xFF, 0xC0, 0x0F, 0x83, 0xC0, 0x3C, 0x01,
  0x80, 0x60, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x20, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0x80,
  0x06, 0x01, 0x80, 0x18, 0x03, 0x80, 0x70, 0x03, 0xE7, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3E, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x7E, 0x03, 0x1F, 0xF8, 0x37, 0x83, 0xC6, 0xE0,
  0x0C, 0x6C, 0x00, 0xE7, 0x80, 0x06, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C,
  0xC0, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x87, 0x00, 0x70, 0x38, 0x0E,
  0x01, 0xF7, 0xC0, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0xF0, 0x1C, 0x00, 0xC0, 0x0E, 0x01,
  0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03,
  0x80, 0x30, 0x01, 0xC0, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0x81, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x38, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x0F, 0x9F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xEF, 0x80, 0x70, 0x1C, 0x0E, 0x00, 0xE1,
  0xC0, 0x06, 0x18, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00,
  0x0E, 0x60, 0x00, 0xE6, 0x00, 0x1E, 0x70, 0x03, 0x63, 0x00, 0x6C, 0x3C,
  0x1C, 0xC1, 0xFF, 0x8C, 0x07, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x07, 0x80, 0x00, 0x06, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0x3C, 0x07,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xBC, 0x1C, 0x0E, 0x38, 0x06, 0x70,
  0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x07, 0xE0, 0x02, 0x06, 0x00, 0x3F, 0xC0,
  0x08, 0x18, 0x03, 0x81, 0x80, 0x30, 0xC0, 0x1C, 0x03, 0x00, 0xC3, 0x00,
  0x60, 0x08, 0x03, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x60, 0x18, 0x01, 0x80,
  0x33, 0x00, 0x60, 0x06, 0x00, 0xCC, 0x03, 0x00, 0x10, 0x03, 0x30, 0x0C,
  0x00, 0xC0, 0x08, 0x80, 0x30, 0x03, 0x00, 0x26, 0x01, 0x80, 0x0C, 0x01,
  0x98, 0x06, 0x00, 0x30, 0x06, 0x60, 0x18, 0x01, 0x80, 0x19, 0x00, 0xC0,
  0x06, 0x00, 0x6C, 0x03, 0x00, 0x18, 0x01, 0x30, 0x0C, 0x00, 0x60, 0x0C,
  0xC0, 0x30, 0x03, 0x00, 0x33, 0x00, 0xC0, 0x0C, 0x00, 0x8C, 0x03, 0x00,
  0x30, 0x06, 0x30, 0x08, 0x01, 0xC0, 0x18, 0xC0, 0x20, 0x07, 0x00, 0xC3,
  0x00, 0xC0, 0x2C, 0x03, 0x0C, 0x03, 0x01, 0xB0, 0x18, 0x30, 0x0C, 0x0C,
  0xC0, 0xC0, 0xC0, 0x1C, 0xE1, 0x8E, 0x03, 0x00, 0x7F, 0x03, 0xF0, 0x04,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x08, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x78, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01,
  0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x0C, 0x00,
  0x1C, 0x0C, 0x00, 0x3C, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0C, 0x00, 0x78, 0x01,
  0x80, 0x03, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0xF0, 0x0C, 0x00, 0x78, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0x80, 0x38, 0x01, 0x80, 0x07,
  0x00, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xF3, 0x00,
  0x1F, 0xFC, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x78, 0x07, 0x00, 0x7C, 0x00,
  0xFD, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x03,
  0x80, 0x70, 0x03, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x01, 0x80,
  0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x30, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x60, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x33, 0xB0, 0x00, 0x01, 0xB9, 0x80, 0x00, 0x0F, 0x86, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x09, 0x80,
  0x00, 0x06, 0xC0, 0xCC, 0x00, 0x00, 0x66, 0x06, 0x60, 0x00, 0x03, 0x30,
  0x33, 0x00, 0x00, 0x33, 0x81, 0x98, 0x00, 0x01, 0x98, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x63, 0x00, 0x00, 0xC6, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x30,
  0xC0, 0x00, 0x61, 0x81, 0x86, 0x00, 0x06, 0x18, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x60, 0x80, 0x03, 0x06, 0x07, 0x06, 0x00, 0x18, 0x30, 0x30, 0x30,
  0x01, 0x81, 0x81, 0x81, 0x80, 0x0C, 0x0C, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x60, 0x60, 0x06, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x38, 0x0C, 0x07,
  0x01, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x80, 0xE0, 0x60,
  0x18, 0x18, 0x06, 0x03, 0x00, 0x41, 0xC0, 0x30, 0x18, 0x03, 0x0C, 0x01,
  0x81, 0x80, 0x18, 0xC0, 0x0C, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x60, 0x06,
  0x60, 0x07, 0x03, 0x00, 0x33, 0x00, 0x30, 0x18, 0x00, 0xB0, 0x01, 0x80,
  0xC0, 0x07, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x60, 0x01, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0x18, 0x0D, 0x80, 0x00, 0x60, 0x36, 0x00, 0x01, 0x81, 0xCC, 0x00,
  0x06, 0x06, 0x30, 0x00, 0x18, 0x18, 0xC0, 0x00, 0x60, 0x61, 0x80, 0x03,
  0x01, 0x86, 0x00, 0x0C, 0x06, 0x18, 0x00, 0x30, 0x38, 0x30, 0x00, 0xC0,
  0xC0, 0xC0, 0x03, 0x03, 0x01, 0x80, 0x1C, 0x0C, 0x06, 0x00, 0x60, 0x30,
  0x18, 0x01, 0x81, 0xC0, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x03,
  0x80, 0x60, 0x60, 0x06, 0x03, 0x81, 0x80, 0x18, 0x0C, 0x06, 0x00, 0x30,
  0x30, 0x38, 0x00, 0xC0, 0xC0, 0xC0, 0x03, 0x03, 0x03, 0x00, 0x06, 0x0C,
  0x0C, 0x00, 0x18, 0x70, 0x30, 0x00, 0x31, 0x80, 0xC0, 0x00, 0xC6, 0x07,
  0x00, 0x03, 0x18, 0x18, 0x00, 0x06, 0x60, 0x60, 0x00, 0x1B, 0x81, 0x80,
  0x00, 0x6C, 0x06, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0x30, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03,
  0x80, 0x06, 0x00, 0x38, 0x03, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x30, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00,
  0x78, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x78,
  0x07, 0x80, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x70,
  0x00, 0x1C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x01, 0xE0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x60, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03,
  0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x03, 0x00, 0x0E,
  0x00, 0x3C, 0x01, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x07,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0D, 0xC0, 0x00, 0x70, 0x00, 0x19, 0x80, 0x01, 0xE0, 0x00,
  0x73, 0x00, 0x03, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x80, 0x01, 0x8C, 0x00,
  0x1B, 0x00, 0x06, 0x18, 0x00, 0x36, 0x00, 0x0C, 0x30, 0x00, 0xCC, 0x00,
  0x18, 0x60, 0x01, 0x98, 0x00, 0x60, 0xC0, 0x03, 0x30, 0x00, 0xC1, 0x80,
  0x0C, 0x20, 0x03, 0x83, 0x00, 0x18, 0x40, 0x06, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x18, 0x01, 0x83, 0x00, 0x60, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x03, 0x00, 0xE0, 0x30, 0x18,
  0x06, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x03,
  0x03, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x01, 0x81, 0xC0, 0x0C, 0x18, 0x01,
  0x03, 0x00, 0x18, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xCE, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0B, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x1C, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x03, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x32, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0C,
  0x30, 0x18, 0x60, 0x60, 0x40, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06,
  0x30, 0x0C, 0xC0, 0x19, 0x80, 0x16, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x60, 0xE0, 0xC1, 0xC1, 0x81, 0x83, 0x00, 0x00, 0x04, 0x00, 0x03,
  0xFE, 0x00, 0x7E, 0xF8, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x07, 0x00, 0x1C,
  0x30, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0x00, 0x60, 0xE0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x01, 0xC6, 0x00, 0x1E, 0x38, 0x01, 0xB0, 0xE0, 0x39, 0x83, 0xFF, 0x8C,
  0x0F, 0xF0, 0x60, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x1F, 0xE0, 0x19, 0xF7, 0xC0, 0x6C, 0x03, 0x81,
  0xE0, 0x06, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1,
  0xE0, 0x07, 0x06, 0xC0, 0x38, 0x11, 0xF7, 0xC0, 0xC3, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xE7, 0xC0, 0x70, 0x0E,
  0x0E, 0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x03, 0x00, 0xE0,
  0x3F, 0x7C, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0x0C, 0x03,
  0xE7, 0x8C, 0x07, 0x00, 0xCC, 0x0E, 0x00, 0x78, 0x0C, 0x00, 0x38, 0x18,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x70,
  0x03, 0xC0, 0x30, 0x0F, 0x80, 0x3F, 0x79, 0x80, 0x0F, 0xF1, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xE7, 0xC0, 0x70, 0x0E,
  0x0E, 0x00, 0x60, 0xC0, 0x07, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00,
  0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x01, 0x83, 0x80, 0x70,
  0x1F, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x1E, 0x60, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0xF9, 0xE3, 0x01,
  0xC0, 0x33, 0x03, 0x80, 0x1E, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x0C,
  0x03, 0xE0, 0x0F, 0xBF, 0x60, 0x03, 0xFC, 0x60, 0x00, 0x40, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x40,
  0x01, 0x80, 0x40, 0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x61, 0xFE, 0x03, 0x1E, 0xF8, 0x19, 0x80, 0xC0, 0xD8, 0x03, 0x07,
  0x80, 0x18, 0x78, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0xC0, 0xC0,
  0x07, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x18, 0x07,
  0x00, 0x30, 0x1C, 0x00, 0x60, 0x70, 0x00, 0xC1, 0xC0, 0x01, 0x87, 0x00,
  0x03, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x19, 0xC0, 0x00, 0x37, 0x80, 0x00,
  0x7D, 0x80, 0x00, 0xE3, 0x00, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x01, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x30,
  0xFF, 0x01, 0xFE, 0x01, 0x9E, 0x7C, 0x1E, 0x78, 0x0D, 0xC0, 0x61, 0x80,
  0x60, 0xF8, 0x01, 0x98, 0x03, 0x86, 0x80, 0x0D, 0x80, 0x0C, 0x3C, 0x00,
  0x68, 0x00, 0x61, 0xC0, 0x03, 0xC0, 0x03, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x60, 0x00, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x00, 0x06, 0x30, 0x00, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xE0, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x06, 0x30, 0x00, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x00,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60,
  0x00, 0x63, 0x00, 0x03, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x30, 0xC0,
  0x01, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0xFF, 0x01, 0x8F, 0x7C, 0x0C, 0xC0, 0x60,
  0x6C, 0x01, 0x83, 0xC0, 0x0C, 0x3C, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x7C, 0xF8, 0x0F, 0x01, 0xC0, 0x60, 0x07, 0x06, 0x00, 0x18,
  0x70, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x60,
  0x00, 0xC3, 0x00, 0x0C, 0x1C, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xF3, 0xE0,
  0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0xF8,
  0x01, 0x9F, 0x7C, 0x01, 0xB0, 0x0E, 0x01, 0xE0, 0x06, 0x03, 0xC0, 0x07,
  0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x70, 0x1B, 0x00, 0xE0, 0x39, 0xF7, 0xC0, 0x30, 0xFF, 0x80,
  0x30, 0x08, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x30, 0x3E, 0x78, 0xC1, 0xC0, 0x33, 0x0E, 0x00, 0x78, 0x30,
  0x00, 0xE1, 0x80, 0x03, 0x86, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x3C, 0x0C,
  0x03, 0xE0, 0x3E, 0x7D, 0x80, 0x3F, 0xC6, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x3F, 0x06, 0x7F, 0x06, 0xE0, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xF7, 0xC0, 0x70, 0x0E,
  0x06, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x01, 0xCE, 0x00, 0x18, 0x60, 0x03, 0x87, 0x00, 0x70,
  0x3F, 0x7E, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0xF0, 0x3F, 0x00, 0x80, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x07, 0x87, 0x00,
  0x6C, 0x1C, 0x06, 0xC0, 0xF9, 0xE6, 0x01, 0xFE, 0x30, 0x01, 0x00, 0x00,
  0xE0, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0x60, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x18,
  0x1C, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x86, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00,
  0x0D, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1B, 0x80, 0x0E, 0x00,
  0x33, 0x00, 0x3C, 0x00, 0xE6, 0x00, 0x78, 0x01, 0x8C, 0x01, 0xB0, 0x03,
  0x18, 0x03, 0x60, 0x0C, 0x30, 0x0C, 0xC0, 0x18, 0x60, 0x19, 0x80, 0x70,
  0xC0, 0x33, 0x00, 0xC1, 0x80, 0xC2, 0x01, 0x83, 0x01, 0x86, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x38, 0x18, 0x30, 0x30, 0x60, 0x30,
  0x60, 0x60, 0xC0, 0x60, 0xC0, 0xC3, 0x00, 0xC3, 0x01, 0x86, 0x00, 0xC6,
  0x03, 0x18, 0x01, 0x98, 0x06, 0x30, 0x03, 0x30, 0x04, 0x60, 0x06, 0xC0,
  0x09, 0x80, 0x0D, 0x80, 0x13, 0x00, 0x1A, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x06, 0x03, 0x00, 0x0E,
  0x03, 0x00, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x70,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x63, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x87, 0x00, 0x03, 0x83, 0x00, 0x03, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0xC0,
  0x30, 0x00, 0xE0, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x01, 0x80, 0x70, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x33, 0x87, 0x80, 0x18, 0xC0, 0x60, 0x06,
  0x60, 0x0C, 0x01, 0x98, 0x01, 0x80, 0xC6, 0x00, 0x70, 0x63, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 40, 11, 1, -39 },
  { 46, 9, 12, 14, 6, -41 },
  { 60, 28, 39, 27, 1, -39 },
  { 197, 23, 51, 26, 2, -45 },
  { 344, 26, 41, 34, 5, -40 },
  { 478, 24, 41, 29, 2, -40 },
  { 601, 4, 11, 9, 5, -41 },
  { 607, 15, 57, 15, 3, -44 },
  { 714, 15, 57, 15, -3, -44 },
  { 821, 21, 22, 22, 3, -39 },
  { 879, 23, 28, 26, 2, -32 },
  { 960, 7, 12, 10, -2, -5 },
  { 971, 11, 2, 14, 2, -19 },
  { 974, 4, 4, 12, 1, -3 },
  { 976, 23, 42, 19, -2, -39 },
  { 1097, 21, 41, 26, 3, -40 },
  { 1205, 12, 39, 26, 7, -39 },
  { 1264, 23, 40, 26, 1, -40 },
  { 1379, 22, 41, 26, 2, -40 },
  { 1492, 23, 39, 26, 1, -39 },
  { 1605, 23, 40, 26, 3, -39 },
  { 1720, 20, 40, 26, 3, -39 },
  { 1820, 22, 39, 26, 5, -39 },
  { 1928, 24, 41, 26, 1, -40 },
  { 2051, 20, 40, 26, 4, -40 },
  { 2151, 8, 29, 10, 1, -28 },
  { 2180, 11, 35, 10, -2, -28 },
  { 2229, 21, 22, 24, 2, -29 },
  { 2287, 21, 12, 26, 3, -24 },
  { 2319, 21, 22, 24, 1, -29 },
  { 2377, 16, 41, 21, 5, -40 },
  { 2459, 38, 50, 43, 2, -38 },
  { 2697, 27, 39, 29, -2, -39 },
  { 2829, 25, 39, 28, 2, -39 },
  { 2951, 26, 41, 30, 3, -40 },
  { 3085, 27, 39, 31, 2, -39 },
  { 3217, 26, 39, 27, 2, -39 },
  { 3344, 27, 39, 27, 2, -39 },
  { 3476, 26, 41, 32, 4, -40 },
  { 3610, 30, 39, 33, 2, -39 },
  { 3757, 8, 39, 13, 3, -39 },
  { 3796, 24, 40, 26, 1, -39 },
  { 3916, 29, 39, 30, 2, -39 },
  { 4058, 18, 39, 25, 2, -39 },
  { 4146, 37, 39, 40, 2, -39 },
  { 4327, 30, 39, 33, 2, -39 },
  { 4474, 27, 41, 31, 3, -40 },
  { 4613, 26, 39, 28, 2, -39 },
  { 4740, 27, 47, 31, 3, -40 },
  { 4899, 26, 39, 30, 2, -39 },
  { 5026, 27, 41, 28, 1, -40 },
  { 5165, 25, 39, 28, 5, -39 },
  { 5287, 28, 40, 31, 3, -39 },
  { 5427, 26, 39, 28, 5, -39 },
  { 5554, 39, 39, 42, 5, -39 },
  { 5745, 31, 39, 28, -1, -39 },
  { 5897, 26, 39, 28, 5, -39 },
  { 6024, 29, 39, 28, 0, -39 },
  { 6166, 16, 53, 11, 0, -45 },
  { 6272, 8, 42, 18, 6, -39 },
  { 6314, 15, 53, 11, -3, -45 },
  { 6414, 15, 20, 20, 3, -39 },
  { 6452, 20, 2, 20, -3, 0 },
  { 6457, 7, 7, 15, 7, -41 },
  { 6464, 21, 31, 25, 1, -30 },
  { 6546, 22, 42, 26, 1, -41 },
  { 6662, 20, 31, 24, 2, -30 },
  { 6740, 24, 42, 26, 2, -41 },
  { 6866, 20, 31, 24, 2, -30 },
  { 6944, 17, 42, 16, 3, -42 },
  { 7034, 24, 41, 26, 0, -30 },
  { 7157, 21, 41, 26, 1, -41 },
  { 7265, 9, 40, 11, 2, -40 },
  { 7310, 18, 51, 11, -7, -40 },
  { 7425, 23, 41, 23, 1, -41 },
  { 7543, 9, 41, 11, 2, -41 },
  { 7590, 37, 30, 41, 1, -30 },
  { 7729, 21, 30, 26, 1, -30 },
  { 7808, 21, 31, 26, 2, -30 },
  { 7890, 24, 41, 26, -1, -30 },
  { 8013, 22, 41, 26, 2, -30 },
  { 8126, 16, 30, 16, 1, -30 },
  { 8186, 20, 31, 24, 1, -30 },
  { 8264, 12, 38, 15, 3, -37 },
  { 8321, 21, 30, 26, 3, -29 },
  { 8400, 20, 29, 23, 3, -29 },
  { 8473, 31, 29, 35, 4, -29 },
  { 8586, 24, 29, 23, -1, -29 },
  { 8673, 26, 40, 22, -2, -29 },
  { 8803, 22, 29, 23, 0, -29 },
  { 8883, 17, 54, 16, 2, -43 },
  { 8998, 9, 46, 11, 1, -39 },
  { 9050, 17, 55, 16, -3, -43 },
  { 9167, 26, 9, 32, 3, -21 },
};

const GFXfont RobotoCondensed_ExtraLightItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC55PT7B_H_
