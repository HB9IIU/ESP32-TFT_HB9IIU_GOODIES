#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC71PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0x00,
  0x38, 0x73, 0x07, 0x30, 0x73, 0x06, 0x70, 0x67, 0x06, 0x70, 0xE6, 0x0E,
  0x60, 0xE6, 0x0C, 0xE0, 0xCE, 0x0C, 0xC1, 0xCC, 0x1C, 0xC1, 0x80, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x3E,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x20, 0xE0, 0x06, 0x00, 0x18, 0x60, 0x03, 0x00, 0x1C, 0x70,
  0x01, 0x80, 0x1C, 0x38, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x60, 0x0C, 0x0C,
  0x00, 0x30, 0x0E, 0x06, 0x00, 0x38, 0x0E, 0x03, 0x00, 0x1C, 0x06, 0x01,
  0x80, 0x0C, 0x07, 0x00, 0xC0, 0x06, 0x07, 0x00, 0x60, 0x07, 0x03, 0x00,
  0x30, 0x03, 0x03, 0x80, 0x1C, 0x03, 0x83, 0x80, 0x06, 0x03, 0x81, 0x80,
  0x03, 0xC3, 0x81, 0x80, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x3F, 0x80, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x3F, 0x80, 0x00, 0x70,
  0x3F, 0xE0, 0x00, 0x30, 0x38, 0x38, 0x00, 0x38, 0x38, 0x0C, 0x00, 0x38,
  0x38, 0x07, 0x00, 0x18, 0x18, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0x1C,
  0x0E, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x18, 0x0E,
  0x03, 0x80, 0x0C, 0x0E, 0x01, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x03, 0x07,
  0x00, 0x60, 0x01, 0x87, 0x00, 0x30, 0x01, 0xC3, 0x00, 0x18, 0x00, 0xC3,
  0x80, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x00, 0x70, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x30, 0xF0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x1B, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x06, 0x0E, 0x01, 0xC0,
  0x06, 0x0E, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0x70, 0x0E, 0x38, 0x00, 0x70,
  0x0E, 0x38, 0x00, 0x38, 0x0C, 0x70, 0x00, 0x38, 0x1C, 0x70, 0x00, 0x1C,
  0x1C, 0x60, 0x00, 0x1C, 0x38, 0x60, 0x00, 0x0E, 0x38, 0xE0, 0x00, 0x0E,
  0x70, 0xE0, 0x00, 0x07, 0x70, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0xE0, 0x38, 0x00, 0x0E, 0xE0, 0x3C, 0x00, 0x3C, 0x70, 0x1F, 0x00, 0xF0,
  0x38, 0x0F, 0xFF, 0xE0, 0x38, 0x03, 0xFF, 0x80, 0x1C, 0x00, 0x7C, 0x00,
  0x00, 0x19, 0xCE, 0x73, 0x98, 0xCE, 0x73, 0x98, 0xCE, 0x73, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x0D, 0xE0, 0x18, 0x0F,
  0xBF, 0x83, 0x0F, 0xF1, 0xFC, 0xE7, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xCC, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x07,
  0x80, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x08, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38,
  0x70, 0x70, 0xE0, 0x40, 0x7F, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01,
  0xFE, 0x0F, 0xE6, 0x3F, 0x06, 0x7C, 0x0E, 0x60, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0xFE, 0x00,
  0x01, 0x9F, 0xFE, 0x00, 0x06, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x1F, 0xC0, 0x0E, 0x1F, 0xFE, 0x01, 0xC7, 0xFF, 0xE0,
  0x31, 0xC0, 0x1E, 0x06, 0x70, 0x01, 0xC1, 0xD8, 0x00, 0x1C, 0x3E, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x30,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x78,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x60, 0x00,
  0x07, 0x9C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x6C, 0x38,
  0x00, 0x3B, 0x0F, 0x00, 0x1D, 0xC1, 0xE0, 0x1E, 0x70, 0x3F, 0xFF, 0x1C,
  0x07, 0xFF, 0x06, 0x00, 0x7F, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0x70, 0x70, 0x00, 0xC1, 0xC0, 0x03,
  0x8E, 0x00, 0x0E, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x98,
  0x00, 0x06, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xC0, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x60, 0x60, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x70, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x06, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0x00, 0x60,
  0x01, 0x8E, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC6, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x63, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x33, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x39, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0xC0, 0x06, 0x00, 0x07,
  0x00, 0x0C, 0x60, 0x03, 0x00, 0x03, 0x00, 0x06, 0x70, 0x03, 0x80, 0x01,
  0x80, 0x03, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x98, 0x00, 0xC0, 0x00,
  0xE0, 0x01, 0x8C, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x63, 0x00, 0x38, 0x00, 0x38, 0x00, 0x71, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x60, 0x06, 0x00,
  0x0E, 0x00, 0x18, 0x70, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x38, 0x01, 0x80,
  0x07, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0x06, 0xC0, 0x0E, 0x06, 0x00, 0x70,
  0x06, 0x60, 0x06, 0x03, 0x00, 0x38, 0x07, 0x38, 0x07, 0x01, 0x80, 0x0E,
  0x07, 0x0C, 0x0F, 0x00, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x60, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x0F, 0x80, 0x0E, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xF8, 0x60, 0x00, 0xFF, 0xFE,
  0x18, 0x00, 0x3F, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x3F,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x00, 0x03, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x01, 0xC7,
  0xC0, 0x00, 0x00, 0x07, 0x3F, 0x80, 0x00, 0x00, 0x19, 0xEF, 0x00, 0x00,
  0x00, 0x6F, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x38, 0x00, 0x00, 0x0F, 0xC0,
  0xE0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00,
  0x3C, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xD8, 0x01, 0xB8, 0x00, 0x00,
  0x00, 0xEC, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x73, 0x80, 0x00, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x00,
  0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x60, 0x06, 0x18, 0x00, 0x00, 0x1C, 0x70, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x01, 0xC3, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x30, 0x30, 0x00, 0x03, 0x83, 0x80, 0x38, 0x1C,
  0x00, 0x01, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x03, 0x00,
  0xC0, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x06, 0x00, 0x38, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x1C, 0x00,
  0xC0, 0x03, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0x81, 0x80, 0x07, 0x00,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0xC0, 0x01, 0x80,
  0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0xE0, 0x00, 0xE0,
  0x06, 0x00, 0x06, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x78, 0x00, 0x00, 0x06, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0x00, 0xEE, 0x00, 0x00, 0x0C,
  0x00, 0xEE, 0x00, 0x00, 0x1C, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x01, 0xC7,
  0x00, 0x00, 0x1C, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x01, 0xC3, 0x80, 0x00,
  0x18, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x01, 0x81, 0x80, 0x00, 0x38, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x03, 0x80, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x03, 0x80, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x01, 0xC0,
  0x0C, 0x00, 0x03, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x1C, 0x00, 0x01, 0xC1,
  0x80, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x38,
  0x00, 0x00, 0xE3, 0x80, 0x38, 0x00, 0x00, 0x63, 0x80, 0x38, 0x00, 0x00,
  0x73, 0x00, 0x38, 0x00, 0x00, 0x77, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78,
  0x00, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x36, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C,
  0xE0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03,
  0x86, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0x70, 0x00,
  0x60, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x30, 0x00, 0x70, 0x1C, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x0C,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x00,
  0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x30, 0x00, 0x70, 0x30, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x73, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x39, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x6E, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00, 0xE3,
  0x00, 0x18, 0x60, 0x07, 0x0C, 0x00, 0xC1, 0xC0, 0x38, 0x38, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x0C, 0x0E, 0x01, 0x81, 0x80, 0x38, 0x70, 0x07,
  0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x07,
  0xE0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xE0, 0x7C, 0x00, 0x18, 0x1E,
  0x00, 0x03, 0x07, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x1E, 0x0C, 0x00, 0x06, 0xC1, 0xC0, 0x01, 0xD8, 0x3C, 0x00,
  0xF7, 0x03, 0xC0, 0x7C, 0xE0, 0x3F, 0xFE, 0x1C, 0x03, 0xFF, 0x83, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x7F, 0xE0, 0x03,
  0x8F, 0xFF, 0x80, 0x33, 0xC0, 0x3C, 0x03, 0x70, 0x01, 0xC0, 0x7E, 0x00,
  0x0E, 0x07, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xE0, 0xEC, 0x00, 0x1E, 0x0E, 0xE0, 0x03, 0xC0, 0xE7, 0x80,
  0xF8, 0x0C, 0x3F, 0xFF, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x78,
  0x07, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1E, 0x00,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x03, 0xE0,
  0x0C, 0x00, 0x1F, 0xF8, 0x38, 0x00, 0xFF, 0xF8, 0x70, 0x03, 0xC0, 0x38,
  0xE0, 0x0F, 0x00, 0x19, 0xC0, 0x3C, 0x00, 0x1B, 0x00, 0x70, 0x00, 0x36,
  0x01, 0xC0, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x70, 0x01, 0xD8, 0x00, 0xF0, 0x0F, 0x70, 0x00, 0xFF, 0xF8, 0xE0,
  0x00, 0xFF, 0xE1, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x1C, 0x00, 0x7F, 0xFC, 0x38, 0x01, 0xE0, 0x1C, 0x70, 0x07, 0x80, 0x1C,
  0xC0, 0x1E, 0x00, 0x1D, 0x80, 0x38, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xEC,
  0x00, 0x78, 0x07, 0xB8, 0x00, 0x7F, 0xFC, 0x70, 0x00, 0x7F, 0xF0, 0xE0,
  0x00, 0x1F, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x1C, 0x1F,
  0xF8, 0x03, 0x8F, 0xFF, 0x80, 0x63, 0xC0, 0x70, 0x0C, 0xE0, 0x07, 0x03,
  0xB8, 0x00, 0xE0, 0x76, 0x00, 0x0E, 0x0F, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x30, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x30, 0x00,
  0x3C, 0x03, 0x00, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x00, 0x60, 0x0F, 0x00, 0x06, 0x01,
  0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x0C, 0x78, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x1D, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x1C, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0x83, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0x87, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0x8E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0x9C, 0x00, 0xE1, 0xC0, 0x0E, 0x03, 0xB0, 0x00, 0xE3, 0x80, 0x06,
  0x03, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x03, 0x60, 0x00, 0x7E, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x70, 0x7F,
  0xC0, 0x0C, 0x3F, 0xFE, 0x01, 0x8F, 0x01, 0xC0, 0x33, 0x80, 0x1C, 0x0E,
  0xE0, 0x03, 0x81, 0xD8, 0x00, 0x38, 0x3E, 0x00, 0x07, 0x07, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x0E, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0E, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xE1, 0xFF, 0x80, 0x01, 0x8F, 0xFF, 0xC0, 0x03, 0x3C, 0x07,
  0xC0, 0x0E, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x03, 0x80, 0x3E, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x03, 0x80, 0x76, 0x00, 0x0E,
  0x00, 0xEE, 0x00, 0x3C, 0x01, 0xCF, 0x01, 0xF0, 0x03, 0x0F, 0xFF, 0xC0,
  0x06, 0x07, 0xFE, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0x07, 0x00, 0xFF, 0xF8, 0x70, 0x1E, 0x01,
  0xC7, 0x03, 0xC0, 0x06, 0x60, 0x78, 0x00, 0x36, 0x07, 0x00, 0x03, 0x60,
  0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x06, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x7C, 0x03, 0x80, 0x0F, 0xC0, 0x3C, 0x03, 0xDC, 0x01, 0xFF, 0xF9, 0xC0,
  0x0F, 0xFE, 0x1C, 0x00, 0x1F, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x38, 0x7F, 0x03, 0x1F,
  0xF0, 0x33, 0xC0, 0x03, 0x70, 0x00, 0x76, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xF8,
  0x07, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1B, 0x01, 0xC0,
  0x0E, 0xE0, 0x3C, 0x03, 0x9C, 0x03, 0xFF, 0xE3, 0x80, 0x3F, 0xF8, 0x70,
  0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07,
  0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x0E, 0x00,
  0x1C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x76, 0x00,
  0x03, 0xC0, 0x00, 0xEC, 0x00, 0x0F, 0x80, 0x01, 0x9C, 0x00, 0x1B, 0x00,
  0x07, 0x38, 0x00, 0x76, 0x00, 0x0E, 0x70, 0x00, 0xCC, 0x00, 0x38, 0xE0,
  0x01, 0x98, 0x00, 0x71, 0xC0, 0x07, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0x60,
  0x03, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0x18, 0x03, 0x87, 0x00, 0x60, 0x30, 0x06, 0x0E,
  0x01, 0xC0, 0x60, 0x1C, 0x1C, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x01,
  0x80, 0xE0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x06, 0x07, 0x00,
  0xC0, 0xE0, 0x0E, 0x0E, 0x01, 0x81, 0xC0, 0x1C, 0x18, 0x03, 0x07, 0x00,
  0x38, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x0E, 0x18, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x01, 0xC6, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x33, 0x80,
  0x07, 0x30, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0xC0,
  0x01, 0xB8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x06, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xC3, 0xFF, 0x80, 0x00, 0xE3, 0x81,
  0xE0, 0x00, 0x63, 0x80, 0x38, 0x00, 0x31, 0xC0, 0x0E, 0x00, 0x39, 0xC0,
  0x07, 0x80, 0x18, 0xE0, 0x01, 0xE0, 0x1C, 0x60, 0x00, 0x78, 0x1C, 0x70,
  0x00, 0x1F, 0xFC, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 51, 14, 2, -50 },
  { 72, 12, 15, 19, 8, -53 },
  { 95, 35, 50, 34, 2, -50 },
  { 314, 29, 65, 33, 3, -58 },
  { 550, 33, 52, 44, 7, -51 },
  { 765, 32, 52, 37, 2, -51 },
  { 973, 5, 15, 12, 7, -53 },
  { 983, 20, 72, 19, 3, -56 },
  { 1163, 20, 72, 20, -4, -56 },
  { 1343, 27, 28, 29, 4, -50 },
  { 1438, 29, 37, 34, 3, -42 },
  { 1573, 8, 15, 13, -2, -6 },
  { 1588, 14, 2, 18, 2, -24 },
  { 1592, 4, 5, 16, 2, -4 },
  { 1595, 29, 54, 24, -3, -50 },
  { 1791, 28, 52, 33, 3, -51 },
  { 1973, 16, 50, 33, 9, -50 },
  { 2073, 29, 51, 33, 2, -51 },
  { 2258, 30, 52, 33, 2, -51 },
  { 2453, 30, 50, 33, 1, -50 },
  { 2641, 30, 51, 33, 4, -50 },
  { 2833, 27, 51, 33, 3, -50 },
  { 3006, 28, 50, 33, 6, -50 },
  { 3181, 30, 52, 33, 2, -51 },
  { 3376, 26, 51, 33, 5, -51 },
  { 3542, 11, 38, 13, 1, -37 },
  { 3595, 13, 46, 13, -2, -37 },
  { 3670, 26, 28, 31, 3, -37 },
  { 3761, 27, 18, 34, 4, -32 },
  { 3822, 27, 28, 31, 2, -37 },
  { 3917, 22, 52, 27, 6, -51 },
  { 4060, 49, 65, 55, 2, -49 },
  { 4459, 34, 50, 37, -2, -50 },
  { 4672, 33, 50, 37, 2, -50 },
  { 4879, 34, 52, 39, 4, -51 },
  { 5100, 35, 50, 39, 2, -50 },
  { 5319, 35, 50, 34, 2, -50 },
  { 5538, 35, 50, 34, 2, -50 },
  { 5757, 34, 52, 41, 5, -51 },
  { 5978, 39, 50, 42, 2, -50 },
  { 6222, 12, 50, 17, 3, -50 },
  { 6297, 32, 51, 33, 1, -50 },
  { 6501, 38, 50, 38, 2, -50 },
  { 6739, 24, 50, 32, 2, -50 },
  { 6889, 49, 50, 51, 2, -50 },
  { 7196, 40, 50, 43, 2, -50 },
  { 7446, 34, 52, 40, 4, -51 },
  { 7667, 35, 50, 37, 2, -50 },
  { 7886, 34, 60, 40, 4, -51 },
  { 8141, 34, 50, 39, 2, -50 },
  { 8354, 34, 52, 36, 2, -51 },
  { 8575, 32, 50, 36, 7, -50 },
  { 8775, 35, 51, 40, 4, -50 },
  { 8999, 34, 50, 37, 6, -50 },
  { 9212, 49, 50, 54, 7, -50 },
  { 9519, 40, 50, 37, -1, -50 },
  { 9769, 33, 50, 36, 7, -50 },
  { 9976, 37, 50, 36, 0, -50 },
  { 10208, 19, 69, 15, 1, -58 },
  { 10372, 11, 54, 24, 7, -50 },
  { 10447, 19, 69, 15, -4, -58 },
  { 10611, 19, 25, 26, 4, -50 },
  { 10671, 25, 3, 26, -3, 0 },
  { 10681, 9, 9, 19, 9, -53 },
  { 10692, 27, 40, 32, 1, -39 },
  { 10827, 28, 54, 33, 2, -53 },
  { 11016, 27, 40, 31, 2, -39 },
  { 11151, 31, 54, 33, 3, -53 },
  { 11361, 27, 40, 31, 2, -39 },
  { 11496, 22, 54, 20, 4, -54 },
  { 11645, 31, 53, 33, 0, -39 },
  { 11851, 27, 53, 33, 2, -53 },
  { 12030, 12, 52, 14, 2, -52 },
  { 12108, 23, 66, 14, -9, -52 },
  { 12298, 28, 53, 29, 2, -53 },
  { 12484, 12, 53, 14, 2, -53 },
  { 12564, 48, 39, 53, 1, -39 },
  { 12798, 27, 39, 33, 2, -39 },
  { 12930, 27, 40, 34, 3, -39 },
  { 13065, 31, 53, 33, -1, -39 },
  { 13271, 28, 53, 33, 3, -39 },
  { 13457, 20, 39, 21, 2, -39 },
  { 13555, 27, 40, 31, 1, -39 },
  { 13690, 15, 48, 20, 4, -47 },
  { 13780, 27, 39, 33, 4, -38 },
  { 13912, 26, 38, 29, 4, -38 },
  { 14036, 39, 38, 45, 6, -38 },
  { 14222, 30, 38, 29, -1, -38 },
  { 14365, 33, 52, 29, -3, -38 },
  { 14580, 29, 38, 29, 0, -38 },
  { 14718, 23, 70, 20, 2, -55 },
  { 14920, 12, 59, 14, 1, -50 },
  { 15009, 22, 70, 20, -4, -55 },
  { 15202, 33, 12, 41, 4, -27 },
};

const GFXfont RobotoCondensed_ExtraLightItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC71PT7B_H_
