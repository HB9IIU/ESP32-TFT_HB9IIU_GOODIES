#ifndef _NOTOSANS_CONDENSED_EXTRABOLD22PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x60, 0x6F, 0xFF, 0xF7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC7, 0xFF,
  0x7F, 0xF1, 0xD8, 0x19, 0x8F, 0xFE, 0xFF, 0xEF, 0xFE, 0x3B, 0x83, 0xB8,
  0x33, 0x03, 0x30, 0x08, 0x04, 0x0F, 0xCF, 0xFF, 0xF7, 0x43, 0xA1, 0xF0,
  0x7E, 0x0F, 0x83, 0xE1, 0x78, 0xBF, 0x7F, 0xFC, 0xFC, 0x08, 0x04, 0x00,
  0x78, 0x38, 0x7E, 0x18, 0x3F, 0x1C, 0x19, 0x8E, 0x0C, 0xE6, 0x06, 0x77,
  0x03, 0x33, 0x31, 0xFB, 0xBE, 0xFD, 0xBF, 0x3D, 0xDD, 0xC0, 0xCE, 0xE0,
  0xE7, 0x70, 0x73, 0xB8, 0x31, 0xDC, 0x38, 0x7C, 0x38, 0x3C, 0x1E, 0x01,
  0xF8, 0x1F, 0xE0, 0xE7, 0x07, 0x38, 0x3F, 0xC0, 0xFC, 0x07, 0xCF, 0x7E,
  0x7F, 0xFB, 0xB9, 0xFD, 0xC7, 0xCE, 0x3E, 0x7F, 0xF3, 0xFF, 0xCF, 0xEF,
  0xFE, 0xEE, 0xEE, 0x1C, 0xE3, 0x9C, 0x73, 0xCE, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x87, 0x1C, 0x70, 0xE3, 0xC0, 0xE1, 0xC3, 0x8E, 0x38, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x39, 0xCF, 0x00, 0x0E, 0x03, 0x80,
  0xE1, 0xF7, 0x7F, 0xEF, 0xE1, 0xF0, 0xEE, 0x7B, 0x84, 0x40, 0x1C, 0x0E,
  0x07, 0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x7F,
  0xEE, 0xEC, 0xFF, 0xFE, 0x6F, 0xFF, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC1, 0xC0,
  0x1E, 0x3F, 0x9F, 0xDE, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7F, 0x3B, 0xFD, 0xFC, 0x7C, 0x0F, 0x1F, 0x3F, 0x7F, 0xFF, 0x6F,
  0x4F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x3E, 0x7F,
  0xBF, 0xFC, 0xF4, 0x38, 0x3C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0xBF, 0xE8, 0xF0, 0x38, 0x3C, 0x3C,
  0x7C, 0x3F, 0x07, 0xC0, 0xE0, 0x78, 0x7F, 0xFF, 0xFD, 0xFC, 0x03, 0x80,
  0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x3F, 0x06, 0xE1, 0xDC, 0x73, 0x8E, 0x73,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0, 0x1C, 0x7F, 0x3F, 0x9F, 0xCE,
  0x07, 0x07, 0x83, 0xF9, 0xFE, 0x7F, 0x83, 0xC0, 0xE0, 0x78, 0x7F, 0xFF,
  0xFD, 0xFC, 0x0F, 0x9F, 0xDF, 0xEE, 0x0F, 0x07, 0x03, 0xBD, 0xFF, 0xF7,
  0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0xFD, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xC0,
  0xE0, 0xF0, 0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x3F, 0xBD, 0xFC, 0x7C, 0x7F,
  0x7B, 0xF8, 0xFC, 0x7E, 0x3F, 0xBF, 0xFE, 0x7E, 0x3C, 0x3F, 0xBF, 0xDC,
  0xFE, 0x3F, 0x1F, 0x8F, 0xEF, 0xFF, 0xBF, 0xCC, 0xE0, 0x70, 0x7F, 0xFB,
  0xF9, 0xF8, 0xFF, 0xF6, 0x00, 0x00, 0x6F, 0xFF, 0xFF, 0xF6, 0x00, 0x00,
  0x07, 0xFE, 0xEE, 0xE0, 0x00, 0x83, 0xC7, 0xEF, 0xCF, 0x87, 0x81, 0xF8,
  0x3F, 0x07, 0x80, 0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0xC0, 0x3C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF1, 0xF3, 0xF0, 0xF0,
  0x30, 0x08, 0x00, 0x3E, 0x7F, 0x9F, 0xE8, 0xF0, 0x38, 0x3C, 0x3C, 0x3C,
  0x1C, 0x0C, 0x06, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x78, 0x07, 0xE0, 0x1F,
  0xF8, 0x3C, 0x3C, 0x30, 0x0C, 0x73, 0xEE, 0x67, 0xE6, 0xEE, 0x66, 0xCE,
  0x67, 0xCC, 0x67, 0xCC, 0x66, 0xCC, 0xE6, 0xCE, 0xFE, 0xE7, 0xBC, 0x60,
  0x00, 0x70, 0x00, 0x3C, 0x30, 0x1F, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0xBC, 0x38, 0xE1,
  0xC7, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x38, 0x3B, 0xC1, 0xFE, 0x0F, 0xFE,
  0x1F, 0xF3, 0xFF, 0x78, 0xEF, 0x1D, 0xE3, 0xBD, 0xF7, 0xFC, 0xFF, 0xDE,
  0x7B, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xBF, 0xF7, 0xF8, 0x0F, 0x8F, 0xF3,
  0xFD, 0xE2, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x5F, 0xF3, 0xFC, 0x7F, 0xFE, 0x0F, 0xF8, 0xFF, 0xCF, 0x3E, 0xF1,
  0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x1E, 0xF1,
  0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F, 0xFF,
  0xFF, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C,
  0x38, 0x7F, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x0F, 0xC3, 0xFC,
  0xFF, 0xBC, 0x27, 0x01, 0xE0, 0x3C, 0x07, 0x9F, 0xF3, 0xFE, 0x7F, 0xC3,
  0xF8, 0x77, 0x8E, 0xFF, 0xCF, 0xF8, 0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xDE, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xEF, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xFF, 0xBE, 0xE0, 0xE1, 0xFC, 0x7B,
  0x8E, 0x73, 0xCE, 0xF1, 0xDE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xBC,
  0x73, 0xCE, 0x79, 0xC7, 0xB8, 0xF7, 0x0F, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x8D,
  0xFF, 0x3B, 0xFE, 0x77, 0xEC, 0xEF, 0xDD, 0x9F, 0xBF, 0x3F, 0x7E, 0x7E,
  0x78, 0xFC, 0xF1, 0xF9, 0xE3, 0xF1, 0xC7, 0xF0, 0x7F, 0x07, 0xF8, 0x7F,
  0x87, 0xFC, 0x7F, 0xC7, 0xFE, 0x7E, 0xE7, 0xEF, 0x7E, 0x77, 0xE7, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0x0F, 0x81, 0xFE, 0x1F, 0xF8,
  0xF1, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1D, 0xE1, 0xE7, 0x8F, 0x3F, 0xF0, 0xFF, 0x83, 0xF0, 0xFE, 0x3F, 0xEF,
  0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xFF, 0xBF, 0xCF, 0xC3, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xF1, 0xEF,
  0x0F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1,
  0xE7, 0x8F, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0xFE, 0x0F, 0xF8, 0xFF, 0xCF, 0x3C, 0xF1, 0xCF, 0x1C, 0xF3,
  0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF7, 0x8F, 0x38, 0xF3, 0xCF, 0x1C, 0xF1,
  0xEF, 0x1F, 0x3E, 0x3F, 0xFF, 0xDE, 0x2E, 0x07, 0x83, 0xE0, 0xFC, 0x3F,
  0x0F, 0x81, 0xE0, 0xF8, 0x7F, 0xFB, 0xFD, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0x0E, 0xFF, 0xCF,
  0xF0, 0xFC, 0xF0, 0x7F, 0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0x8E, 0x3C, 0x70,
  0xE3, 0x87, 0x3C, 0x39, 0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0xE0, 0xE1, 0xFE, 0x1C, 0x3B, 0xC7, 0x87, 0x38,
  0xF0, 0xE7, 0x1F, 0x3C, 0xE3, 0xE7, 0x9E, 0xFC, 0xE3, 0xDD, 0x9C, 0x3B,
  0xB3, 0x87, 0x77, 0xF0, 0xEC, 0xFC, 0x1D, 0x9F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0xF0, 0xF7, 0x0E, 0x79, 0xE3, 0x9C,
  0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xFC,
  0x39, 0xC7, 0x9E, 0x70, 0xEF, 0x0F, 0xF0, 0xF7, 0x0E, 0x79, 0xE7, 0x9E,
  0x39, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0xDF, 0xF7, 0xFC, 0x0F, 0x03,
  0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0xFF, 0xF0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0xFF, 0xFF, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xFF,
  0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x81, 0xB8, 0x39, 0xC3, 0x1C,
  0x70, 0xEF, 0x0F, 0xFF, 0xFF, 0xF0, 0xF1, 0xC3, 0x87, 0x7F, 0x3F, 0xD9,
  0xE0, 0x71, 0xFB, 0xFF, 0xEF, 0xC7, 0xE3, 0xFB, 0xFF, 0xEF, 0x30, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xEF, 0xFB, 0xFF, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0xFF, 0xFF, 0xFE, 0xEF, 0x00, 0x3F, 0x7F, 0xFF,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF1, 0xFF, 0x7F, 0x3F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xCF, 0x77, 0xFF, 0xFF, 0xF3, 0xF8, 0xFE, 0x1F, 0x87,
  0xE3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3D, 0xC0, 0x3F, 0x3F, 0xBC, 0xFC, 0x7E,
  0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x7C, 0xDF, 0xE7, 0xF0, 0x0F, 0x3F, 0x3F,
  0x38, 0x38, 0x7E, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x3D, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8, 0x7E, 0x1F, 0x8F,
  0xF3, 0xFF, 0xF7, 0xDC, 0xFF, 0x03, 0xC0, 0xFF, 0xFB, 0xFE, 0x7F, 0x00,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xC0, 0x6F, 0xF6,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xC6, 0x00, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFB, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE3, 0xFC, 0xF7, 0xBC, 0xF7,
  0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF1, 0xEF, 0x3C, 0xF7, 0x8E, 0xF1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xBE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3,
  0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xF3, 0xC7, 0xEF, 0xBF, 0xFF,
  0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0x3F, 0x1F, 0xEF, 0x7B, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF,
  0xE7, 0xF8, 0xFC, 0xEF, 0xBF, 0xEF, 0xBF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFF, 0xFF, 0xFB, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x3D, 0xDF, 0xFF, 0xFF, 0xCF, 0xE3, 0xF8, 0x7E, 0x1F, 0x8F, 0xF3,
  0xFF, 0xF7, 0xDC, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xEF,
  0xDF, 0xFF, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x7E, 0xFE,
  0xE6, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0xFE, 0xFE, 0xFC, 0x18, 0x38,
  0x38, 0x7F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F,
  0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3,
  0xFF, 0xF7, 0xFC, 0xF7, 0xF1, 0xEE, 0x3D, 0xC7, 0x38, 0xE7, 0xBC, 0x77,
  0x0E, 0xE1, 0xDC, 0x1B, 0x03, 0xE0, 0x7C, 0x07, 0x00, 0xF3, 0xC7, 0xB9,
  0xF3, 0x9C, 0xF9, 0xCE, 0x7D, 0xE7, 0x36, 0xE3, 0xFB, 0x70, 0xFD, 0xB8,
  0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF1,
  0xEF, 0x78, 0xEE, 0x1F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3B, 0x8F,
  0x71, 0xCF, 0x78, 0xF0, 0xF1, 0xEE, 0x3D, 0xC7, 0x3C, 0xE3, 0xBC, 0x77,
  0x0E, 0xE0, 0xDC, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x1F,
  0x03, 0xE0, 0x78, 0x00, 0x7F, 0x3F, 0x9F, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0,
  0x70, 0x78, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x7C, 0xF8, 0xF8, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xE3, 0xC3, 0x87,
  0x0E, 0x1C, 0x3C, 0x3C, 0x3C, 0xF9, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xE3,
  0xC4, 0x00, 0x70, 0x7F, 0xBF, 0xFE, 0x3E,
};

const GFXglyph NotoSans_Condensed_ExtraBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 12, 16, 12, 0, -16 },
  { 39, 9, 18, 11, 1, -17 },
  { 60, 17, 16, 18, 1, -16 },
  { 94, 13, 16, 14, 1, -16 },
  { 120, 4, 6, 6, 1, -16 },
  { 123, 6, 19, 7, 1, -16 },
  { 138, 6, 19, 7, 0, -16 },
  { 153, 10, 10, 11, 0, -17 },
  { 166, 9, 11, 11, 1, -13 },
  { 179, 4, 6, 6, 1, -3 },
  { 182, 5, 3, 7, 1, -7 },
  { 184, 4, 4, 6, 1, -4 },
  { 186, 9, 16, 9, 0, -16 },
  { 204, 9, 16, 11, 1, -16 },
  { 222, 8, 16, 11, 1, -16 },
  { 238, 9, 16, 11, 1, -16 },
  { 256, 9, 16, 11, 1, -16 },
  { 274, 11, 16, 11, 0, -16 },
  { 296, 9, 16, 11, 1, -16 },
  { 314, 9, 16, 11, 1, -16 },
  { 332, 9, 16, 11, 1, -16 },
  { 350, 9, 16, 11, 1, -16 },
  { 368, 9, 16, 11, 1, -16 },
  { 386, 4, 12, 6, 1, -12 },
  { 392, 4, 15, 6, 1, -12 },
  { 400, 9, 11, 11, 1, -13 },
  { 413, 9, 7, 11, 1, -11 },
  { 421, 10, 11, 11, 1, -13 },
  { 435, 9, 16, 9, 0, -16 },
  { 453, 16, 18, 17, 1, -16 },
  { 489, 13, 16, 13, 0, -16 },
  { 515, 11, 16, 13, 1, -16 },
  { 537, 10, 16, 12, 1, -16 },
  { 557, 12, 16, 14, 1, -16 },
  { 581, 7, 16, 10, 2, -16 },
  { 595, 7, 16, 10, 2, -16 },
  { 609, 11, 16, 14, 1, -16 },
  { 631, 11, 16, 14, 2, -16 },
  { 653, 6, 16, 8, 1, -16 },
  { 665, 6, 21, 7, -1, -16 },
  { 681, 11, 16, 13, 2, -16 },
  { 703, 9, 16, 10, 1, -16 },
  { 721, 15, 16, 18, 2, -16 },
  { 751, 12, 16, 15, 2, -16 },
  { 775, 13, 16, 15, 1, -16 },
  { 801, 10, 16, 12, 1, -16 },
  { 821, 13, 20, 15, 1, -16 },
  { 854, 12, 16, 13, 1, -16 },
  { 878, 9, 16, 10, 1, -16 },
  { 896, 10, 16, 11, 0, -16 },
  { 916, 11, 16, 14, 1, -16 },
  { 938, 13, 16, 13, 0, -16 },
  { 964, 19, 16, 19, 0, -16 },
  { 1002, 12, 16, 12, 0, -16 },
  { 1026, 12, 16, 12, 0, -16 },
  { 1050, 10, 16, 11, 0, -16 },
  { 1070, 5, 20, 7, 1, -16 },
  { 1083, 9, 16, 9, 0, -16 },
  { 1101, 6, 20, 7, 0, -16 },
  { 1116, 12, 10, 12, 0, -16 },
  { 1131, 10, 2, 10, 0, 2 },
  { 1134, 6, 4, 8, 1, -17 },
  { 1137, 9, 12, 11, 1, -12 },
  { 1151, 10, 17, 12, 1, -17 },
  { 1173, 8, 12, 10, 1, -12 },
  { 1185, 10, 17, 12, 1, -17 },
  { 1207, 9, 12, 11, 1, -12 },
  { 1221, 8, 17, 7, 0, -17 },
  { 1238, 10, 17, 12, 1, -12 },
  { 1260, 10, 17, 12, 1, -17 },
  { 1282, 4, 17, 6, 1, -17 },
  { 1291, 6, 22, 6, -1, -17 },
  { 1308, 11, 17, 12, 1, -17 },
  { 1332, 4, 17, 6, 1, -17 },
  { 1341, 16, 12, 18, 1, -12 },
  { 1365, 10, 12, 12, 1, -12 },
  { 1380, 10, 12, 12, 1, -12 },
  { 1395, 10, 17, 12, 1, -12 },
  { 1417, 10, 17, 12, 1, -12 },
  { 1439, 7, 12, 9, 1, -12 },
  { 1450, 8, 12, 9, 1, -12 },
  { 1462, 8, 15, 8, 0, -15 },
  { 1477, 10, 12, 12, 1, -12 },
  { 1492, 11, 12, 11, 0, -12 },
  { 1509, 17, 12, 17, 0, -12 },
  { 1535, 11, 12, 11, 0, -12 },
  { 1552, 11, 17, 11, 0, -12 },
  { 1576, 9, 12, 9, 0, -12 },
  { 1590, 8, 20, 8, 0, -16 },
  { 1610, 2, 22, 10, 4, -17 },
  { 1616, 7, 20, 8, 1, -16 },
  { 1634, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraBold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD22PT7B_H_
