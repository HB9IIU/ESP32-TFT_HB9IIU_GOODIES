#ifndef _NOTOSANS_CONDENSED_EXTRABOLD14PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xF7, 0xB0, 0x16, 0x36, 0x34, 0x7F, 0x34,
  0x2C, 0xFE, 0x2C, 0x68, 0x68, 0x20, 0xCF, 0xBA, 0xE3, 0xC3, 0x8B, 0xBB,
  0xE2, 0x08, 0x71, 0x8B, 0x23, 0x6C, 0x6D, 0x05, 0xEE, 0xEB, 0xC3, 0x68,
  0x6D, 0x19, 0xE3, 0x1C, 0x3C, 0x3E, 0x1B, 0x0F, 0x83, 0x83, 0xDF, 0xBD,
  0xDE, 0x7F, 0x3F, 0xC0, 0xFF, 0x6B, 0x6D, 0xB6, 0xD9, 0x30, 0xC6, 0x63,
  0x33, 0x33, 0x32, 0x6E, 0x30, 0x47, 0xFF, 0x39, 0xB0, 0x10, 0x23, 0xFF,
  0xF1, 0x02, 0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C, 0x61, 0x84, 0x30, 0xC6,
  0x18, 0x63, 0x00, 0x38, 0xF9, 0xB3, 0x7E, 0xFD, 0xDB, 0xB6, 0x7C, 0x70,
  0x3B, 0xFF, 0xF3, 0x9C, 0xE7, 0x39, 0xC0, 0x79, 0xF9, 0x30, 0x60, 0xC3,
  0x0C, 0x38, 0xFF, 0xFC, 0xFC, 0xF8, 0x30, 0x63, 0x87, 0x83, 0x07, 0xFD,
  0xF0, 0x0C, 0x38, 0xF1, 0x66, 0xC9, 0xBF, 0xFF, 0x0C, 0x18, 0xFB, 0xEC,
  0x30, 0xFA, 0x61, 0xC6, 0xFB, 0xC0, 0x3C, 0xF9, 0x83, 0x45, 0xDD, 0xF9,
  0xB7, 0x7C, 0x78, 0xFF, 0xFC, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xE0,
  0x7C, 0xF9, 0xB3, 0x63, 0x8F, 0x9B, 0xE3, 0x7C, 0xF8, 0x38, 0xFB, 0xB7,
  0x76, 0xEF, 0xC9, 0x06, 0x7C, 0xF0, 0xFC, 0x0F, 0x6D, 0x80, 0x1B, 0x78,
  0x02, 0x0C, 0xF7, 0x8F, 0x07, 0x81, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x81,
  0xC1, 0xE0, 0xF1, 0xEF, 0x38, 0x00, 0xFB, 0xE0, 0xC6, 0x38, 0xC2, 0x00,
  0x71, 0xC0, 0x3E, 0x18, 0xCC, 0xDA, 0x7A, 0xB6, 0xED, 0xAB, 0x6A, 0xFE,
  0xC0, 0x18, 0x83, 0xE0, 0x1C, 0x3C, 0x3C, 0x36, 0x76, 0x66, 0x7E, 0x7F,
  0xE3, 0xE3, 0xF9, 0xFB, 0x36, 0x6F, 0x9F, 0xB3, 0x67, 0xFD, 0xF0, 0x3D,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xFD, 0xF0, 0xF9, 0xFB, 0x3E, 0x3C, 0x78,
  0xF1, 0xE7, 0xFD, 0xF0, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xFF, 0xC0, 0xFF,
  0xF1, 0x8F, 0xFF, 0x18, 0xC6, 0x00, 0x3E, 0xFB, 0x86, 0x0D, 0xFB, 0xF1,
  0xE3, 0xFE, 0xFC, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8C,
  0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x77, 0xC0, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xE0, 0xCF, 0x9B, 0x76, 0xCF, 0x1F, 0x36, 0x66, 0xCD, 0x9C, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xE1, 0xF8, 0xFF, 0x3F, 0xCB, 0xF6,
  0xF5, 0xBD, 0xEF, 0x73, 0xDC, 0xF3, 0x30, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB,
  0xDB, 0xDF, 0xCF, 0xCF, 0xC7, 0x7C, 0xFE, 0xC6, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC6, 0xFE, 0x7C, 0xFB, 0xFC, 0xF3, 0xDF, 0xEF, 0x30, 0xC3, 0x00, 0x7C,
  0xFE, 0xC6, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xFE, 0x7C, 0x0C, 0x0F, 0xF9,
  0xFB, 0x36, 0x6F, 0xDF, 0x36, 0x6E, 0xCD, 0x9C, 0x3D, 0xF6, 0x18, 0x78,
  0xF0, 0xE3, 0xFF, 0xE0, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFE, 0xF8, 0xC3, 0xE7,
  0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x3C, 0x18, 0xC6, 0x3C, 0x67, 0xEE,
  0x66, 0xF6, 0x6F, 0x66, 0xF6, 0x6B, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0xE6,
  0x6E, 0x7C, 0x3C, 0x38, 0x38, 0x3C, 0x7C, 0x66, 0xE7, 0xE7, 0x66, 0x6C,
  0x3C, 0x3C, 0x38, 0x18, 0x18, 0x18, 0x18, 0xFD, 0xF8, 0x30, 0xC1, 0x86,
  0x1C, 0x30, 0xFF, 0xFC, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xC1, 0x86, 0x18,
  0x30, 0xC1, 0x06, 0x18, 0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10,
  0x70, 0xE1, 0x66, 0x58, 0xC0, 0xFC, 0xCC, 0x80, 0x39, 0xF0, 0xCF, 0x7F,
  0xB7, 0xDD, 0xC3, 0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF, 0xFF, 0x80, 0x7F,
  0xF1, 0x8C, 0x63, 0xEF, 0x0C, 0x30, 0xDB, 0xFF, 0x3C, 0xF3, 0xCF, 0xFE,
  0xC0, 0x73, 0xEC, 0xFF, 0xFF, 0x0F, 0x9E, 0x3B, 0xD8, 0xFF, 0xB1, 0x8C,
  0x63, 0x18, 0x6F, 0xFC, 0xF3, 0xCF, 0x3F, 0xFB, 0x0E, 0x7F, 0x80, 0xC3,
  0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0xF3, 0xFF, 0xFC, 0x33,
  0x03, 0x33, 0x33, 0x33, 0x33, 0xFF, 0xC1, 0x83, 0x06, 0x7D, 0xDB, 0x3C,
  0x7C, 0xD9, 0xBB, 0x38, 0xFF, 0xFF, 0xFC, 0xDB, 0xBF, 0xFC, 0xCF, 0x33,
  0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xDB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0x73,
  0xEC, 0xF3, 0xCF, 0x3F, 0xDE, 0xDB, 0xFC, 0xF3, 0xCF, 0x3F, 0xFE, 0xC3,
  0x0C, 0x00, 0x6F, 0xFC, 0xF3, 0xCF, 0x3F, 0xFB, 0x0C, 0x30, 0xC0, 0xDF,
  0xEC, 0xCC, 0xCC, 0x3B, 0xF8, 0xE3, 0x8F, 0xFF, 0x63, 0xFE, 0xC6, 0x31,
  0x8F, 0x38, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xC7, 0xDD, 0xB3, 0x66,
  0xC5, 0x0E, 0x1C, 0xCE, 0xF9, 0xD9, 0xBB, 0x3D, 0x67, 0xAC, 0xF7, 0x0E,
  0xE1, 0x9C, 0xEE, 0xD9, 0xF1, 0xC3, 0x8F, 0x9B, 0x77, 0xC7, 0xCD, 0xB3,
  0x66, 0xC7, 0x0E, 0x1C, 0x39, 0x61, 0xC0, 0xFB, 0xE1, 0x8C, 0x31, 0x8F,
  0xFF, 0x39, 0xCC, 0x63, 0x73, 0x86, 0x31, 0x8C, 0x70, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE7, 0x08, 0x43, 0x1C, 0xE6, 0x21, 0x19, 0xC0, 0xF3, 0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 7, 1, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 6, 12, 7, 1, -11 },
  { 26, 11, 10, 12, 0, -10 },
  { 40, 9, 10, 9, 0, -10 },
  { 52, 2, 4, 4, 1, -10 },
  { 53, 3, 12, 5, 1, -10 },
  { 58, 4, 12, 5, 0, -10 },
  { 64, 6, 6, 7, 0, -11 },
  { 69, 7, 6, 7, 0, -8 },
  { 75, 3, 4, 4, 0, -2 },
  { 77, 4, 2, 4, 0, -5 },
  { 78, 2, 2, 4, 1, -2 },
  { 79, 6, 10, 6, 0, -10 },
  { 87, 7, 10, 7, 0, -10 },
  { 96, 5, 10, 7, 1, -10 },
  { 103, 7, 10, 7, 0, -10 },
  { 112, 7, 10, 7, 0, -10 },
  { 121, 7, 10, 7, 0, -10 },
  { 130, 6, 10, 7, 1, -10 },
  { 138, 7, 10, 7, 0, -10 },
  { 147, 7, 10, 7, 0, -10 },
  { 156, 7, 10, 7, 0, -10 },
  { 165, 7, 10, 7, 0, -10 },
  { 174, 2, 8, 4, 1, -8 },
  { 176, 3, 10, 4, 0, -8 },
  { 180, 7, 7, 7, 0, -9 },
  { 187, 7, 4, 7, 0, -7 },
  { 191, 7, 7, 7, 0, -9 },
  { 198, 6, 10, 6, 0, -10 },
  { 206, 10, 11, 11, 1, -10 },
  { 220, 8, 10, 8, 0, -10 },
  { 230, 7, 10, 8, 1, -10 },
  { 239, 6, 10, 8, 1, -10 },
  { 247, 7, 10, 9, 1, -10 },
  { 256, 5, 10, 7, 1, -10 },
  { 263, 5, 10, 7, 1, -10 },
  { 270, 7, 10, 9, 1, -10 },
  { 279, 7, 10, 9, 1, -10 },
  { 288, 5, 10, 5, 0, -10 },
  { 295, 4, 13, 4, -1, -10 },
  { 302, 7, 10, 8, 1, -10 },
  { 311, 5, 10, 6, 1, -10 },
  { 318, 10, 10, 12, 1, -10 },
  { 331, 8, 10, 10, 1, -10 },
  { 341, 8, 10, 9, 1, -10 },
  { 351, 6, 10, 8, 1, -10 },
  { 359, 8, 12, 9, 1, -10 },
  { 371, 7, 10, 8, 1, -10 },
  { 380, 6, 10, 7, 0, -10 },
  { 388, 7, 10, 7, 0, -10 },
  { 397, 7, 10, 9, 1, -10 },
  { 406, 8, 10, 8, 0, -10 },
  { 416, 12, 10, 12, 0, -10 },
  { 431, 8, 10, 8, 0, -10 },
  { 441, 8, 10, 8, 0, -10 },
  { 451, 7, 10, 7, 0, -10 },
  { 460, 3, 12, 4, 1, -10 },
  { 465, 6, 10, 6, 0, -10 },
  { 473, 4, 12, 4, 0, -10 },
  { 479, 7, 6, 8, 0, -10 },
  { 485, 6, 1, 6, 0, 1 },
  { 486, 3, 3, 5, 1, -11 },
  { 488, 6, 8, 7, 0, -8 },
  { 494, 6, 11, 8, 1, -11 },
  { 503, 5, 8, 6, 1, -8 },
  { 508, 6, 11, 8, 1, -11 },
  { 517, 6, 8, 7, 1, -8 },
  { 523, 5, 11, 5, 0, -11 },
  { 530, 6, 11, 8, 1, -8 },
  { 539, 6, 11, 8, 1, -11 },
  { 548, 2, 11, 4, 1, -11 },
  { 551, 4, 14, 4, -1, -11 },
  { 558, 7, 11, 8, 1, -11 },
  { 568, 2, 11, 4, 1, -11 },
  { 571, 10, 8, 12, 1, -8 },
  { 581, 6, 8, 8, 1, -8 },
  { 587, 6, 8, 8, 1, -8 },
  { 593, 6, 11, 8, 1, -8 },
  { 602, 6, 11, 8, 1, -8 },
  { 611, 4, 8, 5, 1, -8 },
  { 615, 5, 8, 6, 0, -8 },
  { 620, 5, 9, 5, 0, -9 },
  { 626, 6, 8, 8, 1, -8 },
  { 632, 7, 8, 7, 0, -8 },
  { 639, 11, 8, 11, 0, -8 },
  { 650, 7, 8, 7, 0, -8 },
  { 657, 7, 11, 7, 0, -8 },
  { 667, 6, 8, 6, 0, -8 },
  { 673, 5, 12, 5, 0, -10 },
  { 681, 2, 14, 6, 2, -11 },
  { 685, 5, 12, 5, 0, -10 },
  { 693, 7, 2, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_ExtraBold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD14PT7B_H_
