#ifndef _NOTOSANS_CONDENSED_EXTRABOLD47PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF,
  0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xF7, 0x7C, 0xFE, 0x70, 0xCF, 0xC7, 0x00, 0xFC,
  0x70, 0x0F, 0xE7, 0x00, 0xFF, 0x70, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0x7F, 0x00, 0x77, 0xF0, 0x07, 0x3F, 0x80, 0x73,
  0xFE, 0x07, 0x7F, 0xFC, 0x7F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xC0, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0x3E, 0x03, 0xF0, 0x01, 0xF1,
  0xF8, 0x1F, 0x00, 0x1F, 0x8F, 0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x0F, 0x80,
  0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0xFC,
  0x7E, 0x00, 0x0F, 0xC7, 0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0x1F, 0x07, 0x01,
  0xF1, 0xF9, 0xF8, 0xFF, 0x0F, 0xCF, 0x8F, 0x8F, 0xFC, 0x7F, 0xFC, 0xFC,
  0xFF, 0xE1, 0xFF, 0xE7, 0xCF, 0xFF, 0x8F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3F,
  0xE3, 0xE3, 0xE3, 0xF0, 0x7C, 0x3F, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF8,
  0x7C, 0x00, 0x0F, 0x8F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x1F, 0x00, 0x07,
  0xC3, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0x7C, 0x7E,
  0x00, 0x3F, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0x1F, 0x1F, 0x80, 0x1F, 0x80,
  0xFD, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x07,
  0xF0, 0x7F, 0xFC, 0x1F, 0xC3, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xE3, 0xF8,
  0x7F, 0xBF, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0xFC, 0x3F,
  0xC3, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0x83, 0xFC, 0x0F, 0xFE, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xCF,
  0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x19, 0xE3, 0xE7, 0xCF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0xC1,
  0xFC, 0x7F, 0x07, 0xC3, 0xE0, 0x0E, 0x0E, 0x00, 0x20, 0x40, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x9F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18,
  0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x9F, 0xE7, 0xF0,
  0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF1, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFC, 0x7F, 0xC7, 0x81, 0xFE, 0x18,
  0x07, 0xF0, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7C,
  0x3F, 0xE3, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3E, 0xFE, 0x00, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x3F, 0x80,
  0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xE0,
  0xFE, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x78, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3C, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xEE, 0x01, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF1, 0xF0, 0x3F, 0x3F, 0xE1, 0xFB, 0xFF, 0x8F,
  0xDF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F,
  0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xE0, 0xFE, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFC, 0xFF, 0x3F, 0xC3, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xF7, 0xF8, 0x7F,
  0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0xDF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xBF, 0x87, 0xF9, 0xFC,
  0x02, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x1F,
  0x0F, 0xE3, 0xF9, 0xFF, 0x7F, 0xCF, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F,
  0x87, 0xE3, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF,
  0xC1, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x87,
  0xF9, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x81, 0xFF,
  0x0F, 0x8F, 0x83, 0xFF, 0xE7, 0xCF, 0xC3, 0xFF, 0xE3, 0xF7, 0xC3, 0xFF,
  0xF0, 0xFB, 0xE1, 0xF8, 0xF8, 0x7F, 0xF1, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8,
  0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x0F, 0xFC, 0x7E, 0x0F, 0x87, 0xFE, 0x3F,
  0x07, 0xC3, 0xFF, 0x1F, 0x83, 0xE1, 0xFF, 0x8F, 0xC1, 0xF0, 0xFF, 0xC7,
  0xE1, 0xF8, 0x7F, 0xE1, 0xF0, 0xFC, 0x7D, 0xF0, 0xF8, 0x7E, 0x3E, 0xF8,
  0x7F, 0xFF, 0xFF, 0x7E, 0x1F, 0xFB, 0xFF, 0x1F, 0x0F, 0xFD, 0xFF, 0x0F,
  0x83, 0xFC, 0x7F, 0x07, 0xE0, 0x30, 0x06, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x80, 0x0F, 0xF0, 0x03, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFC, 0x01, 0xFC, 0x7F,
  0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xF1, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x3F, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3F, 0xCF, 0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0x0F, 0x8F, 0xF8, 0x04, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x8F, 0xFC, 0x0E, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x07,
  0xFC, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFC, 0x7E, 0x3F, 0xF0, 0x04,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0xE0, 0x7F,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFF, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xFA, 0x1F, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xBF, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xEF, 0xC0,
  0xFB, 0xFF, 0xF7, 0xE0, 0xFD, 0xFF, 0xFB, 0xF0, 0x7E, 0xFF, 0xFD, 0xF8,
  0x3F, 0x7F, 0xFE, 0x7E, 0x1F, 0x3F, 0xFF, 0x3F, 0x1F, 0x9F, 0xFF, 0x9F,
  0x8F, 0xCF, 0xFF, 0xC7, 0xE7, 0xC7, 0xFF, 0xE3, 0xF7, 0xE3, 0xFF, 0xF1,
  0xFB, 0xF1, 0xFF, 0xF8, 0xFD, 0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0xF8, 0x3F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFE, 0x0F, 0xFF,
  0xBF, 0x83, 0xFF, 0xEF, 0xF0, 0xFF, 0xF9, 0xFC, 0x3F, 0xFE, 0x7F, 0x8F,
  0xFF, 0x8F, 0xE3, 0xFF, 0xE3, 0xFC, 0xFF, 0xF8, 0x7F, 0x3F, 0xFE, 0x1F,
  0xEF, 0xFF, 0x83, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0,
  0x07, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF8,
  0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xE1, 0xFE, 0x03, 0xFC,
  0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xDF,
  0xC0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07,
  0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F,
  0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xF8, 0x0C, 0xFE, 0x00, 0x9F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x01,
  0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF7, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x7F,
  0x01, 0xFF, 0x01, 0xFC, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFF,
  0x81, 0xFC, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFF, 0x83, 0xFC,
  0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x3F, 0x83, 0xFF, 0xC3, 0xF8, 0x1F, 0xC3,
  0xEF, 0xC3, 0xF8, 0x1F, 0xC3, 0xEF, 0xC3, 0xF8, 0x1F, 0xC7, 0xEF, 0xC7,
  0xF8, 0x1F, 0xC7, 0xE7, 0xC7, 0xF0, 0x1F, 0xC7, 0xE7, 0xE7, 0xF0, 0x0F,
  0xE7, 0xE7, 0xE7, 0xF0, 0x0F, 0xE7, 0xC7, 0xE7, 0xF0, 0x0F, 0xEF, 0xC7,
  0xE7, 0xF0, 0x0F, 0xEF, 0xC3, 0xEF, 0xE0, 0x07, 0xEF, 0xC3, 0xEF, 0xE0,
  0x07, 0xEF, 0xC3, 0xEF, 0xE0, 0x07, 0xEF, 0x83, 0xFF, 0xE0, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x9F, 0xE0,
  0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x07,
  0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x07, 0xF3, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE3, 0xF8,
  0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x1F,
  0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xC7, 0xF8, 0x30, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF7, 0xF8, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0x3F, 0x3F, 0xF9, 0xF8, 0x7F, 0x0F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x8F, 0xC1, 0xFD, 0xFF, 0x0F, 0xEF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xBF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFB, 0xFF, 0x7F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE7, 0xEF, 0xFE, 0x3F, 0x3F, 0xF1, 0xF8, 0xFE, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xF8,
  0x13, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x05, 0xFE, 0x06, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xF8,
  0xFE, 0x3F, 0xE7, 0xF3, 0xFF, 0xBF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFD, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xFE, 0x7E, 0x1F, 0xE3, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0x7F, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x02, 0x7F, 0xC1, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x07, 0xE1, 0xF8, 0xFF, 0xCF, 0xCF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0x7F, 0x1F, 0xFB, 0xF8, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xA0, 0x03, 0xFD, 0xC0, 0x3F, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x9F, 0xC1, 0xFD, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0x8F, 0xF7, 0xF8,
  0x3F, 0xBF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x7F,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC1, 0xFE,
  0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF, 0x03,
  0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE,
  0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x83,
  0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xF3, 0xF8, 0x0F,
  0xF7, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7F, 0x83, 0xFC, 0x7E, 0x7F, 0xE3, 0xFF, 0x3F, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x07, 0xF8,
  0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F,
  0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03,
  0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xF8, 0x7F, 0x87, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0x9F, 0xC1, 0xFE, 0x7F, 0xCF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0x07,
  0xE7, 0xFC, 0x3F, 0x3F, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFC, 0x3F, 0xDF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFE, 0xFF, 0xC7, 0xF3, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0xFF, 0xCF, 0xCF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0x7F, 0x1F, 0xFB, 0xF8, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xF8, 0x79, 0xF8, 0x09, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xEC, 0x07, 0xF7, 0xEF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xBF, 0x3F, 0xF1, 0xF1,
  0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x0F,
  0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE7, 0xE0, 0x07,
  0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x0F,
  0xEF, 0xE0, 0x7F, 0x81, 0xFD, 0xFC, 0x1F, 0xF0, 0x3F, 0xBF, 0x83, 0xFE,
  0x07, 0xF7, 0xF0, 0x7F, 0xE1, 0xFC, 0x7F, 0x0F, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFF, 0x87, 0xF1, 0xFC, 0x7D, 0xF0, 0xFE, 0x3F, 0x8F, 0xBE, 0x1F, 0x83,
  0xF1, 0xF7, 0xE7, 0xF0, 0x7F, 0x3E, 0x7C, 0xFE, 0x0F, 0xE7, 0xCF, 0x9F,
  0xC1, 0xFD, 0xF9, 0xF3, 0xF0, 0x3F, 0xBE, 0x3E, 0x7E, 0x03, 0xF7, 0xC7,
  0xDF, 0xC0, 0x7E, 0xF8, 0xFF, 0xF8, 0x0F, 0xDF, 0x0F, 0xFE, 0x01, 0xFB,
  0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xF1, 0xFE,
  0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFD, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07,
  0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x09, 0xFF, 0x00, 0x5F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFE, 0x80, 0x00, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 35, 13, 2, -34 },
  { 36, 18, 13, 22, 2, -34 },
  { 66, 25, 34, 26, 1, -34 },
  { 173, 20, 39, 24, 2, -36 },
  { 271, 37, 34, 39, 1, -34 },
  { 429, 30, 34, 31, 1, -34 },
  { 557, 8, 13, 12, 2, -34 },
  { 570, 13, 41, 15, 2, -34 },
  { 637, 12, 41, 15, 1, -34 },
  { 699, 21, 21, 23, 1, -36 },
  { 755, 20, 23, 24, 2, -28 },
  { 813, 9, 12, 13, 1, -6 },
  { 827, 13, 7, 15, 1, -16 },
  { 839, 8, 9, 13, 2, -8 },
  { 848, 19, 34, 20, 0, -34 },
  { 929, 20, 34, 24, 2, -34 },
  { 1014, 16, 34, 24, 2, -34 },
  { 1082, 21, 34, 24, 1, -34 },
  { 1172, 20, 34, 24, 2, -34 },
  { 1257, 22, 34, 24, 1, -34 },
  { 1351, 20, 34, 24, 2, -34 },
  { 1436, 21, 34, 24, 1, -34 },
  { 1526, 21, 34, 24, 1, -34 },
  { 1616, 21, 34, 24, 1, -34 },
  { 1706, 21, 34, 24, 1, -34 },
  { 1796, 8, 27, 13, 2, -26 },
  { 1823, 10, 32, 13, 1, -26 },
  { 1863, 21, 24, 24, 1, -29 },
  { 1926, 20, 15, 24, 2, -24 },
  { 1964, 20, 24, 24, 2, -29 },
  { 2024, 19, 35, 20, 0, -34 },
  { 2108, 33, 38, 37, 2, -34 },
  { 2265, 28, 34, 28, 0, -34 },
  { 2384, 22, 34, 27, 3, -34 },
  { 2478, 22, 34, 25, 2, -34 },
  { 2572, 24, 34, 29, 3, -34 },
  { 2674, 17, 34, 22, 3, -34 },
  { 2747, 17, 34, 22, 3, -34 },
  { 2820, 24, 34, 29, 2, -34 },
  { 2922, 24, 34, 30, 3, -34 },
  { 3024, 15, 34, 17, 1, -34 },
  { 3088, 14, 44, 14, -3, -34 },
  { 3165, 24, 34, 27, 3, -34 },
  { 3267, 18, 34, 22, 3, -34 },
  { 3344, 33, 34, 39, 3, -34 },
  { 3485, 26, 34, 33, 3, -34 },
  { 3596, 27, 34, 31, 2, -34 },
  { 3711, 21, 34, 25, 3, -34 },
  { 3801, 27, 42, 31, 2, -34 },
  { 3943, 24, 34, 27, 3, -34 },
  { 4045, 19, 34, 22, 2, -34 },
  { 4126, 21, 34, 23, 1, -34 },
  { 4216, 24, 34, 30, 3, -34 },
  { 4318, 27, 34, 27, 0, -34 },
  { 4433, 40, 34, 40, 0, -34 },
  { 4603, 26, 34, 26, 0, -34 },
  { 4714, 25, 34, 25, 0, -34 },
  { 4821, 21, 34, 23, 1, -34 },
  { 4911, 11, 42, 15, 3, -34 },
  { 4969, 19, 34, 20, 0, -34 },
  { 5050, 11, 42, 15, 1, -34 },
  { 5108, 24, 22, 25, 1, -34 },
  { 5174, 21, 4, 21, 0, 4 },
  { 5185, 12, 8, 16, 2, -36 },
  { 5197, 21, 26, 24, 1, -26 },
  { 5266, 21, 36, 26, 3, -36 },
  { 5361, 18, 26, 21, 2, -26 },
  { 5420, 21, 36, 26, 2, -36 },
  { 5515, 20, 26, 24, 2, -26 },
  { 5580, 16, 36, 16, 1, -36 },
  { 5652, 21, 37, 26, 2, -26 },
  { 5750, 21, 36, 26, 3, -36 },
  { 5845, 7, 36, 13, 3, -36 },
  { 5877, 12, 47, 13, -2, -36 },
  { 5948, 23, 36, 25, 3, -36 },
  { 6052, 7, 36, 13, 3, -36 },
  { 6084, 33, 26, 39, 3, -26 },
  { 6192, 21, 26, 26, 3, -26 },
  { 6261, 22, 26, 25, 2, -26 },
  { 6333, 21, 37, 26, 3, -26 },
  { 6431, 21, 37, 26, 2, -26 },
  { 6529, 15, 26, 18, 3, -26 },
  { 6578, 17, 26, 20, 1, -26 },
  { 6634, 15, 31, 17, 1, -31 },
  { 6693, 20, 26, 26, 3, -26 },
  { 6758, 24, 26, 24, 0, -26 },
  { 6836, 35, 26, 36, 0, -26 },
  { 6950, 23, 26, 23, 0, -26 },
  { 7025, 24, 37, 24, 0, -26 },
  { 7136, 17, 26, 19, 1, -26 },
  { 7192, 15, 42, 18, 1, -34 },
  { 7271, 6, 47, 22, 8, -36 },
  { 7307, 16, 42, 18, 1, -34 },
  { 7391, 21, 9, 24, 1, -21 },
};

const GFXfont NotoSans_Condensed_ExtraBold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD47PT7B_H_
