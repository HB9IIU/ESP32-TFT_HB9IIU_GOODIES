#ifndef _NOTOSANS_CONDENSED_EXTRABOLD67PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0xC7,
  0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3,
  0xFC, 0x0F, 0x00, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xFB, 0xFE, 0x0F, 0xFD, 0xFF, 0x07,
  0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0,
  0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF,
  0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0xF1, 0xFC, 0xFF, 0xCF,
  0x01, 0x8F, 0xF8, 0xF0, 0x08, 0xFF, 0x8F, 0x00, 0x0F, 0xF8, 0xF0, 0x00,
  0xFF, 0x8F, 0x00, 0x0F, 0xFC, 0xF0, 0x00, 0xFF, 0xEF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0x7F, 0xF0, 0x00, 0xF3, 0xFF, 0x00, 0x0F, 0x1F, 0xF0,
  0x00, 0xF1, 0xFF, 0x00, 0x0F, 0x1F, 0xFC, 0x00, 0xF1, 0xFF, 0xF0, 0x0F,
  0x1F, 0xFF, 0xC0, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0xF0, 0x7F, 0x8F, 0xF1,
  0xFE, 0x1F, 0xFF, 0x87, 0xFD, 0xFF, 0x1F, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xF8, 0xFF, 0xBF, 0xE1, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x0F, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x00, 0x60, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF7, 0xFF, 0x9F, 0xFC, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF7, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC,
  0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x0C, 0x03, 0xF8, 0x04, 0x3E, 0x0F, 0xE0, 0xF8, 0xFF, 0x3F, 0x9F,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xCF,
  0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x83, 0xFC, 0x7F,
  0xE7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x3F,
  0xC0, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE,
  0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFE,
  0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF8, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1D,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xBF, 0xF3, 0xFF,
  0x3F, 0xC7, 0xFE, 0x3E, 0x0F, 0xFC, 0x38, 0x1F, 0xF8, 0x20, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xFF, 0x8F, 0xF0, 0x3F, 0xFC,
  0x3E, 0x00, 0xFF, 0xE0, 0xE0, 0x03, 0xFF, 0x06, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0x87, 0xC0, 0x1F, 0xFC, 0x18, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0xE0,
  0x00, 0xFF, 0x7F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0,
  0x03, 0xFC, 0x7F, 0xE0, 0x03, 0xFC, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xE0,
  0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x0C, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xEF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x20, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xF8, 0x1F,
  0xF3, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE1,
  0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF,
  0xF8, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0,
  0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07,
  0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF,
  0x9F, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFD, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xC7, 0xFE, 0x03,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F,
  0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xCF, 0xF8, 0x1F, 0xFE, 0x3F,
  0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x08, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xC3, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0xC0, 0xF0, 0x0F, 0xE0, 0xFF,
  0x8F, 0xFC, 0x7F, 0xF3, 0xFF, 0xBF, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF0,
  0xFF, 0x83, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7,
  0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0xF8, 0x78, 0x03, 0xFF,
  0x8C, 0x00, 0x3F, 0xF1, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0x8F, 0xF0,
  0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0xFE, 0x7F, 0x81,
  0xFF, 0xFF, 0xE1, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFD, 0xFC, 0x0F,
  0xF8, 0x7F, 0x83, 0xFB, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x83, 0xFC,
  0x07, 0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFF, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0xF8, 0x3F, 0x80,
  0x7F, 0x03, 0xFF, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x03,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0x83, 0xF8, 0x0F,
  0xF0, 0x7F, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFD, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xF3, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0x3F,
  0xFF, 0x0F, 0xF0, 0x3F, 0xFE, 0x7F, 0xFC, 0x1F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0x80, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xEF, 0xFC,
  0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x01,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x01,
  0xE0, 0xFF, 0xF0, 0x00, 0xC3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0x0F, 0xFF, 0x80, 0x1E, 0x1F, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0,
  0x3F, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE,
  0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF,
  0xF3, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF0, 0x0F,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x3C, 0x0F, 0xFF, 0x80, 0x01, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF,
  0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF,
  0xCF, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x87,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFB,
  0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF,
  0x8F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC, 0x00,
  0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x03, 0xFD,
  0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xF7, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0x9F,
  0xFF, 0xFB, 0xFE, 0x01, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8, 0x07, 0xF9, 0xFF,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF,
  0x8F, 0xF8, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0x87, 0xF8, 0xFF, 0xFF, 0xE1, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0x87,
  0xFC, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xCF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF,
  0xFD, 0xFF, 0xC0, 0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xF0,
  0x3F, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0x1F,
  0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xFF, 0x03,
  0xFF, 0x3F, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF,
  0xFE, 0x03, 0xFF, 0xBF, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFC,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x0F, 0xFF, 0xBF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0x7F, 0xE0, 0x7F, 0xFB, 0xFF, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xBF, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFD,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x03,
  0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xF8, 0x07,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0,
  0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0x87, 0xFF, 0x00, 0x38,
  0x7F, 0xE0, 0x00, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xE0,
  0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xF8, 0x00,
  0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFB, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81,
  0xFE, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFE, 0x7F, 0x83, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x9F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xCF, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x3F,
  0xE3, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFE,
  0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x07, 0xFB, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0x03, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x81, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xBF, 0xC0, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xE0,
  0x3F, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xF7, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x07, 0xF9, 0xFF, 0xF0, 0x3C, 0x03, 0xFF, 0x80, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0x0F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xCF, 0xFF,
  0xFB, 0xFE, 0x3F, 0xFF, 0x8F, 0xF0, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0x03,
  0xFC, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x3F, 0xF1, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x87, 0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFB, 0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0x87, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xEF, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF, 0xC3, 0xFE, 0x3F, 0xFE,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0x83, 0xC3, 0xFF, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0x3F, 0xF8, 0x01, 0xCF, 0xFF, 0x01, 0xF3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x00, 0xFF, 0xC0, 0x3F, 0xC1,
  0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xE7, 0xFE, 0x1F, 0xFF, 0xEF,
  0xFC, 0x3F, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF,
  0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x3F, 0xFB,
  0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xBF, 0xF8,
  0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xE3,
  0xFE, 0x07, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x04, 0x3F, 0xF8,
  0x00, 0x70, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0x08, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0x1F,
  0xF0, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x7F, 0xFC,
  0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF,
  0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x81,
  0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xDF,
  0xF8, 0x3F, 0xFF, 0x3F, 0xF0, 0x3F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x06, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF1, 0x80, 0x00, 0xFF, 0xE3,
  0xC0, 0x03, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF3, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF, 0x8F, 0xFB,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0x9F, 0xFB, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFE, 0x7F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF7,
  0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF,
  0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFD, 0xFF,
  0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xC7,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF1, 0xFF,
  0x80, 0x3F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x04, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x03,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xC7, 0xFF, 0xF0, 0xFF,
  0xBF, 0xFF, 0xE3, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF1, 0xFF, 0xEF, 0xFF, 0x03,
  0xFF, 0xBF, 0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F,
  0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x03, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE3, 0xFF, 0xF0, 0xFF, 0x9F,
  0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0x03, 0xFF,
  0xBF, 0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0xE1, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFE, 0x3F, 0xF3, 0xFF, 0xF0, 0xFF, 0xC7,
  0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0x80, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF,
  0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x7F, 0xFC, 0xFF, 0xE0, 0x7F,
  0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF,
  0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF,
  0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x81, 0xFF, 0xE7, 0xFF,
  0x87, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF,
  0x3F, 0xF0, 0x3F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x06, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x27, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xF1, 0xFC, 0xFF, 0xC0, 0x3C, 0xFF, 0xC0,
  0x08, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xF1, 0xFE,
  0x1F, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0x80, 0x3C, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xEF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFB, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFE, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xBF, 0xC3, 0xFE, 0x03, 0xFE,
  0x1F, 0xCF, 0xF0, 0xFF, 0x80, 0xFF, 0xC7, 0xF3, 0xFC, 0x7F, 0xE0, 0x3F,
  0xF1, 0xFC, 0x7F, 0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0x1F, 0xC7, 0xFC, 0x01,
  0xFF, 0x3F, 0xC7, 0xF1, 0xFF, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF3, 0xF8, 0x7F, 0xBF, 0xF0, 0x07, 0xFC, 0xFE, 0x0F, 0xEF, 0xFC,
  0x01, 0xFF, 0x3F, 0x83, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0xFE, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x3F, 0xBF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xEF,
  0xF8, 0x00, 0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x7F, 0xE0, 0x00, 0x13, 0xFF, 0xF0, 0x00,
  0xDF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xEC, 0x00, 0x1F, 0xFF, 0x20, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBold67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 49, 18, 3, -48 },
  { 75, 25, 17, 32, 3, -48 },
  { 129, 36, 48, 38, 1, -48 },
  { 345, 28, 55, 34, 3, -51 },
  { 538, 52, 50, 56, 2, -49 },
  { 863, 42, 49, 43, 2, -48 },
  { 1121, 11, 17, 17, 3, -48 },
  { 1145, 18, 60, 22, 3, -49 },
  { 1280, 18, 60, 22, 1, -49 },
  { 1415, 30, 29, 32, 1, -51 },
  { 1524, 30, 33, 34, 2, -40 },
  { 1648, 13, 18, 18, 2, -9 },
  { 1678, 17, 10, 21, 2, -23 },
  { 1700, 12, 12, 18, 3, -11 },
  { 1718, 28, 49, 28, 0, -48 },
  { 1890, 30, 50, 34, 2, -49 },
  { 2078, 23, 48, 34, 3, -48 },
  { 2216, 29, 49, 34, 2, -49 },
  { 2394, 29, 50, 34, 2, -49 },
  { 2576, 32, 48, 34, 1, -48 },
  { 2768, 28, 49, 34, 3, -48 },
  { 2940, 30, 49, 34, 2, -48 },
  { 3124, 30, 48, 34, 2, -48 },
  { 3304, 30, 49, 34, 2, -48 },
  { 3488, 30, 49, 34, 2, -48 },
  { 3672, 12, 38, 18, 3, -37 },
  { 3729, 13, 46, 18, 2, -37 },
  { 3804, 30, 34, 34, 2, -41 },
  { 3932, 30, 21, 34, 2, -34 },
  { 4011, 30, 34, 34, 2, -41 },
  { 4139, 27, 50, 28, 0, -49 },
  { 4308, 47, 53, 53, 3, -48 },
  { 4620, 40, 48, 40, 0, -48 },
  { 4860, 31, 48, 39, 5, -48 },
  { 5046, 31, 50, 36, 3, -49 },
  { 5240, 34, 48, 42, 5, -48 },
  { 5444, 24, 48, 32, 5, -48 },
  { 5588, 23, 48, 31, 5, -48 },
  { 5726, 35, 50, 42, 3, -49 },
  { 5945, 34, 48, 43, 5, -48 },
  { 6149, 20, 48, 24, 2, -48 },
  { 6269, 19, 63, 20, -4, -48 },
  { 6419, 34, 48, 39, 5, -48 },
  { 6623, 25, 48, 31, 5, -48 },
  { 6773, 46, 48, 56, 5, -48 },
  { 7049, 37, 48, 47, 5, -48 },
  { 7271, 38, 50, 44, 3, -49 },
  { 7509, 29, 48, 36, 5, -48 },
  { 7683, 38, 60, 44, 3, -49 },
  { 7968, 33, 48, 38, 5, -48 },
  { 8166, 28, 50, 32, 2, -49 },
  { 8341, 30, 48, 33, 1, -48 },
  { 8521, 34, 49, 42, 4, -48 },
  { 8730, 38, 48, 38, 0, -48 },
  { 8958, 57, 48, 56, 0, -48 },
  { 9300, 37, 48, 37, 0, -48 },
  { 9522, 36, 48, 36, 0, -48 },
  { 9738, 30, 48, 33, 1, -48 },
  { 9918, 16, 60, 21, 4, -49 },
  { 10038, 28, 49, 28, 0, -48 },
  { 10210, 16, 60, 21, 1, -49 },
  { 10330, 34, 31, 36, 1, -48 },
  { 10462, 30, 6, 30, 0, 5 },
  { 10485, 17, 10, 23, 3, -51 },
  { 10507, 29, 39, 35, 2, -38 },
  { 10649, 30, 52, 37, 4, -51 },
  { 10844, 26, 39, 30, 2, -38 },
  { 10971, 31, 52, 37, 2, -51 },
  { 11173, 30, 38, 34, 2, -37 },
  { 11316, 24, 51, 23, 1, -51 },
  { 11469, 31, 54, 37, 2, -38 },
  { 11679, 30, 51, 37, 4, -51 },
  { 11871, 11, 51, 18, 4, -51 },
  { 11942, 18, 67, 18, -3, -51 },
  { 12093, 33, 51, 36, 4, -51 },
  { 12304, 10, 51, 18, 4, -51 },
  { 12368, 48, 38, 56, 4, -38 },
  { 12596, 30, 38, 37, 4, -38 },
  { 12739, 32, 39, 36, 2, -38 },
  { 12895, 30, 54, 37, 4, -38 },
  { 13098, 31, 54, 37, 2, -38 },
  { 13308, 21, 38, 26, 4, -38 },
  { 13408, 24, 39, 28, 2, -38 },
  { 13525, 22, 45, 25, 1, -44 },
  { 13649, 29, 38, 37, 4, -37 },
  { 13787, 34, 37, 34, 0, -37 },
  { 13945, 50, 37, 51, 0, -37 },
  { 14177, 33, 37, 33, 0, -37 },
  { 14330, 34, 53, 34, 0, -37 },
  { 14556, 25, 37, 28, 1, -37 },
  { 14672, 22, 59, 25, 1, -48 },
  { 14835, 9, 66, 31, 11, -51 },
  { 14910, 22, 59, 25, 2, -48 },
  { 15073, 30, 12, 34, 2, -30 },
};

const GFXfont NotoSans_Condensed_ExtraBold67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD67PT7B_H_
