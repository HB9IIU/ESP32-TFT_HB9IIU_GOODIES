#ifndef _NOTOSANS_CONDENSED_EXTRABOLD13PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xFE, 0xA4, 0x34, 0x69, 0xFB, 0xF2, 0xDF, 0xDA,
  0x34, 0x78, 0x23, 0xFF, 0x4E, 0x38, 0xF7, 0xF9, 0x08, 0x73, 0x1A, 0x43,
  0x48, 0x6B, 0x47, 0x5C, 0x1A, 0xC2, 0xD8, 0xCA, 0x11, 0xC0, 0x3C, 0x6C,
  0x6C, 0x38, 0x7B, 0xFF, 0xCE, 0x7E, 0x7B, 0xF8, 0x7B, 0x69, 0x26, 0xD9,
  0x80, 0xC6, 0x23, 0x33, 0x32, 0x66, 0xC0, 0x32, 0xDF, 0xCC, 0x7C, 0xA0,
  0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x6D, 0x60, 0xF0, 0xF0, 0x18, 0xC4,
  0x63, 0x31, 0x88, 0xC0, 0x79, 0xB6, 0xF3, 0xCF, 0x36, 0xDF, 0x38, 0x37,
  0xFB, 0x33, 0x33, 0x30, 0xF9, 0x30, 0xC3, 0x18, 0xC6, 0x3F, 0xFC, 0xF9,
  0x30, 0xCE, 0x38, 0x30, 0xFF, 0xF8, 0x18, 0x62, 0x9E, 0x5B, 0x6F, 0xC6,
  0x18, 0xFE, 0x31, 0xEF, 0x8C, 0x7F, 0xF0, 0x3D, 0x86, 0x16, 0xFF, 0x36,
  0xDF, 0x38, 0xFC, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x60, 0x7D, 0xB6, 0xDE,
  0x79, 0xBC, 0xDB, 0x78, 0x79, 0xBC, 0xF3, 0x7D, 0xF0, 0xDE, 0x70, 0xF0,
  0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x04, 0x77, 0x38, 0x38, 0x30, 0x40, 0xFF,
  0xF0, 0x3F, 0xFC, 0x83, 0x83, 0x83, 0x7B, 0x88, 0x00, 0xFC, 0xC6, 0x73,
  0x10, 0x0C, 0x60, 0x1F, 0x08, 0x64, 0xED, 0x6B, 0x52, 0xF4, 0xB5, 0xF9,
  0xA4, 0x31, 0x07, 0xC0, 0x38, 0x3C, 0x3C, 0x6C, 0x66, 0x7E, 0x7E, 0xE6,
  0xC7, 0xFB, 0x7C, 0xFE, 0xFB, 0x3C, 0xFF, 0xF8, 0x7F, 0xAC, 0x30, 0xC3,
  0x0C, 0x3E, 0x78, 0xFB, 0x7C, 0xF3, 0xCF, 0x3C, 0xFF, 0xF0, 0xFE, 0x31,
  0xEF, 0x63, 0x1F, 0xF8, 0xFE, 0x31, 0x8F, 0x63, 0x18, 0xC0, 0x7F, 0x9C,
  0x30, 0xDF, 0x3C, 0xFF, 0x7C, 0xCF, 0x9F, 0x3F, 0xFF, 0xF9, 0xF3, 0xE7,
  0xCE, 0xF6, 0x66, 0x66, 0x67, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE,
  0xCF, 0xB3, 0x67, 0x8F, 0x1B, 0x36, 0x66, 0xCE, 0xC6, 0x31, 0x8C, 0x63,
  0x1F, 0xF8, 0xE3, 0xF1, 0xF9, 0xFE, 0xFF, 0x5E, 0xAF, 0x77, 0xBB, 0xD9,
  0x80, 0xE7, 0xCF, 0xDF, 0xBD, 0xFB, 0xF3, 0xE7, 0xCE, 0x7D, 0xDF, 0x1E,
  0x3C, 0x78, 0xF1, 0xFE, 0x78, 0xFB, 0x6C, 0xF7, 0xFB, 0xCC, 0x30, 0xC0,
  0x7D, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xFE, 0x78, 0x18, 0x38, 0xFB, 0x7C,
  0xF7, 0xFB, 0x6D, 0xB7, 0xCC, 0x7D, 0xA6, 0x1C, 0x38, 0x70, 0xFF, 0xF8,
  0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0x78, 0xC7, 0xCD, 0x9B, 0x66, 0xC5, 0x8F, 0x1C, 0x38, 0xCE, 0x79,
  0xCD, 0x3B, 0x35, 0x66, 0xAC, 0xF7, 0x9E, 0xF1, 0xDC, 0x31, 0x80, 0xEE,
  0xD8, 0xF1, 0xC3, 0x87, 0x1B, 0x36, 0xC6, 0xC6, 0xD9, 0xB1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0xFC, 0x31, 0x86, 0x31, 0xC6, 0x3F, 0xFC, 0xF2, 0x49,
  0x24, 0x93, 0x80, 0xC3, 0x18, 0x43, 0x18, 0x43, 0x18, 0xE4, 0x92, 0x49,
  0x27, 0x80, 0x10, 0x70, 0xA3, 0x64, 0x58, 0xC0, 0xFC, 0xCC, 0x79, 0x30,
  0xDF, 0xCF, 0xF7, 0xC0, 0xC3, 0x0C, 0x3E, 0xDB, 0x3C, 0xF3, 0xFB, 0xE0,
  0x7D, 0xA6, 0x38, 0x61, 0xE3, 0x80, 0x0C, 0x30, 0xDF, 0x6D, 0xBE, 0xDB,
  0x7D, 0xD0, 0x79, 0xB4, 0xFF, 0x41, 0x93, 0xC0, 0x3B, 0x99, 0xE6, 0x31,
  0x8C, 0x63, 0x00, 0x75, 0xB6, 0xFB, 0x6D, 0xF7, 0xC3, 0x7D, 0xE0, 0xC3,
  0x0C, 0x3E, 0xDB, 0x3C, 0xF3, 0xCF, 0x30, 0xF3, 0xFF, 0xF0, 0x33, 0x03,
  0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC3, 0x0C, 0x37, 0xDB, 0xCF, 0x36, 0xDB,
  0x30, 0xFF, 0xFF, 0xF0, 0xBF, 0xEE, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x66,
  0xBB, 0x6C, 0xF3, 0xCF, 0x3C, 0xC0, 0x7C, 0xD9, 0xB7, 0x36, 0xCD, 0x8E,
  0x00, 0xFB, 0x6C, 0xF3, 0xCF, 0xEF, 0xB0, 0xC3, 0x00, 0x75, 0xB6, 0xFB,
  0x6D, 0xF7, 0xC3, 0x0C, 0x30, 0xBF, 0xCC, 0xCC, 0xC0, 0x7E, 0x58, 0xF1,
  0xFF, 0xC0, 0x23, 0x3C, 0xC6, 0x31, 0x8F, 0x78, 0xCE, 0x73, 0x9D, 0xFF,
  0xA0, 0xCE, 0x99, 0xB3, 0x47, 0x87, 0x0C, 0x00, 0xCC, 0xF3, 0x67, 0xF9,
  0xFE, 0x77, 0x9C, 0xC3, 0x30, 0xED, 0xE7, 0x8E, 0x79, 0xBC, 0xC0, 0xCE,
  0xD9, 0xB3, 0x43, 0x87, 0x0C, 0x18, 0x70, 0xC0, 0xF8, 0xCC, 0x66, 0x7F,
  0xE0, 0x32, 0x22, 0x6C, 0x62, 0x23, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3,
  0x18, 0xC3, 0x1D, 0xCC, 0x63, 0x38, 0x67, 0xF8, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 5, 3, 6, 1, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 11, 7, 1, -10 },
  { 21, 11, 9, 11, 0, -9 },
  { 34, 8, 9, 8, 0, -9 },
  { 43, 2, 3, 3, 1, -9 },
  { 44, 3, 11, 4, 1, -9 },
  { 49, 4, 11, 4, 0, -9 },
  { 55, 6, 6, 6, 0, -10 },
  { 60, 6, 7, 7, 0, -8 },
  { 66, 3, 4, 4, 0, -2 },
  { 68, 4, 1, 4, 0, -4 },
  { 69, 2, 2, 4, 1, -2 },
  { 70, 5, 9, 5, 0, -9 },
  { 76, 6, 9, 7, 0, -9 },
  { 83, 4, 9, 7, 1, -9 },
  { 88, 6, 9, 7, 0, -9 },
  { 95, 6, 9, 7, 0, -9 },
  { 102, 6, 9, 7, 0, -9 },
  { 109, 5, 9, 7, 1, -9 },
  { 115, 6, 9, 7, 0, -9 },
  { 122, 6, 9, 7, 0, -9 },
  { 129, 6, 9, 7, 0, -9 },
  { 136, 6, 9, 7, 0, -9 },
  { 143, 2, 7, 4, 1, -7 },
  { 145, 3, 9, 4, 0, -7 },
  { 149, 6, 7, 7, 0, -8 },
  { 155, 6, 5, 7, 0, -7 },
  { 159, 6, 7, 7, 0, -8 },
  { 165, 5, 9, 5, 0, -9 },
  { 171, 10, 10, 10, 0, -9 },
  { 184, 8, 9, 8, 0, -9 },
  { 193, 6, 9, 8, 1, -9 },
  { 200, 6, 9, 7, 1, -9 },
  { 207, 6, 9, 8, 1, -9 },
  { 214, 5, 9, 6, 1, -9 },
  { 220, 5, 9, 6, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 7, 9, 8, 1, -9 },
  { 241, 4, 9, 5, 0, -9 },
  { 246, 4, 12, 4, -1, -9 },
  { 252, 7, 9, 7, 1, -9 },
  { 260, 5, 9, 6, 1, -9 },
  { 266, 9, 9, 11, 1, -9 },
  { 277, 7, 9, 9, 1, -9 },
  { 285, 7, 9, 9, 1, -9 },
  { 293, 6, 9, 7, 1, -9 },
  { 300, 7, 11, 9, 1, -9 },
  { 310, 6, 9, 7, 1, -9 },
  { 317, 6, 9, 6, 0, -9 },
  { 324, 6, 9, 6, 0, -9 },
  { 331, 6, 9, 8, 1, -9 },
  { 338, 7, 9, 7, 0, -9 },
  { 346, 11, 9, 11, 0, -9 },
  { 359, 7, 9, 7, 0, -9 },
  { 367, 7, 9, 7, 0, -9 },
  { 375, 6, 9, 6, 0, -9 },
  { 382, 3, 11, 4, 1, -9 },
  { 387, 5, 9, 5, 0, -9 },
  { 393, 3, 11, 4, 0, -9 },
  { 398, 7, 6, 7, 0, -9 },
  { 404, 6, 1, 6, 0, 1 },
  { 405, 3, 2, 4, 1, -10 },
  { 406, 6, 7, 7, 0, -7 },
  { 412, 6, 10, 7, 1, -10 },
  { 420, 6, 7, 6, 0, -7 },
  { 426, 6, 10, 7, 0, -10 },
  { 434, 6, 7, 7, 0, -7 },
  { 440, 5, 10, 4, 0, -10 },
  { 447, 6, 10, 7, 0, -7 },
  { 455, 6, 10, 7, 1, -10 },
  { 463, 2, 10, 4, 1, -10 },
  { 466, 4, 13, 4, -1, -10 },
  { 473, 6, 10, 7, 1, -10 },
  { 481, 2, 10, 4, 1, -10 },
  { 484, 9, 7, 11, 1, -7 },
  { 492, 6, 7, 7, 1, -7 },
  { 498, 7, 7, 7, 0, -7 },
  { 505, 6, 10, 7, 1, -7 },
  { 513, 6, 10, 7, 0, -7 },
  { 521, 4, 7, 5, 1, -7 },
  { 525, 5, 7, 5, 0, -7 },
  { 530, 5, 9, 5, 0, -9 },
  { 536, 5, 7, 7, 1, -7 },
  { 541, 7, 7, 7, 0, -7 },
  { 548, 10, 7, 10, 0, -7 },
  { 557, 6, 7, 6, 0, -7 },
  { 563, 7, 10, 7, 0, -7 },
  { 572, 5, 7, 5, 0, -7 },
  { 577, 4, 11, 5, 0, -9 },
  { 583, 2, 13, 6, 2, -10 },
  { 587, 5, 11, 5, 0, -9 },
  { 594, 6, 3, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_ExtraBold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD13PT7B_H_
