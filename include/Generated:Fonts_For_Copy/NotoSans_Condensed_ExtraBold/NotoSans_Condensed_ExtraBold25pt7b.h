#ifndef _NOTOSANS_CONDENSED_EXTRABOLD25PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xEF, 0x79, 0xCE, 0x73, 0x9C, 0xE0, 0x01, 0xDE, 0xFB,
  0x80, 0xF3, 0xFC, 0xFF, 0x3B, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x0E, 0xE0,
  0x67, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x19,
  0xC1, 0xCE, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x19, 0xC0, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x98, 0x00, 0x04, 0x00, 0x80, 0xFF, 0x3F, 0xEF, 0xFD, 0xE8,
  0xB9, 0x07, 0xA0, 0x7C, 0x07, 0xE0, 0x7F, 0x03, 0xE0, 0x5E, 0x0B, 0xF1,
  0x7F, 0xFE, 0xFF, 0x8F, 0xE0, 0x10, 0x02, 0x00, 0x3C, 0x0E, 0x0F, 0xC3,
  0x83, 0xF8, 0x70, 0x77, 0x1C, 0x0E, 0x63, 0x81, 0xCE, 0x60, 0x39, 0x9C,
  0x07, 0x73, 0xBC, 0xEE, 0xEF, 0xCF, 0xDD, 0xFC, 0xF7, 0x3B, 0x80, 0xEE,
  0x70, 0x39, 0xCE, 0x07, 0x39, 0xC0, 0xC3, 0xB8, 0x38, 0x77, 0x07, 0x0F,
  0xC1, 0xC0, 0xF8, 0x1F, 0x00, 0x7F, 0x81, 0xFF, 0x03, 0xCE, 0x07, 0x9C,
  0x0F, 0x78, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x1E, 0xFE, 0x7B, 0xFE, 0xF7,
  0xBF, 0xEF, 0x3F, 0x9E, 0x3F, 0x3C, 0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0x7C, 0xFF, 0xFF, 0x77, 0x70, 0x1E, 0x38, 0xE1, 0xC7, 0x8E, 0x1C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xF0, 0xE1, 0xC1, 0xC3,
  0xC0, 0xF0, 0xF0, 0xE1, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x38, 0x70,
  0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xC7, 0x9E, 0x00, 0x0F, 0x00, 0x70,
  0x06, 0x07, 0x6E, 0x7F, 0xEF, 0xFF, 0x0F, 0x01, 0xF8, 0x3D, 0xC7, 0x9E,
  0x08, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7B, 0xBD, 0xEE, 0x70, 0xFF,
  0xFF, 0xC0, 0x77, 0xBE, 0xE0, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x3C, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x3D, 0xEF, 0x1D, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE7, 0x9E,
  0xF3, 0xFE, 0x3F, 0x83, 0xE0, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xBD,
  0x9E, 0x4F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0x3F, 0x0F, 0xF3, 0xFF, 0x7B, 0xE4, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x1F, 0xF3, 0xFF, 0x31, 0xE0, 0x3C, 0x07, 0x80,
  0xF1, 0xFC, 0x3E, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x1E, 0x07, 0xE0, 0xF7,
  0xFE, 0xFF, 0x9F, 0xE0, 0x01, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x1D, 0xE1, 0xDE, 0x39, 0xE3, 0x9E, 0x71, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0x00, 0xE0, 0x1D, 0x03, 0xFC, 0xFF, 0xCF, 0xF8, 0x0F, 0x00, 0xF0,
  0x1E, 0x07, 0xF0, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0xFF,
  0x3E, 0x07, 0x01, 0xE0, 0x3D, 0xC7, 0x7E, 0xFF, 0xDF, 0x7F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFE, 0xFB, 0xFE, 0x3F, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x80, 0x1F, 0x0F,
  0xF1, 0xFF, 0x79, 0xEF, 0x1D, 0xE3, 0x9E, 0xF3, 0xFC, 0x3F, 0x0F, 0xF1,
  0xFF, 0x79, 0xFF, 0x1F, 0xC3, 0xFC, 0x7F, 0xFE, 0x7F, 0xC7, 0xF0, 0x1F,
  0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF,
  0xFD, 0xFF, 0x9E, 0xF0, 0x1C, 0x07, 0x81, 0xF3, 0xFC, 0x7F, 0x0F, 0xC0,
  0x77, 0xBE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x77, 0xBE, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF7, 0x7B, 0xDC, 0xE0, 0x00, 0x60, 0x3C, 0x1F,
  0x8F, 0xE7, 0xE1, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0x80,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xF8, 0xFE, 0x7F,
  0x1F, 0x83, 0xC0, 0x40, 0x00, 0x3F, 0x3F, 0xE7, 0xFD, 0x8F, 0x03, 0xC0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x81, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0xF8, 0x3E, 0x07, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xE1, 0xF0, 0xE0,
  0x1C, 0x70, 0x43, 0x9C, 0xFE, 0xE6, 0x7F, 0x9F, 0x9C, 0xE7, 0xE7, 0x39,
  0xFB, 0x8E, 0x7E, 0xE3, 0x9F, 0x98, 0xE6, 0xE7, 0x7B, 0xB9, 0xFF, 0xE6,
  0x3C, 0xF1, 0xC0, 0x00, 0x38, 0x02, 0x0F, 0xCF, 0x00, 0xFF, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x03, 0xDC,
  0x07, 0xBC, 0x0F, 0x78, 0x1C, 0x70, 0x78, 0xF0, 0xF1, 0xE1, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0x3C, 0xFF,
  0x1F, 0xFB, 0xFF, 0xF9, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xFE, 0xFF, 0x9F,
  0xFB, 0xCF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0,
  0x0F, 0xE1, 0xFF, 0x3F, 0xE7, 0xE6, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x23, 0xFE,
  0x3F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF8, 0xFF, 0xEF, 0xFE, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF7, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xFE, 0xFF, 0x7F, 0xBC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFF, 0x7F, 0xBF, 0xDE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00,
  0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0xFC, 0x67, 0xC0, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0xF7, 0x87, 0xBC, 0x3D, 0xF1,
  0xE7, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFB,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x7F, 0xFF,
  0xFC, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0xFE, 0xFE, 0xFC,
  0xF0, 0xFF, 0x8F, 0xBC, 0x79, 0xE7, 0xCF, 0x3C, 0x7B, 0xC3, 0xFE, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xEF, 0x0F, 0x3C, 0x79, 0xE3, 0xC7,
  0x9E, 0x3C, 0xF1, 0xF7, 0x87, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF1, 0xDF, 0xB8, 0xEF, 0xDC, 0x77, 0xEE, 0x7F, 0xF7, 0xBB,
  0xF9, 0xDD, 0xFC, 0xEE, 0xFE, 0x7E, 0x7F, 0x1F, 0x3F, 0x8F, 0x9F, 0xC7,
  0xCF, 0xE3, 0xC7, 0xF0, 0xE3, 0xC0, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFE, 0x3F, 0xF8, 0xFE, 0xE3, 0xFB, 0xCF, 0xE7, 0x3F, 0x9E, 0xFE,
  0x7B, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x81, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7F, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x3D, 0xE1, 0xF7, 0xCF, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x1F,
  0xF3, 0xFF, 0x7B, 0xEF, 0x3F, 0xE3, 0xFC, 0x7F, 0x9F, 0xF7, 0xDF, 0xFB,
  0xFE, 0x7F, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xE1, 0xF7,
  0xCF, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0xFE, 0x0F, 0xF8, 0xFF, 0xCF, 0x7E, 0xF1, 0xEF, 0x1E, 0xF1,
  0xEF, 0x3C, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0x78, 0xF7, 0x8F, 0x3C, 0xF3,
  0xCF, 0x1E, 0xF1, 0xFF, 0x0F, 0x1F, 0x9F, 0xF7, 0xFF, 0xEE, 0xF0, 0x3C,
  0x0F, 0x81, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFE, 0x7F,
  0xFE, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFE, 0x7F, 0xE3, 0xF8, 0xF0, 0x3F,
  0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE3, 0xC7, 0x8F, 0x1C,
  0x3C, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0xB8, 0x1F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF0, 0x70, 0x7F, 0x83, 0xC3, 0xFC,
  0x3E, 0x1E, 0xE1, 0xF0, 0xE7, 0x8F, 0x8F, 0x3C, 0x7C, 0x79, 0xE7, 0x73,
  0xCF, 0x3B, 0x9E, 0x39, 0xDC, 0xE1, 0xEE, 0xEF, 0x0F, 0x77, 0x78, 0x7F,
  0xBF, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x87, 0xC0, 0x78, 0x3C, 0x00, 0xF8, 0x79, 0xE1, 0xE7, 0x8F, 0x0F,
  0x3C, 0x3D, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xF7, 0xC3, 0xCF, 0x1E, 0x3E, 0x78, 0x7B,
  0xC1, 0xF0, 0xF0, 0x7D, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0x3C, 0xF0, 0xF7,
  0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0x70, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x38, 0x01, 0xE0, 0x1F, 0x00, 0xFC, 0x0E, 0xE0, 0x73, 0x87, 0x1C, 0x38,
  0xF3, 0xC3, 0x9C, 0x1F, 0xE0, 0x70, 0xFF, 0xFF, 0xFC, 0xF8, 0xF0, 0xF0,
  0xF0, 0x1F, 0x0F, 0xF9, 0xFF, 0x11, 0xE0, 0x1E, 0x1F, 0xDF, 0xFF, 0xFF,
  0xF1, 0xFE, 0x3F, 0xCF, 0xFF, 0xFF, 0xFE, 0xF9, 0xC0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x38, 0xF7, 0xCF, 0xFE, 0xF9, 0xEF, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9E, 0xFF, 0xEF, 0xFE,
  0xF7, 0xC0, 0x1F, 0x8F, 0xF7, 0xF9, 0xE2, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x89, 0xFE, 0x7F, 0x87, 0xE0, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x7B, 0xDF, 0xBB, 0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8,
  0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0x7F, 0xEF, 0xDC, 0xFB, 0x80, 0x1F,
  0x07, 0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x03, 0xC1, 0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0x0F, 0x8F, 0xCF, 0xE7, 0x83,
  0xC1, 0xFB, 0xFD, 0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x3C, 0xEF, 0xDD, 0xFF, 0xFD, 0xFF, 0x1F,
  0xE3, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xEE, 0x7B,
  0xC0, 0x78, 0x0F, 0x43, 0xEF, 0xF9, 0xFF, 0x1F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x78, 0xFF, 0xEF, 0xFE, 0xFD, 0xEF, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x7F, 0xF3, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0xF3, 0xC3, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x1E, 0xE3, 0xEE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEF, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF8, 0xF7, 0x8E, 0x3C, 0xE3, 0xCE, 0x1E, 0xE1, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xCF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xCF, 0xF9, 0xF3, 0xFC, 0x38, 0x7F,
  0x0E, 0x1F, 0xC3, 0x87, 0xF0, 0xE1, 0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3,
  0x87, 0xF0, 0xE1, 0xFC, 0x38, 0x70, 0xE7, 0xCF, 0xFE, 0xFF, 0xEF, 0x9E,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0x1F, 0x03, 0xFC, 0x7F, 0xC7, 0x9E, 0xF1, 0xEF, 0x0E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x1E, 0xF9, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0xF3, 0x8F, 0x7C, 0xFF, 0xEF, 0x9E, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF9, 0xEF, 0xFE, 0xFF, 0xEF, 0x7C, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0xEF, 0xDD, 0xFF, 0xFC, 0xFF,
  0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xEE,
  0x7B, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xE3, 0xFB,
  0xBF, 0xDF, 0xEF, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x80, 0x3E, 0x3F, 0xFF, 0xDE, 0x2F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F,
  0x83, 0xE1, 0xFF, 0xFF, 0xF7, 0xF0, 0x1C, 0x0E, 0x0F, 0x07, 0xFF, 0xFF,
  0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFE, 0x7F,
  0x1F, 0x80, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x3F, 0xE7, 0xBF, 0xF7, 0xFE, 0x7D, 0xC0, 0xF0, 0x7F,
  0x87, 0x9E, 0x3C, 0xF1, 0xE7, 0x9E, 0x1C, 0xF0, 0xF7, 0x87, 0xB8, 0x1D,
  0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0xF1, 0xF1, 0xFE,
  0x3E, 0x3D, 0xC7, 0xC7, 0x3C, 0xF9, 0xE7, 0x9B, 0x3C, 0xF7, 0x77, 0x8E,
  0xEE, 0xE1, 0xDD, 0xDC, 0x3B, 0xBF, 0x87, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x00, 0xF8, 0xF7, 0x9E, 0x79, 0xE3,
  0xFC, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0x3F, 0xC7,
  0x9E, 0x79, 0xEF, 0x0F, 0xF0, 0x7F, 0x87, 0x9E, 0x3C, 0xF1, 0xE7, 0x9E,
  0x1C, 0xF0, 0xF7, 0x87, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xF0, 0x1F, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x3C,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0x87, 0xC7, 0xE3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x3E, 0x3E, 0x1F, 0x0F, 0xC0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xF0, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xF8, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3E, 0x1F, 0x1F, 0x3F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8,
  0xF8, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xC3, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 10, 7, 12, 1, -18 },
  { 22, 13, 18, 14, 1, -18 },
  { 52, 11, 20, 13, 1, -19 },
  { 80, 19, 18, 21, 1, -18 },
  { 123, 15, 18, 16, 1, -18 },
  { 157, 4, 7, 6, 1, -18 },
  { 161, 7, 22, 8, 1, -18 },
  { 181, 7, 22, 8, 0, -18 },
  { 201, 12, 11, 12, 0, -19 },
  { 218, 11, 12, 13, 1, -15 },
  { 235, 5, 6, 7, 1, -3 },
  { 239, 6, 3, 8, 1, -8 },
  { 242, 5, 4, 7, 1, -4 },
  { 245, 10, 18, 10, 0, -18 },
  { 268, 11, 18, 13, 1, -18 },
  { 293, 9, 18, 13, 1, -18 },
  { 314, 11, 18, 13, 1, -18 },
  { 339, 11, 18, 13, 1, -18 },
  { 364, 12, 18, 13, 0, -18 },
  { 391, 11, 18, 13, 1, -18 },
  { 416, 11, 18, 13, 1, -18 },
  { 441, 11, 18, 13, 1, -18 },
  { 466, 11, 18, 13, 1, -18 },
  { 491, 11, 18, 13, 1, -18 },
  { 516, 5, 14, 7, 1, -14 },
  { 525, 5, 17, 7, 1, -14 },
  { 536, 11, 12, 13, 1, -15 },
  { 553, 11, 8, 13, 1, -13 },
  { 564, 11, 12, 13, 1, -15 },
  { 581, 10, 18, 10, 0, -18 },
  { 604, 18, 20, 20, 1, -18 },
  { 649, 15, 18, 15, 0, -18 },
  { 683, 11, 18, 14, 2, -18 },
  { 708, 12, 18, 14, 1, -18 },
  { 735, 12, 18, 16, 2, -18 },
  { 762, 9, 18, 12, 2, -18 },
  { 783, 9, 18, 12, 2, -18 },
  { 804, 13, 18, 16, 1, -18 },
  { 834, 12, 18, 16, 2, -18 },
  { 861, 7, 18, 9, 1, -18 },
  { 877, 8, 23, 7, -2, -18 },
  { 900, 13, 18, 14, 2, -18 },
  { 930, 9, 18, 12, 2, -18 },
  { 951, 17, 18, 21, 2, -18 },
  { 990, 14, 18, 17, 2, -18 },
  { 1022, 14, 18, 17, 1, -18 },
  { 1054, 11, 18, 14, 2, -18 },
  { 1079, 14, 22, 17, 1, -18 },
  { 1118, 12, 18, 14, 2, -18 },
  { 1145, 10, 18, 12, 1, -18 },
  { 1168, 12, 18, 12, 0, -18 },
  { 1195, 12, 18, 16, 2, -18 },
  { 1222, 14, 18, 14, 0, -18 },
  { 1254, 21, 18, 21, 0, -18 },
  { 1302, 14, 18, 14, 0, -18 },
  { 1334, 14, 18, 14, 0, -18 },
  { 1366, 12, 18, 12, 0, -18 },
  { 1393, 6, 22, 8, 1, -18 },
  { 1410, 10, 18, 10, 0, -18 },
  { 1433, 6, 22, 8, 1, -18 },
  { 1450, 13, 12, 14, 0, -18 },
  { 1470, 11, 2, 11, 0, 2 },
  { 1473, 7, 4, 9, 1, -19 },
  { 1477, 11, 14, 13, 1, -14 },
  { 1497, 12, 19, 14, 1, -19 },
  { 1526, 10, 14, 11, 1, -14 },
  { 1544, 11, 19, 14, 1, -19 },
  { 1571, 11, 14, 13, 1, -14 },
  { 1591, 9, 19, 8, 0, -19 },
  { 1613, 11, 20, 14, 1, -14 },
  { 1641, 12, 19, 14, 1, -19 },
  { 1670, 4, 19, 7, 1, -19 },
  { 1680, 6, 25, 7, -1, -19 },
  { 1699, 12, 19, 14, 2, -19 },
  { 1728, 4, 19, 7, 1, -19 },
  { 1738, 18, 14, 21, 1, -14 },
  { 1770, 12, 14, 14, 1, -14 },
  { 1791, 12, 14, 14, 1, -14 },
  { 1812, 12, 20, 14, 1, -14 },
  { 1842, 11, 20, 14, 1, -14 },
  { 1870, 9, 14, 10, 1, -14 },
  { 1886, 9, 14, 11, 1, -14 },
  { 1902, 9, 17, 9, 0, -17 },
  { 1922, 11, 14, 14, 1, -14 },
  { 1942, 13, 14, 13, 0, -14 },
  { 1965, 19, 14, 19, 0, -14 },
  { 1999, 12, 14, 12, 0, -14 },
  { 2020, 13, 20, 13, 0, -14 },
  { 2053, 9, 14, 10, 1, -14 },
  { 2069, 9, 22, 9, 0, -18 },
  { 2094, 3, 25, 12, 4, -19 },
  { 2104, 8, 22, 9, 1, -18 },
  { 2126, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraBold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD25PT7B_H_
