#ifndef _NOTOSANS_CONDENSED_EXTRABOLD46PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0xFE,
  0x3F, 0xFF, 0x8F, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87,
  0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9,
  0xF8, 0x7E, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01,
  0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x03,
  0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F,
  0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xDC, 0x7B, 0xF3, 0x81, 0x7E, 0x70, 0x0F, 0xCE, 0x01,
  0xFD, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3B, 0xF8,
  0x07, 0x3F, 0x00, 0xE7, 0xF0, 0x1C, 0xFF, 0x83, 0x9F, 0xFC, 0x77, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x03,
  0xE0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x7E, 0xFC, 0x07, 0xC0, 0x07, 0xC7,
  0xC0, 0xFC, 0x00, 0xFC, 0x7C, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0xF8, 0x00,
  0xFC, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x7E, 0x00, 0x07, 0xC7,
  0xC7, 0xC3, 0xF0, 0x7C, 0x7C, 0xFC, 0x7F, 0xC7, 0xEF, 0xCF, 0x8F, 0xFC,
  0x3F, 0xF8, 0xF9, 0xFF, 0xE3, 0xFF, 0x9F, 0x1F, 0xFE, 0x1F, 0xF1, 0xF3,
  0xF3, 0xF0, 0xFE, 0x3F, 0x3F, 0x1F, 0x00, 0x03, 0xE3, 0xE1, 0xF0, 0x00,
  0x7E, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x1F,
  0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x1F, 0x03,
  0xF1, 0xF0, 0x01, 0xF0, 0x3F, 0x3F, 0x00, 0x3F, 0x01, 0xFB, 0xF0, 0x03,
  0xE0, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC1, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF,
  0xE3, 0xF8, 0xFF, 0x7F, 0xBF, 0xC7, 0xF3, 0xFD, 0xFC, 0x7F, 0x8F, 0xFF,
  0xE3, 0xFC, 0x3F, 0xFE, 0x1F, 0xE0, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFB,
  0xFE, 0x07, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF0, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07,
  0xF0, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x06, 0x0F, 0x86, 0x7C, 0xF3, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x3F, 0x9F, 0xC1, 0xF0,
  0xF8, 0x0F, 0x0F, 0x00, 0x20, 0x40, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F,
  0x1F, 0x9F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F, 0x08, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x03,
  0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x3E, 0x0F, 0xF1, 0xC0, 0xFF, 0x18, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8E, 0x07, 0xF9, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xDF, 0xC0, 0x3F, 0x7F, 0x01, 0xF9, 0xFC, 0x07, 0xC7,
  0xF0, 0x3F, 0x1F, 0xC0, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x07, 0xF0,
  0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x40, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x18, 0x07, 0xE7, 0xF8, 0x3F, 0x7F, 0xE1, 0xFB, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF7, 0xFE, 0x7F, 0xBF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFB, 0xF8, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07,
  0xF3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x9F, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7, 0xF8, 0xFF, 0x3F, 0x83, 0xF9, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFF, 0x0F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xF1, 0xFF, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xF7, 0xE0, 0xFF, 0x3F, 0x01,
  0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x73, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0C, 0x7E, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x04, 0x1F,
  0x8F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x1F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x0F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF3, 0x81, 0xFC, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x01, 0xF0, 0x3E, 0x1F, 0x07, 0xFF, 0x9F, 0x1F, 0x87, 0xFF,
  0xC7, 0xCF, 0x87, 0xFF, 0xE3, 0xE7, 0xC3, 0xF1, 0xF1, 0xF7, 0xE3, 0xF0,
  0xF8, 0xFB, 0xE1, 0xF0, 0x7C, 0x3D, 0xF1, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8,
  0x3F, 0x0F, 0xFC, 0x7C, 0x1F, 0x87, 0xBE, 0x3E, 0x0F, 0xC7, 0xDF, 0x1F,
  0x07, 0xE3, 0xEF, 0x8F, 0x83, 0xE1, 0xF7, 0xC7, 0xE1, 0xF0, 0xFB, 0xE3,
  0xF1, 0xFC, 0x79, 0xF0, 0xFD, 0xFE, 0xFC, 0xF8, 0x7F, 0xFF, 0xFC, 0x3E,
  0x1F, 0xF3, 0xFE, 0x1F, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xF0, 0x3C, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x00,
  0x1F, 0xC0, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xE7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF,
  0xBF, 0x81, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x81, 0xFC, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x81, 0xFE,
  0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFE, 0x07, 0x0F, 0xF0, 0x04, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x23,
  0xFE, 0x03, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFE, 0x1F, 0xF8, 0xFE, 0x07, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07,
  0xFC, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xF0, 0x1C, 0x3F, 0xE0, 0x04, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x3F,
  0xC0, 0x7F, 0x3F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F,
  0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xBF,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03,
  0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xBF, 0xFF, 0xF8, 0x1F, 0xBF,
  0xFE, 0xF8, 0x1F, 0xBF, 0xFE, 0xFC, 0x1F, 0x3F, 0xFE, 0xFC, 0x3F, 0x3F,
  0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0x7E, 0x3F, 0x7F, 0xFE, 0x7E, 0x3E, 0x7F,
  0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0x7C, 0x7F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x1F, 0xFC, 0x7F,
  0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F,
  0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0xFE, 0x1F, 0xFF, 0xBF, 0x87, 0xFF, 0xE7, 0xF1,
  0xFF, 0xF9, 0xFC, 0x7F, 0xFE, 0x7F, 0x9F, 0xFF, 0x8F, 0xE7, 0xFF, 0xE3,
  0xFD, 0xFF, 0xF8, 0x7F, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF9, 0xFF,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF7,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xF0, 0x1F,
  0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF9, 0xFF, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xE3,
  0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x87, 0xFC, 0x7F, 0x07, 0xF8,
  0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF,
  0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x87, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE7,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF0, 0xFB, 0xF8, 0x06, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFE, 0x0F, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF7,
  0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0x0F,
  0xE7, 0xF0, 0x1F, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0xE0, 0x3F, 0x9F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFF, 0x03,
  0xF8, 0x7F, 0x07, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0x7C, 0x1F, 0x83, 0xF8, 0x3E, 0xF8, 0x7F, 0x03, 0xF8, 0xFD, 0xF0,
  0xFE, 0x07, 0xF1, 0xFB, 0xE1, 0xFC, 0x0F, 0xE3, 0xF7, 0xE3, 0xF8, 0x1F,
  0xC7, 0xCF, 0xC7, 0xE0, 0x1F, 0x8F, 0x9F, 0x9F, 0xC0, 0x3F, 0x3F, 0x1F,
  0x3F, 0x80, 0x7F, 0x7E, 0x3E, 0x7F, 0x00, 0xFE, 0xFC, 0x7E, 0xFE, 0x01,
  0xFD, 0xF8, 0xFD, 0xF8, 0x01, 0xFB, 0xE1, 0xFB, 0xF0, 0x03, 0xF7, 0xC1,
  0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0xBF, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF,
  0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F,
  0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xF8,
  0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x0F, 0xF0, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x7F, 0xF7, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0x7F, 0x1F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xBF, 0x3F, 0xF1, 0xF1, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xE0, 0x3F, 0x9F, 0xC1, 0xFD,
  0xFF, 0x0F, 0xDF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xF3, 0xFE,
  0xFF, 0x0F, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xF0, 0xFF, 0x7F, 0xEF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFD, 0xFF, 0xC7, 0xE7, 0xFC, 0x3E,
  0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC7, 0xF8, 0x71, 0xFC, 0x04, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x06, 0x7F,
  0xCF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x1C, 0x1F, 0xC3, 0xFC, 0xFE, 0x3F, 0xF7, 0xF3, 0xFF, 0xBF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xCF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFB, 0xF8, 0xFF, 0xDF, 0xC3, 0xF8, 0x7E, 0x00, 0xF0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x02, 0x7F,
  0x81, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x03, 0xC0, 0x00, 0x7F, 0x9F, 0xC7, 0xFE, 0xFE, 0x7F, 0xF7, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xF7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE7, 0xFF, 0x7F, 0x1F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x20, 0x03, 0xF9, 0xC0, 0x3F, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE1, 0xE0, 0xFE, 0xFF, 0x8F, 0xDF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF,
  0x8F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE,
  0x0F, 0xF3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x7F,
  0x83, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFD, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x8F, 0xE0, 0xFF, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E,
  0x01, 0xF0, 0x7C, 0x7F, 0xC3, 0xFE, 0x3F, 0x7F, 0xF3, 0xFF, 0x9F, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0x7F, 0xF3, 0xFD, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF,
  0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF,
  0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F,
  0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1E,
  0x0F, 0x8F, 0xF8, 0xFD, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xDF, 0xE0, 0xFE,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x1C, 0x07, 0xE3, 0xF8, 0x3F, 0x3F, 0xF1, 0xFB, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFE, 0x3F, 0xDF, 0xE1, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFF, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFE, 0x1F, 0xEF, 0xFD, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xBF, 0xF8, 0xFE, 0xFF, 0x87, 0xF3, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x9F, 0xC7, 0xFE, 0xFE, 0x7F, 0xF7,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0x7F, 0x1F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x8F, 0xFF, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xF8, 0x19, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE8, 0x07, 0xF7, 0x8F, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xDC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFB, 0xF3, 0xFF, 0x3F, 0x1F, 0xE3, 0xF0,
  0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0xFE, 0x07, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0xF0,
  0x7F, 0x3F, 0x83, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xC1, 0xF8, 0x7E, 0x1F,
  0xFC, 0x7F, 0x0F, 0xE3, 0xEF, 0x8F, 0xE1, 0xFC, 0x7D, 0xF1, 0xFC, 0x3F,
  0x8F, 0xBE, 0x3F, 0x03, 0xF1, 0xF7, 0xC7, 0xE0, 0x7E, 0x7C, 0xF9, 0xFC,
  0x0F, 0xEF, 0x8F, 0xBF, 0x81, 0xFD, 0xF1, 0xF7, 0xF0, 0x1F, 0xBE, 0x3E,
  0xFC, 0x03, 0xF7, 0xC7, 0xDF, 0x80, 0x7E, 0xF8, 0xFB, 0xF0, 0x0F, 0xDE,
  0x1F, 0x7E, 0x01, 0xFF, 0xC1, 0xEF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE,
  0x3F, 0x81, 0xFC, 0xFF, 0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0xFE, 0x7F, 0x81,
  0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7F, 0x3F,
  0x00, 0xFE, 0x7E, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE1,
  0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x0B, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00,
  0xFF, 0xD0, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 34, 12, 2, -33 },
  { 35, 18, 12, 22, 2, -33 },
  { 62, 24, 33, 26, 1, -33 },
  { 161, 19, 38, 23, 2, -35 },
  { 252, 36, 33, 39, 1, -33 },
  { 401, 29, 33, 30, 1, -33 },
  { 521, 7, 12, 12, 2, -33 },
  { 532, 12, 40, 15, 2, -33 },
  { 592, 12, 40, 15, 1, -33 },
  { 652, 20, 20, 22, 1, -35 },
  { 702, 20, 22, 23, 2, -27 },
  { 757, 9, 12, 12, 1, -6 },
  { 771, 12, 7, 15, 1, -16 },
  { 782, 8, 9, 12, 2, -8 },
  { 791, 19, 33, 19, 0, -33 },
  { 870, 20, 33, 23, 2, -33 },
  { 953, 16, 33, 23, 2, -33 },
  { 1019, 20, 33, 23, 1, -33 },
  { 1102, 19, 33, 23, 2, -33 },
  { 1181, 22, 33, 23, 1, -33 },
  { 1272, 19, 33, 23, 2, -33 },
  { 1351, 21, 33, 23, 1, -33 },
  { 1438, 21, 33, 23, 1, -33 },
  { 1525, 21, 33, 23, 1, -33 },
  { 1612, 21, 33, 23, 1, -33 },
  { 1699, 8, 27, 13, 2, -26 },
  { 1726, 9, 32, 13, 1, -26 },
  { 1762, 21, 23, 23, 1, -28 },
  { 1823, 20, 15, 23, 2, -24 },
  { 1861, 20, 23, 23, 2, -28 },
  { 1919, 18, 34, 19, 0, -33 },
  { 1996, 33, 37, 36, 2, -33 },
  { 2149, 27, 33, 27, 0, -33 },
  { 2261, 22, 33, 27, 3, -33 },
  { 2352, 22, 33, 25, 2, -33 },
  { 2443, 24, 33, 29, 3, -33 },
  { 2542, 17, 33, 22, 3, -33 },
  { 2613, 17, 33, 21, 3, -33 },
  { 2684, 24, 33, 29, 2, -33 },
  { 2783, 24, 33, 30, 3, -33 },
  { 2882, 14, 33, 16, 1, -33 },
  { 2940, 13, 43, 14, -3, -33 },
  { 3010, 24, 33, 26, 3, -33 },
  { 3109, 17, 33, 21, 3, -33 },
  { 3180, 32, 33, 39, 3, -33 },
  { 3312, 26, 33, 32, 3, -33 },
  { 3420, 26, 33, 30, 2, -33 },
  { 3528, 20, 33, 25, 3, -33 },
  { 3611, 26, 41, 30, 2, -33 },
  { 3745, 23, 33, 26, 3, -33 },
  { 3840, 18, 33, 22, 2, -33 },
  { 3915, 21, 33, 22, 1, -33 },
  { 4002, 23, 33, 29, 3, -33 },
  { 4097, 26, 33, 26, 0, -33 },
  { 4205, 39, 33, 39, 0, -33 },
  { 4366, 25, 33, 26, 0, -33 },
  { 4470, 25, 33, 25, 0, -33 },
  { 4574, 20, 33, 22, 1, -33 },
  { 4657, 11, 41, 14, 2, -33 },
  { 4714, 19, 33, 19, 0, -33 },
  { 4793, 11, 41, 14, 1, -33 },
  { 4850, 23, 21, 25, 1, -33 },
  { 4911, 21, 4, 21, 0, 4 },
  { 4922, 12, 7, 16, 2, -35 },
  { 4933, 20, 26, 24, 1, -26 },
  { 4998, 21, 35, 25, 3, -35 },
  { 5090, 18, 26, 21, 2, -26 },
  { 5149, 21, 35, 25, 2, -35 },
  { 5241, 20, 26, 23, 2, -26 },
  { 5306, 16, 35, 16, 1, -35 },
  { 5376, 21, 37, 25, 2, -26 },
  { 5474, 20, 35, 26, 3, -35 },
  { 5562, 8, 35, 12, 2, -35 },
  { 5597, 12, 46, 12, -2, -35 },
  { 5666, 22, 35, 25, 3, -35 },
  { 5763, 7, 35, 12, 3, -35 },
  { 5794, 33, 26, 38, 3, -26 },
  { 5902, 20, 26, 26, 3, -26 },
  { 5967, 21, 26, 25, 2, -26 },
  { 6036, 21, 37, 25, 3, -26 },
  { 6134, 21, 37, 25, 2, -26 },
  { 6232, 14, 26, 18, 3, -26 },
  { 6278, 17, 26, 19, 1, -26 },
  { 6334, 15, 31, 17, 1, -31 },
  { 6393, 20, 25, 26, 3, -25 },
  { 6456, 23, 25, 23, 0, -25 },
  { 6528, 35, 25, 35, 0, -25 },
  { 6638, 23, 25, 23, 0, -25 },
  { 6710, 23, 36, 23, 0, -25 },
  { 6814, 17, 25, 19, 1, -25 },
  { 6868, 15, 41, 17, 1, -33 },
  { 6945, 5, 45, 21, 8, -35 },
  { 6974, 15, 41, 17, 1, -33 },
  { 7051, 21, 8, 23, 1, -20 },
};

const GFXfont NotoSans_Condensed_ExtraBold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD46PT7B_H_
