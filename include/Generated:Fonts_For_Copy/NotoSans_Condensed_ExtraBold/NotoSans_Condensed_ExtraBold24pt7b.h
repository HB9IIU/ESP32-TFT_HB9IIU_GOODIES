#ifndef _NOTOSANS_CONDENSED_EXTRABOLD24PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x70, 0x07, 0xFF, 0x70, 0xF7, 0xF9,
  0xFC, 0xFE, 0x77, 0x3B, 0x9C, 0x06, 0x70, 0x73, 0x03, 0x98, 0x1D, 0xC0,
  0xEE, 0x3F, 0xFD, 0xFF, 0xE3, 0x98, 0x1C, 0xC0, 0xEE, 0x3F, 0xFD, 0xFF,
  0xE1, 0x9C, 0x0C, 0xC0, 0xE6, 0x07, 0x30, 0x3B, 0x80, 0x0C, 0x03, 0x83,
  0xFD, 0xFF, 0xFD, 0xBB, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F,
  0x0D, 0xE3, 0x7F, 0xFF, 0xFE, 0x7F, 0x03, 0x00, 0xC0, 0x7C, 0x1C, 0x3F,
  0x07, 0x0E, 0xE3, 0x83, 0xB8, 0xE0, 0xCE, 0x70, 0x33, 0x9C, 0x0E, 0xEE,
  0x23, 0xBB, 0xBE, 0xFC, 0xDF, 0xDF, 0x77, 0x70, 0x1D, 0xCC, 0x0E, 0x73,
  0x03, 0x9C, 0xC1, 0xC7, 0x70, 0x71, 0xDC, 0x38, 0x3F, 0x0E, 0x07, 0x80,
  0x1F, 0x80, 0x7F, 0x01, 0xEF, 0x03, 0x8E, 0x07, 0xBC, 0x0F, 0x78, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x3D, 0xFE, 0x7B, 0xDF, 0xE7, 0x1F, 0xCE, 0x1F,
  0x1E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0x3E, 0xFF, 0xFF, 0x77, 0x1E,
  0x70, 0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C,
  0x38, 0x70, 0xF0, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xE1, 0xE1, 0xC3, 0x87,
  0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x8F,
  0x00, 0x0E, 0x01, 0xC1, 0x38, 0xBF, 0xF7, 0xFF, 0x7F, 0x07, 0xC1, 0xFC,
  0x79, 0xC3, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFC,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x77, 0xFF, 0xEE, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF7, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x3F,
  0x1F, 0xE7, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xCF, 0xF3, 0xFC, 0xF7, 0xF9, 0xFE, 0x3F, 0x00, 0x07, 0x0F, 0x3F,
  0x7F, 0xFF, 0x77, 0x27, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x3F, 0x3F, 0xEF, 0xF9, 0x8F, 0x43, 0xC0, 0xF0, 0x38, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x3F, 0xE7, 0xFD, 0x0F, 0x03, 0xC0, 0xF0, 0xF8, 0xFC, 0x3F, 0x0F,
  0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC3, 0xBC, 0x3B, 0xC7,
  0x3C, 0x73, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C, 0x0F, 0xF3, 0xFE, 0xFF, 0xC1,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xFF, 0xFB, 0xFE, 0xFF, 0x00, 0x1F, 0x8F,
  0xE7, 0xF9, 0xE0, 0xF0, 0x3C, 0x0E, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F,
  0xC7, 0xF1, 0xFC, 0xF7, 0xFD, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x03, 0xC0, 0xF0, 0x78, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xCF, 0xF3,
  0xFC, 0xF7, 0xF8, 0xFC, 0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7F,
  0xFD, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xCF, 0xE3, 0xF8, 0x7E,
  0x1F, 0xCF, 0xFF, 0xDF, 0xF3, 0xDC, 0x07, 0x03, 0xC1, 0xE7, 0xF9, 0xFC,
  0x7C, 0x00, 0xFF, 0xF6, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x7F, 0xF6, 0x00,
  0x00, 0x00, 0x77, 0xFF, 0xEE, 0x00, 0x40, 0x30, 0x3C, 0x3F, 0x3F, 0x3F,
  0x0F, 0x03, 0xF0, 0x3F, 0x83, 0xF0, 0x3C, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x30, 0x0F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3C, 0x3F, 0x3F, 0x3F, 0x0F, 0x03, 0x00, 0x7F, 0x3F, 0xE7, 0xF9,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0xF0, 0x1C, 0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0x03,
  0x87, 0x00, 0xE7, 0x1F, 0x33, 0x1F, 0xDF, 0x9C, 0xCF, 0xDC, 0x67, 0xEE,
  0x33, 0xF7, 0x19, 0xFB, 0x9C, 0xFD, 0xCE, 0x6E, 0x7F, 0xF7, 0x1E, 0xF1,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x3C, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7B, 0x81, 0xCE, 0x07,
  0x3C, 0x3C, 0xF0, 0xF1, 0xC3, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xE1, 0xE7,
  0x83, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0x1F, 0xFB, 0xFF, 0x71, 0xEE, 0x1F,
  0xC3, 0xB8, 0xF7, 0xFC, 0xFF, 0x9F, 0xFB, 0x87, 0xF0, 0xFE, 0x1F, 0xC7,
  0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0xFF, 0xBE, 0x27, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x5F, 0xF9, 0xFF, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE, 0x3E, 0xE1,
  0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1E, 0xE1,
  0xEE, 0x3E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xC1, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x7F, 0x07, 0x78,
  0x77, 0xC7, 0x3F, 0xF3, 0xFF, 0x0F, 0xF0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0xFF, 0xFD, 0xF3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0x7F, 0xFE,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x73, 0xFF, 0xFB, 0xC0, 0xE1, 0xFE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7,
  0x8E, 0xF8, 0xEF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8E, 0x78, 0xE3,
  0xCE, 0x3C, 0xE1, 0xEE, 0x1E, 0xE1, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xEE, 0x77, 0xEE, 0x77, 0xEE, 0x77, 0xEE, 0x77, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xB8,
  0xFD, 0xE7, 0xE7, 0x3F, 0x3D, 0xF9, 0xEF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0xF8, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E,
  0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x78, 0x79, 0xF3, 0xE3, 0xFF, 0x0F, 0xFC, 0x0F, 0xC0, 0xFF,
  0x3F, 0xEF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xBF, 0xEF,
  0xE3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x9E, 0x1E, 0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x79, 0xF3, 0xE3, 0xFF, 0x0F,
  0xFC, 0x0F, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0xFF, 0x0F,
  0xF8, 0xFF, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE3, 0xCE, 0xFC, 0xFF, 0x8F,
  0xF0, 0xEF, 0x0E, 0x78, 0xE7, 0x8E, 0x3C, 0xE3, 0xCE, 0x1E, 0xE1, 0xF0,
  0x3F, 0x9F, 0xFF, 0xFB, 0xC6, 0xF0, 0x3C, 0x0F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x78, 0x0F, 0x83, 0xF1, 0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xEF, 0x1E, 0xFF, 0xE7, 0xFC, 0x3F, 0x80,
  0xF0, 0x3F, 0xC1, 0xE7, 0x07, 0x9E, 0x1E, 0x78, 0x70, 0xE1, 0xC3, 0x8F,
  0x0F, 0x3C, 0x3C, 0xE0, 0x73, 0x81, 0xDE, 0x07, 0xF8, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xF7, 0x0F, 0x8F, 0x79, 0xF8, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE3,
  0x9F, 0x9E, 0x39, 0xDD, 0xC3, 0xB9, 0xDC, 0x3F, 0x9D, 0xC3, 0xF9, 0xFC,
  0x1F, 0x9F, 0xC1, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x80, 0xF8, 0xFB, 0xC7, 0x8E, 0x3C, 0x7B, 0xC1, 0xDE, 0x0F, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x83, 0xDE, 0x1E, 0x71,
  0xE3, 0xCF, 0x1F, 0xF0, 0x78, 0xF0, 0x7B, 0xC7, 0x9E, 0x3C, 0x71, 0xC3,
  0xDE, 0x1E, 0xF0, 0x77, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xEF, 0xFD,
  0xFF, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0x80, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF,
  0xFC, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0E, 0xE0, 0xE7,
  0x87, 0x1C, 0x78, 0xF3, 0x83, 0xBC, 0x1E, 0xFF, 0xFF, 0xFC, 0xF8, 0xE1,
  0xC0, 0x7F, 0x9F, 0xE3, 0x7C, 0x0F, 0x03, 0xCF, 0xFF, 0xFF, 0xCF, 0xE3,
  0xF8, 0xFF, 0xFF, 0xFF, 0x7D, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xEF, 0x3F, 0xF7, 0xFF, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F,
  0xE3, 0xFE, 0x7F, 0xFF, 0xFF, 0xDE, 0xF0, 0x3F, 0xBF, 0xDF, 0xDE, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x5F, 0xEF, 0xF3, 0xF0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x7B, 0xDF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7B, 0xFF, 0x7F, 0xE7, 0x9C, 0x3F,
  0x1F, 0xE7, 0xBF, 0xC7, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x17,
  0xFD, 0xFF, 0x3F, 0x80, 0x1F, 0x9F, 0x8F, 0xC7, 0x83, 0xC3, 0xFB, 0xFD,
  0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x00, 0x3C, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xFF, 0xBF, 0xF3, 0xDE, 0x03, 0xC0, 0x7B, 0x1E, 0x7F,
  0xCF, 0xF0, 0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xEF,
  0xBF, 0xF7, 0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3C, 0xFF, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0xF3, 0xC0, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xBF, 0xFF, 0xBC, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x1F, 0xF1, 0xEF, 0x3C, 0xF7, 0x8F, 0x78, 0xFF,
  0x0F, 0xF0, 0xFF, 0x8F, 0xBC, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xDF, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xE7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xC0, 0xE7, 0xDF, 0xFB, 0xFF, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1E, 0x3F, 0x8F, 0xF9, 0xFF,
  0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3D, 0xFF, 0x3F,
  0xE1, 0xF0, 0xF7, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0x79, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xFF, 0xBF, 0xF3, 0xDE, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE7, 0xFF, 0xFF, 0xFC,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x7F, 0xFF, 0xF7,
  0xE0, 0xF8, 0xFC, 0x7F, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFE, 0x18, 0x38,
  0x38, 0x7F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F,
  0x3F, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3D, 0xFF, 0xBF, 0x73, 0xEE, 0xF0, 0xF7, 0x0F, 0x78,
  0xE7, 0x9E, 0x79, 0xE3, 0x9C, 0x39, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0xF1, 0xE3, 0xDC, 0x78, 0xF7, 0x1F, 0x39, 0xEF,
  0xCE, 0x7B, 0xF7, 0x9E, 0xED, 0xE3, 0xB3, 0x70, 0xEC, 0xFC, 0x3B, 0x3F,
  0x0F, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0x78, 0x1E, 0x1E, 0x00, 0xF9, 0xF7,
  0x9E, 0x3B, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x83,
  0xFC, 0x79, 0xC7, 0x9E, 0xF0, 0xF0, 0xF0, 0xF7, 0x0F, 0x78, 0xE7, 0x9E,
  0x39, 0xE3, 0x9C, 0x3D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x05, 0xE0, 0x7E, 0x07, 0xC0, 0x70, 0x00, 0x7F,
  0xBF, 0xDF, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x3C, 0x3C, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xFC,
  0xF0, 0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x1F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF8, 0xF8, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3C, 0x3F, 0x0F, 0x3F, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x78, 0xF8, 0xF0, 0xE0, 0x20, 0x7F, 0x1F, 0xFE, 0x3F, 0x81, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 9, 6, 11, 1, -17 },
  { 17, 13, 17, 13, 0, -17 },
  { 45, 10, 19, 12, 1, -18 },
  { 69, 18, 17, 20, 1, -17 },
  { 108, 15, 17, 16, 1, -17 },
  { 140, 4, 6, 6, 1, -17 },
  { 143, 7, 21, 8, 1, -17 },
  { 162, 7, 21, 8, 0, -17 },
  { 181, 11, 10, 12, 0, -18 },
  { 195, 10, 11, 12, 1, -14 },
  { 209, 4, 6, 6, 1, -3 },
  { 212, 6, 3, 8, 1, -8 },
  { 215, 4, 4, 6, 1, -4 },
  { 217, 10, 17, 10, 0, -17 },
  { 239, 10, 17, 12, 1, -17 },
  { 261, 8, 17, 12, 1, -17 },
  { 278, 10, 17, 12, 1, -17 },
  { 300, 10, 17, 12, 1, -17 },
  { 322, 12, 17, 12, 0, -17 },
  { 348, 10, 17, 12, 1, -17 },
  { 370, 10, 17, 12, 1, -17 },
  { 392, 10, 17, 12, 1, -17 },
  { 414, 10, 17, 12, 1, -17 },
  { 436, 10, 17, 12, 1, -17 },
  { 458, 4, 13, 7, 1, -13 },
  { 465, 4, 16, 7, 1, -13 },
  { 473, 10, 12, 12, 1, -15 },
  { 488, 10, 7, 12, 1, -12 },
  { 497, 10, 12, 12, 1, -15 },
  { 512, 10, 17, 10, 0, -17 },
  { 534, 17, 19, 19, 1, -17 },
  { 575, 14, 17, 14, 0, -17 },
  { 605, 11, 17, 14, 2, -17 },
  { 629, 11, 17, 13, 1, -17 },
  { 653, 12, 17, 15, 2, -17 },
  { 679, 8, 17, 11, 2, -17 },
  { 696, 8, 17, 11, 2, -17 },
  { 713, 12, 17, 15, 1, -17 },
  { 739, 12, 17, 16, 2, -17 },
  { 765, 7, 17, 9, 1, -17 },
  { 780, 6, 22, 7, -1, -17 },
  { 797, 12, 17, 14, 2, -17 },
  { 823, 9, 17, 11, 2, -17 },
  { 843, 16, 17, 20, 2, -17 },
  { 877, 13, 17, 17, 2, -17 },
  { 905, 14, 17, 16, 1, -17 },
  { 935, 10, 17, 13, 2, -17 },
  { 957, 14, 21, 16, 1, -17 },
  { 994, 12, 17, 14, 2, -17 },
  { 1020, 10, 17, 11, 1, -17 },
  { 1042, 11, 17, 12, 0, -17 },
  { 1066, 12, 17, 15, 2, -17 },
  { 1092, 14, 17, 14, 0, -17 },
  { 1122, 20, 17, 20, 0, -17 },
  { 1165, 13, 17, 13, 0, -17 },
  { 1193, 13, 17, 13, 0, -17 },
  { 1221, 11, 17, 12, 0, -17 },
  { 1245, 6, 21, 8, 1, -17 },
  { 1261, 10, 17, 10, 0, -17 },
  { 1283, 5, 21, 8, 1, -17 },
  { 1297, 13, 11, 13, 0, -17 },
  { 1315, 11, 2, 11, 0, 2 },
  { 1318, 6, 3, 8, 1, -18 },
  { 1321, 10, 13, 12, 1, -13 },
  { 1338, 11, 18, 13, 1, -18 },
  { 1363, 9, 13, 11, 1, -13 },
  { 1378, 11, 18, 13, 1, -18 },
  { 1403, 10, 13, 12, 1, -13 },
  { 1420, 9, 18, 8, 0, -18 },
  { 1441, 11, 19, 13, 1, -13 },
  { 1468, 11, 18, 13, 1, -18 },
  { 1493, 4, 18, 7, 1, -18 },
  { 1502, 6, 24, 7, -1, -18 },
  { 1520, 12, 18, 13, 1, -18 },
  { 1547, 4, 18, 6, 1, -18 },
  { 1556, 18, 13, 20, 1, -13 },
  { 1586, 11, 13, 13, 1, -13 },
  { 1604, 11, 13, 13, 1, -13 },
  { 1622, 11, 19, 13, 1, -13 },
  { 1649, 11, 19, 13, 1, -13 },
  { 1676, 8, 13, 9, 1, -13 },
  { 1689, 8, 13, 10, 1, -13 },
  { 1702, 8, 16, 9, 0, -16 },
  { 1718, 11, 13, 13, 1, -13 },
  { 1736, 12, 13, 12, 0, -13 },
  { 1756, 18, 13, 18, 0, -13 },
  { 1786, 12, 13, 12, 0, -13 },
  { 1806, 12, 19, 12, 0, -13 },
  { 1835, 9, 13, 10, 0, -13 },
  { 1850, 8, 21, 9, 0, -17 },
  { 1871, 3, 23, 11, 4, -18 },
  { 1880, 8, 21, 9, 1, -17 },
  { 1901, 10, 5, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraBold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD24PT7B_H_
