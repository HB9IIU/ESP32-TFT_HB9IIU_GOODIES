#ifndef _NOTOSANS_CONDENSED_EXTRABOLD31PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x80, 0x01, 0xE7, 0xFF, 0x7D, 0xE0, 0xF9, 0xF7, 0x9F, 0x78, 0xF7, 0x8F,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x3C,
  0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0,
  0x39, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0xE3, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0x62, 0xFB, 0x07, 0xD8, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0x7C, 0x1B, 0xF8, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF0, 0x3E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3E, 0x01, 0xE0,
  0x7F, 0x03, 0xC0, 0xFF, 0x83, 0xC0, 0xF3, 0x87, 0x80, 0xF3, 0x87, 0x80,
  0xF3, 0xC7, 0x00, 0xE3, 0xCF, 0x00, 0xE3, 0xCE, 0x00, 0xF3, 0x9E, 0x10,
  0xF3, 0x9C, 0xFC, 0x7F, 0xBD, 0xFE, 0x7F, 0x3D, 0xFF, 0x3E, 0x79, 0xCF,
  0x00, 0x7B, 0xCF, 0x00, 0x73, 0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xE3, 0xCF,
  0x01, 0xE1, 0xCF, 0x01, 0xC1, 0xCF, 0x03, 0xC1, 0xFE, 0x03, 0xC0, 0xFE,
  0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x1F, 0x3F, 0xE3, 0xE7, 0xFE, 0x7D, 0xF3, 0xFF,
  0x3E, 0x7F, 0xE7, 0xC7, 0xFC, 0xF8, 0x7F, 0x1F, 0x0F, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xCF, 0xC0, 0xFB, 0xDE, 0xF7, 0xBD,
  0xEF, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x3C,
  0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3C,
  0x3C, 0x3E, 0x00, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x0E, 0x73, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xFE, 0x0F, 0x78, 0xFB, 0xE3, 0x8E,
  0x04, 0x40, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x7D, 0xF7, 0x9E, 0x7B, 0xEF, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0xFF, 0x83, 0xFF,
  0x1F, 0xFC, 0x7C, 0xF9, 0xE3, 0xEF, 0x87, 0xBE, 0x1E, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x1E, 0x78,
  0xF9, 0xF3, 0xE7, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x03, 0xE0,
  0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFF, 0xF9, 0xDF, 0x13, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x1F, 0xC3, 0xFF, 0x3F, 0xFD, 0xFF, 0xF7,
  0x0F, 0x90, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE7, 0xFF, 0xBF, 0xFC, 0xFF, 0xF2,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xF0, 0xFF, 0x07, 0xE0, 0x3F,
  0xE1, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0E, 0xF8, 0x3D, 0xF0,
  0xF3, 0xE1, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0x07,
  0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x20, 0xFB, 0xF3, 0xDF, 0xCF, 0xFF, 0xBF, 0xBE, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xF3, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0x3E,
  0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x9F, 0x3E, 0x3F, 0xF0, 0xFF, 0x81, 0xFC,
  0x0F, 0xF8, 0x7F, 0xF1, 0xF3, 0xEF, 0x87, 0xBE, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xDF, 0x9F, 0xFE, 0x7F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x87,
  0xFF, 0x1F, 0xFE, 0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0xBE, 0x1F, 0xF8, 0x7F,
  0xE3, 0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xF8, 0xFD, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x07, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xF0, 0x79, 0xF7,
  0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDF, 0x79, 0xEF,
  0xBC, 0xF0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x7F,
  0x87, 0xF0, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x3F, 0xE0, 0xFE, 0x03, 0xE0,
  0x0C, 0x00, 0x20, 0x00, 0x3F, 0xCF, 0xFE, 0x7F, 0xF7, 0xFF, 0x60, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFE, 0xFE, 0x07, 0xC0, 0x3C,
  0x3C, 0x00, 0x78, 0xF0, 0xF0, 0xE7, 0x8F, 0xF3, 0xDE, 0x7F, 0xC7, 0x71,
  0xE7, 0x1F, 0xCF, 0x1C, 0x7F, 0x3C, 0x71, 0xFC, 0xE1, 0xC7, 0xF3, 0x87,
  0x1F, 0xCE, 0x1C, 0x7F, 0x3C, 0xF3, 0xFC, 0xF7, 0xEE, 0x71, 0xFF, 0xF9,
  0xC3, 0xE7, 0xC7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x40, 0x7F,
  0xBF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF1, 0xE0, 0x7C, 0x7C, 0x1E, 0x1F,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x03, 0xE7,
  0xC0, 0xFD, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xE1, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E,
  0xF8, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xCF, 0x9F, 0xDF, 0x0F, 0xBE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF,
  0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xE0,
  0x4F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x08, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFE, 0x3F, 0x02, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0x7C, 0x7F, 0x7C, 0x0F, 0x7C,
  0x0F, 0x7C, 0x0F, 0x7E, 0x0F, 0x3F, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFE, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0xBF, 0xFF, 0xBF, 0xDF, 0xC7, 0x80, 0xF8, 0x3F, 0xF8,
  0x3E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0, 0xFB,
  0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFD,
  0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8,
  0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x78, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x3D, 0xFF, 0xBC, 0xF7, 0xFE, 0xF3, 0xDF, 0xFB,
  0xCE, 0x7F, 0xE7, 0xF9, 0xFF, 0x9F, 0xE7, 0xFE, 0x7F, 0x9F, 0xF9, 0xFC,
  0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F,
  0xE1, 0xE1, 0xF0, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xEF, 0x8F, 0xF7, 0xC7, 0xFD, 0xF3,
  0xFE, 0xF9, 0xFF, 0x3E, 0xFF, 0x9F, 0x7F, 0xC7, 0xBF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E,
  0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xFD, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x3F, 0x7E, 0x0F, 0x8F, 0x87, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE3, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xFD, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3F, 0x7E, 0x0F, 0x8F, 0x87, 0xE3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFF, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0xFC, 0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x3E, 0xF8, 0x3F, 0x1F, 0xE1, 0xFF, 0xDF, 0xFC, 0xFF, 0xEF, 0xC3,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF,
  0xEF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xFE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x07,
  0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x03, 0xDF, 0x00, 0xF7,
  0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0xC1, 0xFF,
  0x83, 0xF0, 0x7D, 0xE0, 0xFC, 0x1E, 0x7C, 0x3F, 0x0F, 0x9F, 0x0F, 0xC3,
  0xE7, 0xC3, 0xF8, 0xF8, 0xF1, 0xFE, 0x3E, 0x3C, 0x7F, 0x8F, 0x0F, 0x9F,
  0xE3, 0xC3, 0xE7, 0xB9, 0xF0, 0xFB, 0xCF, 0x7C, 0x1E, 0xF3, 0xDF, 0x07,
  0xBC, 0xF7, 0x81, 0xEF, 0x3D, 0xE0, 0x7B, 0xC7, 0xF8, 0x1F, 0xE1, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE0,
  0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xBE, 0x0F, 0x8F, 0x8F, 0x87,
  0xC7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x83, 0xE7,
  0xC1, 0xF7, 0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xC7, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C,
  0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x1F, 0xE3, 0xFF, 0x8F, 0xFE, 0x79,
  0xF2, 0x0F, 0x80, 0x3C, 0x1F, 0xE7, 0xFF, 0x7F, 0xFF, 0xE3, 0xFE, 0x1F,
  0xF1, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xEF, 0xEF, 0x3E, 0x38, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0xF8,
  0xF7, 0xF3, 0xFF, 0xEF, 0xFF, 0xBE, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3E, 0xFF, 0xFB, 0xFF,
  0xEF, 0x7F, 0x3C, 0xF8, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFE, 0x7C, 0x2F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x17,
  0xFF, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xCF, 0x3F, 0xBD, 0xFF, 0xF7,
  0xFF, 0xDF, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x87, 0xDF, 0x1F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF,
  0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7B, 0xE1, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x7C, 0x09, 0xF9,
  0xE3, 0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0x03, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1,
  0xF2, 0x7C, 0x0F, 0x81, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0x7C, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F,
  0x7C, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x01, 0xF0, 0x07,
  0xD0, 0x1F, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0xF8, 0xF7,
  0xF3, 0xFF, 0xEF, 0xFF, 0xBE, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0x77, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFE,
  0xFC, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x3F, 0xF8, 0xFD, 0xF1, 0xF3, 0xE7, 0xC7, 0xDF, 0x0F,
  0xBE, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xE7,
  0xC7, 0xCF, 0x8F, 0x8F, 0x9F, 0x1F, 0xBE, 0x1F, 0x7C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE3, 0xF3, 0xDF, 0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8,
  0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78,
  0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7C,
  0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFB, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xF7, 0xC3, 0xE7, 0xC7, 0xCF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8,
  0x0F, 0xE0, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFB, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBD, 0xFC, 0xF3, 0xE3, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x3C, 0xFE, 0xF7,
  0xFF, 0xDF, 0xFF, 0x7C, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0x7C, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xEF,
  0x1F, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0xF3, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xBE, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00,
  0x3F, 0xCF, 0xFF, 0xFF, 0x7C, 0xEF, 0x81, 0xF0, 0x3F, 0x83, 0xFC, 0x3F,
  0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xFC, 0x7F, 0x8F, 0xF0, 0xFE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF1,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0x38, 0xF8, 0x3F, 0x78,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x3C, 0x7C, 0x3E, 0x7C, 0x3E,
  0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x7E, 0x1E, 0xF0, 0xFC,
  0x7D, 0xE1, 0xF8, 0xFB, 0xE7, 0xF1, 0xE7, 0xCF, 0xE3, 0xC7, 0x9D, 0xCF,
  0x8F, 0x3B, 0xDF, 0x1E, 0x77, 0xBE, 0x3F, 0xE7, 0x78, 0x7F, 0xCE, 0xF0,
  0x7F, 0x9D, 0xE0, 0xFE, 0x3B, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0xFC, 0x3E, 0xF8, 0xF8,
  0xF9, 0xF1, 0xF7, 0xC1, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x83, 0xEF, 0x87, 0xDF, 0x1F, 0x1F,
  0x3E, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x3C, 0x7C, 0x3C, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE1, 0xFC, 0x3F, 0x87, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x3F, 0x8F, 0xE1, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x7F, 0x1F, 0xC1, 0xF1, 0xFC, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0x00, 0x18, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 22, 8, 1, -22 },
  { 18, 12, 8, 15, 1, -22 },
  { 30, 16, 22, 17, 1, -22 },
  { 74, 13, 26, 16, 1, -24 },
  { 117, 24, 22, 26, 1, -22 },
  { 183, 19, 22, 20, 1, -22 },
  { 236, 5, 8, 8, 1, -22 },
  { 241, 9, 27, 10, 1, -22 },
  { 272, 9, 27, 10, 0, -22 },
  { 303, 13, 14, 15, 1, -24 },
  { 326, 14, 15, 16, 1, -18 },
  { 353, 6, 8, 8, 1, -4 },
  { 359, 8, 4, 10, 1, -10 },
  { 363, 6, 5, 8, 1, -5 },
  { 367, 13, 22, 13, 0, -22 },
  { 403, 14, 22, 16, 1, -22 },
  { 442, 11, 22, 16, 1, -22 },
  { 473, 13, 22, 16, 1, -22 },
  { 509, 13, 22, 16, 1, -22 },
  { 545, 15, 22, 16, 0, -22 },
  { 587, 13, 22, 16, 1, -22 },
  { 623, 14, 22, 16, 1, -22 },
  { 662, 14, 22, 16, 1, -22 },
  { 701, 14, 22, 16, 1, -22 },
  { 740, 14, 22, 16, 1, -22 },
  { 779, 5, 17, 9, 2, -17 },
  { 790, 6, 21, 9, 1, -17 },
  { 806, 14, 16, 16, 1, -19 },
  { 834, 14, 10, 16, 1, -16 },
  { 852, 14, 16, 16, 1, -19 },
  { 880, 12, 22, 13, 0, -22 },
  { 913, 22, 24, 24, 1, -22 },
  { 979, 18, 22, 18, 0, -22 },
  { 1029, 15, 22, 18, 2, -22 },
  { 1071, 15, 22, 17, 1, -22 },
  { 1113, 16, 22, 19, 2, -22 },
  { 1157, 11, 22, 15, 2, -22 },
  { 1188, 11, 22, 14, 2, -22 },
  { 1219, 16, 22, 19, 1, -22 },
  { 1263, 16, 22, 20, 2, -22 },
  { 1307, 9, 22, 11, 1, -22 },
  { 1332, 9, 29, 9, -2, -22 },
  { 1365, 16, 22, 18, 2, -22 },
  { 1409, 12, 22, 14, 2, -22 },
  { 1442, 22, 22, 26, 2, -22 },
  { 1503, 17, 22, 22, 2, -22 },
  { 1550, 18, 22, 21, 1, -22 },
  { 1600, 14, 22, 17, 2, -22 },
  { 1639, 18, 27, 21, 1, -22 },
  { 1700, 16, 22, 18, 2, -22 },
  { 1744, 13, 22, 15, 1, -22 },
  { 1780, 14, 22, 15, 1, -22 },
  { 1819, 16, 22, 20, 2, -22 },
  { 1863, 18, 22, 18, 0, -22 },
  { 1913, 26, 22, 26, 0, -22 },
  { 1985, 17, 22, 17, 0, -22 },
  { 2032, 17, 22, 17, 0, -22 },
  { 2079, 13, 22, 15, 1, -22 },
  { 2115, 7, 27, 10, 2, -22 },
  { 2139, 13, 22, 13, 0, -22 },
  { 2175, 7, 27, 10, 1, -22 },
  { 2199, 16, 14, 17, 0, -22 },
  { 2227, 14, 3, 14, 0, 2 },
  { 2233, 8, 5, 11, 1, -24 },
  { 2238, 13, 17, 16, 1, -17 },
  { 2266, 14, 24, 17, 2, -24 },
  { 2308, 12, 17, 14, 1, -17 },
  { 2334, 14, 24, 17, 1, -24 },
  { 2376, 14, 17, 16, 1, -17 },
  { 2406, 11, 24, 10, 0, -24 },
  { 2439, 14, 24, 17, 1, -17 },
  { 2481, 14, 24, 17, 2, -24 },
  { 2523, 5, 24, 8, 2, -24 },
  { 2538, 8, 31, 8, -1, -24 },
  { 2569, 15, 24, 17, 2, -24 },
  { 2614, 5, 24, 8, 2, -24 },
  { 2629, 22, 17, 26, 2, -17 },
  { 2676, 14, 17, 17, 2, -17 },
  { 2706, 15, 17, 17, 1, -17 },
  { 2738, 14, 24, 17, 2, -17 },
  { 2780, 14, 24, 17, 1, -17 },
  { 2822, 10, 17, 12, 2, -17 },
  { 2844, 11, 17, 13, 1, -17 },
  { 2868, 11, 21, 12, 0, -21 },
  { 2897, 13, 17, 17, 2, -17 },
  { 2925, 16, 17, 16, 0, -17 },
  { 2959, 23, 17, 24, 0, -17 },
  { 3008, 15, 17, 15, 0, -17 },
  { 3040, 16, 24, 16, 0, -17 },
  { 3088, 11, 17, 13, 1, -17 },
  { 3112, 11, 27, 12, 0, -22 },
  { 3150, 4, 31, 14, 5, -24 },
  { 3166, 10, 27, 12, 1, -22 },
  { 3200, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_ExtraBold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD31PT7B_H_
