#ifndef _NOTOSANS_CONDENSED_EXTRABOLD35PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xF8, 0x00, 0x1C, 0xFB, 0xFF, 0xFF, 0xF8, 0xF9, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7B, 0xE3, 0xDF, 0x1E, 0xF8, 0xF0, 0x03,
  0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE1, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x3F, 0xC1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x3E, 0xCE, 0xF9,
  0x81, 0xF3, 0x01, 0xF6, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0x7C, 0x06, 0x7C, 0x0C, 0xF6, 0x1B, 0xEF,
  0xBF, 0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF0, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x1F, 0x00, 0x78, 0x0F, 0xF0, 0x1F, 0x01, 0xFF, 0x03,
  0xC0, 0x7D, 0xE0, 0x78, 0x0F, 0x1E, 0x1E, 0x01, 0xE3, 0xC3, 0xC0, 0x3C,
  0x78, 0xF0, 0x07, 0x8F, 0x1E, 0x00, 0xF1, 0xE7, 0x80, 0x1E, 0x3C, 0xF0,
  0x03, 0xC7, 0xBE, 0x7E, 0x3D, 0xE7, 0x9F, 0xE7, 0xFC, 0xF7, 0xFC, 0x7F,
  0x3C, 0xF3, 0xC7, 0xC7, 0x9E, 0x78, 0x01, 0xE7, 0xCF, 0x00, 0x3C, 0xF9,
  0xE0, 0x0F, 0x1F, 0x3C, 0x01, 0xE3, 0xE7, 0x80, 0x7C, 0x3C, 0xF0, 0x0F,
  0x07, 0x9E, 0x01, 0xE0, 0xF7, 0xC0, 0x78, 0x1F, 0xF0, 0x0F, 0x01, 0xFE,
  0x03, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x9F, 0x80, 0x3F, 0x7C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x7E, 0x3F, 0xE1, 0xF9, 0xFF, 0xC7, 0xC7, 0xFF, 0x9F, 0x3F, 0x3F, 0xFC,
  0xFC, 0xFF, 0xE3, 0xE1, 0xFF, 0x8F, 0xC3, 0xFC, 0x3F, 0x07, 0xF0, 0xFE,
  0x3F, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E,
  0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0xF8, 0x3C,
  0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x04, 0x38, 0x5F, 0x77, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xC0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x8F, 0x8F, 0x87,
  0x1C, 0x04, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x73, 0xEF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFC, 0x7E, 0xFC, 0x7C, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC,
  0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC,
  0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0x3F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x0F, 0xF1,
  0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xF3, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0xE0, 0x7F,
  0xF1, 0xFF, 0xF7, 0xFF, 0xE7, 0xCF, 0xE6, 0x0F, 0xC8, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFF, 0xE3, 0x8F, 0xE4, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1E, 0xFC, 0x1E, 0xFC, 0x3C, 0xFC, 0x7C, 0xFC, 0x78, 0xFC, 0xF8,
  0xFC, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFF, 0xF9, 0xCF, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF9,
  0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7C, 0x7E, 0xFC, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7E, 0xFE, 0xFC, 0x7E, 0xFC,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0x7F,
  0xFF, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xBE, 0x04, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x01, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0x80, 0x23, 0xEF, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x3E, 0xFF, 0xFF, 0xFE, 0x10, 0xF9, 0xFB, 0xF7, 0xEF, 0x86, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x1E,
  0x7C, 0xF0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x78, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0xF0,
  0x7E, 0x3C, 0x78, 0xFF, 0xCF, 0x78, 0xFF, 0xE7, 0xBC, 0x7C, 0xF3, 0xDE,
  0x7C, 0x79, 0xEE, 0x3C, 0x3C, 0xFF, 0x1E, 0x1E, 0x7F, 0x8F, 0x1F, 0x3F,
  0xC7, 0x8F, 0x1F, 0xE3, 0xC7, 0x8F, 0xF1, 0xE3, 0xC7, 0xB8, 0xFB, 0xF7,
  0x9E, 0x7F, 0xFF, 0xCF, 0x1F, 0xDF, 0xC7, 0x87, 0xC3, 0xC1, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x60, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xFC, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xE0, 0x7C, 0x1F, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC,
  0x01, 0xF8, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xCF,
  0xF7, 0xE1, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x3F, 0x7E, 0x1F, 0x3F,
  0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFD, 0xF8, 0x3E,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0x9E, 0x7E, 0x02, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x02,
  0x7F, 0x9E, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x0F, 0xEF,
  0xC1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF,
  0xDF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xCF, 0x1F, 0xC0, 0x47, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD,
  0xF8, 0x3F, 0x7F, 0x8F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0xFF, 0xBF, 0xEF,
  0xF3, 0xF8, 0x70, 0x00, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0x83, 0xFF, 0xFB, 0xC1, 0xEF, 0xFD, 0xF0,
  0xF7, 0xFE, 0xF8, 0xFB, 0xFF, 0x3C, 0x79, 0xFF, 0xDE, 0x3C, 0xFF, 0xEF,
  0x9E, 0x7F, 0xF7, 0xDF, 0x3F, 0xF9, 0xEF, 0x1F, 0xFC, 0xF7, 0x8F, 0xFE,
  0x7F, 0xC7, 0xFF, 0x3F, 0xE3, 0xFF, 0x8F, 0xE1, 0xFF, 0xC7, 0xF0, 0xFF,
  0xE3, 0xF8, 0x7F, 0xF0, 0xF8, 0x3F, 0xF8, 0x7C, 0x1F, 0xFC, 0x3E, 0x0F,
  0x80, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFB, 0xE1, 0xFF,
  0xBF, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F, 0xF9, 0xF9, 0xFF, 0x8F, 0x9F,
  0xFC, 0xFD, 0xFF, 0xC7, 0xDF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0x9F, 0xC7, 0xE0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0x7F, 0xBF, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x9F, 0xC7, 0xE0, 0xFC,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0xFC, 0x7F,
  0xBF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xF7, 0xE0, 0xFC, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0x81, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFF,
  0x03, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x3E, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07,
  0xBE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xEF, 0xC0, 0xFC, 0x0F, 0x9F, 0x03, 0xF0,
  0x7E, 0x7C, 0x1F, 0xC1, 0xF9, 0xF0, 0x7F, 0x07, 0xC7, 0xE1, 0xFC, 0x1F,
  0x1F, 0x87, 0xF8, 0x7C, 0x3E, 0x1F, 0xE3, 0xF0, 0xF8, 0xFF, 0x8F, 0xC3,
  0xE3, 0xDE, 0x3E, 0x0F, 0x8F, 0x7C, 0xF8, 0x1F, 0x3D, 0xF3, 0xE0, 0x7D,
  0xF3, 0xCF, 0x81, 0xF7, 0xCF, 0x7E, 0x07, 0xDE, 0x3D, 0xF0, 0x1F, 0x78,
  0xF7, 0xC0, 0x3D, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xEF, 0xC1,
  0xF8, 0xF8, 0x3F, 0x1F, 0x8F, 0xC1, 0xF1, 0xF8, 0x3F, 0x7E, 0x03, 0xEF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x01, 0xF7, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xEF, 0x80,
  0xF9, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xC7,
  0xC0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3E, 0xF0, 0x0F,
  0x3E, 0x07, 0xC7, 0x81, 0xF1, 0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x8F, 0x01,
  0xE7, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x00, 0x80, 0x3F, 0xF0, 0xFF,
  0xF1, 0xFF, 0xE1, 0xFF, 0xE2, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0xFE,
  0x7F, 0xFD, 0xFF, 0xFB, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFD, 0xFE, 0x79, 0xF8, 0xF0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x40, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFE, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB,
  0xFC, 0xF1, 0xF8, 0x00, 0x80, 0x3F, 0xE1, 0xFF, 0xCF, 0xFE, 0x3F, 0xF9,
  0xF8, 0x67, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x5F, 0xC6, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF,
  0x83, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x02, 0x1F, 0x1F, 0x9F, 0x3F, 0xDF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x0F, 0x8F, 0x00, 0x80, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0x7E, 0x7C, 0x3E, 0x7C, 0x1E, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x06, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x03, 0xE0, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE1, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x00, 0x1F, 0xDF,
  0x3F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0x7C, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x70, 0x7F, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xFC, 0x3F, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x60, 0xF9, 0xF8, 0xFB, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x73, 0xEF,
  0xFF, 0xF8, 0xC0, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x0E, 0x0F, 0x87, 0xE3, 0xF1,
  0xF0, 0x20, 0x00, 0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE, 0x1F, 0x9F, 0x1F,
  0x8F, 0x8F, 0x87, 0xCF, 0xC3, 0xEF, 0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xCF, 0x87, 0xC7, 0xE3, 0xE1, 0xF9,
  0xF0, 0xFC, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x60, 0x10, 0x79, 0xFC, 0x7F, 0x3F, 0xFF, 0x7F, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0xFF, 0xF0, 0xFC, 0x3F,
  0xF8, 0x7C, 0x1F, 0xFC, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83,
  0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8,
  0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F,
  0x83, 0xFF, 0x07, 0xC1, 0xF0, 0x00, 0x40, 0xF3, 0xF8, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x00, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0x60, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFE, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0x00, 0x1F, 0xDF, 0x3F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F,
  0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x3F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00,
  0x02, 0x01, 0xFF, 0x9F, 0xFC, 0xFF, 0xEF, 0xFF, 0x7C, 0x13, 0xF0, 0x1F,
  0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xFC, 0x3F, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x91, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xBC, 0x7E, 0x78, 0xFC, 0x0F, 0xDF, 0x03,
  0xE7, 0xC1, 0xF9, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0,
  0xF8, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x3F, 0x07, 0xDF, 0x0F, 0xE1, 0xF7, 0xC3, 0xF8,
  0x7D, 0xF0, 0xFE, 0x3E, 0x7C, 0x7F, 0x8F, 0x8F, 0x9F, 0xE3, 0xE3, 0xE7,
  0xBC, 0xF8, 0xF9, 0xEF, 0x7C, 0x3E, 0x73, 0xDF, 0x07, 0xBC, 0xF7, 0xC1,
  0xFF, 0x3D, 0xF0, 0x7F, 0xC7, 0x7C, 0x1F, 0xF1, 0xDE, 0x07, 0xFC, 0x7F,
  0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0xBF, 0x1F, 0x8F, 0x8F, 0xC7,
  0xEF, 0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0xFD,
  0xF8, 0x7C, 0x7C, 0x7E, 0x3F, 0x3F, 0x0F, 0xBF, 0x07, 0xE0, 0xFC, 0x0F,
  0xDF, 0x03, 0xE7, 0xC1, 0xF9, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x80, 0xF7, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x8F, 0xF8, 0xFF, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x00, 0xB0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0x0F,
  0xF1, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x7F, 0x01,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_Condensed_ExtraBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 25, 9, 2, -25 },
  { 20, 13, 9, 17, 2, -25 },
  { 35, 18, 25, 20, 1, -25 },
  { 92, 15, 29, 18, 1, -27 },
  { 147, 27, 25, 29, 1, -25 },
  { 232, 22, 25, 23, 1, -25 },
  { 301, 5, 9, 9, 2, -25 },
  { 307, 10, 31, 12, 1, -25 },
  { 346, 9, 31, 12, 1, -25 },
  { 381, 15, 16, 17, 1, -27 },
  { 411, 16, 17, 18, 1, -21 },
  { 445, 7, 10, 9, 1, -5 },
  { 454, 9, 5, 11, 1, -12 },
  { 460, 6, 6, 9, 2, -6 },
  { 465, 14, 25, 15, 0, -25 },
  { 509, 16, 25, 18, 1, -25 },
  { 559, 12, 25, 18, 2, -25 },
  { 597, 15, 25, 18, 1, -25 },
  { 644, 15, 25, 18, 1, -25 },
  { 691, 16, 25, 18, 1, -25 },
  { 741, 14, 25, 18, 2, -25 },
  { 785, 16, 25, 18, 1, -25 },
  { 835, 16, 25, 18, 1, -25 },
  { 885, 16, 25, 18, 1, -25 },
  { 935, 16, 25, 18, 1, -25 },
  { 985, 6, 20, 10, 2, -20 },
  { 1000, 7, 25, 10, 1, -20 },
  { 1022, 16, 17, 18, 1, -21 },
  { 1056, 16, 11, 18, 1, -18 },
  { 1078, 16, 17, 18, 1, -21 },
  { 1112, 14, 25, 15, 0, -25 },
  { 1156, 25, 28, 28, 1, -25 },
  { 1244, 21, 25, 21, 0, -25 },
  { 1310, 17, 25, 20, 2, -25 },
  { 1364, 16, 25, 19, 2, -25 },
  { 1414, 18, 25, 22, 2, -25 },
  { 1471, 13, 25, 17, 2, -25 },
  { 1512, 13, 25, 16, 2, -25 },
  { 1553, 18, 25, 22, 2, -25 },
  { 1610, 18, 25, 23, 2, -25 },
  { 1667, 11, 25, 13, 1, -25 },
  { 1702, 10, 33, 10, -2, -25 },
  { 1744, 18, 25, 20, 2, -25 },
  { 1801, 13, 25, 16, 2, -25 },
  { 1842, 25, 25, 29, 2, -25 },
  { 1921, 20, 25, 24, 2, -25 },
  { 1984, 20, 25, 23, 2, -25 },
  { 2047, 16, 25, 19, 2, -25 },
  { 2097, 20, 31, 23, 2, -25 },
  { 2175, 18, 25, 20, 2, -25 },
  { 2232, 15, 25, 17, 1, -25 },
  { 2279, 15, 25, 17, 1, -25 },
  { 2326, 18, 25, 22, 2, -25 },
  { 2383, 20, 25, 20, 0, -25 },
  { 2446, 30, 25, 30, 0, -25 },
  { 2540, 19, 25, 19, 0, -25 },
  { 2600, 19, 25, 19, 0, -25 },
  { 2660, 15, 25, 17, 1, -25 },
  { 2707, 8, 31, 11, 2, -25 },
  { 2738, 14, 25, 15, 0, -25 },
  { 2782, 8, 31, 11, 1, -25 },
  { 2813, 18, 16, 19, 0, -25 },
  { 2849, 16, 3, 16, 0, 3 },
  { 2855, 10, 6, 12, 1, -27 },
  { 2863, 15, 20, 18, 1, -20 },
  { 2901, 16, 27, 19, 2, -27 },
  { 2955, 14, 20, 16, 1, -20 },
  { 2990, 16, 27, 19, 1, -27 },
  { 3044, 16, 20, 18, 1, -20 },
  { 3084, 13, 27, 12, 0, -27 },
  { 3128, 16, 28, 19, 1, -20 },
  { 3184, 16, 27, 20, 2, -27 },
  { 3238, 6, 27, 9, 2, -27 },
  { 3259, 9, 35, 9, -1, -27 },
  { 3299, 17, 27, 19, 2, -27 },
  { 3357, 5, 27, 9, 2, -27 },
  { 3374, 25, 20, 29, 2, -20 },
  { 3437, 16, 20, 20, 2, -20 },
  { 3477, 17, 20, 19, 1, -20 },
  { 3520, 16, 28, 19, 2, -20 },
  { 3576, 16, 28, 19, 1, -20 },
  { 3632, 11, 20, 14, 2, -20 },
  { 3660, 13, 20, 15, 1, -20 },
  { 3693, 12, 23, 13, 0, -23 },
  { 3728, 15, 19, 20, 2, -19 },
  { 3764, 18, 19, 18, 0, -19 },
  { 3807, 26, 19, 27, 0, -19 },
  { 3869, 17, 19, 17, 0, -19 },
  { 3910, 18, 27, 18, 0, -19 },
  { 3971, 13, 19, 14, 1, -19 },
  { 4002, 12, 31, 13, 0, -25 },
  { 4049, 4, 35, 16, 6, -27 },
  { 4067, 12, 31, 13, 1, -25 },
  { 4114, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_Condensed_ExtraBold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD35PT7B_H_
