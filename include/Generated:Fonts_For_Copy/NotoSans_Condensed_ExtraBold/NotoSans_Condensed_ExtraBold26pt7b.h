#ifndef _NOTOSANS_CONDENSED_EXTRABOLD26PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEE, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xFF,
  0xDC, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0x73, 0xDC, 0xF7, 0x3C, 0x0E, 0x70,
  0x73, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1D,
  0xC0, 0xCE, 0x0E, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE6, 0x07, 0x70,
  0x33, 0x83, 0x9C, 0x1C, 0xE0, 0x06, 0x00, 0xC0, 0x7E, 0x3F, 0xF7, 0xFD,
  0xED, 0xBD, 0x87, 0xB0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F,
  0xE1, 0xBE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x38, 0x0E, 0x07, 0xE0, 0xE0, 0xFE, 0x0E, 0x0E, 0xF1, 0xC0, 0xE7, 0x1C,
  0x0E, 0x73, 0x80, 0xE7, 0x38, 0x0E, 0x77, 0x00, 0xE7, 0x77, 0xCF, 0xEE,
  0x7E, 0x7E, 0xEF, 0x73, 0x8E, 0xE7, 0x01, 0xCE, 0x70, 0x1C, 0xE7, 0x03,
  0x8E, 0x70, 0x38, 0xE7, 0x07, 0x0F, 0xF0, 0x70, 0x7E, 0x0E, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x79, 0xE0, 0x79, 0xE0, 0x79, 0xE0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x1E, 0x7F, 0x9E, 0xFF, 0xFE,
  0xF3, 0xFC, 0xF1, 0xFC, 0xF1, 0xF8, 0xF9, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0x9F, 0xFF, 0xFF, 0x77, 0x70, 0x0E, 0x38, 0xF1, 0xC7, 0x8F, 0x1C,
  0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xF1, 0xE1, 0xC3,
  0xC3, 0x87, 0x80, 0xF0, 0xF0, 0xE1, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0x8F, 0x3C, 0x00,
  0x0E, 0x01, 0xC0, 0x38, 0x67, 0x2F, 0xFF, 0xFF, 0xCF, 0xE1, 0xF8, 0x3F,
  0x8F, 0x78, 0xC6, 0x08, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7B, 0xBD,
  0xEF, 0x70, 0xFF, 0xFF, 0xFF, 0x77, 0xFE, 0xE0, 0x01, 0xE0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x00, 0x0E,
  0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7B, 0xDF, 0x7F, 0xC7, 0xF0,
  0x7C, 0x00, 0x03, 0x83, 0xC3, 0xE3, 0xF3, 0xFF, 0xFD, 0xDE, 0x4F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x1E, 0x0F, 0xF3, 0xFF, 0x7F, 0xE6, 0x3E, 0x83, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xF3, 0xFF, 0x3F, 0xF4, 0x1E, 0x03, 0xC0,
  0x70, 0x3E, 0x3F, 0x87, 0xE0, 0xFF, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7E,
  0x1F, 0xFF, 0xDF, 0xFB, 0xFC, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xBC, 0x1D, 0xE1, 0xCF, 0x1E, 0x78,
  0xE3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0x80, 0xE0, 0x1C, 0x03, 0xF8,
  0x7F, 0xCF, 0xF9, 0x9F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7E, 0x1F, 0xFF,
  0xDF, 0xF9, 0xFC, 0x00, 0x03, 0xC3, 0xF8, 0xFF, 0x3F, 0xE7, 0x80, 0xE0,
  0x3C, 0x07, 0xBC, 0xFF, 0xDF, 0xFF, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7B, 0xCF, 0x7F, 0xE7, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07,
  0xF9, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xDE, 0x7B, 0xFE, 0x3F, 0x87, 0xE1,
  0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0x8F, 0xFF, 0xEF, 0xF8, 0xFE,
  0x00, 0x1E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFF, 0xFD, 0xFF, 0xBF, 0x71, 0x9E, 0x03, 0xC0, 0xF0, 0x3E, 0x7F,
  0x8F, 0xE1, 0xF8, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xFF,
  0xB8, 0x7F, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xBB, 0xDE, 0xE0,
  0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xF9, 0xFC, 0x3E, 0x07, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x78, 0x3F, 0x1F, 0xCF, 0xE3, 0xF0, 0x70, 0x08, 0x00, 0x1E,
  0x1F, 0xEF, 0xFD, 0xFF, 0x43, 0xC0, 0xF0, 0x3C, 0x1F, 0x0F, 0x87, 0xC1,
  0xE0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x81, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xE1,
  0xF3, 0x9C, 0xFF, 0x77, 0x3C, 0xE6, 0xE7, 0x1C, 0xDC, 0xE3, 0x9F, 0x9C,
  0xE3, 0x73, 0x9C, 0x6E, 0x73, 0x9D, 0xCE, 0x7B, 0xB8, 0xFB, 0xE3, 0x8E,
  0x78, 0x70, 0x00, 0x07, 0x00, 0x40, 0x7C, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x3E, 0x78, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xFE, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF1, 0xFF, 0x1F,
  0xF1, 0xEF, 0x3E, 0xFF, 0xCF, 0xFC, 0xFF, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xFF, 0x3F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x07, 0xC1, 0xFF, 0x3F,
  0xF3, 0xFF, 0x7C, 0x27, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xE3, 0x3F, 0xF1, 0xFF, 0x0F,
  0xE0, 0xFC, 0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xCF, 0x1F, 0x78, 0x7B, 0xC3,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7B,
  0xC7, 0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE, 0x7C,
  0x09, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF9, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE,
  0x7F, 0xF8, 0x3D, 0xE0, 0xF7, 0x83, 0xDF, 0x8F, 0x3F, 0xFC, 0x7F, 0xF0,
  0xFF, 0x80, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xFF, 0xFF,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0xFE, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0xFE, 0xFE, 0xFC, 0x70, 0xF0, 0x7F, 0x87, 0xBC, 0x7D, 0xE3, 0xCF,
  0x3E, 0x79, 0xE3, 0xDE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF,
  0x0F, 0x3C, 0x79, 0xE3, 0xCF, 0x9E, 0x3C, 0xF1, 0xF7, 0x87, 0xBC, 0x3E,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFE,
  0xE1, 0xFF, 0xB8, 0xFF, 0xFF, 0x3B, 0xFD, 0xCE, 0xFF, 0x73, 0xBF, 0xDD,
  0xCF, 0xF7, 0xF3, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0xCF, 0x8F, 0xF3, 0xE3,
  0xFC, 0x78, 0xFF, 0x1E, 0x3C, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFE, 0x3F, 0xF8, 0xFE, 0xF3, 0xFB, 0xCF, 0xEF, 0xBF, 0xDE, 0x7F, 0x79,
  0xFC, 0xF7, 0xF3, 0xDF, 0xC7, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3,
  0xCF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x81, 0xEF, 0x07, 0xDE, 0x0F, 0x3F, 0x3E, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xE1, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x07, 0xDE, 0x0F, 0x3F, 0x3E,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0xFC, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0x1E, 0x78, 0xF3,
  0xC7, 0x9E, 0x3C, 0xF3, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0x78, 0x79,
  0xE3, 0xCF, 0x9E, 0x3C, 0xF1, 0xF7, 0x87, 0xBC, 0x3E, 0x0F, 0x07, 0xFD,
  0xFF, 0x7F, 0xEF, 0x09, 0xE0, 0x3C, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0xF7, 0xBE, 0xFF, 0xDF, 0xF1, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0x3E, 0x7F, 0xF3, 0xFF, 0x07, 0xF0,
  0xF0, 0x1F, 0xE0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x8F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xDE, 0x1E, 0x1E, 0x78,
  0xFC, 0x79, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1C, 0x39, 0xFC,
  0xF0, 0xF7, 0x7B, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xE0,
  0x77, 0x3B, 0x81, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7D, 0xE1, 0xE7, 0xC7, 0x8F, 0x3C,
  0x3C, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3E, 0x7C, 0x79, 0xE1,
  0xFF, 0x83, 0xC0, 0xF0, 0x3F, 0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0x3C, 0xF0,
  0xF3, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF,
  0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xCE, 0x07, 0x38,
  0x38, 0xF0, 0xE1, 0xC7, 0x87, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0xF0, 0xF0, 0x02, 0x0F, 0xF1, 0xFF, 0x1F, 0xF2, 0x1E, 0x03, 0xC7, 0xFB,
  0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0xFF, 0xFD, 0xDF, 0x38, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC4, 0x3B, 0xE7, 0xFE, 0xFF, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0xFB,
  0xFF, 0x77, 0xC0, 0x02, 0x07, 0xF7, 0xFD, 0xFE, 0xF8, 0xBC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE3, 0x7F, 0xDF, 0xF1, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x8F, 0x3E, 0xF7, 0xFF, 0x7F, 0xFF,
  0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7,
  0xFF, 0x7F, 0xF3, 0xEF, 0x04, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0x1F, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x7C, 0x17, 0xFE, 0x7F, 0xC7,
  0xF0, 0x0F, 0xC7, 0xE3, 0xF8, 0xFA, 0x3C, 0x0F, 0x07, 0xFB, 0xFE, 0xFF,
  0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x08, 0x03, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF, 0x3E,
  0xF0, 0x0F, 0x00, 0xF4, 0x1E, 0x7F, 0xE7, 0xFC, 0x7F, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC4, 0x3B, 0xF7, 0xFE, 0xFF, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xF0, 0x77, 0xFE, 0xE0, 0x01, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE0, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x07, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x7E,
  0xFD, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1,
  0xFF, 0x3E, 0xF3, 0xCF, 0x78, 0xEF, 0x8E, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x8F, 0x7C, 0xF3, 0xCF, 0x3E, 0xF1, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x04, 0x3B, 0xF7, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xE1, 0xE3,
  0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE,
  0x1E, 0x3C, 0x02, 0x1D, 0xFB, 0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x78, 0x02,
  0x03, 0xF8, 0x7F, 0xE7, 0xFE, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x03, 0x1D,
  0xF3, 0xBF, 0x7F, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC7, 0xF9, 0xFF, 0xFD, 0xDF, 0xBB, 0xE7, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x08, 0x03, 0xEF, 0x7F, 0xF7, 0xFF, 0xF9, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF7, 0xFF,
  0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x02,
  0xEF, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x08, 0x3F, 0xFF, 0xFF, 0xEF, 0x17, 0xC3, 0xF0, 0xFE, 0x3F,
  0x87, 0xC1, 0xF0, 0xFF, 0xFF, 0xFB, 0xF8, 0x1C, 0x0E, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE4, 0xFE,
  0x7F, 0x1F, 0x80, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x79, 0xF7, 0xFF, 0x7F, 0x73, 0xE7,
  0xF0, 0x7B, 0xC7, 0x9E, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0xF0, 0xF7, 0x87,
  0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF1,
  0xF1, 0xF7, 0x1F, 0x1E, 0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xC3,
  0xBB, 0xBC, 0x3B, 0xBB, 0xC3, 0xF9, 0xBC, 0x3F, 0x9F, 0x83, 0xF9, 0xF8,
  0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF0, 0xF0, 0xF8, 0xFB,
  0xCF, 0x8F, 0x78, 0x7B, 0xC1, 0xFC, 0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0xC1, 0xFE, 0x0F, 0x78, 0xFB, 0xC7, 0x8F, 0x7C, 0x7C, 0xF0, 0x7B, 0xC7,
  0x9E, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0xF0, 0xF7, 0x83, 0xBC, 0x1D, 0xC0,
  0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xF0,
  0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0x87,
  0xC7, 0xE3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x3F, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF8, 0x7C, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3F,
  0x0F, 0x1F, 0x3E, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xF0,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 10, 7, 12, 1, -19 },
  { 22, 13, 19, 15, 1, -19 },
  { 53, 11, 22, 13, 1, -20 },
  { 84, 20, 19, 22, 1, -19 },
  { 132, 16, 19, 17, 1, -19 },
  { 170, 4, 7, 7, 1, -19 },
  { 174, 7, 23, 9, 1, -19 },
  { 195, 7, 23, 9, 0, -19 },
  { 216, 11, 12, 13, 1, -20 },
  { 233, 11, 12, 13, 1, -15 },
  { 250, 5, 6, 7, 1, -3 },
  { 254, 6, 4, 8, 1, -9 },
  { 257, 5, 4, 7, 1, -4 },
  { 260, 11, 19, 11, 0, -19 },
  { 287, 11, 19, 13, 1, -19 },
  { 314, 9, 19, 13, 1, -19 },
  { 336, 11, 19, 13, 1, -19 },
  { 363, 11, 19, 13, 1, -19 },
  { 390, 13, 19, 13, 0, -19 },
  { 421, 11, 19, 13, 1, -19 },
  { 448, 11, 19, 13, 1, -19 },
  { 475, 11, 19, 13, 1, -19 },
  { 502, 11, 19, 13, 1, -19 },
  { 529, 11, 19, 13, 1, -19 },
  { 556, 5, 14, 7, 1, -14 },
  { 565, 5, 17, 7, 1, -14 },
  { 576, 11, 13, 13, 1, -16 },
  { 594, 11, 8, 13, 1, -13 },
  { 605, 11, 13, 13, 1, -16 },
  { 623, 10, 19, 11, 0, -19 },
  { 647, 19, 21, 21, 1, -19 },
  { 697, 16, 19, 16, 0, -19 },
  { 735, 12, 19, 15, 2, -19 },
  { 764, 12, 19, 14, 1, -19 },
  { 793, 13, 19, 16, 2, -19 },
  { 824, 9, 19, 12, 2, -19 },
  { 846, 9, 19, 12, 2, -19 },
  { 868, 14, 19, 16, 1, -19 },
  { 902, 13, 19, 17, 2, -19 },
  { 933, 8, 19, 9, 1, -19 },
  { 952, 8, 25, 8, -2, -19 },
  { 977, 13, 19, 15, 2, -19 },
  { 1008, 9, 19, 12, 2, -19 },
  { 1030, 18, 19, 22, 2, -19 },
  { 1073, 14, 19, 18, 2, -19 },
  { 1107, 15, 19, 17, 1, -19 },
  { 1143, 11, 19, 14, 2, -19 },
  { 1170, 15, 23, 17, 1, -19 },
  { 1214, 13, 19, 15, 2, -19 },
  { 1245, 11, 19, 12, 1, -19 },
  { 1272, 12, 19, 13, 0, -19 },
  { 1301, 13, 19, 16, 2, -19 },
  { 1332, 15, 19, 15, 0, -19 },
  { 1368, 22, 19, 22, 0, -19 },
  { 1421, 14, 19, 14, 0, -19 },
  { 1455, 14, 19, 14, 0, -19 },
  { 1489, 11, 19, 13, 1, -19 },
  { 1516, 7, 23, 8, 1, -19 },
  { 1537, 11, 19, 11, 0, -19 },
  { 1564, 6, 23, 8, 1, -19 },
  { 1582, 14, 12, 14, 0, -19 },
  { 1603, 12, 2, 12, 0, 2 },
  { 1606, 7, 4, 9, 1, -20 },
  { 1610, 11, 15, 13, 1, -15 },
  { 1631, 11, 20, 14, 2, -20 },
  { 1659, 10, 15, 12, 1, -15 },
  { 1678, 12, 20, 14, 1, -20 },
  { 1708, 11, 15, 13, 1, -15 },
  { 1729, 10, 20, 9, 0, -20 },
  { 1754, 12, 21, 14, 1, -15 },
  { 1786, 11, 20, 14, 2, -20 },
  { 1814, 5, 20, 7, 1, -20 },
  { 1827, 7, 26, 7, -1, -20 },
  { 1850, 12, 20, 14, 2, -20 },
  { 1880, 3, 20, 7, 2, -20 },
  { 1888, 18, 15, 22, 2, -15 },
  { 1922, 11, 15, 14, 2, -15 },
  { 1943, 12, 15, 14, 1, -15 },
  { 1966, 11, 21, 14, 2, -15 },
  { 1995, 12, 21, 14, 1, -15 },
  { 2027, 8, 15, 10, 2, -15 },
  { 2042, 9, 15, 11, 1, -15 },
  { 2059, 9, 17, 10, 0, -17 },
  { 2079, 12, 14, 14, 1, -14 },
  { 2100, 13, 14, 13, 0, -14 },
  { 2123, 20, 14, 20, 0, -14 },
  { 2158, 13, 14, 13, 0, -14 },
  { 2181, 13, 20, 13, 0, -14 },
  { 2214, 9, 14, 11, 1, -14 },
  { 2230, 9, 23, 10, 0, -19 },
  { 2256, 4, 26, 12, 4, -20 },
  { 2269, 8, 23, 10, 1, -19 },
  { 2292, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraBold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD26PT7B_H_
