#ifndef _NOTOSANS_CONDENSED_EXTRABOLD54PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0xFE, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x30, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x03,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xF7, 0xE7, 0xF9, 0xE1,
  0xCF, 0xF3, 0xC0, 0x1F, 0xE7, 0x80, 0x3F, 0xCF, 0x00, 0x7F, 0x9E, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xF7, 0xF8, 0x01, 0xE7, 0xF0, 0x03,
  0xCF, 0xF0, 0x07, 0x9F, 0xF0, 0x0F, 0x3F, 0xFC, 0x1E, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xC1, 0xF8,
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x7F, 0x07, 0x80, 0x7E,
  0x1F, 0x8F, 0xC3, 0xFE, 0x0F, 0xE7, 0xF3, 0xF8, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7E, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xCF, 0xFF, 0xC3, 0xFF, 0xF3, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFC, 0x7E, 0x3F, 0x3F, 0x83, 0xFF, 0x1F, 0x8F, 0xE3,
  0xF0, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x0F, 0xE0,
  0x00, 0x1F, 0x87, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0xFE, 0x00, 0x07, 0xE0,
  0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x01, 0xFC,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x03, 0xF3, 0xF8,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xF8,
  0x3F, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0xC3, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xE7, 0xF8, 0x7F, 0xCF, 0xFF,
  0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xFF, 0xC3, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xFE, 0x07, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFC, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x02, 0x70, 0x7E, 0x0E, 0x7E, 0x7E,
  0x7E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xC3,
  0xFC, 0x0F, 0xC3, 0xF8, 0x07, 0x81, 0xE0, 0x01, 0x81, 0xC0, 0x00, 0x81,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xCF, 0xF3, 0xFD, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xE3,
  0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8,
  0x1F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE0, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xF7, 0xF9, 0xFE, 0x7E, 0x3F, 0xC7, 0x87, 0xF8, 0x60, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0x87, 0xFE, 0x1E, 0x03, 0xFE, 0x0C, 0x01, 0xFE,
  0x08, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F,
  0x07, 0xFE, 0x18, 0x07, 0xFC, 0x20, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xA0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xEF,
  0xF0, 0x01, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x3F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x07, 0xE7, 0xFC, 0x03, 0xF9, 0xFF, 0x00, 0xFC, 0x7F, 0xC0,
  0x7F, 0x1F, 0xF0, 0x3F, 0x87, 0xFC, 0x0F, 0xC1, 0xFF, 0x07, 0xF0, 0x7F,
  0xC1, 0xF8, 0x1F, 0xF0, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xA0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0x7F, 0xF0, 0xFF, 0x7F, 0xF8, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xEF,
  0xFC, 0x7F, 0x83, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xEF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0x83, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0xFF, 0xC7, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFE,
  0xFE, 0x1F, 0xFC, 0xFE, 0x0F, 0xF8, 0xFE, 0x03, 0xE1, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x30, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x02, 0x80, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xF8, 0x20, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFC,
  0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xF7,
  0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x3F, 0xCF, 0xE3, 0xF8,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0x83, 0xFE,
  0x38, 0x07, 0xFC, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0x07, 0xE1, 0xFC, 0x0F,
  0xFF, 0x8F, 0xC3, 0xF0, 0x7F, 0xFF, 0x0F, 0xC7, 0xE0, 0xFF, 0xFE, 0x1F,
  0x9F, 0x83, 0xFF, 0xFC, 0x3F, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x7E, 0x1F,
  0x83, 0xF0, 0x7C, 0xF8, 0x7F, 0x07, 0xE0, 0xFB, 0xF0, 0xFC, 0x0F, 0xC1,
  0xFF, 0xE1, 0xF8, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0x87,
  0xE0, 0x7E, 0x0F, 0xBF, 0x0F, 0xC0, 0xFC, 0x1F, 0x7E, 0x1F, 0x81, 0xF8,
  0x7E, 0xFC, 0x3F, 0x03, 0xF0, 0xFD, 0xF8, 0x7E, 0x0F, 0xE1, 0xFB, 0xF0,
  0xFE, 0x1F, 0xC3, 0xE7, 0xE0, 0xFC, 0x7F, 0xCF, 0xC7, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC3, 0xFF, 0xDF, 0xFE, 0x1F, 0x83, 0xFF, 0x9F, 0xF8, 0x3F,
  0x83, 0xFE, 0x1F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFE, 0x0F, 0xFE, 0xFF,
  0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xEF,
  0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xF9, 0xFE, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xFD, 0xFE, 0x03,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF0, 0x7C, 0x1F, 0xF8, 0x03, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x10, 0x7F, 0xF0, 0x1C, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0x03, 0xFF, 0x9F, 0xE0, 0x3F, 0xF3, 0xFC, 0x03, 0xFF, 0x7F,
  0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x0F, 0xFD,
  0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0xE7, 0xF8, 0x7F, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x7C, 0x3F, 0xF8, 0x01, 0x8F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF8, 0x07,
  0xF9, 0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8,
  0xFF, 0xE1, 0xFF, 0x81, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xEF, 0xF0, 0x0F, 0xF9, 0xFE,
  0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xFE,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0x8F, 0xFC, 0x0F, 0xF1,
  0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF8, 0x07, 0xFB, 0xFE, 0x00,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xFC, 0x3F,
  0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F,
  0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xF7, 0xFF, 0xEF, 0xE0, 0x1F, 0xBF, 0xFF, 0x7F, 0x01, 0xFD,
  0xFF, 0xFB, 0xF8, 0x0F, 0xEF, 0xFF, 0xCF, 0xC0, 0x7E, 0x7F, 0xFE, 0x7F,
  0x07, 0xF3, 0xFF, 0xF3, 0xF8, 0x3F, 0xBF, 0xFF, 0xDF, 0xC1, 0xF9, 0xFF,
  0xFE, 0x7F, 0x0F, 0xCF, 0xFF, 0xF3, 0xF8, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7,
  0xF3, 0xFF, 0xFC, 0xFE, 0x3F, 0x1F, 0xFF, 0xE3, 0xFB, 0xF8, 0xFF, 0xFF,
  0x1F, 0xDF, 0xC7, 0xFF, 0xF8, 0xFE, 0xFE, 0x3F, 0xFF, 0xC7, 0xF7, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF,
  0x81, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFB, 0xFC,
  0x0F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0x9F, 0xE0, 0xFF, 0xFE, 0x7F, 0xC3,
  0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF, 0x87, 0xF8, 0xFF,
  0xFF, 0x1F, 0xE3, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF,
  0xC3, 0xFE, 0xFF, 0xFF, 0x07, 0xFB, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0,
  0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xA0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x01,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF,
  0x8F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xF8, 0xFF,
  0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F,
  0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE3, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x81,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x03,
  0xFE, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFE, 0x7F, 0x80, 0x7F, 0xCF,
  0xF0, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFD, 0xFC, 0xFF, 0x80, 0x73, 0xFE,
  0x00, 0x4F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0x03, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFD, 0xFF,
  0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x50, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x8F,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0xFF,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xBF, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF9, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xC3, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x0F,
  0xF0, 0x1F, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xF8, 0x1F, 0xE0, 0x7F,
  0x83, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xDF, 0x81, 0xFE, 0x07, 0xF8,
  0x3F, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFD, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xF7, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xCF, 0xC3, 0xFC, 0x03, 0xFC, 0x7F,
  0x3F, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xE3,
  0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x8F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x1F,
  0x9F, 0xE0, 0x07, 0xFB, 0xF8, 0x7E, 0x7F, 0x80, 0x1F, 0xEF, 0xE1, 0xF9,
  0xFC, 0x00, 0x7F, 0xBF, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0xFC, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF9,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x3F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x83, 0xE1, 0xFF, 0x06, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFB, 0xFF, 0xE7, 0xF3, 0xFF, 0x8F, 0xE3, 0xFE, 0x0F, 0xC0,
  0x60, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFC, 0x0F, 0xF3, 0xFF, 0x07, 0xFB, 0xFF, 0xC3, 0xFD,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xF0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB,
  0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFB, 0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xE0,
  0xFF, 0xBF, 0xFC, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFD, 0xFF, 0xE1, 0xFC, 0x7F, 0xE0, 0xFE, 0x1F, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFC, 0x0C,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x05, 0xFF, 0x00, 0xCF, 0xFE, 0x3E, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x7F, 0x1F, 0xF0, 0xFF, 0xCF, 0xF8, 0xFF, 0xF7, 0xFC, 0x7F, 0xFD, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xF0, 0x7F,
  0xEF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0xFF, 0xDF,
  0xF9, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFD, 0xFE, 0x1F, 0xFC, 0xFF, 0x07, 0xFC, 0x3F, 0x80, 0x70, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x04, 0x7F, 0xE0,
  0x1C, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x07, 0xFE, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xC3, 0xFF, 0x9F, 0xE3, 0xFF, 0xEF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0x83,
  0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFD, 0xFF, 0x07, 0xFE,
  0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xDF, 0xF0, 0xFF, 0xEF, 0xF8, 0x3F, 0xC7, 0xF8, 0x01, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x98, 0x00,
  0x7F, 0xCF, 0x80, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0xFF, 0x3F, 0xF8, 0xFF, 0x7F, 0xFC, 0xFF, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xC0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x3F, 0xCF, 0xF8, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0x83, 0xFE, 0x3F, 0xE0,
  0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F,
  0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xFB, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0xF8, 0xFE, 0x7F, 0xFC, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF7, 0xF8,
  0x0F, 0xFB, 0xFC, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0x7F, 0xC7, 0xFE, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x0F, 0xE0,
  0x7F, 0x1F, 0xF8, 0x3F, 0x9F, 0xFE, 0x1F, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x83, 0xFE, 0xFF, 0x81,
  0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF,
  0xF8, 0x0F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFF, 0x07, 0xFD, 0xFF, 0xEF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF,
  0x0F, 0xF3, 0xFF, 0x87, 0xF8, 0xFF, 0x03, 0xFC, 0x04, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xC3, 0xFF, 0x9F, 0xE3, 0xFF, 0xEF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0x83,
  0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFD, 0xFF, 0x07, 0xFE,
  0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xDF,
  0xE3, 0xFF, 0xDF, 0xF0, 0xFF, 0xEF, 0xF8, 0x3F, 0xC7, 0xFC, 0x01, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0xFE, 0x0F, 0xFF, 0x87, 0xEF, 0xE3, 0xFB, 0xF9, 0xFE,
  0xFE, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xF8, 0xBF,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xC1, 0xE7, 0xF8, 0x0C, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xA0,
  0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x71, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x18,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0x3F, 0xFE,
  0x7F, 0x1F, 0xFC, 0x7F, 0x0F, 0xF8, 0x7F, 0x00, 0x80, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7,
  0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07,
  0xF0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF7, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x7F,
  0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xE7, 0xF8, 0x1F, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xEF, 0x83, 0xFC, 0x3F, 0xC3, 0xF7,
  0xE1, 0xFE, 0x0F, 0xE1, 0xFB, 0xF0, 0xFE, 0x07, 0xF8, 0xFD, 0xF8, 0xFF,
  0x03, 0xFC, 0x7E, 0xFC, 0x7F, 0x81, 0xFE, 0x7E, 0x7E, 0x3F, 0xC0, 0xFF,
  0x3F, 0x1F, 0x9F, 0xC0, 0x3F, 0x9F, 0x8F, 0xCF, 0xE0, 0x1F, 0xCF, 0xC7,
  0xEF, 0xF0, 0x0F, 0xF7, 0xE3, 0xF7, 0xF8, 0x07, 0xFB, 0xF1, 0xFB, 0xFC,
  0x01, 0xFD, 0xF0, 0x7D, 0xFC, 0x00, 0xFF, 0xF8, 0x3E, 0xFE, 0x00, 0x7F,
  0xFC, 0x1F, 0x7F, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8,
  0xFF, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0xE0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF8, 0x1F, 0xF1, 0xFF, 0x07,
  0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFD, 0xFE,
  0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x3F,
  0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80,
  0x00, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 40, 15, 3, -39 },
  { 46, 20, 14, 26, 3, -39 },
  { 81, 28, 39, 30, 1, -39 },
  { 218, 23, 44, 27, 2, -41 },
  { 345, 43, 39, 45, 1, -39 },
  { 555, 34, 40, 35, 1, -39 },
  { 725, 8, 14, 14, 3, -39 },
  { 739, 15, 48, 18, 2, -39 },
  { 829, 14, 48, 18, 1, -39 },
  { 913, 24, 24, 26, 1, -41 },
  { 985, 24, 26, 28, 2, -32 },
  { 1063, 10, 14, 15, 2, -7 },
  { 1081, 14, 7, 17, 2, -18 },
  { 1094, 9, 10, 15, 3, -9 },
  { 1106, 22, 39, 23, 0, -39 },
  { 1214, 23, 40, 27, 2, -39 },
  { 1329, 19, 39, 27, 2, -39 },
  { 1422, 24, 39, 27, 1, -39 },
  { 1539, 23, 40, 27, 2, -39 },
  { 1654, 26, 39, 27, 1, -39 },
  { 1781, 22, 40, 27, 3, -39 },
  { 1891, 24, 40, 27, 2, -39 },
  { 2011, 24, 39, 27, 2, -39 },
  { 2128, 24, 40, 27, 2, -39 },
  { 2248, 24, 40, 27, 2, -39 },
  { 2368, 9, 31, 15, 3, -30 },
  { 2403, 10, 37, 15, 2, -30 },
  { 2450, 24, 27, 28, 2, -33 },
  { 2531, 24, 18, 28, 2, -28 },
  { 2585, 24, 27, 28, 2, -33 },
  { 2666, 22, 40, 22, 0, -39 },
  { 2776, 39, 43, 43, 2, -39 },
  { 2986, 32, 39, 32, 0, -39 },
  { 3142, 25, 39, 31, 4, -39 },
  { 3264, 26, 40, 29, 2, -39 },
  { 3394, 27, 39, 33, 4, -39 },
  { 3526, 19, 39, 26, 4, -39 },
  { 3619, 19, 39, 25, 4, -39 },
  { 3712, 27, 40, 34, 3, -39 },
  { 3847, 27, 39, 35, 4, -39 },
  { 3979, 17, 39, 19, 1, -39 },
  { 4062, 15, 51, 16, -3, -39 },
  { 4158, 27, 39, 31, 4, -39 },
  { 4290, 20, 39, 25, 4, -39 },
  { 4388, 37, 39, 45, 4, -39 },
  { 4569, 30, 39, 38, 4, -39 },
  { 4716, 31, 40, 36, 2, -39 },
  { 4871, 23, 39, 29, 4, -39 },
  { 4984, 31, 48, 36, 2, -39 },
  { 5170, 27, 39, 31, 4, -39 },
  { 5302, 22, 40, 26, 2, -39 },
  { 5412, 24, 39, 26, 1, -39 },
  { 5529, 27, 40, 34, 4, -39 },
  { 5664, 31, 39, 31, 0, -39 },
  { 5816, 46, 39, 46, 0, -39 },
  { 6041, 30, 39, 30, 0, -39 },
  { 6188, 29, 39, 29, 0, -39 },
  { 6330, 24, 39, 26, 1, -39 },
  { 6447, 13, 48, 17, 3, -39 },
  { 6525, 22, 39, 23, 0, -39 },
  { 6633, 13, 48, 17, 1, -39 },
  { 6711, 27, 25, 29, 1, -39 },
  { 6796, 24, 5, 24, 0, 4 },
  { 6811, 14, 8, 19, 2, -41 },
  { 6825, 23, 31, 28, 2, -30 },
  { 6915, 25, 42, 30, 3, -41 },
  { 7047, 21, 31, 24, 2, -30 },
  { 7129, 25, 42, 30, 2, -41 },
  { 7261, 24, 31, 28, 2, -30 },
  { 7354, 19, 41, 18, 1, -41 },
  { 7452, 25, 43, 30, 2, -30 },
  { 7587, 24, 41, 30, 3, -41 },
  { 7710, 9, 41, 15, 3, -41 },
  { 7757, 14, 54, 15, -2, -41 },
  { 7852, 26, 41, 29, 3, -41 },
  { 7986, 8, 41, 15, 3, -41 },
  { 8027, 39, 30, 45, 3, -30 },
  { 8174, 24, 30, 30, 3, -30 },
  { 8264, 25, 31, 29, 2, -30 },
  { 8361, 25, 43, 30, 3, -30 },
  { 8496, 25, 43, 30, 2, -30 },
  { 8631, 18, 30, 21, 3, -30 },
  { 8699, 19, 31, 23, 2, -30 },
  { 8773, 18, 37, 20, 1, -36 },
  { 8857, 24, 31, 30, 3, -30 },
  { 8950, 27, 30, 27, 0, -30 },
  { 9052, 41, 30, 41, 0, -30 },
  { 9206, 26, 30, 27, 0, -30 },
  { 9304, 27, 43, 27, 0, -30 },
  { 9450, 20, 30, 22, 1, -30 },
  { 9525, 17, 48, 20, 1, -39 },
  { 9627, 7, 53, 25, 9, -41 },
  { 9674, 17, 48, 20, 2, -39 },
  { 9776, 24, 10, 28, 2, -24 },
};

const GFXfont NotoSans_Condensed_ExtraBold54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD54PT7B_H_
