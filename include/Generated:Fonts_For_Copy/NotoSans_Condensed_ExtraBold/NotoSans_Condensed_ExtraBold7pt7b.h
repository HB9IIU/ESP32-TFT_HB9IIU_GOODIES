#ifndef _NOTOSANS_CONDENSED_EXTRABOLD7PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xC0, 0xB4, 0x6F, 0x6F, 0x60, 0x79, 0xDE, 0xD3, 0x4E, 0x8D,
  0x68, 0x63, 0x15, 0x6F, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xEB, 0x80,
  0x5D, 0x00, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x76, 0xD6, 0x7C, 0x92, 0xE4,
  0xAE, 0xE5, 0x9E, 0x2E, 0xF2, 0x73, 0x9E, 0x73, 0xD6, 0xE4, 0xA4, 0x75,
  0xDE, 0x77, 0x9E, 0xC3, 0xC3, 0x80, 0x38, 0x80, 0xE3, 0x80, 0xC7, 0x00,
  0xE5, 0x04, 0x75, 0xF7, 0x74, 0x18, 0x66, 0x6F, 0x90, 0xED, 0xED, 0xE0,
  0x7C, 0x8C, 0x60, 0xED, 0xDD, 0xE0, 0xFB, 0xEE, 0xFB, 0xEC, 0x7C, 0xBD,
  0x70, 0xDD, 0xFD, 0xD0, 0xD5, 0xC0, 0xFF, 0xF8, 0xDE, 0xEE, 0xD0, 0xDB,
  0x6E, 0xCE, 0xEF, 0xFE, 0x80, 0xDF, 0xBF, 0xD0, 0x7D, 0x9D, 0x70, 0xEF,
  0xEC, 0xC0, 0x7D, 0x9D, 0x71, 0xEF, 0xEE, 0xD0, 0x71, 0x9E, 0xE9, 0x24,
  0xDD, 0xDD, 0x70, 0x99, 0x66, 0x60, 0xB6, 0xD7, 0x9E, 0x58, 0xB6, 0x66,
  0xB0, 0xB6, 0x64, 0x40, 0xE5, 0x2E, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70,
  0x46, 0xB0, 0xE0, 0xC0, 0x6E, 0xF0, 0x8A, 0xFB, 0xE0, 0x72, 0x30, 0x2E,
  0xD6, 0x77, 0x30, 0x79, 0x24, 0x76, 0xBA, 0xC0, 0x8A, 0xFB, 0xB0, 0xEA,
  0x80, 0xEA, 0xA8, 0x8B, 0xAE, 0xB0, 0xF8, 0xFF, 0xEB, 0x50, 0xAF, 0xBB,
  0x6A, 0xB6, 0xAF, 0xBE, 0x88, 0x76, 0xB2, 0x40, 0xBA, 0x40, 0xF9, 0xF0,
  0x75, 0x40, 0xBB, 0xB7, 0xBA, 0x64, 0xAD, 0xD6, 0xA0, 0xAD, 0xD0, 0xBA,
  0x64, 0x48, 0xE9, 0x70, 0x57, 0x50, 0xFE, 0xC9, 0x35, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 4, 0, -5 },
  { 9, 6, 5, 6, 0, -5 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 1, 2, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 2, 6, 2, 0, -5 },
  { 22, 3, 3, 3, 0, -5 },
  { 24, 3, 3, 4, 0, -4 },
  { 26, 2, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -2 },
  { 28, 2, 1, 2, 0, -1 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 4, 0, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 0, -5 },
  { 43, 3, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 0, -5 },
  { 47, 3, 5, 4, 0, -5 },
  { 49, 3, 5, 4, 0, -5 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 2, 5, 2, 0, -4 },
  { 54, 3, 3, 4, 0, -4 },
  { 56, 3, 3, 4, 0, -4 },
  { 58, 3, 3, 4, 0, -4 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 5, 6, 6, 0, -5 },
  { 66, 4, 5, 4, 0, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 3, 5, 3, 0, -5 },
  { 80, 3, 5, 3, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 5, 0, -5 },
  { 88, 2, 5, 3, 0, -5 },
  { 90, 2, 7, 2, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 3, 5, 3, 0, -5 },
  { 97, 5, 5, 6, 0, -5 },
  { 101, 4, 5, 5, 0, -5 },
  { 104, 4, 5, 5, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 6, 5, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 6, 5, 6, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 2, 6, 2, 0, -5 },
  { 140, 3, 5, 3, 0, -5 },
  { 142, 2, 6, 2, 0, -5 },
  { 144, 4, 3, 4, 0, -5 },
  { 146, 3, 1, 3, 0, 0 },
  { 147, 2, 1, 2, 0, -5 },
  { 148, 3, 4, 4, 0, -4 },
  { 150, 4, 5, 4, 0, -5 },
  { 153, 3, 4, 3, 0, -4 },
  { 155, 3, 5, 4, 0, -5 },
  { 157, 3, 4, 4, 0, -4 },
  { 159, 3, 5, 2, 0, -5 },
  { 161, 3, 6, 4, 0, -4 },
  { 164, 4, 5, 4, 0, -5 },
  { 167, 2, 5, 2, 0, -5 },
  { 169, 2, 7, 2, 0, -5 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 1, 5, 2, 0, -5 },
  { 175, 5, 4, 6, 0, -4 },
  { 178, 4, 4, 4, 0, -4 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 4, 6, 4, 0, -4 },
  { 185, 3, 6, 4, 0, -4 },
  { 188, 3, 4, 3, 0, -4 },
  { 190, 3, 4, 3, 0, -4 },
  { 192, 2, 5, 3, 0, -5 },
  { 194, 4, 4, 4, 0, -4 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 5, 4, 5, 0, -4 },
  { 201, 3, 4, 3, 0, -4 },
  { 203, 4, 6, 4, 0, -4 },
  { 206, 3, 4, 3, 0, -4 },
  { 208, 2, 6, 3, 0, -5 },
  { 210, 1, 7, 3, 1, -5 },
  { 211, 3, 6, 3, 0, -5 },
  { 214, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_ExtraBold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD7PT7B_H_
