#ifndef _NOTOSANS_CONDENSED_EXTRABOLD63PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC7, 0xFD, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xE3, 0xF8, 0x1C, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xC3, 0xFE, 0x7F,
  0x83, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x3F, 0xE7, 0x81, 0xCF, 0xF1, 0xE0, 0x13,
  0xFC, 0x78, 0x00, 0xFF, 0x1E, 0x00, 0x3F, 0xE7, 0x80, 0x0F, 0xF9, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xEF, 0xFC, 0x00, 0x79, 0xFF, 0x00, 0x1E, 0x3F, 0xC0, 0x07,
  0x8F, 0xF8, 0x01, 0xE3, 0xFF, 0x00, 0x78, 0xFF, 0xF0, 0x1E, 0x7F, 0xFF,
  0x87, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xE0, 0x1F, 0xC1, 0xFC, 0x7F,
  0x87, 0xFE, 0x0F, 0xF1, 0xFE, 0x3F, 0x87, 0xFF, 0x83, 0xF8, 0xFF, 0x1F,
  0xC7, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0x87,
  0xF1, 0xFE, 0x3F, 0x83, 0xFF, 0xC7, 0xF8, 0xFE, 0x1F, 0xC0, 0xFF, 0x83,
  0xF8, 0x7F, 0x0F, 0xF0, 0x06, 0x03, 0xFC, 0x3F, 0x87, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xF7, 0xFF, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x81, 0xFC, 0x0E,
  0x3F, 0x1F, 0x87, 0xE7, 0xFD, 0xFB, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x04, 0x02, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7,
  0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0x8F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7,
  0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFC, 0xFF, 0xCF,
  0xE3, 0xFF, 0x1F, 0x0F, 0xFC, 0x38, 0x3F, 0xF0, 0x40, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0xF8, 0xFC, 0x03, 0xFF, 0x0F,
  0x00, 0x7F, 0xE0, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0, 0x3F, 0xF8, 0x70, 0x03, 0xFF, 0x04,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF,
  0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0x8F, 0xF8,
  0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x1C, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x7F,
  0x9F, 0xFE, 0x0F, 0xF9, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xEF,
  0xFF, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFE,
  0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xFC, 0x7F, 0xF0, 0xFF,
  0xC7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFE, 0x0F, 0xFC, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0,
  0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7F, 0xF9, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xDF, 0xE1, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3,
  0xFE, 0x00, 0x78, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x3C, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x0F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xC7, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8,
  0xFE, 0x07, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF3, 0xFF, 0x3F, 0xE1, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xC7, 0x00, 0x7F,
  0xE2, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xE3, 0xF8,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0x3F,
  0x83, 0xFF, 0xFF, 0x83, 0xF9, 0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xDF, 0xC1,
  0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF7, 0xF0, 0xFF,
  0x03, 0xF8, 0x3F, 0xBF, 0x87, 0xF0, 0x1F, 0xC1, 0xFD, 0xFC, 0x3F, 0x80,
  0xFE, 0x0F, 0xEF, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x3F,
  0x83, 0xFF, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x0F, 0xE0,
  0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x07, 0xF8, 0x3F,
  0x3F, 0x07, 0xF0, 0x3F, 0xC1, 0xF9, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xCF,
  0xE0, 0xFF, 0x1F, 0xF9, 0xFC, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8,
  0x3F, 0xFF, 0xBF, 0xFE, 0x1F, 0xE0, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0x03,
  0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC,
  0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F,
  0xF3, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC,
  0x07, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0x0F, 0xFF,
  0x00, 0x18, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0x1F, 0xFF, 0x80, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7C, 0x1F, 0xFE, 0x00, 0x08, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xF0, 0x01,
  0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x3F, 0xFC, 0x01,
  0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xFC, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xCF, 0xFE, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x3F, 0xF0,
  0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xF8, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFB, 0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xFF,
  0xF9, 0xFE, 0x03, 0xFD, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0x9F, 0xFF, 0xF9,
  0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0x9F, 0xFF, 0xF8, 0xFF,
  0x07, 0xF9, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x1F, 0xFF, 0xFC, 0xFF, 0x0F,
  0xF1, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x8F, 0xE1,
  0xFF, 0xFF, 0xC7, 0xF9, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x9F, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFD, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xDF, 0xC1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xBF, 0xF0, 0x3F,
  0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF, 0xC7, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xCF,
  0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xE7, 0xFE,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0,
  0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFE, 0x1F, 0xC7, 0xFE, 0x00, 0xF1, 0xFF, 0x80, 0x08, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xA0, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF9,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x7F, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFE, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF7, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFD,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0xC0, 0x1F, 0xF1,
  0xFE, 0x3F, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF8,
  0x01, 0xFF, 0x1F, 0xE1, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFE, 0x0F, 0xE7,
  0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0x83,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF,
  0xE0, 0x7F, 0x7F, 0xC0, 0x01, 0xFE, 0xFE, 0x03, 0xFB, 0xFC, 0x00, 0x0F,
  0xF7, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0x07, 0x00, 0x7F, 0xE0, 0x80,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0x9F, 0xE3, 0xFF, 0xE1, 0xFC, 0x3F,
  0xF0, 0x3F, 0x80, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x8F, 0xFE, 0x0F, 0xF9,
  0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x0F, 0xFE, 0xFF,
  0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE,
  0x07, 0xFE, 0xFF, 0xF9, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xF0, 0xFF,
  0x1F, 0xFE, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xF8, 0x1C, 0x1F, 0xF8, 0x02, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x9F, 0xFE, 0x01, 0xC7, 0xFF,
  0xCF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0x0F, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0xF9,
  0xFF, 0x0F, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x3F, 0xFD, 0xFF,
  0xC0, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF,
  0xEF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0x87, 0xFF,
  0xE7, 0xFC, 0x1F, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE,
  0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xC3,
  0xFF, 0x80, 0x3C, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xFC, 0x7F, 0xC1, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFE,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF8, 0x7F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF,
  0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0,
  0x1F, 0xFB, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0x7F, 0xF9, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0xF8, 0x3F, 0xFC, 0xFF, 0xC0, 0x7F,
  0xC7, 0xFE, 0x00, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x30, 0x00, 0x3F, 0xF1,
  0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x8F,
  0xFE, 0x0F, 0xF9, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x3F, 0x8F, 0xF9,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3, 0xFE, 0x3F, 0x80, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC,
  0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x8F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F,
  0xF3, 0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xE3, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xFB,
  0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0x80,
  0xFF, 0xE3, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x8F, 0xF8,
  0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x00,
  0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x3F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF1, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0xCF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0xFE, 0x07, 0xFC, 0x0F,
  0xE1, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0x0F, 0xF3, 0xFF, 0xF8, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF0, 0xFF, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF,
  0xC7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9,
  0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01,
  0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F,
  0xE3, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF,
  0x0F, 0xF3, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0x0F, 0xF9, 0xFF,
  0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x0E, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x1F, 0xFC, 0x7F, 0xC1, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xDF, 0xF1,
  0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF8, 0x7F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xF8, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0x7F,
  0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xDF, 0xF8, 0x3F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xC7, 0xFE, 0x00, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xE0, 0xF8, 0xFF, 0x80, 0x31, 0xFF, 0x00, 0x23, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x43, 0xFF, 0xDE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x03, 0x40, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0x9F, 0xE3, 0xFF, 0xE1, 0xFC, 0x1F,
  0xF8, 0x3F, 0x80, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFB, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0x07,
  0xFE, 0x3F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFB, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xF7, 0xF0, 0x7F,
  0xC1, 0xFF, 0x0F, 0xE7, 0xF1, 0xFF, 0x03, 0xFF, 0x1F, 0xCF, 0xE3, 0xFE,
  0x03, 0xFE, 0x3F, 0x9F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0x3F, 0x8F, 0xF8,
  0x0F, 0xF9, 0xFC, 0x7F, 0x1F, 0xF0, 0x1F, 0xF3, 0xF8, 0x7E, 0x7F, 0xC0,
  0x1F, 0xE7, 0xF0, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xE1, 0xFD, 0xFF, 0x00,
  0x7F, 0xDF, 0xC3, 0xFB, 0xFE, 0x00, 0xFF, 0xBF, 0x07, 0xF7, 0xF8, 0x00,
  0xFF, 0x7E, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xDF, 0xE0, 0x03,
  0xFF, 0xF8, 0x1F, 0xBF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xF3, 0xFF,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x21, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x11, 0xFF, 0x80, 0x01, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x80, 0x00, 0xFF,
  0x80,
};

const GFXglyph NotoSans_Condensed_ExtraBold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 46, 17, 3, -45 },
  { 65, 24, 16, 30, 3, -45 },
  { 113, 33, 45, 35, 1, -45 },
  { 299, 26, 52, 32, 3, -48 },
  { 468, 49, 47, 53, 2, -46 },
  { 756, 39, 47, 41, 2, -46 },
  { 986, 10, 16, 16, 3, -45 },
  { 1006, 17, 56, 21, 3, -46 },
  { 1125, 17, 56, 21, 1, -46 },
  { 1244, 28, 28, 30, 1, -48 },
  { 1342, 28, 30, 32, 2, -37 },
  { 1447, 12, 16, 17, 2, -8 },
  { 1471, 16, 8, 20, 2, -21 },
  { 1487, 11, 11, 17, 3, -10 },
  { 1503, 26, 46, 26, 0, -45 },
  { 1653, 28, 47, 32, 2, -46 },
  { 1818, 22, 45, 32, 3, -45 },
  { 1942, 27, 46, 32, 2, -46 },
  { 2098, 27, 47, 32, 2, -46 },
  { 2257, 30, 45, 32, 1, -45 },
  { 2426, 26, 46, 32, 3, -45 },
  { 2576, 28, 47, 32, 2, -46 },
  { 2741, 28, 45, 32, 2, -45 },
  { 2899, 28, 47, 32, 2, -46 },
  { 3064, 28, 47, 32, 2, -46 },
  { 3229, 11, 36, 17, 3, -35 },
  { 3279, 12, 43, 17, 2, -35 },
  { 3344, 28, 32, 32, 2, -39 },
  { 3456, 28, 20, 32, 2, -32 },
  { 3526, 28, 32, 32, 2, -39 },
  { 3638, 25, 47, 26, 0, -46 },
  { 3785, 45, 50, 50, 2, -45 },
  { 4067, 38, 45, 38, 0, -45 },
  { 4281, 30, 45, 36, 4, -45 },
  { 4450, 29, 47, 34, 3, -46 },
  { 4621, 32, 45, 39, 4, -45 },
  { 4801, 23, 45, 30, 4, -45 },
  { 4931, 23, 45, 29, 4, -45 },
  { 5061, 32, 47, 39, 3, -46 },
  { 5249, 32, 45, 41, 4, -45 },
  { 5429, 19, 45, 22, 2, -45 },
  { 5536, 18, 59, 19, -4, -45 },
  { 5669, 33, 45, 36, 4, -45 },
  { 5855, 24, 45, 29, 4, -45 },
  { 5990, 44, 45, 53, 4, -45 },
  { 6238, 35, 45, 44, 4, -45 },
  { 6435, 36, 47, 42, 3, -46 },
  { 6647, 28, 45, 34, 4, -45 },
  { 6805, 36, 57, 42, 3, -46 },
  { 7062, 32, 45, 36, 4, -45 },
  { 7242, 26, 47, 30, 2, -46 },
  { 7395, 28, 45, 31, 1, -45 },
  { 7553, 32, 46, 40, 4, -45 },
  { 7737, 36, 45, 36, 0, -45 },
  { 7940, 53, 45, 53, 0, -45 },
  { 8239, 35, 45, 35, 0, -45 },
  { 8436, 34, 45, 34, 0, -45 },
  { 8628, 28, 45, 31, 1, -45 },
  { 8786, 15, 56, 20, 3, -46 },
  { 8891, 26, 46, 26, 0, -45 },
  { 9041, 15, 56, 20, 1, -46 },
  { 9146, 32, 29, 34, 1, -45 },
  { 9262, 29, 6, 28, 0, 5 },
  { 9284, 16, 10, 22, 3, -48 },
  { 9304, 27, 36, 33, 2, -35 },
  { 9426, 28, 49, 35, 4, -48 },
  { 9598, 25, 36, 28, 2, -35 },
  { 9711, 29, 49, 35, 2, -48 },
  { 9889, 28, 36, 32, 2, -35 },
  { 10015, 22, 48, 21, 1, -48 },
  { 10147, 29, 50, 35, 2, -35 },
  { 10329, 28, 48, 35, 4, -48 },
  { 10497, 11, 48, 17, 3, -48 },
  { 10563, 16, 63, 17, -2, -48 },
  { 10689, 30, 48, 34, 4, -48 },
  { 10869, 9, 48, 17, 4, -48 },
  { 10923, 45, 35, 52, 4, -35 },
  { 11120, 28, 35, 35, 4, -35 },
  { 11243, 30, 36, 34, 2, -35 },
  { 11378, 28, 50, 35, 4, -35 },
  { 11553, 29, 50, 35, 2, -35 },
  { 11735, 20, 35, 25, 4, -35 },
  { 11823, 23, 36, 27, 2, -35 },
  { 11927, 21, 43, 23, 1, -42 },
  { 12040, 27, 36, 35, 4, -35 },
  { 12162, 32, 35, 32, 0, -35 },
  { 12302, 47, 35, 48, 0, -35 },
  { 12508, 31, 35, 31, 0, -35 },
  { 12644, 32, 50, 32, 0, -35 },
  { 12844, 24, 35, 26, 1, -35 },
  { 12949, 21, 55, 24, 1, -45 },
  { 13094, 7, 62, 29, 11, -48 },
  { 13149, 21, 55, 24, 2, -45 },
  { 13294, 28, 11, 32, 2, -28 },
};

const GFXfont NotoSans_Condensed_ExtraBold63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD63PT7B_H_
