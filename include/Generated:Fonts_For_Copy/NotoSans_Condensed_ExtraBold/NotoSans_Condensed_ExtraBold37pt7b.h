#ifndef _NOTOSANS_CONDENSED_EXTRABOLD37PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDE, 0x78, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0xFC, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x1E, 0xF8,
  0x78, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x87, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x87, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xC3, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFF, 0x7D, 0xCE, 0xFB, 0x81, 0xF7, 0x03, 0xEE, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0E, 0xF8, 0x1D, 0xF8, 0x3B, 0xFC, 0x77, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF8, 0xFF, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xE0, 0x1F, 0xF0, 0x1F, 0x00, 0xFF,
  0xC0, 0xF0, 0x0F, 0x9E, 0x0F, 0x80, 0x7C, 0xF0, 0x78, 0x03, 0xC7, 0xC3,
  0xC0, 0x1E, 0x3E, 0x3C, 0x00, 0xF1, 0xF1, 0xE0, 0x07, 0x8F, 0x9F, 0x00,
  0x3C, 0x7C, 0xF0, 0x01, 0xF3, 0xCF, 0x9F, 0x87, 0x9E, 0x79, 0xFE, 0x3F,
  0xF7, 0xDF, 0xF9, 0xFF, 0x3C, 0xFF, 0xC7, 0xF1, 0xE7, 0x9F, 0x0F, 0x1E,
  0x3C, 0xF8, 0x00, 0xF3, 0xE3, 0xC0, 0x0F, 0x9F, 0x1E, 0x00, 0x78, 0xF8,
  0xF0, 0x07, 0xC7, 0xC7, 0x80, 0x3C, 0x1E, 0x7C, 0x03, 0xE0, 0xF3, 0xE0,
  0x1E, 0x07, 0xFE, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF8,
  0x03, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x8F,
  0x80, 0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0x8F, 0xFE, 0x3F, 0x3F, 0xFC, 0x7C,
  0x7E, 0xFD, 0xF9, 0xF8, 0xFF, 0xF3, 0xF1, 0xFF, 0xC7, 0xE1, 0xFF, 0x8F,
  0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFB, 0xF8, 0x3F, 0xE3, 0xF8, 0xFF, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xF8, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC3,
  0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63,
  0xC6, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3E, 0x7C, 0x7E, 0x7E, 0x1C, 0x38, 0x04, 0x20, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7E, 0x7E, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x3F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC1,
  0xFE, 0x1F, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xBF, 0x79, 0xF9, 0x8F,
  0xC8, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF,
  0xFE, 0x7C, 0x7E, 0x30, 0x3F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x3F,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x38, 0x7F, 0x20, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xF8, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0x7E, 0x0F, 0xBF,
  0x07, 0x9F, 0x87, 0xCF, 0xC3, 0xC7, 0xE3, 0xE3, 0xF1, 0xE1, 0xF9, 0xF0,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xCF,
  0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0,
  0x00, 0x7E, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x7F, 0x1F,
  0xFF, 0xCF, 0xBF, 0xE7, 0xFF, 0xFB, 0xFD, 0xFD, 0xFC, 0x7E, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF7, 0xC1, 0xF3, 0xF1, 0xF9, 0xFF,
  0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0xFC, 0xF8, 0x3E, 0x7E,
  0x3F, 0x3F, 0x3F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xF0, 0x7F, 0xFC, 0x7E, 0x7F, 0x3E, 0x1F, 0xBF, 0x07, 0xDF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0xF8, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xF3, 0xF3, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x1F, 0x7E,
  0x0F, 0xBF, 0x07, 0xDF, 0x87, 0xFF, 0xC3, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xDF, 0x07, 0xCF, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x8F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF0, 0x00, 0x33, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0x18, 0x7D, 0xFB, 0xF7, 0xEF, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7D, 0xFB, 0xF7,
  0xCF, 0x9F, 0x3C, 0xF9, 0xF0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x70, 0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xCF, 0x1F, 0xC8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE1, 0xF0, 0x7E, 0x3E, 0x3C,
  0x3F, 0xF3, 0xCF, 0x8F, 0xFE, 0x79, 0xE3, 0xF3, 0xC7, 0xBC, 0x78, 0x78,
  0xF7, 0x9F, 0x0F, 0x1E, 0xF3, 0xC3, 0xE3, 0xFE, 0x78, 0x7C, 0x7F, 0x8F,
  0x0F, 0x8F, 0xF1, 0xE1, 0xF1, 0xDF, 0x3C, 0x3E, 0x79, 0xE7, 0xC7, 0xCF,
  0x3C, 0x7F, 0xFF, 0xC7, 0x8F, 0xF7, 0xF8, 0xF0, 0xFE, 0x7E, 0x0F, 0x07,
  0x07, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x87,
  0xF7, 0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x3F, 0xBF,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xF0, 0x7E,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFC, 0x79, 0xFC,
  0x04, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x09, 0xFF, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBE, 0x0F, 0xEF, 0x81, 0xFB,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x81, 0xFB, 0xE0, 0xFE, 0xF8, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xEF, 0xFF, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x87, 0x1F,
  0xC0, 0x23, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFE,
  0x0F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x00, 0xF8, 0x0F, 0xFF, 0x03,
  0xF3, 0xE0, 0xFE, 0x7C, 0x1F, 0x8F, 0x87, 0xF1, 0xF0, 0xFC, 0x3E, 0x3F,
  0x07, 0xCF, 0xE0, 0xF9, 0xF8, 0x1F, 0x7F, 0x03, 0xEF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0xFC,
  0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xF1, 0xF0, 0x7E,
  0x3E, 0x0F, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0xDF, 0x01, 0xF8, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF7,
  0xFE, 0xF0, 0xFB, 0xFF, 0x7C, 0x7D, 0xFF, 0xBE, 0x3C, 0xFF, 0xCF, 0x1E,
  0x7F, 0xE7, 0xDF, 0x3F, 0xF3, 0xEF, 0x9F, 0xF9, 0xF7, 0x8F, 0xFC, 0x7F,
  0xC7, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xE1, 0xFF, 0x8F, 0xF0, 0xFF, 0xC3,
  0xF8, 0x7F, 0xE1, 0xFC, 0x3F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC,
  0x1F, 0x07, 0xC0, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xBE, 0x1F, 0xFB, 0xF1, 0xFF, 0xBF, 0x1F, 0xF9, 0xF9, 0xFF,
  0x9F, 0x9F, 0xF8, 0xFD, 0xFF, 0x8F, 0xDF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0xF8, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1,
  0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xFC, 0x07,
  0xE7, 0xE0, 0x7F, 0x3F, 0x83, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xF9, 0xFE, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0xC7, 0xF1, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFD, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xF9,
  0xFF, 0x3E, 0x1F, 0xCF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F,
  0xCF, 0x87, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xF9, 0xF8, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3, 0xE1, 0xF8, 0xF8,
  0x7E, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xFE, 0xF8, 0x1F, 0xBE, 0x07,
  0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xEF,
  0x9F, 0x01, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFE, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xFC, 0x01,
  0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x1F,
  0x01, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3E,
  0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3F,
  0x3E, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xF8,
  0x0F, 0x80, 0xFD, 0xF0, 0x3F, 0x81, 0xFB, 0xE0, 0x7F, 0x03, 0xE7, 0xE0,
  0xFE, 0x07, 0xCF, 0xC1, 0xFC, 0x1F, 0x9F, 0x83, 0xFC, 0x3F, 0x1F, 0x0F,
  0xF8, 0x7E, 0x3E, 0x1E, 0xF0, 0xF8, 0x7C, 0x3D, 0xE1, 0xF0, 0xFC, 0x7B,
  0xC7, 0xE1, 0xF8, 0xF7, 0xCF, 0xC1, 0xF3, 0xEF, 0x9F, 0x83, 0xE7, 0xDF,
  0x3E, 0x07, 0xCF, 0x9E, 0x7C, 0x0F, 0xDE, 0x3D, 0xF8, 0x1F, 0xBC, 0x7B,
  0xF0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x81, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xF7, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8,
  0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7B, 0xE0, 0x0F, 0x9F, 0x00,
  0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x18, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x03, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF,
  0x3F, 0x8F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0xE0, 0xFD, 0xFC, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xF7, 0xE0, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFD, 0xFE, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3E, 0xFF, 0x9F,
  0x3F, 0x00, 0x01, 0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF,
  0xE1, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x02, 0x7F, 0xBC, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x0E, 0x1F, 0x1F,
  0xCF, 0x9F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0xFD,
  0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFB, 0xE0, 0xFD, 0xF8, 0x7E, 0xFE, 0x7F, 0x7F, 0xFF, 0x9F,
  0xFF, 0xC7, 0xFB, 0xE1, 0xF8, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x02, 0x7F, 0x07, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0x90,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0xE7, 0xC7, 0xFB, 0xE7, 0xFF,
  0xF7, 0xFF, 0xFB, 0xF9, 0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x7E,
  0xFC, 0x3F, 0x7F, 0x3F, 0xBF, 0xFF, 0xCF, 0xFB, 0xE3, 0xFD, 0xF0, 0xFC,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x60, 0x3F, 0xBF, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0xE0, 0xFD, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xE3, 0xF7,
  0xF0, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xF0, 0x7B, 0xFF, 0xFF, 0x78,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xBF, 0xDF, 0xCF, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xBF, 0x0F, 0xEF, 0xC3, 0xF3,
  0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFE, 0xFC, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xFB,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x1C, 0x1F, 0x3F, 0x8F, 0xF3, 0xEF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFF, 0x9F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE1,
  0xFC, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F,
  0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x3E, 0x0F, 0xFF, 0x07,
  0xC1, 0xFF, 0xE0, 0xF8, 0x3F, 0xFC, 0x1F, 0x07, 0xFF, 0x83, 0xE0, 0xFF,
  0xF0, 0x7C, 0x1F, 0xFE, 0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0x7E, 0x00, 0x70,
  0x7C, 0xFE, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF8, 0x01, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xE1, 0xF9, 0xF0,
  0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0x9F, 0x03, 0xE7, 0xC1, 0xF9, 0xF8, 0x7E, 0x7F, 0x3F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x7C, 0xFE, 0x3E,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0x7D, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x7E, 0xFF, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F,
  0xFF, 0xCF, 0xCF, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03,
  0x80, 0x0F, 0xE7, 0xC7, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF1, 0xFD,
  0xF8, 0x7E, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x7E, 0xFC, 0x3F, 0x7F, 0x3F, 0xBF,
  0xFF, 0xCF, 0xFB, 0xE3, 0xFD, 0xF0, 0xFC, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x9F, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0x81, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x0B, 0xF0, 0x1F, 0xC0,
  0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x00, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x33, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xCF, 0x1F, 0x8F, 0xFC, 0x0F, 0xEF, 0x81, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x1F,
  0x3F, 0x03, 0xE7, 0xE0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x83, 0xF7, 0xC3, 0xFC, 0x3E, 0x7C,
  0x3F, 0xC3, 0xE7, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE3, 0xE3, 0xFC,
  0x7C, 0x3E, 0x3F, 0xE7, 0xC3, 0xE7, 0x9E, 0x7C, 0x3F, 0x79, 0xEF, 0xC1,
  0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0x79,
  0xEF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x07, 0xE0, 0xFE, 0x1F, 0xDF, 0x87, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F,
  0xBE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xE7, 0xE1, 0xFB, 0xF0, 0x3F, 0xFC,
  0x07, 0xEF, 0x81, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC3, 0xE1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xF7, 0xE0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xFF, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0xC0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xF0, 0x7F, 0x0F,
  0xF1, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x00,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF4, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 14, 9, 18, 2, -26 },
  { 37, 19, 26, 21, 1, -26 },
  { 99, 15, 30, 19, 2, -28 },
  { 156, 29, 27, 31, 1, -27 },
  { 254, 23, 27, 24, 1, -27 },
  { 332, 6, 9, 9, 2, -26 },
  { 339, 10, 33, 12, 2, -27 },
  { 381, 10, 33, 12, 1, -27 },
  { 423, 16, 16, 18, 1, -28 },
  { 455, 17, 18, 19, 1, -22 },
  { 494, 7, 10, 10, 1, -5 },
  { 503, 10, 5, 12, 1, -12 },
  { 510, 6, 6, 10, 2, -6 },
  { 515, 15, 27, 15, 0, -27 },
  { 566, 16, 27, 19, 1, -27 },
  { 620, 13, 26, 19, 2, -26 },
  { 663, 16, 27, 19, 1, -27 },
  { 717, 16, 27, 19, 1, -27 },
  { 771, 17, 26, 19, 1, -26 },
  { 827, 15, 26, 19, 2, -26 },
  { 876, 17, 27, 19, 1, -27 },
  { 934, 17, 26, 19, 1, -26 },
  { 990, 17, 27, 19, 1, -27 },
  { 1048, 17, 27, 19, 1, -27 },
  { 1106, 6, 21, 10, 2, -21 },
  { 1122, 7, 26, 10, 1, -21 },
  { 1145, 17, 19, 19, 1, -23 },
  { 1186, 17, 12, 19, 1, -19 },
  { 1212, 17, 19, 19, 1, -23 },
  { 1253, 15, 27, 15, 0, -27 },
  { 1304, 27, 30, 29, 1, -27 },
  { 1406, 22, 26, 22, 0, -26 },
  { 1478, 17, 26, 21, 3, -26 },
  { 1534, 17, 27, 20, 2, -27 },
  { 1592, 18, 26, 23, 3, -26 },
  { 1651, 13, 26, 18, 3, -26 },
  { 1694, 13, 26, 17, 3, -26 },
  { 1737, 19, 27, 23, 2, -27 },
  { 1802, 18, 26, 24, 3, -26 },
  { 1861, 11, 26, 13, 1, -26 },
  { 1897, 10, 34, 11, -2, -26 },
  { 1940, 19, 26, 21, 3, -26 },
  { 2002, 13, 26, 17, 3, -26 },
  { 2045, 25, 26, 31, 3, -26 },
  { 2127, 20, 26, 26, 3, -26 },
  { 2192, 21, 27, 25, 2, -27 },
  { 2263, 16, 26, 20, 3, -26 },
  { 2315, 21, 33, 25, 2, -27 },
  { 2402, 18, 26, 21, 3, -26 },
  { 2461, 15, 27, 18, 1, -27 },
  { 2512, 16, 26, 18, 1, -26 },
  { 2564, 19, 26, 23, 2, -26 },
  { 2626, 21, 26, 21, 0, -26 },
  { 2695, 31, 26, 31, 0, -26 },
  { 2796, 21, 26, 21, 0, -26 },
  { 2865, 20, 26, 20, 0, -26 },
  { 2930, 16, 26, 18, 1, -26 },
  { 2982, 9, 33, 12, 2, -27 },
  { 3020, 15, 27, 15, 0, -27 },
  { 3071, 9, 33, 12, 1, -27 },
  { 3109, 20, 16, 20, 0, -26 },
  { 3149, 17, 3, 17, 0, 3 },
  { 3156, 10, 6, 13, 1, -28 },
  { 3164, 16, 21, 19, 1, -21 },
  { 3206, 17, 28, 20, 2, -28 },
  { 3266, 15, 21, 17, 1, -21 },
  { 3306, 17, 28, 20, 1, -28 },
  { 3366, 17, 21, 19, 1, -21 },
  { 3411, 14, 28, 13, 0, -28 },
  { 3460, 17, 30, 20, 1, -21 },
  { 3524, 17, 28, 21, 2, -28 },
  { 3584, 6, 28, 10, 2, -28 },
  { 3605, 9, 37, 10, -1, -28 },
  { 3647, 18, 28, 20, 2, -28 },
  { 3710, 6, 28, 10, 2, -28 },
  { 3731, 27, 21, 31, 2, -21 },
  { 3802, 17, 21, 21, 2, -21 },
  { 3847, 18, 21, 20, 1, -21 },
  { 3895, 17, 30, 20, 2, -21 },
  { 3959, 17, 30, 20, 1, -21 },
  { 4023, 12, 21, 14, 2, -21 },
  { 4055, 13, 21, 16, 1, -21 },
  { 4090, 12, 25, 14, 1, -25 },
  { 4128, 16, 20, 21, 2, -20 },
  { 4168, 19, 20, 19, 0, -20 },
  { 4216, 28, 20, 28, 0, -20 },
  { 4286, 18, 20, 18, 0, -20 },
  { 4331, 19, 29, 19, 0, -20 },
  { 4400, 14, 20, 15, 1, -20 },
  { 4435, 12, 33, 14, 1, -27 },
  { 4485, 5, 36, 17, 6, -28 },
  { 4508, 12, 33, 14, 1, -27 },
  { 4558, 17, 6, 19, 1, -16 },
};

const GFXfont NotoSans_Condensed_ExtraBold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD37PT7B_H_
