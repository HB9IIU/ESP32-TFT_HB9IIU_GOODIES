#ifndef _NOTOSANS_CONDENSED_EXTRABOLD20PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xEE, 0xE6, 0xE6, 0xE6,
  0x0D, 0xC1, 0xB0, 0x76, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0xE0, 0xD8, 0xFF,
  0xDF, 0xF8, 0xCC, 0x19, 0x83, 0x70, 0x6E, 0x00, 0x18, 0x3E, 0x7F, 0xFF,
  0xF8, 0xF8, 0xF8, 0x7E, 0x1F, 0x1F, 0x1B, 0xDF, 0xFF, 0xFE, 0x18, 0x18,
  0xF8, 0x71, 0xF0, 0xC3, 0x73, 0x06, 0xE6, 0x0D, 0xDC, 0x1B, 0xB3, 0x3E,
  0xEF, 0x3D, 0xBB, 0x07, 0x66, 0x0C, 0xCC, 0x19, 0x98, 0x63, 0x30, 0xC3,
  0xE3, 0x87, 0x80, 0x3E, 0x07, 0xF0, 0x77, 0x07, 0x70, 0x77, 0x07, 0xE0,
  0x7C, 0xFF, 0xEE, 0xEE, 0xEE, 0x7C, 0xE7, 0xCF, 0x7C, 0xFF, 0xE7, 0xEF,
  0xFF, 0xFE, 0x3B, 0x9C, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xC6,
  0x38, 0xF1, 0xC3, 0x8E, 0x38, 0x61, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3,
  0x1C, 0xE0, 0x1C, 0x06, 0x1B, 0x6F, 0xFF, 0xF8, 0xF0, 0xDC, 0xE6, 0x12,
  0x00, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0xFF, 0xFD, 0x80, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0x07, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0x7E, 0x7E,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7E, 0x3C,
  0x1E, 0x7D, 0xFF, 0xF6, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC0, 0x7E, 0xFF, 0xC7, 0x47, 0x07, 0x0F, 0x0E, 0x1C, 0x3C, 0x78, 0x70,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x47, 0x07, 0x07, 0x7E, 0x78, 0x7E, 0x07,
  0x07, 0x07, 0xCF, 0xFF, 0xFC, 0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC3, 0x71, 0xDC, 0xE7, 0x3F, 0xFF, 0xFC, 0x1C, 0x07, 0x01, 0xC0, 0x7E,
  0xFE, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0x4F, 0x07, 0x07, 0x07, 0xCF, 0xFE,
  0xFC, 0x3F, 0x3F, 0x9C, 0x1C, 0x0E, 0x07, 0xF3, 0xFD, 0xCE, 0xE7, 0x73,
  0xF9, 0xDE, 0xE7, 0xF1, 0xF0, 0xFF, 0xFF, 0x07, 0x07, 0x0F, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x7E, 0x7F, 0xB9, 0xDC, 0xEE,
  0x73, 0xF0, 0xF0, 0xFC, 0xE7, 0x73, 0xB8, 0xFC, 0xEF, 0xF3, 0xF0, 0x7E,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFF, 0x7B, 0x07, 0x07, 0x9E, 0xFE,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xFD, 0x80,
  0x01, 0x83, 0xC7, 0xCF, 0x8F, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0x80, 0x40,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x3E, 0x07, 0xC0,
  0xF8, 0x7D, 0xF9, 0xF0, 0xC0, 0x40, 0x00, 0x7E, 0xFF, 0x47, 0x07, 0x07,
  0x0E, 0x1C, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x0F, 0xE0, 0xF3,
  0xC7, 0x03, 0x98, 0xF6, 0xEF, 0xCF, 0x33, 0x3D, 0xCC, 0xF7, 0x33, 0xDC,
  0xCF, 0x37, 0x7C, 0xF7, 0xB9, 0x8C, 0x70, 0x00, 0xE1, 0x81, 0xFE, 0x00,
  0xC0, 0x0F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0x9C, 0x39, 0xC3,
  0x9C, 0x7F, 0xC7, 0xFE, 0x7F, 0xE7, 0x0E, 0xF0, 0xFF, 0x0F, 0xFF, 0x3F,
  0xEF, 0x3B, 0xCE, 0xF3, 0xBF, 0xEF, 0xE3, 0xFE, 0xF3, 0xFC, 0xFF, 0x3F,
  0xFE, 0xFF, 0xBF, 0xC0, 0x3F, 0xBF, 0xDE, 0x7E, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3C, 0x0F, 0xF7, 0xF8, 0xFC, 0xFF, 0x1F, 0xF3, 0xDF,
  0x78, 0xEF, 0x1D, 0xE3, 0xBC, 0x7F, 0x8E, 0xF1, 0xDE, 0x3B, 0xCF, 0x7F,
  0xCF, 0xF1, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFE, 0xFE, 0xFE,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x8F, 0x1E, 0x3F,
  0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0x1F, 0xCF, 0xF7, 0x8B, 0xC0,
  0xF0, 0x38, 0x0E, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x1D, 0xFF, 0x3F, 0xC7,
  0xF0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0xFF, 0xE7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xF0, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xAE, 0xFB, 0xC0, 0xF1, 0xFE,
  0x7B, 0xDE, 0x7B, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xF7, 0x1E, 0xE3,
  0xDE, 0x79, 0xCF, 0x3D, 0xE3, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF,
  0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xB3, 0xFE, 0xEF, 0xFB, 0xB7, 0xE6, 0xDF,
  0x9F, 0x7E, 0x7D, 0xF9, 0xE7, 0xE3, 0x9F, 0x8E, 0x70, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE, 0x7E, 0x77, 0xE7, 0x7E, 0x3F,
  0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0x04, 0x07, 0xF1, 0xFF, 0x3C, 0xFF,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xF7, 0xFC,
  0x7F, 0x87, 0xE0, 0xFF, 0x7F, 0xFD, 0xFE, 0x7F, 0x3F, 0x9F, 0xFF, 0xFE,
  0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x04, 0x07, 0xF1, 0xFF, 0x3C,
  0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xF7,
  0xFC, 0x7F, 0x87, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0xFF, 0x3F, 0xEF, 0x7B,
  0xCE, 0xF3, 0xBC, 0xEF, 0xFB, 0xF8, 0xFF, 0x3D, 0xCF, 0x7B, 0xCE, 0xF3,
  0xFC, 0x70, 0x7F, 0xFF, 0xE6, 0xE0, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07,
  0x87, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1D, 0xFF, 0x7F,
  0x8F, 0xC0, 0xE0, 0xFE, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0x73, 0x8E, 0x71,
  0xDC, 0x3B, 0x83, 0x70, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0xE1, 0xC3,
  0xF0, 0xE3, 0xDC, 0xF1, 0xCE, 0x7C, 0xE7, 0x3E, 0x73, 0x9B, 0x39, 0xCD,
  0xB8, 0x6E, 0xDC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x8F, 0x87, 0xC7, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0xF1, 0xEE, 0x38, 0xEE, 0x1D, 0xC1, 0xF0, 0x3E,
  0x03, 0x80, 0xF8, 0x1F, 0x07, 0x70, 0xEE, 0x3D, 0xE7, 0x1D, 0xE3, 0xC0,
  0xF1, 0xEE, 0x39, 0xCF, 0x1D, 0xC3, 0xB8, 0x3E, 0x07, 0xC0, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xBF, 0xC0, 0xE0,
  0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xE0,
  0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E, 0x06, 0x07,
  0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF8,
  0x0C, 0x01, 0xC0, 0x78, 0x0F, 0x83, 0xB0, 0x67, 0x1C, 0x63, 0x0E, 0xE0,
  0xE0, 0xFF, 0x80, 0xF3, 0x8E, 0x7E, 0x7F, 0x47, 0x07, 0x3F, 0xFF, 0xE7,
  0xE7, 0xE7, 0xFF, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xF7, 0xFB, 0xDF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x7F, 0xFB, 0xBC, 0x3F, 0x7E, 0xF2,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF2, 0x7E, 0x3E, 0x03, 0x81, 0xC0, 0xE0,
  0x77, 0xBB, 0xFF, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x7B, 0xFD,
  0xEE, 0x3E, 0x3F, 0xB9, 0xDC, 0x6F, 0xFF, 0xFF, 0x81, 0xC0, 0xF1, 0x3F,
  0x8F, 0xC0, 0x3E, 0x7C, 0xE1, 0xC7, 0xFF, 0xCE, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x00, 0x7B, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xF7, 0xBF, 0xDE, 0xE0, 0x78, 0x7F, 0xFB, 0xFC, 0xF8, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0xF7, 0xFF, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8E, 0xFD, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xC6, 0x03,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE3, 0xF9, 0xEE, 0x73, 0xB8, 0xFC, 0x3F, 0x8F, 0xE3,
  0x9C, 0xE7, 0xB8, 0xEE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEF,
  0x79, 0xFF, 0xFB, 0xDF, 0x77, 0x1C, 0xFE, 0x39, 0xFC, 0x73, 0xF8, 0xE7,
  0xF1, 0xCF, 0xE3, 0x9F, 0xC7, 0x3F, 0x8E, 0x78, 0xEF, 0x7F, 0xFD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x3E, 0x3F, 0xBD,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xBF, 0x8F, 0x80, 0xEF, 0x7F,
  0xBD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xFF, 0xBB, 0xDC, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0x7B, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xF7, 0xBF, 0xDE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xEF, 0xFB,
  0xF7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x7F, 0xFB, 0x97, 0x0F,
  0x8F, 0x8F, 0x87, 0x8F, 0xFB, 0xF0, 0x30, 0x61, 0xFF, 0xF7, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0xE9, 0xF3, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xF7, 0xBF, 0xDE, 0xE0, 0xE1, 0xDC, 0xF7, 0x39, 0xCE,
  0x73, 0x8F, 0xC3, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xE3, 0x8F, 0xC7,
  0x9D, 0xDF, 0x33, 0xB6, 0xE7, 0x6D, 0xCE, 0xDB, 0x8D, 0xB6, 0x1B, 0x7C,
  0x3C, 0x78, 0x78, 0xF0, 0x71, 0xE0, 0xF3, 0xDC, 0xE7, 0xF0, 0xFC, 0x1E,
  0x07, 0x83, 0xE0, 0xFC, 0x77, 0x1C, 0xEF, 0x3C, 0xE1, 0xDC, 0xF7, 0x39,
  0xCE, 0x33, 0x8F, 0xC3, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x1F, 0x07, 0x81, 0xC0, 0x7F, 0x7F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x78,
  0x70, 0xFF, 0xFF, 0x1E, 0x3C, 0xE1, 0xC3, 0x87, 0x0E, 0x7C, 0xE1, 0xF0,
  0xE1, 0xC3, 0x87, 0x0E, 0x0F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x1C, 0xF7, 0x1C, 0x71,
  0xC7, 0x3C, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 8, 5, 9, 1, -14 },
  { 12, 11, 14, 11, 0, -14 },
  { 32, 8, 16, 10, 1, -15 },
  { 48, 15, 14, 17, 1, -14 },
  { 75, 12, 14, 13, 1, -14 },
  { 96, 3, 5, 5, 1, -14 },
  { 98, 5, 17, 7, 1, -14 },
  { 109, 6, 17, 7, 0, -14 },
  { 122, 9, 9, 10, 0, -15 },
  { 133, 9, 10, 10, 1, -12 },
  { 145, 3, 6, 5, 1, -3 },
  { 148, 5, 3, 6, 1, -7 },
  { 150, 3, 3, 5, 1, -3 },
  { 152, 8, 14, 8, 0, -14 },
  { 166, 8, 14, 10, 1, -14 },
  { 180, 7, 14, 10, 1, -14 },
  { 193, 8, 14, 10, 1, -14 },
  { 207, 8, 14, 10, 1, -14 },
  { 221, 10, 14, 10, 0, -14 },
  { 239, 8, 14, 10, 1, -14 },
  { 253, 9, 14, 10, 1, -14 },
  { 269, 8, 14, 10, 1, -14 },
  { 283, 9, 14, 10, 1, -14 },
  { 299, 8, 14, 10, 1, -14 },
  { 313, 3, 11, 5, 1, -11 },
  { 318, 3, 14, 6, 1, -11 },
  { 324, 9, 10, 10, 1, -12 },
  { 336, 9, 6, 10, 1, -10 },
  { 343, 9, 10, 10, 1, -12 },
  { 355, 8, 14, 8, 0, -14 },
  { 369, 14, 16, 16, 1, -14 },
  { 397, 12, 14, 12, 0, -14 },
  { 418, 10, 14, 12, 1, -14 },
  { 436, 9, 14, 11, 1, -14 },
  { 452, 11, 14, 12, 1, -14 },
  { 472, 8, 14, 9, 1, -14 },
  { 486, 7, 14, 9, 1, -14 },
  { 499, 10, 14, 12, 1, -14 },
  { 517, 11, 14, 13, 1, -14 },
  { 537, 6, 14, 7, 1, -14 },
  { 548, 6, 18, 6, -1, -14 },
  { 562, 11, 14, 12, 1, -14 },
  { 582, 8, 14, 9, 1, -14 },
  { 596, 14, 14, 17, 1, -14 },
  { 621, 12, 14, 14, 1, -14 },
  { 642, 11, 15, 13, 1, -15 },
  { 663, 9, 14, 11, 1, -14 },
  { 679, 11, 18, 13, 1, -15 },
  { 704, 10, 14, 11, 1, -14 },
  { 722, 8, 14, 10, 1, -14 },
  { 736, 9, 14, 10, 0, -14 },
  { 752, 10, 14, 13, 1, -14 },
  { 770, 11, 14, 11, 0, -14 },
  { 790, 17, 14, 17, 0, -14 },
  { 820, 11, 14, 11, 0, -14 },
  { 840, 11, 14, 11, 0, -14 },
  { 860, 9, 14, 10, 0, -14 },
  { 876, 5, 17, 6, 1, -14 },
  { 887, 8, 14, 8, 0, -14 },
  { 901, 5, 17, 6, 0, -14 },
  { 912, 11, 9, 11, 0, -14 },
  { 925, 9, 1, 9, 0, 2 },
  { 927, 5, 3, 7, 1, -15 },
  { 929, 8, 11, 10, 1, -11 },
  { 940, 9, 15, 11, 1, -15 },
  { 957, 8, 11, 9, 1, -11 },
  { 968, 9, 15, 11, 1, -15 },
  { 985, 9, 11, 10, 1, -11 },
  { 998, 7, 15, 7, 0, -15 },
  { 1012, 9, 16, 11, 1, -11 },
  { 1030, 9, 15, 11, 1, -15 },
  { 1047, 3, 15, 5, 1, -15 },
  { 1053, 5, 20, 5, -1, -15 },
  { 1066, 10, 15, 11, 1, -15 },
  { 1085, 3, 15, 5, 1, -15 },
  { 1091, 15, 11, 17, 1, -11 },
  { 1112, 9, 11, 11, 1, -11 },
  { 1125, 9, 11, 11, 1, -11 },
  { 1138, 9, 16, 11, 1, -11 },
  { 1156, 9, 16, 11, 1, -11 },
  { 1174, 7, 11, 8, 1, -11 },
  { 1184, 7, 11, 8, 1, -11 },
  { 1194, 7, 13, 7, 0, -13 },
  { 1206, 9, 11, 11, 1, -11 },
  { 1219, 10, 11, 10, 0, -11 },
  { 1233, 15, 11, 15, 0, -11 },
  { 1254, 10, 11, 10, 0, -11 },
  { 1268, 10, 16, 10, 0, -11 },
  { 1288, 8, 11, 8, 0, -11 },
  { 1299, 7, 17, 7, 0, -14 },
  { 1314, 3, 20, 9, 3, -15 },
  { 1322, 6, 17, 7, 1, -14 },
  { 1335, 9, 4, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_ExtraBold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD20PT7B_H_
