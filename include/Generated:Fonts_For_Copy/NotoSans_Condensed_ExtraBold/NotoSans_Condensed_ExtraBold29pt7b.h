#ifndef _NOTOSANS_CONDENSED_EXTRABOLD29PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLD29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x33,
  0xFF, 0xF7, 0x80, 0xF9, 0xFF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3, 0xDC,
  0x7B, 0x8F, 0x07, 0x38, 0x1E, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x01,
  0xCE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xE0, 0x73, 0x80, 0xE7,
  0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x1C, 0xF0, 0x39, 0xE0, 0x73, 0x80,
  0xE7, 0x01, 0xCE, 0x07, 0x9C, 0x00, 0x02, 0x00, 0x10, 0x03, 0xF0, 0x7F,
  0xE7, 0xFF, 0x7F, 0xFB, 0xC8, 0x9E, 0x40, 0xFA, 0x03, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x0B, 0xC0, 0x4F, 0xC2, 0xF7, 0xDF, 0xBF,
  0xFD, 0xFF, 0xC1, 0xF8, 0x01, 0x00, 0x08, 0x00, 0x40, 0x3C, 0x03, 0x80,
  0xFC, 0x0F, 0x03, 0xFC, 0x1C, 0x07, 0xBC, 0x38, 0x0E, 0x78, 0xF0, 0x1C,
  0xF1, 0xC0, 0x39, 0xE7, 0x80, 0x73, 0xCE, 0x00, 0xE7, 0xBC, 0x61, 0xEF,
  0x73, 0xF1, 0xFC, 0xEF, 0xF3, 0xFB, 0x9C, 0xE3, 0xC7, 0x39, 0xC0, 0x1E,
  0xF3, 0x80, 0x39, 0xE7, 0x80, 0xF3, 0xCF, 0x01, 0xC7, 0x9C, 0x07, 0x87,
  0x38, 0x0E, 0x0F, 0xF0, 0x1C, 0x0F, 0xC0, 0x70, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0xF9, 0xFF,
  0x3E, 0xFB, 0xEF, 0x3E, 0xFF, 0xCF, 0x1F, 0xF3, 0xC3, 0xF8, 0xF8, 0x7E,
  0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xCF, 0xC0, 0xFF, 0xDE,
  0xF7, 0xBD, 0xCE, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78,
  0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x3C,
  0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0C,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x3F, 0xC3, 0xFC, 0x79, 0xE3,
  0x9C, 0x10, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x7B, 0xDE, 0xFF, 0xFB, 0xDC, 0xFF, 0xFF, 0xFF, 0xF0, 0x33,
  0xFF, 0xF7, 0x80, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x81, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0x9F, 0x7C, 0x7B, 0xE3, 0xDF, 0x1F,
  0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xDF,
  0x1E, 0x78, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0xC1, 0xF8, 0x00, 0x03, 0xC1,
  0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xBD, 0xCF, 0x23, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0x1F, 0x87, 0xFC, 0xFF, 0xEF, 0xFF, 0x71, 0xF2, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFF,
  0x3F, 0xF8, 0xFF, 0xE6, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x81,
  0xF7, 0xBF, 0xBF, 0xFD, 0xFF, 0xC7, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E, 0xF0,
  0x73, 0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xE7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xC7, 0xFE,
  0x7F, 0xF3, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0x7F, 0x80, 0x03, 0xF0, 0x7F, 0x87, 0xFC, 0x7F, 0xE7,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x30, 0xF7, 0xE7, 0xFF, 0xBF, 0xFD, 0xF1,
  0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0xFB, 0xFF, 0x9F, 0xFC,
  0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0x7C,
  0x79, 0xE3, 0xCF, 0xBE, 0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0xC7, 0xDF,
  0x7C, 0x7B, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0xC7, 0xDF, 0xFC, 0xFF, 0xC1,
  0xFC, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0x9F, 0x78, 0x7B,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x8F,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE2, 0x7F, 0x1F, 0xF0, 0xFF, 0x07, 0xF0,
  0x00, 0x7B, 0xFE, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x67, 0xFD, 0xEF, 0x79,
  0xE7, 0xDE, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xE7, 0x9E, 0x7B,
  0xCF, 0x3C, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x1F, 0xE3,
  0xF8, 0x1F, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x80,
  0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x03, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x87, 0xFC, 0xFF, 0xE7,
  0xFE, 0x61, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0xE0, 0xFC, 0x0F, 0x81,
  0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x1F, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3E,
  0x07, 0xC3, 0xC0, 0x0E, 0x1C, 0x1C, 0x79, 0xE3, 0xF9, 0xCE, 0x3F, 0xCE,
  0x73, 0xCE, 0x7F, 0x9C, 0x71, 0xF9, 0xE3, 0x8F, 0xCF, 0x1C, 0x7E, 0x78,
  0xE7, 0xF3, 0xC7, 0x3B, 0x8E, 0x79, 0xDE, 0x7F, 0xFE, 0x71, 0xF7, 0xE3,
  0x83, 0x0C, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x01, 0xFD, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF8, 0x1F, 0x3C, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xC7, 0xC3, 0xE3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFE, 0x7F, 0xFF, 0x3E, 0x07, 0x9F, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xF8, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE3, 0xEF,
  0x8F, 0xBE, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0xF8, 0xFB,
  0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC,
  0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x19, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x08, 0xFF, 0xE3, 0xFF, 0x87,
  0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x9F,
  0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0xF9, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3, 0xF0, 0x4F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xEF, 0x03, 0xDF, 0x07, 0xBE, 0x0F, 0x7E, 0x1E, 0x7F, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xFF, 0xFF,
  0xEF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3D, 0xFE,
  0xFF, 0x7F, 0x3F, 0x00, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xCF,
  0x9F, 0x1F, 0x3E, 0x3E, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x7C, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9,
  0xF1, 0xF3, 0xE1, 0xF7, 0xC3, 0xEF, 0x83, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0x70, 0xFF, 0xF7, 0x0E, 0xFF,
  0x79, 0xEF, 0xF7, 0x9E, 0xFF, 0x39, 0xCF, 0xF3, 0xDC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xF7, 0x8F,
  0xF7, 0xCF, 0xF3, 0xCF, 0xF3, 0xEF, 0xF1, 0xEF, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0,
  0xF9, 0xF0, 0x3C, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x7E, 0x1F,
  0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x07, 0xFF,
  0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0x7C, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xCF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3C, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x7E, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F,
  0x9F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF7, 0xE3, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x3E, 0xF8, 0x7C, 0xF8, 0xF9, 0xF1,
  0xF1, 0xF3, 0xE3, 0xE7, 0xC3, 0xEF, 0x87, 0xE0, 0x0F, 0xC3, 0xFF, 0x7F,
  0xF7, 0xFE, 0xF8, 0x6F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0xC1, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x07,
  0xCF, 0x03, 0xE7, 0xC1, 0xE3, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3E,
  0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xF7, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0xF0, 0x3C, 0x0F, 0xFC, 0x1E, 0x07, 0xBE, 0x0F, 0x83,
  0xCF, 0x07, 0xC3, 0xE7, 0x87, 0xE1, 0xF3, 0xC3, 0xF0, 0xF1, 0xF1, 0xF8,
  0x78, 0xF8, 0xFE, 0x3C, 0x3C, 0xFF, 0x3E, 0x1E, 0x7B, 0x9F, 0x0F, 0x3D,
  0xCF, 0x07, 0x9E, 0xF7, 0x81, 0xEE, 0x7B, 0xC0, 0xF7, 0x3D, 0xE0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xBC,
  0x0F, 0x38, 0x1C, 0x78, 0x78, 0x70, 0xF0, 0xF3, 0xC0, 0xE7, 0x81, 0xFE,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x3C, 0x1E, 0x0F, 0x1F,
  0xC7, 0xFE, 0x3F, 0xF3, 0x1F, 0x00, 0xF0, 0x0F, 0x1F, 0xF7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x7F, 0x73, 0xE7, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xDF, 0x1F, 0xFC,
  0xFF, 0xF7, 0xFF, 0xBE, 0x3D, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0xC7, 0xBF, 0x7D, 0xFF, 0xEF, 0xFE, 0x73, 0xE0, 0x0F,
  0xE7, 0xFD, 0xFF, 0xBF, 0xE7, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x17, 0xEE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x79, 0xE7, 0xEF, 0x7F, 0xFB,
  0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC7, 0xDF, 0x7E, 0xFF, 0xF3, 0xFF, 0x8F, 0x9C, 0x1F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xF9, 0xEF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC3, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xE0, 0x7C, 0x0F, 0xF7, 0xFE, 0xFF, 0xDF,
  0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xFB,
  0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF1, 0xF7, 0xDF, 0xBF, 0xFC, 0xFD, 0xE3, 0xEF, 0x00, 0x78, 0x03, 0xD0,
  0x3E, 0xFF, 0xE7, 0xFF, 0x3F, 0xF0, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xDF, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xBE, 0x3D, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7C, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF0, 0x00,
  0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0xFF, 0xFF, 0xEF, 0x80, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0xFC, 0x3E, 0xF1,
  0xF3, 0xCF, 0x8F, 0x3C, 0x3D, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFB, 0xE3, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xE7, 0xE7, 0xFF, 0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x8F, 0x8F,
  0x78, 0x7C, 0x7B, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xFF, 0x87,
  0x87, 0xFC, 0x3C, 0x3F, 0xE1, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F,
  0xC3, 0xC3, 0xFE, 0x1E, 0x1F, 0xE7, 0xC7, 0x7F, 0x3F, 0xFD, 0xFF, 0xEF,
  0x8F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0x0F, 0xC0, 0xFF, 0x87, 0xFF,
  0x1F, 0x3E, 0x78, 0x7B, 0xE1, 0xEF, 0x87, 0xBE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xEF, 0x87, 0x9E, 0x1E, 0x7C, 0xF9, 0xFF, 0xC3, 0xFE, 0x03, 0xF0, 0xE7,
  0xC7, 0xBF, 0x3F, 0xFD, 0xFB, 0xEF, 0x8F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xEF, 0xDF, 0x7F, 0xFB, 0xFF, 0x9E,
  0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF7, 0xDF, 0xBF, 0xFC,
  0xFD, 0xE3, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0xE3, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x3F, 0x9F, 0xFF,
  0xFF, 0xC6, 0xF0, 0x3E, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF0, 0x3E, 0x0F,
  0xE7, 0xFF, 0xFF, 0xFB, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xFD, 0x3F, 0xC7, 0xF0, 0xFC, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x73, 0xE7, 0xF8, 0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xC3,
  0xC7, 0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x78, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0xF8,
  0xFC, 0x7D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x78, 0xFC,
  0x79, 0xF7, 0xFB, 0xE3, 0xDD, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0,
  0xF7, 0x3B, 0xC1, 0xDC, 0xEE, 0x07, 0xF3, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0xF8, 0x7D, 0xF1, 0xE3, 0xCF,
  0x8F, 0xBC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x81, 0xFE, 0x0F, 0xFC, 0x3C, 0xF1, 0xF3, 0xE7, 0xC7, 0xBE, 0x1F, 0xF8,
  0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3E,
  0x1F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xC1, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xE0, 0x7C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0x7C, 0x3F, 0x1F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83,
  0xF0, 0xF8, 0x7C, 0x7E, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE3,
  0xF1, 0xF8, 0xF8, 0x60, 0x00, 0x38, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 21, 8, 1, -21 },
  { 15, 11, 8, 14, 1, -21 },
  { 26, 15, 21, 16, 1, -21 },
  { 66, 13, 24, 15, 1, -22 },
  { 105, 23, 21, 24, 1, -21 },
  { 166, 18, 21, 19, 1, -21 },
  { 214, 5, 8, 7, 1, -21 },
  { 219, 8, 26, 10, 1, -21 },
  { 245, 8, 26, 10, 0, -21 },
  { 271, 12, 13, 14, 1, -22 },
  { 291, 13, 14, 15, 1, -17 },
  { 314, 5, 8, 8, 1, -4 },
  { 319, 7, 4, 9, 1, -10 },
  { 323, 5, 5, 8, 1, -5 },
  { 327, 12, 21, 12, 0, -21 },
  { 359, 13, 21, 15, 1, -21 },
  { 394, 10, 21, 15, 1, -21 },
  { 421, 12, 21, 15, 1, -21 },
  { 453, 13, 21, 15, 1, -21 },
  { 488, 14, 21, 15, 0, -21 },
  { 525, 12, 21, 15, 1, -21 },
  { 557, 13, 21, 15, 1, -21 },
  { 592, 13, 21, 15, 1, -21 },
  { 627, 13, 21, 15, 1, -21 },
  { 662, 13, 21, 15, 1, -21 },
  { 697, 5, 16, 8, 1, -16 },
  { 707, 6, 20, 8, 1, -16 },
  { 722, 13, 15, 15, 1, -18 },
  { 747, 13, 9, 15, 1, -15 },
  { 762, 13, 15, 15, 1, -18 },
  { 787, 12, 21, 12, 0, -21 },
  { 819, 21, 23, 23, 1, -21 },
  { 880, 17, 21, 17, 0, -21 },
  { 925, 14, 21, 17, 2, -21 },
  { 962, 14, 21, 16, 1, -21 },
  { 999, 15, 21, 18, 2, -21 },
  { 1039, 10, 21, 14, 2, -21 },
  { 1066, 10, 21, 14, 2, -21 },
  { 1093, 15, 21, 18, 1, -21 },
  { 1133, 15, 21, 19, 2, -21 },
  { 1173, 9, 21, 10, 1, -21 },
  { 1197, 9, 27, 9, -2, -21 },
  { 1228, 15, 21, 17, 2, -21 },
  { 1268, 11, 21, 13, 2, -21 },
  { 1297, 20, 21, 24, 2, -21 },
  { 1350, 16, 21, 20, 2, -21 },
  { 1392, 17, 21, 19, 1, -21 },
  { 1437, 13, 21, 16, 2, -21 },
  { 1472, 17, 26, 19, 1, -21 },
  { 1528, 15, 21, 17, 2, -21 },
  { 1568, 12, 21, 14, 1, -21 },
  { 1600, 14, 21, 14, 0, -21 },
  { 1637, 14, 21, 18, 2, -21 },
  { 1674, 17, 21, 17, 0, -21 },
  { 1719, 25, 21, 24, 0, -21 },
  { 1785, 16, 21, 16, 0, -21 },
  { 1827, 16, 21, 16, 0, -21 },
  { 1869, 13, 21, 14, 1, -21 },
  { 1904, 6, 26, 9, 2, -21 },
  { 1924, 12, 21, 12, 0, -21 },
  { 1956, 7, 26, 9, 1, -21 },
  { 1979, 15, 14, 16, 0, -21 },
  { 2006, 13, 3, 13, 0, 2 },
  { 2011, 8, 4, 10, 1, -22 },
  { 2015, 12, 16, 15, 1, -16 },
  { 2039, 13, 22, 16, 2, -22 },
  { 2075, 11, 16, 13, 1, -16 },
  { 2097, 13, 22, 16, 1, -22 },
  { 2133, 13, 16, 15, 1, -16 },
  { 2159, 11, 22, 10, 0, -22 },
  { 2190, 13, 23, 16, 1, -16 },
  { 2228, 13, 22, 16, 2, -22 },
  { 2264, 4, 22, 8, 2, -22 },
  { 2275, 7, 29, 8, -1, -22 },
  { 2301, 14, 22, 16, 2, -22 },
  { 2340, 4, 22, 8, 2, -22 },
  { 2351, 21, 16, 24, 2, -16 },
  { 2393, 13, 16, 16, 2, -16 },
  { 2419, 14, 16, 16, 1, -16 },
  { 2447, 13, 23, 16, 2, -16 },
  { 2485, 13, 23, 16, 1, -16 },
  { 2523, 9, 16, 11, 2, -16 },
  { 2541, 10, 16, 12, 1, -16 },
  { 2561, 10, 19, 11, 0, -19 },
  { 2585, 12, 16, 16, 2, -16 },
  { 2609, 15, 16, 15, 0, -16 },
  { 2639, 22, 16, 22, 0, -16 },
  { 2683, 14, 16, 14, 0, -16 },
  { 2711, 15, 23, 15, 0, -16 },
  { 2755, 10, 16, 12, 1, -16 },
  { 2775, 10, 26, 11, 0, -21 },
  { 2808, 3, 29, 13, 5, -22 },
  { 2819, 9, 26, 11, 1, -21 },
  { 2849, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ExtraBold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBold29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLD29PT7B_H_
