#ifndef _ROBOTOCONDENSED_THINITALIC48PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x18, 0x30, 0x40,
  0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x23, 0x23, 0x23, 0x62, 0x62,
  0x42, 0x42, 0x46, 0x46, 0xC4, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x0C, 0x00,
  0x08, 0x08, 0x00, 0x08, 0x08, 0x00, 0x18, 0x18, 0x00, 0x10, 0x10, 0x00,
  0x10, 0x10, 0x00, 0x30, 0x30, 0x00, 0x20, 0x20, 0x00, 0x20, 0x20, 0x0F,
  0xFF, 0xFF, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x00,
  0x80, 0x80, 0x00, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x00, 0x01,
  0x01, 0x00, 0x03, 0x01, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00, 0x02,
  0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x08,
  0x0C, 0x00, 0x08, 0x08, 0x00, 0x08, 0x08, 0x00, 0x18, 0x18, 0x00, 0x10,
  0x10, 0x00, 0x10, 0x10, 0x00, 0x30, 0x30, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00,
  0x0C, 0x18, 0x03, 0x00, 0xC0, 0x20, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x02,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x80, 0x00, 0x88,
  0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x30,
  0x60, 0x06, 0x02, 0x00, 0xC0, 0x18, 0x38, 0x00, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x40, 0x80, 0x01, 0x81, 0x00, 0x02, 0x03, 0x00, 0x8C, 0x06,
  0x03, 0x10, 0x0C, 0x04, 0x20, 0x10, 0x10, 0x40, 0x20, 0x40, 0x80, 0x41,
  0x81, 0x00, 0x82, 0x02, 0x02, 0x08, 0x04, 0x04, 0x30, 0x0C, 0x10, 0xC0,
  0x0C, 0xC1, 0x00, 0x0F, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x83, 0xE0, 0x03, 0x0C, 0x60, 0x0C, 0x30, 0x40, 0x10, 0xC0, 0xC0,
  0x41, 0x00, 0x81, 0x82, 0x01, 0x02, 0x08, 0x02, 0x08, 0x10, 0x0C, 0x30,
  0x20, 0x18, 0xC0, 0x40, 0x21, 0x00, 0x80, 0x44, 0x01, 0x01, 0x80, 0x02,
  0x02, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x01, 0xCE, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x10, 0x01, 0x80, 0x40,
  0x04, 0x01, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x80, 0x0C,
  0x04, 0x00, 0x30, 0x30, 0x00, 0x41, 0x80, 0x01, 0x08, 0x00, 0x06, 0x40,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x80, 0x00,
  0x43, 0x00, 0x02, 0x04, 0x02, 0x10, 0x18, 0x08, 0xC0, 0x20, 0x22, 0x00,
  0xC1, 0x98, 0x01, 0x04, 0x40, 0x02, 0x11, 0x00, 0x0C, 0x84, 0x00, 0x16,
  0x10, 0x00, 0x70, 0x40, 0x00, 0xC1, 0x00, 0x07, 0x06, 0x00, 0x34, 0x0C,
  0x01, 0x08, 0x1C, 0x38, 0x30, 0x1F, 0x80, 0x40, 0x2D, 0xB4, 0x96, 0xD0,
  0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x08, 0x04, 0x07, 0x83, 0x0F, 0x3C, 0xCE,
  0x01, 0xFC, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x02, 0x60, 0x01, 0x88, 0x00,
  0xC3, 0x00, 0x60, 0x40, 0x30, 0x18, 0x08, 0x02, 0x06, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x84, 0x23, 0x18, 0x8C, 0xC4, 0x00, 0xFF, 0x80, 0x5F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x1C, 0x70, 0x06, 0x03, 0x01, 0x80, 0x20, 0x60, 0x06, 0x08, 0x00,
  0x43, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00,
  0x98, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x00, 0x03,
  0x60, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x0C,
  0x80, 0x01, 0x30, 0x00, 0x26, 0x00, 0x04, 0xC0, 0x01, 0x98, 0x00, 0x23,
  0x00, 0x0C, 0x20, 0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x18, 0x03, 0x01,
  0x80, 0xC0, 0x18, 0x70, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0xE1, 0xC9, 0xC2,
  0x80, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x1C, 0x01, 0x80, 0x40, 0x30, 0x06,
  0x06, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00,
  0x31, 0x80, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0x1C, 0x01, 0x80, 0x60, 0x30,
  0x02, 0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00,
  0x08, 0x40, 0x00, 0x86, 0x00, 0x10, 0x20, 0x03, 0x03, 0x00, 0x60, 0x0C,
  0x18, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xA0,
  0x00, 0x1E, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0xC4,
  0x00, 0x08, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0x40,
  0x80, 0x0C, 0x08, 0x01, 0x81, 0x80, 0x10, 0x18, 0x02, 0x01, 0x00, 0x60,
  0x10, 0x0C, 0x01, 0x00, 0x80, 0x10, 0x18, 0x03, 0x03, 0x00, 0x30, 0x20,
  0x02, 0x04, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x11,
  0xF8, 0x01, 0x70, 0xC0, 0x18, 0x02, 0x03, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01,
  0x08, 0x00, 0x20, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x40, 0x0C, 0x02, 0x01,
  0x80, 0x18, 0x70, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0xFC, 0x08,
  0xE1, 0x82, 0x60, 0x30, 0xA0, 0x06, 0x70, 0x00, 0x98, 0x00, 0x36, 0x00,
  0x0D, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02,
  0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03, 0x18,
  0x00, 0x82, 0x00, 0x40, 0xC0, 0x30, 0x1C, 0x38, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0x8E, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x20, 0x01, 0x03, 0x00, 0x0C,
  0x10, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00,
  0x04, 0x10, 0x00, 0x60, 0xC0, 0x06, 0x02, 0x00, 0x20, 0x18, 0x06, 0x00,
  0x30, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00, 0x60, 0x30, 0x01,
  0x83, 0x00, 0x04, 0x10, 0x00, 0x21, 0x00, 0x01, 0x88, 0x00, 0x0C, 0xC0,
  0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x11, 0x80, 0x01, 0x8C, 0x00, 0x08,
  0x20, 0x00, 0x81, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x1C, 0x38, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xE1, 0x80, 0x60, 0x10, 0x30, 0x06, 0x18,
  0x00, 0x84, 0x00, 0x33, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x58, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0D,
  0x00, 0x02, 0x40, 0x01, 0x90, 0x00, 0x66, 0x00, 0x28, 0x80, 0x16, 0x30,
  0x19, 0x07, 0x1C, 0x40, 0x7C, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x20, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x38, 0x61, 0x80, 0x8C, 0x03, 0x20,
  0x05, 0x00, 0x14, 0x00, 0x70, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x1F,
  0x00, 0x21, 0x80, 0x30, 0xC0, 0x10, 0x80, 0x30, 0x30, 0x08, 0xC0, 0x30,
  0x08, 0x04, 0x40, 0x30, 0x0C, 0x02, 0x60, 0x10, 0x04, 0x01, 0x20, 0x10,
  0x02, 0x00, 0x90, 0x08, 0x01, 0x00, 0x58, 0x0C, 0x01, 0x80, 0x68, 0x04,
  0x00, 0x80, 0x24, 0x06, 0x00, 0x40, 0x16, 0x02, 0x00, 0x20, 0x0B, 0x01,
  0x00, 0x30, 0x0D, 0x00, 0x80, 0x10, 0x04, 0x80, 0xC0, 0x08, 0x02, 0x40,
  0x40, 0x0C, 0x03, 0x20, 0x20, 0x06, 0x01, 0x10, 0x10, 0x06, 0x00, 0x88,
  0x08, 0x03, 0x00, 0x84, 0x04, 0x02, 0x80, 0xC2, 0x01, 0x02, 0x60, 0xC1,
  0x00, 0xC6, 0x18, 0xC0, 0x80, 0x3E, 0x07, 0x80, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x00,
  0x00, 0x14, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x19, 0x00, 0x00,
  0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x60, 0x00, 0x60, 0x80, 0x01, 0x02,
  0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x04, 0x02, 0x00,
  0x10, 0x0C, 0x00, 0x80, 0x30, 0x02, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40,
  0x04, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x40, 0x01, 0x81, 0xFF, 0xFE,
  0x0C, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x02, 0x30,
  0x00, 0x08, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x03, 0xFF, 0x00, 0x30, 0x06, 0x01, 0x80, 0x0C,
  0x08, 0x00, 0x20, 0x40, 0x01, 0x82, 0x00, 0x04, 0x10, 0x00, 0x21, 0x80,
  0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x20,
  0x80, 0x03, 0x0C, 0x00, 0x30, 0x40, 0x03, 0x02, 0x00, 0xE0, 0x1F, 0xFE,
  0x00, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x60, 0x00, 0xC2, 0x00, 0x02, 0x10,
  0x00, 0x10, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x01,
  0x10, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x63, 0x00,
  0x06, 0x10, 0x00, 0x60, 0x80, 0x1E, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0x83, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x08,
  0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0xC0,
  0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x06,
  0x30, 0x00, 0x10, 0xC0, 0x00, 0xC1, 0x00, 0x02, 0x06, 0x00, 0x10, 0x0C,
  0x01, 0x80, 0x1C, 0x1C, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0C,
  0x01, 0xC0, 0x18, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x80,
  0x00, 0x81, 0x00, 0x01, 0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00,
  0xC4, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x11, 0x80, 0x00, 0x62, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00,
  0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x10, 0x30, 0x00,
  0x60, 0x40, 0x03, 0x00, 0x80, 0x3C, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x60, 0x00, 0x40, 0x80, 0x00, 0x83, 0x00, 0x01, 0x84, 0x00,
  0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x7F, 0xC4,
  0x00, 0x00, 0x88, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x11, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01, 0x84, 0x00,
  0x03, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x0E, 0x1F,
  0x00, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x1F, 0xFF, 0xFE, 0x04,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x20, 0x00, 0x04,
  0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x08, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x00, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81,
  0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x80, 0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0x41,
  0x00, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x02, 0x01, 0x00, 0x30, 0x0C, 0x03,
  0x00, 0x38, 0x70, 0x00, 0x7E, 0x00, 0x00, 0x02, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x40, 0x03, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x00, 0x08, 0x01, 0x00, 0x04,
  0x01, 0x00, 0x02, 0x01, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x11, 0x40, 0x00,
  0x09, 0x30, 0x00, 0x05, 0x08, 0x00, 0x07, 0x06, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x40, 0x08, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x08, 0x00, 0x20, 0x04, 0x00,
  0x18, 0x02, 0x00, 0x04, 0x03, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x60, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0x03, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x05, 0x00, 0x00, 0x0E, 0x05, 0x00, 0x00, 0x0A, 0x05, 0x00,
  0x00, 0x1A, 0x05, 0x80, 0x00, 0x12, 0x0C, 0x80, 0x00, 0x36, 0x08, 0x80,
  0x00, 0x26, 0x08, 0x80, 0x00, 0x44, 0x08, 0x80, 0x00, 0x44, 0x08, 0xC0,
  0x00, 0x84, 0x08, 0x40, 0x00, 0x84, 0x18, 0x40, 0x01, 0x0C, 0x10, 0x40,
  0x03, 0x0C, 0x10, 0x40, 0x02, 0x08, 0x10, 0x40, 0x06, 0x08, 0x10, 0x60,
  0x04, 0x08, 0x10, 0x20, 0x0C, 0x08, 0x30, 0x20, 0x08, 0x18, 0x20, 0x20,
  0x18, 0x10, 0x20, 0x20, 0x10, 0x10, 0x20, 0x30, 0x30, 0x10, 0x20, 0x10,
  0x20, 0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x40, 0x30, 0x40, 0x10,
  0x80, 0x20, 0x40, 0x10, 0x80, 0x20, 0x40, 0x19, 0x00, 0x20, 0x40, 0x0B,
  0x00, 0x20, 0xC0, 0x0A, 0x00, 0x60, 0xC0, 0x0E, 0x00, 0x60, 0x80, 0x0C,
  0x00, 0x40, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x00, 0x41, 0xC0, 0x00,
  0x10, 0x70, 0x00, 0x0C, 0x14, 0x00, 0x02, 0x04, 0x80, 0x00, 0x81, 0x20,
  0x00, 0x20, 0x48, 0x00, 0x08, 0x31, 0x00, 0x06, 0x0C, 0x40, 0x01, 0x82,
  0x18, 0x00, 0x40, 0x82, 0x00, 0x10, 0x20, 0x80, 0x04, 0x08, 0x10, 0x01,
  0x06, 0x04, 0x00, 0xC1, 0x81, 0x80, 0x30, 0x40, 0x20, 0x08, 0x10, 0x08,
  0x02, 0x04, 0x01, 0x00, 0x83, 0x00, 0x40, 0x20, 0xC0, 0x18, 0x18, 0x30,
  0x02, 0x06, 0x08, 0x00, 0x81, 0x02, 0x00, 0x10, 0x40, 0x80, 0x04, 0x10,
  0x60, 0x01, 0x8C, 0x18, 0x00, 0x23, 0x04, 0x00, 0x08, 0xC1, 0x00, 0x03,
  0x20, 0x40, 0x00, 0x48, 0x10, 0x00, 0x12, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x00, 0xE0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xC1, 0xC0, 0x06, 0x00, 0xC0, 0x10, 0x00, 0x40, 0x60, 0x00, 0xC1,
  0x80, 0x00, 0x82, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x0C, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01,
  0x20, 0x00, 0x06, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x84, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x10, 0x18,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0x40, 0x20, 0x00, 0x40, 0x40,
  0x00, 0xC0, 0x80, 0x00, 0x81, 0x00, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00,
  0x83, 0x00, 0x01, 0x04, 0x00, 0x06, 0x08, 0x00, 0x18, 0x10, 0x00, 0x60,
  0x20, 0x01, 0x80, 0x40, 0x0E, 0x01, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x70, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x04, 0x02, 0x00, 0x06, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00,
  0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x60, 0x00, 0x20, 0x20, 0x00, 0x40, 0x30, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x20, 0x00,
  0x40, 0x40, 0x00, 0xC0, 0x80, 0x00, 0x83, 0x00, 0x01, 0x06, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x61,
  0x80, 0x00, 0x83, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x10, 0x10,
  0x00, 0x40, 0x20, 0x07, 0x00, 0xFF, 0xF8, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x80, 0x60, 0x01,
  0x00, 0x80, 0x02, 0x01, 0x00, 0x06, 0x02, 0x00, 0x04, 0x04, 0x00, 0x0C,
  0x08, 0x00, 0x18, 0x30, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x61,
  0x00, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x20, 0x00, 0x40, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x84,
  0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00, 0x00, 0x46, 0x00, 0x01, 0x84,
  0x00, 0x02, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x0E,
  0x0E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10,
  0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0xC0,
  0x00, 0xC0, 0x40, 0x00, 0x80, 0x60, 0x01, 0x00, 0x30, 0x06, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x02, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x00, 0x80, 0x80, 0x03,
  0x01, 0x00, 0x04, 0x02, 0x00, 0x18, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x10, 0x00,
  0x80, 0x60, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x02, 0x04, 0x00, 0x04,
  0x18, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x21, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x70, 0x00, 0x68,
  0x00, 0x2C, 0x00, 0x24, 0x00, 0x12, 0x00, 0x12, 0x00, 0x11, 0x00, 0x19,
  0x80, 0x08, 0x80, 0x08, 0xC0, 0x0C, 0x40, 0x04, 0x60, 0x04, 0x20, 0x06,
  0x30, 0x06, 0x10, 0x02, 0x18, 0x02, 0x08, 0x03, 0x04, 0x01, 0x04, 0x01,
  0x02, 0x01, 0x82, 0x00, 0x81, 0x00, 0x81, 0x00, 0xC0, 0x80, 0xC0, 0xC0,
  0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x10, 0x30, 0x10, 0x30, 0x08,
  0x10, 0x08, 0x10, 0x04, 0x18, 0x04, 0x18, 0x02, 0x08, 0x02, 0x08, 0x01,
  0x04, 0x01, 0x84, 0x00, 0x86, 0x00, 0xC6, 0x00, 0x42, 0x00, 0x62, 0x00,
  0x21, 0x00, 0x33, 0x00, 0x19, 0x80, 0x19, 0x00, 0x0C, 0x80, 0x04, 0x80,
  0x06, 0xC0, 0x02, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x40, 0x20, 0x00, 0x18, 0x04,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x08, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x10, 0x01, 0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x18, 0x00, 0x04,
  0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x20, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x03, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x20, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x08, 0x01, 0x80, 0x03,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0x20, 0x04, 0x00, 0x04,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x06, 0x80, 0x00, 0x19, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00,
  0x03, 0x06, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x60, 0x18, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x10, 0x00, 0x40, 0x40,
  0x00, 0x81, 0x80, 0x01, 0x82, 0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00,
  0x04, 0x40, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x3E, 0x00, 0x81, 0x03, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC1,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0x40, 0x81, 0x02, 0x06, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60,
  0x01, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x7E, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24,
  0x04, 0x60, 0x42, 0x08, 0x20, 0x82, 0x10, 0x23, 0x02, 0x20, 0x36, 0x03,
  0x40, 0x1C, 0x01, 0x80, 0x10, 0xFF, 0xFF, 0xC2, 0x18, 0x43, 0x08, 0x00,
  0xFE, 0x00, 0xE0, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x08, 0x00, 0xC4, 0x00,
  0x11, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x01, 0xFF, 0x83, 0xC0, 0x61, 0x80, 0x18, 0x80, 0x04, 0x40,
  0x01, 0x30, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x01,
  0x88, 0x00, 0xA3, 0x00, 0xC8, 0x70, 0xE2, 0x07, 0xE0, 0x80, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0xFC,
  0x06, 0x70, 0xC0, 0xD0, 0x0C, 0x14, 0x00, 0x83, 0x00, 0x18, 0x40, 0x01,
  0x08, 0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0x44, 0x00, 0x19, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x62, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x43,
  0x00, 0x08, 0x70, 0x02, 0x0B, 0x00, 0x81, 0x38, 0x60, 0x61, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xE0, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x08, 0x00, 0x46,
  0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x04, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x10,
  0x00, 0x86, 0x00, 0x60, 0xC0, 0x30, 0x1C, 0x38, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x7E, 0x08, 0x06, 0x0C, 0xC0, 0x40, 0x34, 0x04, 0x00, 0xA0,
  0x60, 0x03, 0x02, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00,
  0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02,
  0x08, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x40,
  0x0E, 0x03, 0x00, 0xF0, 0x0C, 0x19, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x60, 0xC0, 0x60, 0x18, 0x10, 0x03, 0x08, 0x00, 0x46, 0x00, 0x11,
  0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x16, 0x00, 0x05, 0xFF,
  0xFF, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x20, 0xC0, 0x18, 0x1C, 0x38, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x07, 0xFE, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x00, 0x7E, 0x18, 0x06, 0x1C, 0xC0, 0x40, 0x34, 0x04, 0x00, 0xA0, 0x40,
  0x03, 0x02, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x20,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08,
  0x00, 0x30, 0x40, 0x01, 0x82, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x40, 0x0E,
  0x03, 0x00, 0xD0, 0x0C, 0x19, 0x80, 0x3F, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x40, 0x04, 0x03, 0x00, 0xC0, 0x0E, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0xFC, 0x06, 0x30, 0xC0, 0xC8, 0x0C, 0x12, 0x00, 0x82, 0x80, 0x10, 0x60,
  0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0x84, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x03, 0x10, 0x00,
  0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x60, 0x01,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x41,
  0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x1E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x18, 0x10, 0x06, 0x02, 0x01, 0x80,
  0x40, 0x60, 0x08, 0x18, 0x03, 0x06, 0x00, 0x61, 0x80, 0x08, 0x60, 0x01,
  0x10, 0x00, 0x26, 0x00, 0x05, 0x60, 0x01, 0xC4, 0x00, 0x30, 0xC0, 0x04,
  0x08, 0x00, 0x81, 0x80, 0x10, 0x10, 0x02, 0x03, 0x00, 0xC0, 0x20, 0x10,
  0x06, 0x02, 0x00, 0x40, 0x40, 0x0C, 0x08, 0x00, 0x81, 0x00, 0x18, 0x60,
  0x01, 0x00, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x00, 0x0C, 0x3F,
  0x00, 0xFC, 0x04, 0x70, 0xC1, 0xC3, 0x02, 0x60, 0x31, 0x80, 0xC1, 0x60,
  0x09, 0x80, 0x20, 0xA0, 0x05, 0x80, 0x10, 0xE0, 0x02, 0x80, 0x08, 0x70,
  0x01, 0x80, 0x06, 0x30, 0x00, 0xC0, 0x02, 0x18, 0x00, 0x40, 0x01, 0x08,
  0x00, 0x20, 0x00, 0x84, 0x00, 0x10, 0x00, 0x46, 0x00, 0x08, 0x00, 0x23,
  0x00, 0x0C, 0x00, 0x31, 0x00, 0x04, 0x00, 0x18, 0x80, 0x02, 0x00, 0x08,
  0x40, 0x01, 0x00, 0x04, 0x20, 0x00, 0x80, 0x02, 0x30, 0x00, 0x40, 0x01,
  0x18, 0x00, 0x60, 0x01, 0x88, 0x00, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x00,
  0x42, 0x00, 0x08, 0x00, 0x21, 0x00, 0x04, 0x00, 0x11, 0x80, 0x02, 0x00,
  0x08, 0xC0, 0x03, 0x00, 0x0C, 0x40, 0x01, 0x00, 0x06, 0x00, 0x04, 0x3F,
  0x01, 0x8C, 0x30, 0x22, 0x03, 0x04, 0x80, 0x20, 0xA0, 0x04, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x21, 0x00, 0x04, 0x60, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x30, 0x00, 0xC4, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x60,
  0x00, 0xFC, 0x00, 0xE1, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x18, 0x00, 0xC4,
  0x00, 0x13, 0x00, 0x04, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x05, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x30,
  0x01, 0x84, 0x00, 0xC1, 0x80, 0x60, 0x38, 0x70, 0x03, 0xF0, 0x00, 0x02,
  0x1F, 0x80, 0x67, 0x0C, 0x04, 0x80, 0x60, 0x50, 0x02, 0x06, 0x00, 0x30,
  0x40, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00,
  0x04, 0x20, 0x00, 0x83, 0x00, 0x08, 0x38, 0x01, 0x02, 0xC0, 0x30, 0x67,
  0x0C, 0x06, 0x1F, 0x80, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x20, 0x61, 0xCC, 0x10, 0x0D,
  0x04, 0x00, 0xA1, 0x80, 0x0C, 0x20, 0x01, 0x88, 0x00, 0x31, 0x00, 0x06,
  0x60, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22,
  0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x21, 0x80, 0x0C, 0x10, 0x03, 0x83,
  0x00, 0xD0, 0x30, 0xE6, 0x03, 0xF0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x04, 0x3C, 0x33, 0x00, 0x98,
  0x02, 0x80, 0x0A, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xC3, 0x81, 0x00, 0x41,
  0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x33, 0x00, 0x10, 0xC0, 0x30, 0x38, 0x70, 0x07, 0xE0,
  0x00, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x0F, 0xFC, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xF0, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01,
  0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x46, 0x00, 0x18,
  0xC0, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x02, 0x83,
  0x00, 0x90, 0x30, 0x66, 0x03, 0xF0, 0xC0, 0x80, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0x80, 0x08,
  0x60, 0x08, 0x10, 0x04, 0x08, 0x06, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01,
  0x00, 0xC1, 0x80, 0x60, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x04, 0x60, 0x02,
  0x20, 0x01, 0x90, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x50, 0x01, 0x80, 0x0A, 0x00, 0x30,
  0x03, 0x40, 0x0A, 0x00, 0x4C, 0x01, 0x40, 0x19, 0x80, 0x68, 0x02, 0x30,
  0x09, 0x00, 0xC6, 0x03, 0x20, 0x18, 0xC0, 0x46, 0x02, 0x08, 0x08, 0xC0,
  0xC1, 0x02, 0x18, 0x10, 0x20, 0x41, 0x06, 0x04, 0x18, 0x20, 0xC0, 0x82,
  0x04, 0x10, 0x10, 0xC0, 0x86, 0x02, 0x10, 0x10, 0x80, 0x42, 0x02, 0x30,
  0x08, 0x80, 0x46, 0x01, 0x10, 0x08, 0x80, 0x36, 0x01, 0x30, 0x06, 0x80,
  0x34, 0x00, 0xF0, 0x06, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00, 0x04, 0x00, 0x10, 0x30, 0x01,
  0x80, 0x80, 0x18, 0x06, 0x00, 0x80, 0x10, 0x08, 0x00, 0x80, 0xC0, 0x06,
  0x04, 0x00, 0x10, 0x40, 0x00, 0xC6, 0x00, 0x02, 0x60, 0x00, 0x12, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x13,
  0x00, 0x01, 0x88, 0x00, 0x18, 0x40, 0x00, 0x81, 0x00, 0x08, 0x08, 0x00,
  0xC0, 0x60, 0x04, 0x01, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x20, 0x60, 0x01,
  0x82, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x10, 0x00, 0x40, 0x20, 0x01, 0x00, 0x40, 0x02, 0x00, 0x80, 0x0C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x02, 0x00, 0x80, 0x04, 0x03, 0x00,
  0x08, 0x04, 0x00, 0x10, 0x18, 0x00, 0x30, 0x20, 0x00, 0x60, 0xC0, 0x00,
  0x41, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04,
  0x40, 0x00, 0x0D, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x38, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x03, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x01,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x04, 0x63, 0x00, 0x32, 0x06, 0x00,
  0x98, 0x08, 0x02, 0x40, 0x10, 0x19, 0x00, 0x60, 0x4C, 0x00, 0xC6, 0x20,
  0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ThinItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 34, 9, 1, -34 },
  { 31, 8, 10, 12, 5, -36 },
  { 41, 24, 34, 23, 1, -34 },
  { 143, 20, 42, 23, 2, -38 },
  { 248, 23, 34, 30, 4, -34 },
  { 346, 22, 34, 25, 1, -34 },
  { 440, 3, 10, 8, 5, -36 },
  { 444, 13, 49, 13, 2, -38 },
  { 524, 13, 49, 13, -3, -38 },
  { 604, 18, 19, 20, 3, -34 },
  { 647, 20, 25, 23, 2, -28 },
  { 710, 5, 10, 9, -1, -4 },
  { 717, 9, 1, 13, 2, -16 },
  { 719, 3, 3, 10, 1, -3 },
  { 721, 20, 37, 16, -2, -34 },
  { 814, 19, 34, 23, 2, -34 },
  { 895, 10, 34, 23, 7, -34 },
  { 938, 20, 34, 23, 1, -34 },
  { 1023, 20, 34, 23, 1, -34 },
  { 1108, 20, 34, 23, 1, -34 },
  { 1193, 20, 34, 23, 3, -34 },
  { 1278, 18, 34, 23, 2, -34 },
  { 1355, 19, 34, 23, 4, -34 },
  { 1436, 21, 34, 23, 1, -34 },
  { 1526, 18, 34, 23, 3, -34 },
  { 1603, 6, 25, 8, 1, -25 },
  { 1622, 9, 31, 8, -2, -25 },
  { 1657, 18, 19, 21, 2, -25 },
  { 1700, 18, 11, 23, 3, -21 },
  { 1725, 18, 19, 21, 1, -25 },
  { 1768, 14, 34, 18, 4, -34 },
  { 1828, 33, 44, 37, 2, -33 },
  { 2010, 22, 34, 25, -1, -34 },
  { 2104, 21, 34, 25, 2, -34 },
  { 2194, 22, 34, 26, 3, -34 },
  { 2288, 23, 34, 27, 2, -34 },
  { 2386, 23, 34, 23, 2, -34 },
  { 2484, 23, 34, 23, 2, -34 },
  { 2582, 23, 34, 28, 3, -34 },
  { 2680, 26, 34, 29, 2, -34 },
  { 2791, 7, 34, 11, 3, -34 },
  { 2821, 21, 34, 23, 1, -34 },
  { 2911, 25, 34, 26, 2, -34 },
  { 3018, 16, 34, 21, 2, -34 },
  { 3086, 32, 34, 35, 2, -34 },
  { 3222, 26, 34, 29, 2, -34 },
  { 3333, 23, 34, 27, 3, -34 },
  { 3431, 23, 34, 25, 2, -34 },
  { 3529, 24, 40, 27, 2, -34 },
  { 3649, 23, 34, 27, 2, -34 },
  { 3747, 23, 34, 24, 1, -34 },
  { 3845, 21, 34, 24, 5, -34 },
  { 3935, 24, 34, 27, 3, -34 },
  { 4037, 23, 34, 25, 4, -34 },
  { 4135, 33, 34, 37, 5, -34 },
  { 4276, 27, 34, 25, -1, -34 },
  { 4391, 23, 34, 24, 4, -34 },
  { 4489, 25, 34, 25, 0, -34 },
  { 4596, 13, 46, 9, 0, -39 },
  { 4671, 7, 37, 16, 5, -34 },
  { 4704, 13, 46, 9, -3, -39 },
  { 4779, 12, 17, 17, 3, -34 },
  { 4805, 16, 1, 17, -2, 0 },
  { 4807, 5, 6, 12, 7, -36 },
  { 4811, 18, 26, 22, 1, -26 },
  { 4870, 19, 36, 23, 1, -36 },
  { 4956, 18, 26, 21, 1, -26 },
  { 5015, 21, 36, 23, 2, -36 },
  { 5110, 18, 26, 21, 1, -26 },
  { 5169, 14, 36, 13, 3, -36 },
  { 5232, 21, 36, 23, 0, -26 },
  { 5327, 19, 36, 22, 1, -36 },
  { 5413, 7, 36, 9, 2, -36 },
  { 5445, 15, 46, 9, -6, -36 },
  { 5532, 19, 36, 20, 1, -36 },
  { 5618, 7, 36, 9, 2, -36 },
  { 5650, 33, 26, 36, 1, -26 },
  { 5758, 19, 26, 23, 1, -26 },
  { 5820, 18, 26, 23, 2, -26 },
  { 5879, 20, 36, 23, 0, -26 },
  { 5969, 19, 36, 23, 2, -26 },
  { 6055, 14, 26, 14, 1, -26 },
  { 6101, 17, 26, 21, 1, -26 },
  { 6157, 10, 32, 13, 3, -32 },
  { 6197, 19, 26, 23, 2, -26 },
  { 6259, 17, 26, 20, 3, -26 },
  { 6315, 27, 26, 31, 4, -26 },
  { 6403, 21, 26, 20, -1, -26 },
  { 6472, 23, 36, 20, -2, -26 },
  { 6576, 19, 26, 20, 0, -26 },
  { 6638, 15, 47, 14, 2, -37 },
  { 6727, 8, 40, 9, 1, -34 },
  { 6767, 15, 47, 14, -3, -37 },
  { 6856, 22, 8, 28, 3, -18 },
};

const GFXfont RobotoCondensed_ThinItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_THINITALIC48PT7B_H_
