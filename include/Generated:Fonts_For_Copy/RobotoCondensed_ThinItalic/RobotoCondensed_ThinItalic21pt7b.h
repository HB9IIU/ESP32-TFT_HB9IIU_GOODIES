#ifndef _ROBOTOCONDENSED_THINITALIC21PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x22, 0x44, 0x40, 0x00, 0x80, 0x55, 0xAA, 0x02,
  0x40, 0x88, 0x11, 0x02, 0x43, 0xFE, 0x11, 0x02, 0x40, 0x88, 0x11, 0x02,
  0x43, 0xFE, 0x11, 0x02, 0x40, 0x88, 0x11, 0x00, 0x04, 0x04, 0x1A, 0x21,
  0x21, 0x41, 0x40, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x82, 0x82, 0x84,
  0x78, 0x10, 0x20, 0x30, 0x12, 0x08, 0x8A, 0x24, 0x8A, 0x24, 0x86, 0x40,
  0x20, 0x0B, 0x85, 0x12, 0x44, 0x91, 0x44, 0x41, 0x20, 0x30, 0x0E, 0x09,
  0x08, 0x44, 0x42, 0x21, 0x60, 0x40, 0x60, 0x48, 0xC4, 0x61, 0x50, 0x68,
  0x24, 0x29, 0xE4, 0x6A, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x40, 0x80, 0x10, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22, 0x11, 0x08, 0x84, 0x40, 0x08,
  0x08, 0x08, 0x6F, 0x10, 0x28, 0x24, 0x44, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x25, 0x40, 0xF0, 0xC0, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x1E, 0x21, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x78, 0x3D, 0x11, 0x11, 0x22, 0x22,
  0x22, 0x44, 0x40, 0x1E, 0x21, 0x41, 0x41, 0x01, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0xFE, 0x1E, 0x21, 0x41, 0x41, 0x01, 0x01,
  0x02, 0x1C, 0x02, 0x02, 0x01, 0x81, 0x82, 0x84, 0x78, 0x00, 0x80, 0xC0,
  0xA0, 0x60, 0x50, 0x48, 0x44, 0x22, 0x21, 0x21, 0x1F, 0xE0, 0x40, 0x20,
  0x10, 0x08, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x01, 0x01, 0xF0, 0x84, 0x01,
  0x00, 0x80, 0x50, 0x28, 0x22, 0x10, 0xF0, 0x07, 0x18, 0x20, 0x20, 0x40,
  0x5C, 0xE2, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0xFF, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80,
  0x80, 0x0F, 0x04, 0x21, 0x04, 0x81, 0x20, 0x48, 0x22, 0x10, 0x78, 0x31,
  0x10, 0x24, 0x0A, 0x02, 0x81, 0x10, 0x83, 0xC0, 0x1E, 0x21, 0x41, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x02, 0x02, 0x04, 0x08, 0x70, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x44, 0x80, 0x03,
  0x0C, 0x30, 0x40, 0xC0, 0x20, 0x18, 0x04, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x40, 0x60, 0x30, 0x10, 0x63, 0x18, 0x40, 0x39, 0x18, 0x61, 0x04,
  0x10, 0x84, 0x21, 0x04, 0x00, 0x00, 0x08, 0x00, 0x03, 0xF0, 0x30, 0x21,
  0x00, 0x48, 0x01, 0x23, 0xC5, 0x10, 0x14, 0x44, 0x62, 0x11, 0x88, 0x46,
  0x22, 0x19, 0x08, 0x64, 0x22, 0x91, 0x8A, 0x39, 0xC8, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x40, 0x28, 0x0A, 0x04,
  0x81, 0x20, 0x88, 0x22, 0x10, 0x47, 0xE2, 0x04, 0x81, 0x40, 0x50, 0x18,
  0x04, 0x3F, 0x10, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x04, 0xFC, 0x41, 0x20,
  0xA0, 0x30, 0x28, 0x14, 0x13, 0xF0, 0x0F, 0x84, 0x12, 0x05, 0x01, 0x40,
  0x50, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0A, 0x02, 0x81, 0x10, 0x83,
  0xC0, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40,
  0x50, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x8F, 0xC0, 0x3F, 0xC8, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xE0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0xFC, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F, 0x84,
  0x12, 0x04, 0x81, 0x40, 0x10, 0x04, 0x01, 0x00, 0x87, 0xE0, 0x18, 0x0A,
  0x02, 0x40, 0x90, 0x63, 0xE0, 0x20, 0x24, 0x04, 0x80, 0x90, 0x14, 0x02,
  0x80, 0x90, 0x13, 0xFE, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x20, 0x24, 0x92, 0x52, 0x49, 0x49, 0x20, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x12, 0x04, 0x82,
  0x10, 0x83, 0xC0, 0x20, 0x44, 0x10, 0x84, 0x11, 0x04, 0x40, 0x90, 0x14,
  0x03, 0x40, 0x48, 0x10, 0x82, 0x10, 0x41, 0x08, 0x21, 0x02, 0x20, 0x40,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x3F, 0x80, 0x20, 0x04, 0x80, 0x33, 0x00, 0x8C, 0x05, 0x50, 0x19, 0x40,
  0xA4, 0x84, 0x92, 0x12, 0x48, 0x89, 0x22, 0x48, 0x91, 0x22, 0x44, 0x86,
  0x12, 0x18, 0x48, 0x41, 0x00, 0x20, 0x26, 0x04, 0xC0, 0x94, 0x14, 0x82,
  0x90, 0x51, 0x12, 0x22, 0x44, 0x48, 0x4A, 0x09, 0x40, 0xA8, 0x19, 0x01,
  0x20, 0x20, 0x0F, 0x84, 0x12, 0x05, 0x01, 0x40, 0x50, 0x14, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x10, 0xC3, 0xC0, 0x3F, 0x08, 0x22,
  0x04, 0x81, 0x40, 0x50, 0x24, 0x09, 0x04, 0x7E, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x00, 0x0F, 0x84, 0x12, 0x05, 0x01, 0x40, 0x50, 0x14,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x10, 0xC3, 0xC0, 0x08,
  0x02, 0x00, 0x40, 0x3F, 0x08, 0x22, 0x05, 0x01, 0x40, 0x50, 0x14, 0x09,
  0x04, 0x7E, 0x20, 0x88, 0x22, 0x08, 0x81, 0x20, 0x48, 0x10, 0x0F, 0x82,
  0x08, 0x80, 0x90, 0x12, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x40, 0x48, 0x08, 0x82, 0x0F, 0x80, 0xFF, 0xC2, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x20, 0x24, 0x04, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x10, 0x86, 0x0F, 0x00, 0x80,
  0x20, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x84, 0x21, 0x10, 0x44, 0x12, 0x04,
  0x81, 0x20, 0x50, 0x08, 0x02, 0x00, 0x81, 0x03, 0x02, 0x0A, 0x0C, 0x14,
  0x28, 0x28, 0x50, 0x90, 0xA1, 0x22, 0x24, 0x44, 0x48, 0x90, 0x91, 0x21,
  0x41, 0x42, 0x83, 0x05, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x00, 0x20,
  0x22, 0x08, 0x41, 0x08, 0x40, 0x90, 0x14, 0x01, 0x80, 0x20, 0x0A, 0x02,
  0x40, 0x48, 0x10, 0x84, 0x10, 0x81, 0x20, 0x20, 0x80, 0x20, 0x24, 0x11,
  0x04, 0x42, 0x09, 0x02, 0x40, 0xA0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x1F, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x3F, 0xE0,
  0x1C, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10,
  0x42, 0x08, 0x38, 0x92, 0x44, 0x92, 0x49, 0x12, 0x49, 0x18, 0x42, 0x10,
  0x84, 0x42, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x09, 0x80, 0x08, 0x62,
  0x8A, 0x49, 0x18, 0x40, 0xFE, 0x94, 0x1E, 0x21, 0x21, 0x01, 0x01, 0x3F,
  0x41, 0x81, 0x82, 0x86, 0x7A, 0x20, 0x20, 0x20, 0x40, 0x40, 0x5E, 0x61,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0x3C, 0x42, 0x41,
  0x81, 0x80, 0x80, 0x80, 0x82, 0x84, 0x84, 0x78, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x11, 0xE9, 0x0C, 0x82, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x12,
  0x10, 0xF4, 0x3C, 0x85, 0x0C, 0x1F, 0xF0, 0x20, 0x40, 0x81, 0x09, 0xE0,
  0x0C, 0x20, 0x81, 0x02, 0x0F, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10,
  0x20, 0x40, 0x1E, 0x90, 0xC8, 0x28, 0x14, 0x12, 0x09, 0x04, 0x82, 0x41,
  0x21, 0x0F, 0x80, 0x40, 0x24, 0x21, 0xE0, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x5E, 0x61, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x20,
  0x04, 0x92, 0x52, 0x49, 0x20, 0x02, 0x00, 0x00, 0x00, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x23, 0x80, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x42, 0x44, 0x48, 0x50, 0xA0, 0xD0, 0x90, 0x88, 0x88,
  0x84, 0x84, 0x24, 0x94, 0x92, 0x4A, 0x49, 0x24, 0x2F, 0x3C, 0x61, 0x84,
  0x82, 0x09, 0x04, 0x14, 0x08, 0x28, 0x20, 0x90, 0x41, 0x20, 0x82, 0x41,
  0x05, 0x02, 0x0A, 0x08, 0x10, 0x5E, 0x61, 0x41, 0x41, 0x81, 0x82, 0x82,
  0x82, 0x82, 0x82, 0x82, 0x3E, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x78, 0x2F, 0x18, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x82,
  0x41, 0x21, 0x2F, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3D, 0x43, 0x41, 0x81,
  0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x7C, 0x04, 0x04, 0x04, 0x04, 0x59,
  0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x1E, 0x21, 0x41, 0x40,
  0x30, 0x0C, 0x02, 0x02, 0x82, 0x82, 0x7C, 0x21, 0x09, 0xF2, 0x21, 0x08,
  0x42, 0x21, 0x08, 0x30, 0x41, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x7C, 0x81, 0x82, 0x82, 0x44, 0x44, 0x48, 0x48, 0x48, 0x50,
  0x20, 0x20, 0x84, 0x10, 0x86, 0x30, 0xC6, 0x29, 0x45, 0x25, 0x28, 0xA5,
  0x18, 0xC3, 0x18, 0x42, 0x08, 0x00, 0x20, 0x10, 0x88, 0x82, 0x81, 0x80,
  0x40, 0x60, 0x48, 0x44, 0x21, 0x20, 0x80, 0x20, 0x48, 0x21, 0x08, 0x44,
  0x11, 0x04, 0x81, 0x20, 0x50, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x0C, 0x00, 0x3F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x40,
  0xFE, 0x04, 0x21, 0x04, 0x10, 0x82, 0x08, 0x21, 0x08, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x20, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44,
  0x44, 0x88, 0x10, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x42, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x10, 0x80, 0x38, 0x51, 0x18, 0x38,
};

const GFXglyph RobotoCondensed_ThinItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 4, 0, -15 },
  { 9, 4, 4, 5, 2, -16 },
  { 11, 11, 15, 10, 0, -15 },
  { 32, 8, 19, 10, 1, -17 },
  { 51, 10, 15, 13, 2, -15 },
  { 70, 9, 15, 11, 1, -15 },
  { 87, 2, 4, 3, 2, -16 },
  { 88, 6, 22, 6, 1, -17 },
  { 105, 5, 22, 6, -1, -17 },
  { 119, 8, 8, 9, 1, -15 },
  { 127, 8, 11, 10, 1, -13 },
  { 138, 3, 4, 4, -1, -2 },
  { 140, 4, 1, 5, 1, -8 },
  { 141, 2, 1, 4, 0, -1 },
  { 142, 9, 16, 7, -1, -15 },
  { 160, 8, 15, 10, 1, -15 },
  { 175, 4, 15, 10, 3, -15 },
  { 183, 8, 15, 10, 1, -15 },
  { 198, 8, 15, 10, 1, -15 },
  { 213, 9, 15, 10, 0, -15 },
  { 230, 9, 15, 10, 1, -15 },
  { 247, 8, 15, 10, 1, -15 },
  { 262, 8, 15, 10, 2, -15 },
  { 277, 10, 15, 10, 0, -15 },
  { 296, 8, 15, 10, 1, -15 },
  { 311, 3, 11, 4, 0, -11 },
  { 316, 4, 13, 4, -1, -11 },
  { 323, 8, 8, 9, 1, -11 },
  { 331, 8, 6, 10, 1, -10 },
  { 337, 7, 8, 9, 1, -11 },
  { 344, 6, 15, 8, 2, -15 },
  { 356, 14, 19, 16, 1, -14 },
  { 390, 10, 15, 11, -1, -15 },
  { 409, 9, 15, 11, 1, -15 },
  { 426, 10, 15, 12, 1, -15 },
  { 445, 10, 15, 12, 1, -15 },
  { 464, 10, 15, 10, 1, -15 },
  { 483, 10, 15, 10, 1, -15 },
  { 502, 10, 15, 12, 1, -15 },
  { 521, 11, 15, 13, 1, -15 },
  { 542, 3, 15, 5, 1, -15 },
  { 548, 10, 15, 10, 0, -15 },
  { 567, 11, 15, 11, 1, -15 },
  { 588, 7, 15, 9, 1, -15 },
  { 602, 14, 15, 15, 1, -15 },
  { 629, 11, 15, 13, 1, -15 },
  { 650, 10, 15, 12, 1, -15 },
  { 669, 10, 15, 11, 1, -15 },
  { 688, 10, 18, 12, 1, -15 },
  { 711, 10, 15, 12, 1, -15 },
  { 730, 11, 15, 11, 0, -15 },
  { 751, 10, 15, 11, 2, -15 },
  { 770, 11, 15, 12, 1, -15 },
  { 791, 10, 15, 11, 2, -15 },
  { 810, 15, 15, 16, 2, -15 },
  { 839, 11, 15, 11, 0, -15 },
  { 860, 10, 15, 11, 2, -15 },
  { 879, 11, 15, 11, 0, -15 },
  { 900, 6, 20, 4, 0, -17 },
  { 915, 3, 16, 7, 2, -15 },
  { 921, 5, 20, 4, -1, -17 },
  { 934, 6, 7, 8, 1, -15 },
  { 940, 7, 1, 8, -1, 0 },
  { 941, 2, 3, 5, 3, -16 },
  { 942, 8, 11, 10, 0, -11 },
  { 953, 8, 16, 10, 1, -16 },
  { 969, 8, 11, 9, 1, -11 },
  { 980, 9, 16, 10, 1, -16 },
  { 998, 7, 11, 9, 1, -11 },
  { 1008, 7, 16, 6, 1, -16 },
  { 1022, 9, 15, 10, 0, -11 },
  { 1039, 8, 16, 10, 1, -16 },
  { 1055, 3, 15, 4, 1, -15 },
  { 1061, 7, 19, 4, -3, -15 },
  { 1078, 8, 16, 9, 1, -16 },
  { 1094, 3, 16, 4, 1, -16 },
  { 1100, 15, 11, 16, 0, -11 },
  { 1121, 8, 11, 10, 1, -11 },
  { 1132, 8, 11, 10, 1, -11 },
  { 1143, 9, 15, 10, 0, -11 },
  { 1160, 8, 15, 10, 1, -11 },
  { 1175, 6, 11, 6, 1, -11 },
  { 1184, 8, 11, 9, 0, -11 },
  { 1195, 5, 14, 6, 1, -14 },
  { 1204, 8, 11, 10, 1, -11 },
  { 1215, 8, 11, 9, 1, -11 },
  { 1226, 11, 11, 13, 2, -11 },
  { 1242, 9, 11, 9, 0, -11 },
  { 1255, 10, 15, 9, -1, -11 },
  { 1274, 8, 11, 9, 0, -11 },
  { 1285, 6, 21, 6, 1, -16 },
  { 1301, 4, 18, 4, 0, -15 },
  { 1310, 6, 21, 6, -1, -16 },
  { 1326, 10, 3, 12, 1, -8 },
};

const GFXfont RobotoCondensed_ThinItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_THINITALIC21PT7B_H_
