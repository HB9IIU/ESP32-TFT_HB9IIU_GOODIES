#ifndef _ROBOTOCONDENSED_THINITALIC31PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x40, 0x00, 0x00, 0x88,
  0x4A, 0x52, 0x94, 0xC8, 0x00, 0x42, 0x00, 0x82, 0x00, 0x84, 0x00, 0x84,
  0x01, 0x04, 0x01, 0x08, 0x1F, 0xFF, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10,
  0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08, 0x40, 0x7F, 0xF8,
  0x10, 0x40, 0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x21, 0x00, 0x21, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x07, 0xC0, 0x41, 0x04, 0x08, 0x40, 0x22,
  0x01, 0x20, 0x09, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x09, 0x00, 0x48, 0x02, 0x40, 0x11,
  0x01, 0x0C, 0x10, 0x1F, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x1C, 0x01,
  0x88, 0x04, 0x20, 0x20, 0x82, 0x82, 0x12, 0x08, 0x48, 0x22, 0x21, 0x10,
  0x84, 0x81, 0xE2, 0x00, 0x10, 0x00, 0x80, 0x02, 0x38, 0x11, 0x10, 0x88,
  0x44, 0x21, 0x11, 0x04, 0x84, 0x14, 0x10, 0x40, 0x42, 0x00, 0x88, 0x03,
  0xC0, 0x03, 0xC0, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80,
  0x84, 0x02, 0x20, 0x09, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x80, 0x22, 0x05,
  0x04, 0x24, 0x08, 0xA0, 0x22, 0x80, 0x52, 0x01, 0x48, 0x02, 0x20, 0x18,
  0x41, 0x90, 0xF8, 0x20, 0x55, 0xA0, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xC4, 0x33, 0x5C, 0x0E,
  0x00, 0xA0, 0x12, 0x02, 0x10, 0x61, 0x04, 0x08, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x24, 0x95, 0x00, 0xFC, 0xA0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x03, 0xE0, 0x21, 0x82, 0x04, 0x20, 0x11,
  0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80,
  0x24, 0x01, 0x20, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x22, 0x02, 0x10, 0x10,
  0x81, 0x02, 0x10, 0x0F, 0x00, 0x06, 0x37, 0x90, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x00, 0x03, 0xC0, 0x61, 0x02, 0x04, 0x20, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x7F,
  0xF0, 0x03, 0xE0, 0x60, 0x86, 0x04, 0x20, 0x12, 0x00, 0x90, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x01, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x04, 0x80, 0x24, 0x01, 0x20, 0x08, 0x80, 0x86, 0x08, 0x0F,
  0x80, 0x00, 0x10, 0x01, 0x80, 0x14, 0x01, 0x20, 0x0A, 0x00, 0x90, 0x08,
  0x80, 0x44, 0x04, 0x20, 0x42, 0x04, 0x10, 0x20, 0x82, 0x04, 0x20, 0x21,
  0x01, 0x1F, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x2F, 0x01, 0x82, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x80, 0x44, 0x02, 0x20, 0x11, 0x01, 0x04, 0x10, 0x1F,
  0x00, 0x00, 0xF0, 0x30, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x27, 0xC4, 0x86, 0x50, 0x26, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x24, 0x02, 0x40, 0x44, 0x04, 0x20, 0x81, 0xF0, 0xFF, 0xF0,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x03, 0xE0, 0x20, 0x82, 0x02,
  0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0xC3, 0x01,
  0xE0, 0x30, 0x82, 0x02, 0x20, 0x12, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01,
  0x20, 0x09, 0x00, 0x84, 0x08, 0x1F, 0x80, 0x07, 0x81, 0x84, 0x30, 0x22,
  0x02, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x06, 0x40, 0xA6, 0x12, 0x1E, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x07, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x08, 0x21, 0x04, 0x20, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x00, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x80, 0x04, 0x04, 0x00, 0x08, 0x20, 0x00, 0x21, 0x01, 0xE0, 0x84,
  0x18, 0x41, 0x20, 0x41, 0x04, 0x82, 0x08, 0x14, 0x10, 0x20, 0x50, 0x40,
  0x82, 0x42, 0x02, 0x09, 0x08, 0x10, 0x28, 0x20, 0x40, 0xA0, 0x81, 0x02,
  0x84, 0x04, 0x12, 0x10, 0x20, 0x48, 0x41, 0x42, 0x20, 0x89, 0x10, 0x81,
  0xC3, 0x82, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x81, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00, 0x42, 0x00, 0x84,
  0x01, 0x08, 0x04, 0x10, 0x08, 0x20, 0x20, 0x40, 0x40, 0x81, 0x00, 0x83,
  0xFF, 0x08, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x12, 0x00, 0x24, 0x00,
  0x30, 0x00, 0x40, 0x0F, 0xE0, 0x20, 0x61, 0x00, 0x44, 0x01, 0x10, 0x04,
  0x40, 0x11, 0x00, 0x44, 0x02, 0x20, 0x08, 0x80, 0xC3, 0xFC, 0x08, 0x0C,
  0x20, 0x10, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01,
  0x10, 0x08, 0x80, 0x43, 0xFE, 0x00, 0x03, 0xF0, 0x30, 0x21, 0x80, 0x44,
  0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x02, 0x80, 0x12,
  0x00, 0x48, 0x02, 0x10, 0x08, 0x60, 0xC0, 0x7C, 0x00, 0x0F, 0xF0, 0x10,
  0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x01, 0x08, 0x0C,
  0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xC1,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xFF, 0xC1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xF0, 0x08, 0x10, 0x20, 0x10, 0x80, 0x12, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x1F, 0xD0, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x11, 0x00, 0x22, 0x00, 0x82, 0x06, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x84,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04,
  0x20, 0x02, 0x20, 0x01, 0x10, 0x01, 0x0F, 0xFF, 0x84, 0x00, 0x42, 0x00,
  0x21, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10,
  0x01, 0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x40, 0x11, 0x11, 0x12, 0x22,
  0x22, 0x24, 0x44, 0x44, 0x88, 0x88, 0x88, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x80, 0x44, 0x02,
  0x20, 0x21, 0x01, 0x04, 0x10, 0x1F, 0x00, 0x08, 0x01, 0x08, 0x02, 0x10,
  0x04, 0x10, 0x08, 0x10, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x22, 0x00, 0x26, 0x00, 0x2A, 0x00, 0x31, 0x00, 0x21, 0x00, 0x40,
  0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x40, 0x20, 0x40, 0x10, 0x80,
  0x10, 0x80, 0x08, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x3F, 0xF0, 0x08, 0x00, 0x08, 0x40, 0x00,
  0xC5, 0x00, 0x0A, 0x28, 0x00, 0x61, 0x40, 0x05, 0x0A, 0x00, 0x28, 0x50,
  0x02, 0x42, 0x40, 0x12, 0x22, 0x01, 0x11, 0x10, 0x09, 0x08, 0x80, 0x88,
  0x44, 0x04, 0x42, 0x20, 0x42, 0x10, 0x82, 0x11, 0x04, 0x20, 0x88, 0x22,
  0x08, 0x41, 0x10, 0x42, 0x09, 0x02, 0x10, 0x28, 0x10, 0x81, 0x80, 0x88,
  0x0C, 0x04, 0x40, 0x40, 0x40, 0x08, 0x00, 0x84, 0x00, 0x45, 0x00, 0x22,
  0x80, 0x11, 0x20, 0x10, 0x90, 0x08, 0x48, 0x04, 0x22, 0x02, 0x21, 0x01,
  0x10, 0x40, 0x88, 0x20, 0x84, 0x10, 0x42, 0x04, 0x21, 0x02, 0x11, 0x00,
  0x88, 0x80, 0x44, 0x40, 0x24, 0x20, 0x0A, 0x10, 0x05, 0x08, 0x02, 0x88,
  0x00, 0xC4, 0x00, 0x40, 0x03, 0xF0, 0x18, 0x10, 0x60, 0x10, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x0A, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x22, 0x00, 0x42, 0x01, 0x06, 0x0C, 0x03, 0xE0, 0x00, 0x0F, 0xF0,
  0x10, 0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88,
  0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21, 0x01, 0x83, 0xFC, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x18, 0x10, 0x60, 0x10, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x0A, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x22, 0x00, 0x42, 0x01, 0x06, 0x0C, 0x03, 0xE0, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x0F, 0xF0, 0x10, 0x10, 0x40, 0x10, 0x80,
  0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x21, 0x00, 0x83, 0xFE, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x01, 0x00, 0x03,
  0xF0, 0x08, 0x10, 0x20, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x42, 0x01,
  0x06, 0x04, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x10, 0x02, 0x40, 0x04,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x04, 0x80, 0x11, 0x00, 0x22, 0x00, 0x82, 0x01, 0x06, 0x0C, 0x03,
  0xE0, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00,
  0x44, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x04, 0x08, 0x10, 0x20, 0x21,
  0x00, 0x84, 0x02, 0x10, 0x08, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x28, 0x05,
  0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02,
  0x20, 0x44, 0x08, 0x41, 0x10, 0x21, 0x08, 0x41, 0x04, 0x21, 0x04, 0x10,
  0x84, 0x20, 0x44, 0x08, 0x81, 0x10, 0x22, 0x04, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x10, 0x01, 0x04, 0x00, 0x82, 0x00,
  0x80, 0x80, 0x80, 0x40, 0x80, 0x20, 0x40, 0x08, 0x40, 0x04, 0x40, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x20, 0x00, 0x30, 0x00, 0x24, 0x00, 0x12, 0x00,
  0x11, 0x00, 0x10, 0x40, 0x08, 0x20, 0x08, 0x08, 0x08, 0x04, 0x08, 0x02,
  0x04, 0x00, 0x84, 0x00, 0x40, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x04,
  0x40, 0x20, 0x80, 0x82, 0x04, 0x08, 0x20, 0x10, 0x80, 0x44, 0x01, 0x20,
  0x02, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xFF, 0xF8, 0x07, 0x82, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x07, 0x80, 0x84, 0x20, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x84, 0x21, 0x08, 0x41, 0x07, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0xF0, 0x04,
  0x0C, 0x0A, 0x12, 0x12, 0x22, 0x22, 0x42, 0x41, 0x81, 0x81, 0xFF, 0xC0,
  0x44, 0x22, 0x07, 0xC0, 0x82, 0x10, 0x11, 0x01, 0x20, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x0F, 0xE3, 0x02, 0x60, 0x24, 0x02, 0x40, 0x28, 0x06, 0x80,
  0xA4, 0x14, 0x3E, 0x40, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x13, 0xC2, 0xC2, 0x30, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x80, 0x28, 0x04, 0xC0, 0x4A,
  0x08, 0x9F, 0x00, 0x07, 0x81, 0x84, 0x20, 0x22, 0x02, 0x40, 0x14, 0x01,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x48, 0x04,
  0x80, 0x84, 0x10, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x78, 0x86, 0x14, 0x10, 0x30, 0x80, 0x44, 0x01,
  0x10, 0x04, 0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00,
  0x88, 0x04, 0x20, 0x10, 0x40, 0xC1, 0x05, 0x03, 0xE4, 0x00, 0x07, 0x81,
  0x84, 0x20, 0x22, 0x02, 0x40, 0x14, 0x01, 0x80, 0x2F, 0xFE, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x08, 0x3F, 0x00,
  0x03, 0x86, 0x02, 0x02, 0x01, 0x00, 0x83, 0xF8, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x03, 0xC8, 0x61, 0x42, 0x06, 0x20, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x20,
  0x10, 0x81, 0x84, 0x14, 0x1F, 0x20, 0x01, 0x00, 0x10, 0x00, 0x88, 0x08,
  0x20, 0x80, 0xF8, 0x00, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x13, 0xC2, 0x42, 0x28, 0x13, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x04, 0x80, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x44, 0x21, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x40, 0xE0, 0x00, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x32, 0x06, 0x20, 0xC2, 0x18, 0x23, 0x02,
  0x60, 0x2C, 0x05, 0x80, 0x68, 0x04, 0x40, 0x44, 0x04, 0x20, 0x82, 0x08,
  0x10, 0x81, 0x08, 0x08, 0x80, 0x80, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x00, 0x23, 0xC1, 0xE1,
  0x61, 0x30, 0x8A, 0x0A, 0x04, 0x60, 0x30, 0x12, 0x01, 0x00, 0x90, 0x08,
  0x05, 0x00, 0x80, 0x28, 0x04, 0x02, 0x40, 0x20, 0x12, 0x01, 0x00, 0x90,
  0x08, 0x04, 0x80, 0x40, 0x28, 0x04, 0x01, 0x40, 0x20, 0x12, 0x01, 0x00,
  0x90, 0x08, 0x04, 0x80, 0x40, 0x20, 0x23, 0xC2, 0x42, 0x28, 0x23, 0x01,
  0x20, 0x12, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x40, 0x07, 0xC1, 0x82, 0x10,
  0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x40, 0xC6, 0x18, 0x3E, 0x00, 0x11, 0xE0,
  0xB0, 0x86, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x48, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x80, 0x8A, 0x08,
  0x4F, 0x82, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x07, 0x91, 0x85, 0x10, 0x32, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02,
  0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40, 0xC4, 0x14,
  0x3E, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x27,
  0x94, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0,
  0x14, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x05, 0x01, 0x20, 0x26, 0x08, 0x3C, 0x00, 0x10, 0x41, 0x04, 0xFC, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x70, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x14, 0x02, 0x80, 0x50,
  0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x64, 0x14, 0x7C, 0x80, 0x80,
  0x30, 0x06, 0x01, 0x40, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08,
  0x41, 0x10, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x10, 0x00, 0x80,
  0x80, 0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x50, 0x48, 0x28, 0x24, 0x24, 0x12,
  0x12, 0x11, 0x09, 0x08, 0x88, 0x88, 0x44, 0x44, 0x24, 0x22, 0x12, 0x0A,
  0x0A, 0x05, 0x05, 0x03, 0x02, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x00,
  0x20, 0x10, 0x80, 0x84, 0x08, 0x10, 0x80, 0x84, 0x02, 0x40, 0x14, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x02, 0x40, 0x22, 0x01, 0x08, 0x10, 0x41, 0x02,
  0x08, 0x08, 0x80, 0x40, 0x10, 0x04, 0x40, 0x11, 0x00, 0x82, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x48, 0x01,
  0x20, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xC0, 0x00,
  0xC0, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x03, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x00, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x10, 0x03, 0x01, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x08, 0x00, 0x3C, 0x05,
  0x08, 0x14, 0x10, 0xA0, 0x42, 0x80, 0xF0,
};

const GFXglyph RobotoCondensed_ThinItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 6, 1, -22 },
  { 12, 5, 6, 8, 3, -23 },
  { 16, 16, 22, 15, 0, -22 },
  { 60, 13, 28, 15, 1, -25 },
  { 106, 14, 22, 20, 3, -22 },
  { 145, 14, 22, 16, 1, -22 },
  { 184, 2, 6, 5, 3, -23 },
  { 186, 8, 32, 8, 2, -25 },
  { 218, 9, 32, 8, -2, -25 },
  { 254, 12, 12, 13, 2, -22 },
  { 272, 13, 17, 15, 1, -19 },
  { 300, 3, 6, 6, -1, -2 },
  { 303, 6, 1, 8, 1, -11 },
  { 304, 2, 2, 7, 1, -2 },
  { 305, 12, 24, 10, -1, -22 },
  { 341, 13, 22, 15, 1, -22 },
  { 377, 7, 22, 15, 4, -22 },
  { 397, 13, 22, 15, 1, -22 },
  { 433, 13, 22, 15, 1, -22 },
  { 469, 13, 22, 15, 1, -22 },
  { 505, 13, 22, 15, 2, -22 },
  { 541, 12, 22, 15, 1, -22 },
  { 574, 12, 22, 15, 3, -22 },
  { 607, 13, 22, 15, 1, -22 },
  { 643, 12, 22, 15, 2, -22 },
  { 676, 5, 16, 5, 0, -16 },
  { 686, 6, 20, 5, -1, -16 },
  { 701, 12, 12, 14, 1, -16 },
  { 719, 11, 8, 15, 2, -14 },
  { 730, 11, 12, 14, 1, -16 },
  { 747, 9, 22, 12, 3, -22 },
  { 772, 22, 28, 24, 1, -21 },
  { 849, 15, 22, 16, -1, -22 },
  { 891, 14, 22, 16, 1, -22 },
  { 930, 14, 22, 17, 2, -22 },
  { 969, 15, 22, 17, 1, -22 },
  { 1011, 15, 22, 15, 1, -22 },
  { 1053, 15, 22, 15, 1, -22 },
  { 1095, 15, 22, 18, 2, -22 },
  { 1137, 17, 22, 18, 1, -22 },
  { 1184, 4, 22, 7, 2, -22 },
  { 1195, 13, 22, 15, 1, -22 },
  { 1231, 16, 22, 17, 1, -22 },
  { 1275, 10, 22, 14, 1, -22 },
  { 1303, 21, 22, 22, 1, -22 },
  { 1361, 17, 22, 19, 1, -22 },
  { 1408, 15, 22, 18, 2, -22 },
  { 1450, 15, 22, 16, 1, -22 },
  { 1492, 15, 26, 18, 2, -22 },
  { 1541, 15, 22, 17, 1, -22 },
  { 1583, 15, 22, 16, 1, -22 },
  { 1625, 14, 22, 16, 3, -22 },
  { 1664, 15, 22, 18, 2, -22 },
  { 1706, 14, 22, 16, 3, -22 },
  { 1745, 22, 22, 24, 3, -22 },
  { 1806, 17, 22, 16, 0, -22 },
  { 1853, 14, 22, 16, 3, -22 },
  { 1892, 16, 22, 16, 0, -22 },
  { 1936, 9, 30, 6, 0, -25 },
  { 1970, 5, 24, 10, 3, -22 },
  { 1985, 8, 30, 6, -2, -25 },
  { 2015, 8, 11, 11, 2, -22 },
  { 2026, 10, 1, 11, -1, 0 },
  { 2028, 4, 4, 8, 4, -23 },
  { 2030, 12, 17, 14, 0, -17 },
  { 2056, 12, 23, 15, 1, -23 },
  { 2091, 12, 17, 14, 1, -17 },
  { 2117, 14, 23, 15, 1, -23 },
  { 2158, 12, 17, 14, 1, -17 },
  { 2184, 9, 23, 9, 2, -23 },
  { 2210, 13, 23, 15, 0, -17 },
  { 2248, 12, 23, 15, 1, -23 },
  { 2283, 5, 23, 6, 1, -23 },
  { 2298, 10, 29, 6, -4, -23 },
  { 2335, 12, 23, 13, 1, -23 },
  { 2370, 5, 23, 6, 1, -23 },
  { 2385, 21, 17, 23, 1, -17 },
  { 2430, 12, 17, 15, 1, -17 },
  { 2456, 12, 17, 15, 1, -17 },
  { 2482, 13, 23, 15, 0, -17 },
  { 2520, 12, 23, 15, 1, -17 },
  { 2555, 9, 17, 9, 1, -17 },
  { 2575, 11, 17, 13, 1, -17 },
  { 2599, 6, 21, 9, 2, -21 },
  { 2615, 11, 17, 15, 2, -17 },
  { 2639, 11, 17, 13, 2, -17 },
  { 2663, 17, 17, 20, 3, -17 },
  { 2700, 13, 17, 13, 0, -17 },
  { 2728, 14, 23, 13, -1, -17 },
  { 2769, 12, 17, 13, 0, -17 },
  { 2795, 10, 31, 9, 1, -24 },
  { 2834, 5, 26, 6, 1, -22 },
  { 2851, 10, 31, 9, -2, -24 },
  { 2890, 14, 5, 18, 2, -12 },
};

const GFXfont RobotoCondensed_ThinItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_THINITALIC31PT7B_H_
