#ifndef _ROBOTOCONDENSED_THINITALIC10PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x08, 0xC0, 0x09, 0x4C, 0xA5, 0x30, 0x80, 0x03, 0x90, 0x82,
  0x0A, 0x5E, 0x00, 0xC5, 0xB8, 0x47, 0x94, 0xC0, 0x32, 0x98, 0x8A, 0xCB,
  0xC0, 0x80, 0x09, 0x29, 0x24, 0x80, 0x04, 0x92, 0x49, 0x40, 0x09, 0x40,
  0x06, 0x20, 0x80, 0x00, 0x80, 0x02, 0x24, 0x48, 0x80, 0x35, 0x59, 0x99,
  0xE0, 0x55, 0x50, 0x71, 0x11, 0x24, 0x60, 0x71, 0x13, 0x09, 0xF0, 0x03,
  0x35, 0x71, 0x00, 0x68, 0x8E, 0x12, 0xE0, 0x24, 0x79, 0x99, 0x60, 0x72,
  0x24, 0x48, 0x00, 0x32, 0x52, 0xE9, 0x4B, 0xC0, 0xF6, 0xDE, 0x70, 0x00,
  0x20, 0x00, 0x20, 0x34, 0x42, 0x48, 0x43, 0x2C, 0xE4, 0xA0, 0x00, 0x1E,
  0x45, 0x4D, 0x1A, 0xB5, 0x6F, 0xC0, 0x60, 0x13, 0x35, 0x79, 0x00, 0x7A,
  0x52, 0xE8, 0x46, 0xC0, 0x78, 0x88, 0x89, 0xE0, 0x1A, 0x52, 0x98, 0xC6,
  0xC0, 0x12, 0x10, 0xC8, 0x43, 0x80, 0x12, 0x10, 0xC8, 0x42, 0x00, 0x78,
  0x89, 0x89, 0xE0, 0x05, 0x14, 0x5D, 0x8A, 0x28, 0x80, 0x7C, 0x00, 0x44,
  0x21, 0x0B, 0x80, 0x09, 0x46, 0x18, 0x92, 0x48, 0x00, 0x04, 0x44, 0x88,
  0xE0, 0x02, 0x85, 0x1B, 0x5A, 0xB6, 0xA4, 0x00, 0x45, 0x16, 0x55, 0x9A,
  0x68, 0x80, 0x79, 0x99, 0x99, 0xE0, 0x7A, 0x52, 0xE8, 0x42, 0x00, 0x79,
  0x99, 0x99, 0xE0, 0x7A, 0x52, 0xC9, 0x4A, 0x00, 0x7A, 0x10, 0x60, 0xC7,
  0xC0, 0x71, 0x10, 0x84, 0x20, 0x00, 0x84, 0x65, 0x29, 0x4B, 0x80, 0x04,
  0xA5, 0x4A, 0x60, 0x00, 0x13, 0x66, 0xD5, 0xAD, 0x53, 0x20, 0x00, 0x42,
  0x4C, 0x45, 0x2A, 0x00, 0x04, 0xA8, 0x84, 0x20, 0x00, 0x38, 0x44, 0x44,
  0x21, 0x80, 0x09, 0x25, 0x24, 0x80, 0x7E, 0x04, 0x92, 0x52, 0x48, 0x7C,
  0x40, 0x00, 0x71, 0x79, 0xE0, 0x44, 0x47, 0x99, 0x9F, 0x78, 0x89, 0xE0,
  0x08, 0x42, 0xE9, 0x4A, 0x56, 0x7B, 0x88, 0xC0, 0x52, 0x49, 0x20, 0x79,
  0x99, 0xB1, 0xE0, 0x44, 0x47, 0x99, 0x99, 0x01, 0xA8, 0x00, 0x14, 0x92,
  0x00, 0x44, 0x45, 0xA8, 0xA8, 0x15, 0x6A, 0x7F, 0x26, 0x4C, 0x98, 0x00,
  0x75, 0x99, 0x90, 0x79, 0x99, 0xA0, 0x79, 0x99, 0xF8, 0x00, 0x79, 0x99,
  0xB1, 0x00, 0x4A, 0x48, 0x78, 0x61, 0xE0, 0x2A, 0xA0, 0x16, 0xDE, 0x17,
  0x48, 0x27, 0x7B, 0x68, 0x00, 0x16, 0x46, 0x80, 0x05, 0x64, 0x44, 0x00,
  0x32, 0x44, 0xC0, 0x05, 0x20, 0x12, 0x48, 0x55, 0xAA, 0x24, 0x90, 0x4A,
  0x40, 0xC3,
};

const GFXglyph RobotoCondensed_ThinItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -8 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 5, 7, 6, 1, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 2, 2, 1, -8 },
  { 26, 3, 10, 3, 0, -8 },
  { 30, 3, 10, 3, -1, -8 },
  { 34, 3, 4, 4, 1, -7 },
  { 36, 4, 4, 5, 0, -5 },
  { 38, 1, 2, 2, 0, -1 },
  { 39, 2, 1, 3, 0, -4 },
  { 40, 1, 1, 2, 0, -1 },
  { 41, 4, 8, 3, 0, -7 },
  { 45, 4, 7, 5, 0, -7 },
  { 49, 2, 7, 5, 1, -7 },
  { 51, 4, 7, 5, 0, -7 },
  { 55, 4, 7, 5, 0, -7 },
  { 59, 4, 7, 5, 0, -7 },
  { 63, 4, 7, 5, 1, -7 },
  { 67, 4, 7, 5, 0, -7 },
  { 71, 4, 7, 5, 1, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 3, 7, 5, 1, -7 },
  { 83, 2, 6, 2, 0, -6 },
  { 85, 2, 7, 2, 0, -6 },
  { 87, 4, 4, 4, 0, -5 },
  { 89, 3, 2, 5, 1, -4 },
  { 90, 4, 4, 4, 0, -5 },
  { 92, 3, 7, 4, 1, -7 },
  { 95, 7, 9, 8, 0, -7 },
  { 103, 4, 7, 5, 0, -7 },
  { 107, 5, 7, 5, 0, -7 },
  { 112, 4, 7, 6, 1, -7 },
  { 116, 5, 7, 6, 0, -7 },
  { 121, 5, 7, 5, 0, -7 },
  { 126, 5, 7, 5, 0, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 6, 7, 6, 0, -7 },
  { 141, 1, 7, 2, 1, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 6, 7, 5, 0, -7 },
  { 153, 4, 7, 4, 0, -7 },
  { 157, 7, 7, 7, 0, -7 },
  { 164, 6, 7, 6, 0, -7 },
  { 170, 4, 7, 6, 1, -7 },
  { 174, 5, 7, 5, 0, -7 },
  { 179, 4, 8, 6, 1, -7 },
  { 183, 5, 7, 6, 0, -7 },
  { 188, 5, 7, 5, 0, -7 },
  { 193, 5, 7, 5, 1, -7 },
  { 198, 5, 7, 6, 1, -7 },
  { 203, 5, 7, 5, 1, -7 },
  { 208, 7, 7, 8, 1, -7 },
  { 215, 5, 7, 5, 0, -7 },
  { 220, 5, 7, 5, 1, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 3, 10, 2, 0, -8 },
  { 234, 1, 8, 3, 1, -7 },
  { 235, 3, 10, 2, -1, -8 },
  { 239, 2, 4, 4, 1, -7 },
  { 240, 3, 1, 4, 0, 0 },
  { 241, 1, 2, 3, 1, -8 },
  { 242, 4, 5, 5, 0, -5 },
  { 245, 4, 8, 5, 0, -8 },
  { 249, 4, 5, 4, 0, -5 },
  { 252, 5, 8, 5, 0, -8 },
  { 257, 4, 5, 4, 0, -5 },
  { 260, 3, 8, 3, 1, -8 },
  { 263, 4, 7, 5, 0, -5 },
  { 267, 4, 8, 5, 0, -8 },
  { 271, 2, 7, 2, 0, -7 },
  { 273, 3, 9, 2, -1, -7 },
  { 277, 4, 8, 4, 0, -8 },
  { 281, 2, 8, 2, 0, -8 },
  { 283, 7, 5, 8, 0, -5 },
  { 288, 4, 5, 5, 0, -5 },
  { 291, 4, 5, 5, 0, -5 },
  { 294, 4, 7, 5, 0, -5 },
  { 298, 4, 7, 5, 0, -5 },
  { 302, 3, 5, 3, 0, -5 },
  { 304, 4, 5, 4, 0, -5 },
  { 307, 2, 7, 3, 1, -7 },
  { 309, 3, 5, 5, 1, -5 },
  { 311, 3, 5, 4, 1, -5 },
  { 313, 5, 5, 6, 1, -5 },
  { 317, 4, 5, 4, 0, -5 },
  { 320, 4, 7, 4, 0, -5 },
  { 324, 4, 5, 4, 0, -5 },
  { 327, 3, 10, 3, 0, -8 },
  { 331, 2, 8, 2, 0, -7 },
  { 333, 3, 10, 3, -1, -8 },
  { 337, 4, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_ThinItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_THINITALIC10PT7B_H_
