#ifndef _ROBOTOCONDENSED_THINITALIC14PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x15, 0x50, 0x20, 0x70, 0x02, 0x24, 0xF8, 0xA2, 0x45, 0x0A, 0x2E,
  0x50, 0x20, 0x08, 0x52, 0x50, 0x40, 0xC0, 0x81, 0x06, 0x27, 0x80, 0x61,
  0x26, 0x54, 0xCB, 0x03, 0xCA, 0xA9, 0x12, 0x18, 0x18, 0x48, 0x91, 0x43,
  0x0A, 0x12, 0x46, 0x84, 0xF0, 0x40, 0x05, 0x29, 0x24, 0x92, 0x48, 0x00,
  0x01, 0x11, 0x11, 0x11, 0x12, 0x22, 0x48, 0x01, 0x1C, 0xC9, 0x00, 0x01,
  0x1C, 0x42, 0x00, 0x40, 0x00, 0x80, 0x00, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x41, 0x00, 0x00, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0x97, 0x00, 0x64, 0x94,
  0x92, 0x40, 0x3D, 0x14, 0x41, 0x08, 0x21, 0x08, 0x41, 0xC0, 0x1C, 0x94,
  0x41, 0x18, 0x20, 0x61, 0x89, 0xC0, 0x04, 0x31, 0x45, 0x29, 0x27, 0x82,
  0x08, 0x00, 0x39, 0x04, 0x10, 0x70, 0x20, 0x82, 0x8B, 0xC0, 0x32, 0x11,
  0xE8, 0xC6, 0x31, 0x97, 0x00, 0x7C, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42,
  0x00, 0x1C, 0x94, 0x51, 0x39, 0x28, 0x61, 0x89, 0xC0, 0x7A, 0x63, 0x18,
  0xC5, 0xE2, 0x17, 0x00, 0x40, 0x02, 0x40, 0x00, 0x80, 0x1B, 0x20, 0x83,
  0x00, 0x70, 0x1C, 0x60, 0x40, 0xCC, 0xC0, 0x79, 0x11, 0x24, 0x40, 0x00,
  0x0F, 0x84, 0x12, 0x05, 0x19, 0x48, 0x54, 0x99, 0x26, 0x49, 0x92, 0x67,
  0xE8, 0x01, 0x00, 0x3C, 0x00, 0x08, 0x61, 0x89, 0x25, 0x17, 0xE1, 0x84,
  0x00, 0x79, 0x18, 0x61, 0xBA, 0x28, 0x62, 0x89, 0xC0, 0x3D, 0x18, 0x20,
  0x82, 0x08, 0x21, 0x89, 0xC0, 0x79, 0x18, 0x61, 0x86, 0x18, 0x61, 0x89,
  0xC0, 0x79, 0x08, 0x20, 0xB2, 0x08, 0x20, 0x81, 0xC0, 0x79, 0x08, 0x20,
  0xB2, 0x08, 0x20, 0x80, 0x00, 0x3C, 0x85, 0x0C, 0x08, 0x11, 0xA0, 0x42,
  0x84, 0xF0, 0x40, 0x86, 0x0C, 0x1B, 0xB0, 0xA1, 0x42, 0x84, 0x00, 0x55,
  0xAA, 0x80, 0x00, 0x10, 0x41, 0x04, 0x10, 0x62, 0x89, 0xC0, 0x42, 0x8A,
  0x24, 0x8A, 0x1C, 0x24, 0x48, 0x88, 0x00, 0x44, 0x48, 0x88, 0x88, 0x86,
  0x40, 0xA0, 0x68, 0x54, 0x5A, 0x35, 0x2A, 0x95, 0x52, 0x91, 0x08, 0x00,
  0x40, 0x85, 0x8D, 0x19, 0x32, 0x65, 0x46, 0x84, 0x08, 0x3C, 0x86, 0x0C,
  0x18, 0x30, 0xA1, 0x42, 0x88, 0xE0, 0x79, 0x18, 0x61, 0x87, 0xE8, 0x20,
  0x80, 0x00, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x88, 0xE0, 0x40,
  0x40, 0x79, 0x18, 0x61, 0x87, 0xE8, 0x22, 0x88, 0x00, 0x1C, 0x45, 0x02,
  0x03, 0x01, 0x81, 0x42, 0x84, 0xF0, 0x7C, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x00, 0x02, 0x86, 0x0C, 0x28, 0x50, 0xA1, 0x42, 0x88, 0xE0,
  0x83, 0x0A, 0x14, 0x44, 0x89, 0x14, 0x28, 0x20, 0x00, 0x80, 0x23, 0x18,
  0xCA, 0x52, 0x94, 0xA5, 0x4A, 0x51, 0x14, 0x42, 0x10, 0x80, 0x00, 0x22,
  0x24, 0x18, 0x10, 0x10, 0x28, 0x48, 0x44, 0x84, 0x82, 0x89, 0x22, 0x45,
  0x04, 0x08, 0x10, 0x20, 0x00, 0x1E, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20,
  0x41, 0xF0, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x80, 0x29, 0x55, 0x50,
  0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x40, 0x2D, 0xD0, 0x70, 0x80, 0x39,
  0x10, 0x41, 0x7A, 0x28, 0xBE, 0x00, 0x84, 0x1F, 0x45, 0x14, 0x51, 0x86,
  0x2F, 0x00, 0x39, 0x14, 0x60, 0x82, 0x08, 0x9C, 0x04, 0x10, 0x5E, 0x8A,
  0x28, 0xA2, 0x8A, 0x4E, 0x00, 0x39, 0x14, 0x6F, 0x82, 0x08, 0x1C, 0x24,
  0x44, 0x48, 0x88, 0x88, 0x00, 0x39, 0x14, 0x61, 0x86, 0x28, 0x9E, 0x08,
  0x2F, 0x00, 0x00, 0x84, 0x1F, 0x45, 0x14, 0x51, 0x86, 0x28, 0x00, 0x20,
  0x04, 0x92, 0x50, 0x00, 0x08, 0x00, 0x01, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x20, 0x00, 0x84, 0x11, 0x49, 0x46, 0x18, 0x92, 0x48, 0x80, 0x24, 0xA4,
  0x92, 0x50, 0x00, 0x7B, 0xD1, 0x14, 0x45, 0x11, 0x44, 0x62, 0x18, 0x8A,
  0x00, 0x3D, 0x14, 0x51, 0x46, 0x18, 0xA0, 0x74, 0x63, 0x18, 0xC6, 0x5C,
  0x3D, 0x14, 0x51, 0x46, 0x18, 0xBC, 0x82, 0x00, 0x00, 0x74, 0x63, 0x18,
  0xCA, 0x5E, 0x10, 0x80, 0x24, 0x44, 0x48, 0x88, 0x3A, 0x10, 0x41, 0x86,
  0x2E, 0x49, 0x49, 0x24, 0x80, 0x04, 0x63, 0x18, 0xCA, 0x5C, 0x0C, 0x65,
  0x2A, 0x51, 0x08, 0x81, 0x91, 0x92, 0xAA, 0xAC, 0xCC, 0x48, 0x08, 0x41,
  0x23, 0x08, 0x21, 0x45, 0x22, 0x02, 0x44, 0x91, 0x22, 0x85, 0x04, 0x08,
  0x20, 0x41, 0x00, 0x34, 0x21, 0x04, 0x21, 0x08, 0x1C, 0x08, 0x88, 0x42,
  0x13, 0x08, 0x42, 0x10, 0x84, 0x10, 0x05, 0x24, 0x92, 0x92, 0x40, 0x01,
  0x11, 0x11, 0x10, 0x22, 0x22, 0x48, 0xE0, 0x70,
};

const GFXglyph RobotoCondensed_ThinItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 3, 0, -10 },
  { 4, 2, 3, 4, 2, -11 },
  { 5, 7, 10, 7, 0, -10 },
  { 14, 6, 12, 7, 0, -11 },
  { 23, 7, 10, 9, 1, -10 },
  { 32, 7, 10, 7, 0, -10 },
  { 41, 1, 3, 2, 1, -11 },
  { 42, 3, 14, 4, 1, -11 },
  { 48, 4, 14, 4, -1, -11 },
  { 55, 5, 5, 6, 1, -10 },
  { 59, 5, 6, 7, 1, -7 },
  { 63, 1, 3, 3, 0, -1 },
  { 64, 2, 1, 4, 1, -5 },
  { 65, 1, 1, 3, 0, -1 },
  { 66, 6, 11, 5, -1, -10 },
  { 75, 5, 10, 7, 1, -10 },
  { 82, 3, 10, 7, 2, -10 },
  { 86, 6, 10, 7, 0, -10 },
  { 94, 6, 10, 7, 0, -10 },
  { 102, 6, 10, 7, 0, -10 },
  { 110, 6, 10, 7, 1, -10 },
  { 118, 5, 10, 7, 1, -10 },
  { 125, 6, 10, 7, 1, -10 },
  { 133, 6, 10, 7, 0, -10 },
  { 141, 5, 10, 7, 1, -10 },
  { 148, 2, 8, 2, 0, -8 },
  { 150, 2, 10, 2, 0, -8 },
  { 153, 5, 5, 6, 1, -7 },
  { 157, 5, 3, 7, 1, -6 },
  { 159, 6, 5, 6, 0, -7 },
  { 163, 4, 10, 5, 1, -10 },
  { 168, 10, 13, 11, 0, -10 },
  { 185, 6, 10, 7, 0, -10 },
  { 193, 6, 10, 7, 1, -10 },
  { 201, 6, 10, 8, 1, -10 },
  { 209, 6, 10, 8, 1, -10 },
  { 217, 6, 10, 7, 1, -10 },
  { 225, 6, 10, 7, 1, -10 },
  { 233, 7, 10, 8, 1, -10 },
  { 242, 7, 10, 8, 1, -10 },
  { 251, 2, 10, 3, 1, -10 },
  { 254, 6, 10, 7, 0, -10 },
  { 262, 7, 10, 8, 1, -10 },
  { 271, 4, 10, 6, 1, -10 },
  { 276, 9, 10, 10, 1, -10 },
  { 288, 7, 10, 8, 1, -10 },
  { 297, 7, 10, 8, 1, -10 },
  { 306, 6, 10, 7, 1, -10 },
  { 314, 7, 12, 8, 1, -10 },
  { 325, 6, 10, 8, 1, -10 },
  { 333, 7, 10, 7, 0, -10 },
  { 342, 7, 10, 7, 1, -10 },
  { 351, 7, 10, 8, 1, -10 },
  { 360, 7, 10, 7, 1, -10 },
  { 369, 10, 10, 11, 1, -10 },
  { 382, 8, 10, 7, 0, -10 },
  { 392, 7, 10, 7, 1, -10 },
  { 401, 7, 10, 7, 0, -10 },
  { 410, 4, 13, 3, 0, -11 },
  { 417, 2, 11, 5, 1, -10 },
  { 420, 4, 13, 3, -1, -11 },
  { 427, 3, 5, 5, 1, -10 },
  { 429, 5, 1, 5, -1, 0 },
  { 430, 1, 2, 4, 2, -11 },
  { 431, 6, 8, 6, 0, -8 },
  { 437, 6, 11, 7, 0, -11 },
  { 446, 6, 8, 6, 0, -8 },
  { 452, 6, 11, 7, 1, -11 },
  { 461, 6, 8, 6, 0, -8 },
  { 467, 4, 11, 4, 1, -11 },
  { 473, 6, 11, 7, 0, -8 },
  { 482, 6, 11, 7, 0, -11 },
  { 491, 3, 11, 3, 0, -11 },
  { 496, 5, 14, 3, -2, -11 },
  { 505, 6, 11, 6, 0, -11 },
  { 514, 3, 11, 3, 0, -11 },
  { 519, 10, 8, 11, 0, -8 },
  { 529, 6, 8, 7, 0, -8 },
  { 535, 5, 8, 7, 1, -8 },
  { 540, 6, 11, 7, 0, -8 },
  { 549, 5, 11, 7, 1, -8 },
  { 556, 4, 8, 4, 0, -8 },
  { 560, 5, 8, 6, 0, -8 },
  { 565, 3, 9, 4, 1, -9 },
  { 569, 5, 8, 7, 1, -8 },
  { 574, 5, 8, 6, 1, -8 },
  { 579, 8, 8, 9, 1, -8 },
  { 587, 6, 8, 6, 0, -8 },
  { 593, 7, 11, 6, -1, -8 },
  { 603, 6, 8, 6, 0, -8 },
  { 609, 5, 14, 4, 0, -11 },
  { 618, 3, 12, 3, 0, -10 },
  { 623, 4, 14, 4, -1, -11 },
  { 630, 6, 2, 8, 1, -5 },
};

const GFXfont RobotoCondensed_ThinItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_THINITALIC14PT7B_H_
