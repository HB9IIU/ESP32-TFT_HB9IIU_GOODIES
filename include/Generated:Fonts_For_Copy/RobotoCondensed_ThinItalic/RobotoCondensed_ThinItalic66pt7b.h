#ifndef _ROBOTOCONDENSED_THINITALIC66PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0F, 0x01,
  0x00, 0x30, 0x66, 0x0C, 0xC3, 0x18, 0x63, 0x0C, 0x61, 0x98, 0x33, 0x06,
  0x61, 0x8C, 0x31, 0x86, 0x20, 0xCC, 0x18, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x80, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0x04, 0x30, 0x01,
  0x00, 0x18, 0x60, 0x02, 0x00, 0x20, 0xC0, 0x04, 0x00, 0xC1, 0x00, 0x08,
  0x03, 0x06, 0x00, 0x30, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x18, 0x00, 0xC0,
  0x60, 0x30, 0x01, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x0C, 0x0C,
  0x00, 0x80, 0x30, 0x30, 0x01, 0x80, 0xE0, 0x60, 0x03, 0x03, 0x81, 0x80,
  0x03, 0xDE, 0x06, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x1F, 0x80, 0x00, 0xC0, 0xF7, 0x80,
  0x03, 0x03, 0x81, 0x80, 0x04, 0x06, 0x03, 0x00, 0x18, 0x18, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x01, 0x00, 0x18, 0x0C,
  0x06, 0x00, 0x30, 0x30, 0x0C, 0x00, 0x60, 0x60, 0x18, 0x00, 0xC1, 0x80,
  0x20, 0x01, 0x06, 0x00, 0x40, 0x02, 0x0C, 0x00, 0x80, 0x0C, 0x30, 0x01,
  0x00, 0x18, 0xC0, 0x02, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x08, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x40, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x01, 0x8E, 0x00, 0xC0, 0x0C, 0x60, 0x03, 0x00, 0x66, 0x00, 0x18,
  0x06, 0x30, 0x00, 0x60, 0x33, 0x00, 0x03, 0x01, 0x98, 0x00, 0x0C, 0x18,
  0x80, 0x00, 0x60, 0xCC, 0x00, 0x01, 0x8C, 0x60, 0x00, 0x0C, 0x63, 0x00,
  0x00, 0x36, 0x18, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x33, 0x03, 0x00, 0x03, 0x18,
  0x1C, 0x00, 0x30, 0x60, 0x78, 0x0E, 0x01, 0x80, 0xFF, 0xE0, 0x0C, 0x00,
  0xF8, 0x00, 0x00, 0x33, 0x33, 0x66, 0x66, 0x6C, 0xCC, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x40, 0x0C, 0x01, 0xF8, 0x06, 0x03, 0xCF, 0x02, 0x0F, 0x01, 0xF3,
  0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x61, 0xC3,
  0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x27, 0x76, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06,
  0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x04, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x00, 0x80, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xF0, 0x1E, 0xC1, 0xE2, 0x3E, 0x0B, 0xC0, 0x6C, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x01, 0x80, 0x0E,
  0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x10, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x04,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x02, 0x00, 0x06, 0x00, 0x40,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x3F, 0x80, 0x00, 0xCF,
  0xFE, 0x00, 0x0F, 0x80, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x0F, 0xC0, 0x18, 0x7F,
  0xF0, 0x10, 0xE0, 0x38, 0x31, 0x80, 0x0C, 0x36, 0x00, 0x06, 0x34, 0x00,
  0x06, 0x28, 0x00, 0x03, 0x38, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0x40, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x30, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x18, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x1E, 0x60, 0x00, 0x34, 0x60, 0x00, 0x6C, 0x30, 0x00, 0xEC, 0x30,
  0x01, 0xCC, 0x1C, 0x07, 0x0C, 0x0F, 0xFE, 0x18, 0x03, 0xF0, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0x03, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xE0,
  0x70, 0x10, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x1C, 0x0E, 0x07,
  0x00, 0x61, 0x80, 0x0C, 0x70, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x68, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x0F, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xFF, 0xC0, 0x03, 0x03, 0x00, 0x07,
  0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x30, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x30, 0x01, 0x80, 0x06, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0xC6, 0x00, 0x30, 0x00, 0x40, 0x03, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x33, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x8C, 0x00, 0xC0, 0x00, 0x80, 0x02, 0x20, 0x03, 0x00, 0x06, 0x00, 0x19,
  0x80, 0x18, 0x00, 0x18, 0x00, 0x66, 0x00, 0x60, 0x00, 0x60, 0x01, 0x98,
  0x01, 0x80, 0x01, 0x00, 0x04, 0x40, 0x04, 0x00, 0x0C, 0x00, 0x31, 0x00,
  0x30, 0x00, 0x30, 0x00, 0xC4, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x63, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x30, 0x03, 0x00,
  0x1E, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0xD8, 0x01, 0x83, 0x00, 0x30, 0x06,
  0x60, 0x0C, 0x0C, 0x00, 0x40, 0x30, 0x80, 0x60, 0x10, 0x01, 0x81, 0x83,
  0x07, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0xF0,
  0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x04,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x38, 0x06,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7A,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xF8, 0x60, 0x00, 0xFF,
  0xF8, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x06, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x18, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x60, 0x00, 0x08, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x86, 0xC0, 0x00, 0x00, 0x23, 0x30,
  0x00, 0x00, 0x19, 0x86, 0x00, 0x00, 0x06, 0xC1, 0x80, 0x00, 0x01, 0xE0,
  0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x16, 0x00, 0x00, 0x00, 0x36, 0x01, 0x60, 0x00, 0x00, 0x03, 0x60, 0x32,
  0x00, 0x00, 0x00, 0x66, 0x03, 0x20, 0x00, 0x00, 0x06, 0x40, 0x33, 0x00,
  0x00, 0x00, 0xCC, 0x02, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x23, 0x00, 0x00,
  0x01, 0x8C, 0x06, 0x10, 0x00, 0x00, 0x10, 0xC0, 0x61, 0x00, 0x00, 0x03,
  0x08, 0x06, 0x18, 0x00, 0x00, 0x20, 0x80, 0x61, 0x80, 0x00, 0x06, 0x18,
  0x04, 0x18, 0x00, 0x00, 0x41, 0x80, 0x41, 0x80, 0x00, 0x0C, 0x18, 0x0C,
  0x08, 0x00, 0x00, 0x81, 0x80, 0xC0, 0x80, 0x00, 0x18, 0x10, 0x0C, 0x0C,
  0x00, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x08, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x80, 0x40, 0x00, 0x60, 0x30, 0x18, 0x04, 0x00, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x00, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x10, 0x02, 0x00, 0x30, 0x06, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x30, 0x02, 0x00, 0x60, 0x06, 0x03, 0x00,
  0x30, 0x04, 0x00, 0x40, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30,
  0x08, 0x00, 0xC0, 0x20, 0x01, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x10, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x60, 0x00,
  0x80, 0x60, 0x01, 0x86, 0x00, 0x18, 0x06, 0x00, 0x08, 0xC0, 0x01, 0x80,
  0x40, 0x00, 0x8C, 0x00, 0x18, 0x0C, 0x00, 0x09, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xD8, 0x00, 0x10, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x02,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x06, 0x01, 0xE0, 0x00,
  0x00, 0x60, 0x1A, 0x00, 0x00, 0x06, 0x03, 0x30, 0x00, 0x00, 0x40, 0x31,
  0x00, 0x00, 0x04, 0x03, 0x18, 0x00, 0x00, 0xC0, 0x31, 0x80, 0x00, 0x0C,
  0x03, 0x08, 0x00, 0x00, 0xC0, 0x30, 0xC0, 0x00, 0x0C, 0x06, 0x0C, 0x00,
  0x00, 0x80, 0x60, 0x60, 0x00, 0x18, 0x06, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x20, 0x00, 0x18, 0x06, 0x03, 0x00, 0x01, 0x80, 0x40, 0x30, 0x00, 0x18,
  0x0C, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x80,
  0x03, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x18, 0x00, 0x60, 0x02, 0x01, 0x80, 0x02, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x18, 0x00, 0x10,
  0x06, 0x01, 0x00, 0x01, 0x80, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x30, 0x00, 0x0C, 0x0C, 0x03, 0x00, 0x00, 0x40, 0xC0,
  0x20, 0x00, 0x06, 0x0C, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x60, 0x00, 0x02,
  0x18, 0x06, 0x00, 0x00, 0x31, 0x80, 0x60, 0x00, 0x01, 0x18, 0x06, 0x00,
  0x00, 0x19, 0x80, 0x40, 0x00, 0x01, 0x98, 0x0C, 0x00, 0x00, 0x09, 0x80,
  0xC0, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x06,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x20,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x1C, 0x02, 0x00, 0x00, 0x70, 0x04, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7C,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x38, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x05, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x36, 0x00, 0x00, 0x46, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x18, 0x00,
  0x02, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x42, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x20, 0x00, 0x30, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x02, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x10, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x04, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x80, 0x03, 0x03,
  0x00, 0x02, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x10, 0x60,
  0x00, 0x20, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x02, 0x20, 0x03, 0x10, 0x01,
  0x08, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x20,
  0x20, 0x10, 0x30, 0x0C, 0x10, 0x06, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x00,
  0x44, 0x00, 0x36, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0x18, 0x00, 0xE0,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x81, 0xC0,
  0x00, 0x41, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xA1,
  0x80, 0x01, 0xF0, 0x60, 0x01, 0xD8, 0x30, 0x01, 0xCC, 0x0E, 0x03, 0x86,
  0x03, 0xFF, 0x03, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x1E, 0x00, 0x08, 0x3F, 0xF0, 0x06,
  0x38, 0x0E, 0x01, 0x98, 0x00, 0xC0, 0x6C, 0x00, 0x30, 0x1E, 0x00, 0x06,
  0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x3C, 0x00, 0x06,
  0x0D, 0x80, 0x03, 0x03, 0x30, 0x01, 0x80, 0xC7, 0x01, 0xC0, 0x20, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x82,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x1C, 0x00, 0x60, 0x07, 0x80, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0xC0, 0x07, 0xFE, 0x0C, 0x01, 0xE0, 0x70,
  0x80, 0x38, 0x01, 0x98, 0x07, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x78, 0x0C,
  0x00, 0x03, 0x80, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08,
  0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x38, 0x04, 0x00, 0x07, 0x00, 0x60, 0x00, 0xD0, 0x03, 0x00, 0x3B,
  0x00, 0x38, 0x0E, 0x30, 0x01, 0xFF, 0xC3, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x38, 0x00, 0x60, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x80,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x80,
  0x0E, 0x03, 0x84, 0x00, 0xE0, 0x06, 0x60, 0x0E, 0x00, 0x1B, 0x00, 0x60,
  0x00, 0x58, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x08, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x01, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x1E, 0x00, 0x30, 0x03, 0xB0, 0x01, 0xC0, 0x71, 0x80, 0x07,
  0xFF, 0x0C, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x07,
  0xC0, 0x04, 0x0F, 0xF8, 0x06, 0x1C, 0x0E, 0x03, 0x18, 0x01, 0x81, 0x98,
  0x00, 0xC0, 0xD8, 0x00, 0x20, 0x68, 0x00, 0x18, 0x28, 0x00, 0x0C, 0x3C,
  0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x60, 0x00, 0x04, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x04, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00,
  0x20, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x38, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x6F, 0x80, 0x00, 0x16, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x81,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x40, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x18, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xC3, 0x81, 0xC0, 0x70, 0x18, 0x06,
  0x30, 0x07, 0x0E, 0x00, 0x60, 0x33, 0x00, 0x18, 0xE0, 0x03, 0x01, 0x30,
  0x00, 0x46, 0x00, 0x0C, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x60, 0xD0, 0x00,
  0x1E, 0x00, 0x03, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x10, 0x00, 0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x03, 0xFE, 0x01,
  0x87, 0x03, 0x80, 0xC6, 0x00, 0x60, 0x66, 0x00, 0x30, 0x36, 0x00, 0x08,
  0x1A, 0x00, 0x06, 0x0A, 0x00, 0x03, 0x0F, 0x00, 0x01, 0x87, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x40, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x10,
  0x00, 0x02, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x0F, 0x00, 0x30, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x02, 0x0F,
  0xFC, 0x00, 0x31, 0xC0, 0x70, 0x01, 0x98, 0x00, 0xC0, 0x0D, 0x80, 0x06,
  0x00, 0x78, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0xC0,
  0x00, 0x60, 0x1B, 0x00, 0x06, 0x00, 0xCC, 0x00, 0x60, 0x06, 0x38, 0x0E,
  0x00, 0x20, 0xFF, 0xC0, 0x01, 0x00, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x20, 0x1E,
  0x07, 0x08, 0x0E, 0x00, 0x62, 0x07, 0x00, 0x0D, 0x81, 0x80, 0x01, 0xE0,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x10,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x0C, 0x20, 0x00, 0x02, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0xF0, 0x0C, 0x00, 0xEC, 0x03, 0x80, 0xE3, 0x00, 0x7F, 0xF0,
  0xC0, 0x03, 0xE0, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x41,
  0xFC, 0x18, 0xE0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x1C, 0x01, 0x80, 0x0E, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x1C, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x04, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x30,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x10, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xE0, 0x40, 0x00, 0x38, 0x18, 0x00, 0x1E, 0x06, 0x00, 0x0D,
  0x01, 0x80, 0x06, 0xC0, 0x30, 0x03, 0x30, 0x06, 0x03, 0x8C, 0x00, 0xFF,
  0xC3, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x20, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x0C,
  0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01, 0x90,
  0x00, 0x1C, 0x00, 0x0C, 0x80, 0x01, 0xE0, 0x00, 0x64, 0x00, 0x0F, 0x00,
  0x06, 0x30, 0x00, 0xD8, 0x00, 0x31, 0x80, 0x06, 0xC0, 0x03, 0x0C, 0x00,
  0x26, 0x00, 0x18, 0x60, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x80, 0x0C,
  0x18, 0x01, 0x84, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x06, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x30, 0x06, 0x0C, 0x03, 0x01, 0x80, 0x20, 0x60, 0x18, 0x0C,
  0x03, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x18, 0x0C, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x08, 0x0C, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x10, 0x30, 0x03, 0x06,
  0x00, 0x81, 0x80, 0x18, 0x60, 0x04, 0x18, 0x00, 0xC3, 0x00, 0x20, 0xC0,
  0x06, 0x10, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x19, 0x80, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x14,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x11, 0xC1, 0xC0, 0x00, 0xC6, 0x01, 0x80, 0x03, 0x30, 0x07,
  0x00, 0x09, 0x80, 0x0C, 0x00, 0x66, 0x00, 0x18, 0x01, 0x10, 0x00, 0x30,
  0x0C, 0xC0, 0x00, 0x60, 0x63, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00,
};

const GFXglyph RobotoCondensed_ThinItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 48, 12, 1, -47 },
  { 61, 11, 13, 17, 7, -50 },
  { 79, 33, 47, 31, 1, -47 },
  { 273, 28, 61, 31, 2, -54 },
  { 487, 31, 49, 42, 6, -48 },
  { 677, 29, 49, 34, 2, -48 },
  { 855, 4, 13, 11, 7, -50 },
  { 862, 18, 67, 18, 3, -52 },
  { 1013, 18, 67, 18, -4, -52 },
  { 1164, 25, 25, 27, 4, -47 },
  { 1243, 27, 34, 32, 3, -39 },
  { 1358, 7, 13, 12, -2, -5 },
  { 1370, 13, 2, 17, 2, -23 },
  { 1374, 4, 4, 14, 1, -3 },
  { 1376, 26, 51, 22, -2, -47 },
  { 1542, 26, 49, 31, 3, -48 },
  { 1702, 14, 47, 31, 9, -47 },
  { 1785, 27, 48, 31, 2, -48 },
  { 1947, 27, 49, 31, 2, -48 },
  { 2113, 27, 47, 31, 2, -47 },
  { 2272, 28, 48, 31, 4, -47 },
  { 2440, 24, 48, 31, 3, -47 },
  { 2584, 26, 47, 31, 6, -47 },
  { 2737, 29, 49, 31, 1, -48 },
  { 2915, 24, 48, 31, 5, -48 },
  { 3059, 9, 35, 11, 1, -34 },
  { 3099, 12, 42, 11, -2, -34 },
  { 3162, 25, 26, 29, 3, -34 },
  { 3244, 24, 15, 31, 4, -29 },
  { 3289, 24, 25, 29, 2, -34 },
  { 3364, 19, 49, 25, 6, -48 },
  { 3481, 46, 60, 52, 2, -45 },
  { 3826, 31, 47, 34, -2, -47 },
  { 4009, 29, 47, 34, 3, -47 },
  { 4180, 31, 49, 36, 4, -48 },
  { 4370, 32, 47, 37, 3, -47 },
  { 4558, 31, 47, 32, 3, -47 },
  { 4741, 32, 47, 32, 3, -47 },
  { 4929, 32, 49, 39, 4, -48 },
  { 5125, 35, 47, 39, 3, -47 },
  { 5331, 10, 47, 15, 3, -47 },
  { 5390, 29, 48, 31, 1, -47 },
  { 5564, 34, 47, 36, 3, -47 },
  { 5764, 21, 47, 29, 3, -47 },
  { 5888, 44, 47, 48, 3, -47 },
  { 6147, 36, 47, 40, 3, -47 },
  { 6359, 32, 49, 37, 3, -48 },
  { 6555, 31, 47, 34, 3, -47 },
  { 6738, 32, 57, 37, 3, -48 },
  { 6966, 32, 47, 37, 2, -47 },
  { 7154, 31, 49, 33, 2, -48 },
  { 7344, 30, 47, 34, 6, -47 },
  { 7521, 33, 48, 37, 4, -47 },
  { 7719, 31, 47, 34, 6, -47 },
  { 7902, 46, 47, 50, 6, -47 },
  { 8173, 36, 47, 34, -1, -47 },
  { 8385, 31, 47, 34, 6, -47 },
  { 8568, 35, 47, 34, 0, -47 },
  { 8774, 17, 64, 13, 1, -54 },
  { 8910, 9, 51, 22, 7, -47 },
  { 8968, 17, 64, 13, -4, -54 },
  { 9104, 17, 23, 24, 4, -47 },
  { 9153, 23, 2, 24, -3, 0 },
  { 9159, 7, 9, 17, 9, -50 },
  { 9167, 25, 37, 30, 1, -36 },
  { 9283, 26, 51, 31, 2, -50 },
  { 9449, 25, 37, 29, 2, -36 },
  { 9565, 28, 51, 31, 3, -50 },
  { 9744, 25, 37, 29, 2, -36 },
  { 9860, 20, 51, 18, 4, -51 },
  { 9988, 29, 49, 31, 0, -36 },
  { 10166, 25, 50, 31, 2, -50 },
  { 10323, 11, 47, 12, 2, -47 },
  { 10388, 22, 61, 13, -9, -48 },
  { 10556, 26, 50, 27, 2, -50 },
  { 10719, 10, 50, 12, 2, -50 },
  { 10782, 45, 36, 50, 1, -36 },
  { 10985, 25, 36, 31, 2, -36 },
  { 11098, 25, 37, 31, 3, -36 },
  { 11214, 29, 49, 31, -1, -36 },
  { 11392, 26, 49, 31, 3, -36 },
  { 11552, 19, 36, 19, 2, -36 },
  { 11638, 24, 37, 28, 1, -36 },
  { 11749, 14, 45, 18, 4, -44 },
  { 11828, 26, 36, 31, 3, -35 },
  { 11945, 24, 35, 27, 4, -35 },
  { 12050, 37, 35, 42, 5, -35 },
  { 12212, 28, 35, 27, -1, -35 },
  { 12335, 31, 48, 27, -3, -35 },
  { 12521, 27, 35, 27, 0, -35 },
  { 12640, 21, 65, 19, 2, -51 },
  { 12811, 11, 56, 13, 1, -47 },
  { 12888, 20, 65, 19, -4, -51 },
  { 13051, 30, 11, 39, 4, -25 },
};

const GFXfont RobotoCondensed_ThinItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_THINITALIC66PT7B_H_
