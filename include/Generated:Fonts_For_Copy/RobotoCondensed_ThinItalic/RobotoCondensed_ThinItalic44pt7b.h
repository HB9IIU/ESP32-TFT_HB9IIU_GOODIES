#ifndef _ROBOTOCONDENSED_THINITALIC44PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x62, 0x8D, 0x12, 0x24, 0x58, 0xB1, 0x46,
  0x88, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40, 0x01, 0x02, 0x00, 0x0C, 0x08,
  0x00, 0x20, 0x20, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x10, 0x10, 0x00,
  0x40, 0x80, 0x7F, 0xFF, 0xF0, 0x08, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81,
  0x00, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0x40, 0x80, 0x02, 0x02, 0x00,
  0x08, 0x18, 0x00, 0x20, 0x40, 0x01, 0x01, 0x00, 0x04, 0x0C, 0x03, 0xFF,
  0xFF, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x60, 0x40,
  0x01, 0x03, 0x00, 0x04, 0x08, 0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x02,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x7C, 0x00, 0x60, 0xC0, 0x20, 0x10, 0x10, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x31, 0x00, 0x0C, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00,
  0x41, 0x00, 0x30, 0x60, 0x18, 0x0C, 0x1C, 0x00, 0xFC, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x00, 0xC4, 0x00,
  0x0C, 0x10, 0x00, 0x40, 0x80, 0x04, 0x04, 0x02, 0x20, 0x20, 0x23, 0x01,
  0x03, 0x10, 0x08, 0x10, 0x80, 0x41, 0x04, 0x02, 0x10, 0x20, 0x21, 0x81,
  0x01, 0x08, 0x04, 0x10, 0x80, 0x31, 0x88, 0x00, 0xF0, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x41, 0xE0, 0x06, 0x31, 0x80, 0x23, 0x04, 0x02, 0x10, 0x20,
  0x21, 0x81, 0x83, 0x08, 0x0C, 0x10, 0x40, 0x41, 0x02, 0x02, 0x10, 0x30,
  0x10, 0x81, 0x00, 0x88, 0x08, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x06, 0x00,
  0x0C, 0x60, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x0C, 0x30, 0x01, 0x81,
  0x00, 0x10, 0x10, 0x03, 0x01, 0x00, 0x20, 0x10, 0x02, 0x01, 0x00, 0x20,
  0x30, 0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x31, 0x00, 0x01,
  0x60, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x2C, 0x00, 0x04, 0x40, 0x00,
  0x82, 0x03, 0x10, 0x20, 0x22, 0x01, 0x02, 0x20, 0x18, 0x24, 0x00, 0x84,
  0x40, 0x0C, 0x44, 0x00, 0x4C, 0xC0, 0x02, 0x8C, 0x00, 0x30, 0x40, 0x03,
  0x04, 0x00, 0x58, 0x20, 0x08, 0x81, 0x83, 0x0C, 0x0F, 0xC0, 0x40, 0x55,
  0xEA, 0x80, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x30, 0x04, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x87, 0x39, 0x9C, 0x0F, 0xE0,
  0x01, 0x00, 0x02, 0x80, 0x04, 0xC0, 0x08, 0x40, 0x18, 0x60, 0x30, 0x20,
  0x60, 0x30, 0x40, 0x10, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x11, 0x13, 0x22, 0x6C,
  0x80, 0xFF, 0xD8, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x61,
  0x80, 0x30, 0x10, 0x18, 0x06, 0x0C, 0x00, 0x82, 0x00, 0x21, 0x80, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x98, 0x00, 0x24, 0x00, 0x09, 0x00, 0x06, 0x40, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x18, 0x80, 0x04, 0x30, 0x03, 0x04, 0x00, 0x81, 0x00, 0x60, 0x60,
  0x30, 0x0C, 0x38, 0x00, 0xF8, 0x00, 0x00, 0x83, 0xC7, 0x3C, 0x18, 0x18,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x00, 0x7E, 0x00, 0x60, 0xC0, 0x30, 0x18,
  0x18, 0x02, 0x04, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x18, 0x60, 0x0C, 0x02, 0x01, 0x00,
  0x60, 0x40, 0x04, 0x18, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08,
  0xC0, 0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x30, 0x02, 0x03, 0x00, 0xC0,
  0x30, 0x60, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x04, 0x80, 0x02, 0x60, 0x01, 0x90, 0x00, 0x44, 0x00,
  0x21, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x0C, 0x01, 0x02, 0x00, 0x80,
  0x80, 0x60, 0x20, 0x10, 0x08, 0x08, 0x02, 0x04, 0x01, 0x03, 0x00, 0x40,
  0x80, 0x10, 0x40, 0x04, 0x3F, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x07, 0xFF, 0xC1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x4F, 0xC0, 0x2C, 0x18, 0x0C, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x88, 0x00, 0x22, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x01, 0x0C, 0x00, 0x81, 0x00, 0x60, 0x60, 0x30, 0x0C, 0x18, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x21,
  0xF8, 0x27, 0x0C, 0x2C, 0x06, 0x50, 0x02, 0x60, 0x03, 0x60, 0x01, 0x40,
  0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0xC0, 0x06, 0x40, 0x04, 0x60, 0x08, 0x20, 0x18, 0x18,
  0x60, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x18, 0x70, 0x0C, 0x03, 0x01, 0x00, 0x20, 0x40, 0x06, 0x18, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x01, 0x04,
  0x00, 0x40, 0xC0, 0x18, 0x08, 0x06, 0x00, 0xC3, 0x80, 0x0F, 0xC0, 0x06,
  0x0C, 0x03, 0x00, 0x40, 0xC0, 0x04, 0x10, 0x00, 0xC4, 0x00, 0x08, 0x80,
  0x01, 0x30, 0x00, 0x24, 0x00, 0x0C, 0x80, 0x01, 0x10, 0x00, 0x23, 0x00,
  0x08, 0x20, 0x03, 0x06, 0x00, 0xC0, 0x70, 0x60, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0x0C, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x03, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x06, 0x40, 0x06, 0x40, 0x0A, 0x20,
  0x12, 0x30, 0x66, 0x0F, 0x84, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x78,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x10, 0x30, 0x30, 0x20, 0x60,
  0x40, 0xC0, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0xC1, 0x0C, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x30, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x06, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x06, 0x0C, 0x01, 0xF0, 0x04, 0x10, 0x06, 0x30, 0x08, 0x40, 0x30,
  0x30, 0x10, 0x80, 0x40, 0x60, 0x22, 0x01, 0x00, 0x80, 0x44, 0x06, 0x01,
  0x00, 0x98, 0x08, 0x02, 0x01, 0x20, 0x30, 0x0C, 0x02, 0x40, 0x40, 0x10,
  0x0C, 0x80, 0x80, 0x20, 0x12, 0x02, 0x00, 0x40, 0x24, 0x04, 0x01, 0x80,
  0x48, 0x08, 0x02, 0x01, 0x90, 0x10, 0x04, 0x02, 0x20, 0x40, 0x18, 0x04,
  0x40, 0x80, 0x30, 0x10, 0x81, 0x00, 0xC0, 0x21, 0x02, 0x03, 0xC0, 0x82,
  0x02, 0x04, 0x83, 0x04, 0x06, 0x31, 0x8C, 0x08, 0x07, 0x81, 0xE0, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x08, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x48,
  0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x02, 0x08, 0x00, 0x20, 0xC0, 0x04, 0x04, 0x00, 0x40, 0x40, 0x08,
  0x04, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x06, 0x02,
  0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0xFF, 0xFE, 0x08, 0x00, 0x21,
  0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x03, 0x20, 0x00, 0x16, 0x00, 0x01,
  0x40, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x80,
  0x70, 0x10, 0x03, 0x06, 0x00, 0x30, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00,
  0x08, 0x40, 0x01, 0x08, 0x00, 0x23, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x08, 0x20, 0x02, 0x04, 0x01, 0x81, 0xFF, 0xE0, 0x20, 0x07,
  0x04, 0x00, 0x30, 0x80, 0x02, 0x10, 0x00, 0x62, 0x00, 0x04, 0x80, 0x00,
  0x90, 0x00, 0x12, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x33, 0x00, 0x04,
  0x40, 0x01, 0x88, 0x00, 0x61, 0x00, 0x30, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x1C, 0x18, 0x03, 0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x21, 0x80,
  0x01, 0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x83,
  0x80, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x10,
  0x18, 0x00, 0x40, 0x80, 0x03, 0x04, 0x00, 0x08, 0x20, 0x00, 0x61, 0x00,
  0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11,
  0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00,
  0x11, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x02, 0x20,
  0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x0C,
  0x30, 0x00, 0x41, 0x00, 0x04, 0x08, 0x00, 0xC0, 0x40, 0x1C, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xE0, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xFF, 0xF0, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x04,
  0x00, 0x0C, 0x60, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x09, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x01, 0xFF, 0x30, 0x00, 0x09,
  0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x30, 0xC0, 0x03, 0x03,
  0x00, 0x30, 0x0E, 0x0F, 0x00, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x02, 0x08,
  0x00, 0x04, 0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00,
  0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x30, 0x00,
  0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01,
  0x04, 0x00, 0x02, 0x1F, 0xFF, 0xFC, 0x20, 0x00, 0x08, 0x40, 0x00, 0x20,
  0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x43, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x00, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x02, 0x04, 0x08, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x84, 0x00, 0x10, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x20, 0x20, 0x0C,
  0x06, 0x03, 0x00, 0x60, 0xC0, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x30, 0x10, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x80, 0x0C, 0x01, 0x00,
  0x30, 0x02, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x40, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x30, 0x00,
  0x04, 0xE0, 0x00, 0x1B, 0x40, 0x00, 0x2C, 0x40, 0x00, 0x70, 0xC0, 0x00,
  0xC0, 0x80, 0x01, 0x01, 0x80, 0x02, 0x01, 0x00, 0x08, 0x03, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x04, 0x03, 0x00,
  0x0C, 0x04, 0x00, 0x08, 0x08, 0x00, 0x18, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0A, 0x1C, 0x00, 0x00, 0x70,
  0xA0, 0x00, 0x05, 0x04, 0x80, 0x00, 0x28, 0x24, 0x00, 0x02, 0x41, 0x20,
  0x00, 0x12, 0x09, 0x00, 0x01, 0x10, 0xC8, 0x00, 0x19, 0x84, 0x60, 0x00,
  0x88, 0x21, 0x00, 0x0C, 0x41, 0x08, 0x00, 0x42, 0x08, 0x40, 0x06, 0x10,
  0x42, 0x00, 0x20, 0x86, 0x10, 0x02, 0x0C, 0x20, 0x40, 0x10, 0x41, 0x02,
  0x01, 0x02, 0x08, 0x10, 0x08, 0x10, 0x40, 0x80, 0x80, 0x82, 0x04, 0x04,
  0x0C, 0x20, 0x10, 0x40, 0x41, 0x00, 0x86, 0x02, 0x08, 0x04, 0x20, 0x10,
  0x40, 0x23, 0x00, 0x82, 0x01, 0x10, 0x04, 0x30, 0x09, 0x80, 0x61, 0x00,
  0x28, 0x02, 0x08, 0x01, 0xC0, 0x10, 0x40, 0x0C, 0x00, 0x82, 0x00, 0x40,
  0x04, 0x00, 0x04, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x02, 0x0F,
  0x00, 0x02, 0x0D, 0x00, 0x02, 0x09, 0x00, 0x02, 0x08, 0x80, 0x06, 0x08,
  0x80, 0x04, 0x08, 0xC0, 0x04, 0x18, 0x40, 0x04, 0x10, 0x40, 0x04, 0x10,
  0x20, 0x04, 0x10, 0x20, 0x0C, 0x10, 0x30, 0x08, 0x10, 0x10, 0x08, 0x30,
  0x10, 0x08, 0x20, 0x08, 0x08, 0x20, 0x08, 0x18, 0x20, 0x08, 0x18, 0x20,
  0x04, 0x10, 0x20, 0x04, 0x10, 0x60, 0x02, 0x10, 0x40, 0x02, 0x10, 0x40,
  0x02, 0x30, 0x40, 0x01, 0x30, 0x40, 0x01, 0x20, 0xC0, 0x01, 0xA0, 0x80,
  0x00, 0xA0, 0x80, 0x00, 0xA0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0x00,
  0x3F, 0x80, 0x03, 0x83, 0x00, 0x18, 0x03, 0x00, 0x80, 0x04, 0x04, 0x00,
  0x18, 0x30, 0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08,
  0x40, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80,
  0x00, 0x22, 0x00, 0x00, 0x98, 0x00, 0x06, 0x40, 0x00, 0x11, 0x00, 0x00,
  0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x33, 0x00, 0x00, 0x8C,
  0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00,
  0x08, 0x08, 0x00, 0x40, 0x30, 0x06, 0x00, 0x70, 0x70, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x40, 0x1C, 0x04, 0x00, 0x60, 0xC0, 0x02, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x11,
  0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x04,
  0x10, 0x00, 0xC3, 0x00, 0x18, 0x20, 0x07, 0x03, 0xFF, 0xC0, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x83,
  0x00, 0x18, 0x03, 0x00, 0x80, 0x04, 0x04, 0x00, 0x18, 0x30, 0x00, 0x20,
  0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x22, 0x00,
  0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x26, 0x00, 0x00,
  0x98, 0x00, 0x06, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10,
  0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x30, 0x00,
  0x18, 0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x08, 0x08, 0x00, 0x40,
  0x30, 0x06, 0x00, 0x70, 0x70, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x07, 0xFF, 0x00, 0x20, 0x0E, 0x01, 0x00, 0x18, 0x18, 0x00, 0x40,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00,
  0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x02, 0x08,
  0x00, 0x30, 0xC0, 0x03, 0x04, 0x00, 0x30, 0x20, 0x07, 0x01, 0xFF, 0xC0,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x40, 0x20, 0x02, 0x01, 0x00,
  0x18, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x18, 0x20, 0x00, 0x41,
  0x00, 0x02, 0x08, 0x00, 0x18, 0x40, 0x00, 0x42, 0x00, 0x02, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0x07, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x20, 0x40, 0x01,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x32, 0x00, 0x01, 0x90,
  0x00, 0x08, 0x80, 0x00, 0x46, 0x00, 0x06, 0x10, 0x00, 0x20, 0xC0, 0x03,
  0x03, 0x00, 0x30, 0x0E, 0x0E, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x08, 0x40, 0x00, 0x44, 0x00, 0x02, 0x20,
  0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02,
  0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00,
  0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x62,
  0x00, 0x02, 0x10, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00,
  0x22, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x08, 0x30,
  0x00, 0xC0, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x1C, 0x1C, 0x00, 0x3F, 0x80,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x2C, 0x00, 0x02, 0x40,
  0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x06,
  0x00, 0x10, 0x60, 0x03, 0x02, 0x00, 0x20, 0x20, 0x06, 0x02, 0x00, 0x40,
  0x20, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x08, 0x01, 0x01, 0x00, 0x10, 0x10,
  0x01, 0x02, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x88,
  0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00, 0x0A,
  0x00, 0x00, 0xA0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x0B, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x14, 0x00, 0x64, 0x00,
  0x48, 0x00, 0x88, 0x00, 0x90, 0x01, 0x10, 0x03, 0x20, 0x06, 0x20, 0x04,
  0x40, 0x08, 0x40, 0x08, 0x80, 0x10, 0x80, 0x21, 0x00, 0x41, 0x00, 0x42,
  0x00, 0x82, 0x01, 0x04, 0x03, 0x04, 0x02, 0x08, 0x04, 0x08, 0x04, 0x18,
  0x08, 0x10, 0x10, 0x10, 0x20, 0x30, 0x20, 0x20, 0x40, 0x60, 0x80, 0x40,
  0x80, 0xC1, 0x00, 0x82, 0x00, 0x86, 0x01, 0x04, 0x01, 0x08, 0x02, 0x18,
  0x02, 0x10, 0x04, 0x20, 0x04, 0x40, 0x08, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x13, 0x00, 0x22, 0x00, 0x24, 0x00, 0x6C, 0x00, 0x48, 0x00, 0x50, 0x00,
  0xA0, 0x00, 0xA0, 0x01, 0x40, 0x01, 0xC0, 0x02, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x01, 0x01,
  0x80, 0x01, 0x80, 0x40, 0x01, 0x80, 0x20, 0x00, 0x80, 0x18, 0x00, 0x80,
  0x04, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00, 0x40, 0x40,
  0x00, 0x10, 0x60, 0x00, 0x08, 0x20, 0x00, 0x06, 0x20, 0x00, 0x01, 0x20,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x08, 0x80, 0x00, 0x08, 0x40, 0x00, 0x08,
  0x30, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x06, 0x00, 0x04, 0x01, 0x00, 0x04,
  0x00, 0x80, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x02, 0x00, 0x0C, 0x03,
  0x00, 0x02, 0x03, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x12,
  0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00, 0x82, 0x00, 0x0C, 0x10, 0x00,
  0x40, 0xC0, 0x04, 0x02, 0x00, 0x60, 0x10, 0x02, 0x00, 0x80, 0x20, 0x02,
  0x03, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x02, 0x18, 0x00, 0x10, 0x80,
  0x00, 0x88, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x7C, 0x00, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10,
  0x41, 0x04, 0x10, 0x61, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x82, 0x08, 0x20, 0x82, 0x08, 0x30, 0x01, 0xF0, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0xF8,
  0x00, 0x00, 0xC0, 0x0C, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x04, 0x60,
  0x42, 0x08, 0x20, 0x82, 0x10, 0x21, 0x02, 0x20, 0x32, 0x03, 0x40, 0x14,
  0x01, 0xFF, 0xFE, 0xC2, 0x18, 0x41, 0x0C, 0x01, 0xF8, 0x03, 0x06, 0x0C,
  0x03, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x03, 0xFE, 0x1C, 0x02, 0x30, 0x02, 0x60, 0x02, 0x40,
  0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x14, 0xC0,
  0x24, 0x61, 0xCC, 0x3F, 0x04, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x1F, 0x01, 0x30, 0x60, 0xA0, 0x18, 0xE0, 0x04, 0x60,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x26, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x30, 0x00,
  0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x23, 0x00, 0x21, 0xC0, 0x31, 0xB0,
  0x60, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0x83, 0x03, 0x00, 0xC1, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x03, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x04, 0xC0, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x02, 0x01,
  0x81, 0xC3, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x07, 0xC2, 0x03, 0x06, 0x40, 0x80, 0x58,
  0x20, 0x06, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x0C, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08,
  0x00, 0xC1, 0x80, 0x18, 0x10, 0x0F, 0x01, 0x06, 0x40, 0x1F, 0x08, 0x00,
  0x00, 0xF8, 0x01, 0x83, 0x01, 0x00, 0xC1, 0x00, 0x21, 0x00, 0x11, 0x80,
  0x0C, 0x80, 0x06, 0x40, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x9F, 0xFF, 0xC8,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0xC1, 0x80, 0x3F,
  0x00, 0x00, 0xF8, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x3F, 0xF0, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x20, 0x30, 0x64,
  0x08, 0x05, 0x82, 0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0x86, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0xC0, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04,
  0x00, 0x20, 0x80, 0x0C, 0x18, 0x03, 0x81, 0x00, 0xF0, 0x30, 0x64, 0x01,
  0xF0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x0C, 0x00, 0x80, 0xC0, 0x20, 0x0C, 0x18, 0x00, 0x7E, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x1F, 0x01, 0x18,
  0x60, 0x90, 0x10, 0x50, 0x0C, 0x70, 0x02, 0x28, 0x01, 0x18, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x26, 0x00, 0x32, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x03, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x19, 0x80, 0x08, 0x80, 0x04, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x3C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x18, 0x20, 0x0C, 0x08, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x40, 0xC0,
  0x10, 0x60, 0x04, 0x30, 0x01, 0x18, 0x00, 0xC8, 0x00, 0x26, 0x00, 0x0A,
  0x40, 0x03, 0x18, 0x00, 0x82, 0x00, 0x20, 0xC0, 0x18, 0x10, 0x04, 0x06,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x10, 0x04, 0x04, 0x01, 0x83, 0x00, 0x20,
  0x80, 0x0C, 0x00, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18,
  0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10,
  0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC0, 0x08, 0x7C, 0x03, 0xE0,
  0x26, 0x0C, 0x30, 0x41, 0xB0, 0x11, 0x80, 0x86, 0x80, 0x68, 0x02, 0x14,
  0x00, 0xE0, 0x0C, 0x60, 0x03, 0x00, 0x11, 0x80, 0x08, 0x00, 0xC4, 0x00,
  0x20, 0x03, 0x30, 0x01, 0x80, 0x08, 0xC0, 0x04, 0x00, 0x22, 0x00, 0x10,
  0x00, 0x88, 0x00, 0x40, 0x02, 0x20, 0x01, 0x00, 0x08, 0x80, 0x04, 0x00,
  0x66, 0x00, 0x20, 0x01, 0x10, 0x00, 0x80, 0x04, 0x40, 0x02, 0x00, 0x11,
  0x00, 0x08, 0x00, 0x44, 0x00, 0x20, 0x01, 0x10, 0x01, 0x80, 0x0C, 0xC0,
  0x04, 0x00, 0x22, 0x00, 0x10, 0x00, 0x88, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x7C, 0x04, 0x61, 0x82, 0x40, 0x41, 0x40, 0x31, 0xC0, 0x08, 0xA0, 0x04,
  0x60, 0x02, 0x20, 0x01, 0x10, 0x00, 0x98, 0x00, 0xC8, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0xC0, 0x04, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x66, 0x00, 0x22, 0x00, 0x10,
  0x01, 0xF8, 0x06, 0x0C, 0x0C, 0x02, 0x18, 0x03, 0x30, 0x01, 0x20, 0x01,
  0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04,
  0x80, 0x0C, 0xC0, 0x08, 0x60, 0x30, 0x30, 0x60, 0x1F, 0x80, 0x04, 0x3E,
  0x01, 0x30, 0x60, 0x50, 0x08, 0x18, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x31, 0x00, 0x08, 0xC0, 0x02, 0x20, 0x00,
  0x88, 0x00, 0x42, 0x00, 0x10, 0xC0, 0x08, 0x38, 0x04, 0x1B, 0x86, 0x04,
  0x3F, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF0,
  0x83, 0x06, 0x42, 0x01, 0xA2, 0x00, 0x63, 0x00, 0x11, 0x00, 0x09, 0x80,
  0x04, 0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x30, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x19, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x03, 0x10, 0x01, 0x84, 0x03, 0x83, 0x06, 0x40, 0x7C, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x08, 0x78, 0x4C, 0x02, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x06, 0x0C,
  0x08, 0x02, 0x10, 0x03, 0x10, 0x01, 0x20, 0x01, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08,
  0x40, 0x10, 0x30, 0x60, 0x1F, 0x80, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x41, 0xFF, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x04, 0x03, 0xC0, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x66, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x03, 0x30,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x19,
  0x80, 0x08, 0x80, 0x04, 0x40, 0x06, 0x30, 0x03, 0x08, 0x02, 0x84, 0x02,
  0xC1, 0x86, 0x40, 0x7C, 0x20, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0xC0,
  0x04, 0xC0, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x30, 0x40,
  0x20, 0x60, 0x60, 0x20, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x20, 0x80, 0x21,
  0x00, 0x31, 0x00, 0x12, 0x00, 0x12, 0x00, 0x14, 0x00, 0x14, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x80, 0x10, 0x03, 0x80, 0x10, 0x02, 0x80, 0x38, 0x02,
  0x80, 0x28, 0x06, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x80, 0xC8, 0x08,
  0x80, 0x88, 0x08, 0x81, 0x88, 0x10, 0x81, 0x08, 0x10, 0xC1, 0x08, 0x30,
  0xC2, 0x08, 0x20, 0xC2, 0x08, 0x60, 0x44, 0x0C, 0x40, 0x44, 0x04, 0x40,
  0x4C, 0x04, 0xC0, 0x48, 0x04, 0x80, 0x58, 0x05, 0x80, 0x50, 0x05, 0x00,
  0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x06, 0x00,
  0x0C, 0x00, 0x60, 0x80, 0x08, 0x18, 0x02, 0x01, 0x00, 0x80, 0x30, 0x30,
  0x02, 0x04, 0x00, 0x41, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00, 0x0A, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x60, 0x00, 0x44, 0x00,
  0x10, 0x80, 0x06, 0x08, 0x01, 0x81, 0x00, 0x20, 0x30, 0x08, 0x02, 0x03,
  0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x20, 0x00,
  0x81, 0x00, 0x0C, 0x0C, 0x00, 0x40, 0x20, 0x06, 0x01, 0x00, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x02, 0x01, 0x80, 0x18, 0x08, 0x00, 0x40, 0xC0,
  0x02, 0x04, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x04, 0x30, 0x00, 0x31,
  0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x40, 0x00,
  0x0A, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C,
  0x10, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x06, 0x08,
  0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x13, 0x18, 0x03, 0x60,
  0xC0, 0x24, 0x06, 0x02, 0xC0, 0x20, 0x48, 0x01, 0x8C, 0x80, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 31, 8, 1, -31 },
  { 29, 7, 9, 11, 5, -33 },
  { 37, 22, 31, 21, 1, -31 },
  { 123, 18, 39, 21, 2, -35 },
  { 211, 21, 31, 28, 4, -31 },
  { 293, 20, 31, 23, 1, -31 },
  { 371, 2, 9, 7, 5, -33 },
  { 374, 12, 45, 12, 2, -35 },
  { 442, 12, 45, 12, -3, -35 },
  { 510, 16, 17, 18, 3, -31 },
  { 544, 18, 23, 21, 2, -26 },
  { 596, 4, 9, 8, -1, -3 },
  { 601, 8, 1, 12, 2, -15 },
  { 602, 3, 2, 9, 1, -2 },
  { 603, 18, 34, 15, -2, -31 },
  { 680, 18, 31, 21, 2, -31 },
  { 750, 9, 31, 21, 6, -31 },
  { 785, 18, 31, 21, 1, -31 },
  { 855, 19, 31, 21, 1, -31 },
  { 929, 18, 31, 21, 1, -31 },
  { 999, 18, 31, 21, 3, -31 },
  { 1069, 16, 31, 21, 2, -31 },
  { 1131, 17, 31, 21, 4, -31 },
  { 1197, 19, 31, 21, 1, -31 },
  { 1271, 16, 31, 21, 3, -31 },
  { 1333, 7, 23, 8, 0, -23 },
  { 1354, 8, 29, 8, -1, -23 },
  { 1383, 16, 17, 19, 2, -23 },
  { 1417, 17, 10, 21, 2, -19 },
  { 1439, 17, 17, 19, 1, -23 },
  { 1476, 13, 31, 17, 4, -31 },
  { 1527, 31, 40, 34, 1, -30 },
  { 1682, 20, 31, 23, -1, -31 },
  { 1760, 19, 31, 23, 2, -31 },
  { 1834, 20, 31, 24, 3, -31 },
  { 1912, 21, 31, 24, 2, -31 },
  { 1994, 21, 31, 21, 2, -31 },
  { 2076, 21, 31, 21, 2, -31 },
  { 2158, 21, 31, 26, 3, -31 },
  { 2240, 23, 31, 26, 2, -31 },
  { 2330, 7, 31, 10, 2, -31 },
  { 2358, 19, 31, 21, 1, -31 },
  { 2432, 23, 31, 24, 2, -31 },
  { 2522, 14, 31, 20, 2, -31 },
  { 2577, 29, 31, 32, 2, -31 },
  { 2690, 24, 31, 26, 2, -31 },
  { 2783, 22, 31, 25, 2, -31 },
  { 2869, 20, 31, 23, 2, -31 },
  { 2947, 22, 37, 25, 2, -31 },
  { 3049, 21, 31, 24, 2, -31 },
  { 3131, 21, 31, 22, 1, -31 },
  { 3213, 20, 31, 22, 4, -31 },
  { 3291, 21, 31, 25, 3, -31 },
  { 3373, 20, 31, 23, 4, -31 },
  { 3451, 31, 31, 34, 4, -31 },
  { 3572, 25, 31, 22, -1, -31 },
  { 3669, 21, 31, 22, 4, -31 },
  { 3751, 23, 31, 22, 0, -31 },
  { 3841, 12, 43, 9, 0, -36 },
  { 3906, 6, 34, 15, 5, -31 },
  { 3932, 12, 43, 9, -3, -36 },
  { 3997, 12, 16, 16, 2, -31 },
  { 4021, 15, 1, 16, -2, 0 },
  { 4023, 5, 6, 11, 6, -33 },
  { 4027, 16, 23, 20, 1, -23 },
  { 4073, 17, 33, 21, 1, -33 },
  { 4144, 17, 23, 19, 1, -23 },
  { 4193, 19, 33, 21, 2, -33 },
  { 4272, 17, 23, 19, 1, -23 },
  { 4321, 13, 33, 12, 3, -33 },
  { 4375, 19, 32, 21, 0, -23 },
  { 4451, 17, 33, 21, 1, -33 },
  { 4522, 7, 31, 8, 1, -31 },
  { 4550, 14, 40, 9, -6, -31 },
  { 4620, 18, 33, 18, 1, -33 },
  { 4695, 7, 33, 8, 1, -33 },
  { 4724, 30, 23, 33, 1, -23 },
  { 4811, 17, 23, 21, 1, -23 },
  { 4860, 16, 23, 21, 2, -23 },
  { 4906, 18, 32, 21, 0, -23 },
  { 4978, 17, 32, 21, 2, -23 },
  { 5046, 13, 23, 13, 1, -23 },
  { 5084, 16, 23, 19, 1, -23 },
  { 5130, 9, 30, 12, 3, -30 },
  { 5164, 17, 23, 21, 2, -23 },
  { 5213, 16, 23, 18, 3, -23 },
  { 5259, 24, 23, 28, 4, -23 },
  { 5328, 19, 23, 18, -1, -23 },
  { 5383, 21, 32, 18, -2, -23 },
  { 5467, 18, 23, 18, 0, -23 },
  { 5519, 14, 44, 12, 1, -34 },
  { 5596, 7, 37, 9, 1, -31 },
  { 5629, 14, 44, 12, -3, -34 },
  { 5706, 20, 7, 26, 3, -17 },
};

const GFXfont RobotoCondensed_ThinItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_THINITALIC44PT7B_H_
