#ifndef _ROBOTOCONDENSED_THINITALIC23PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x22, 0x24, 0x40, 0x00, 0xC0, 0xB6, 0xDA,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x44, 0x3F, 0xF0, 0x44, 0x08, 0x80, 0x88,
  0x08, 0x81, 0x10, 0x11, 0x01, 0x10, 0xFF, 0xC2, 0x20, 0x22, 0x02, 0x40,
  0x44, 0x00, 0x02, 0x01, 0x03, 0xC2, 0x12, 0x09, 0x05, 0x02, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x1F, 0x02,
  0x01, 0x00, 0x38, 0x09, 0x02, 0x11, 0x42, 0x48, 0x89, 0x12, 0x22, 0x83,
  0x90, 0x04, 0x01, 0x38, 0x28, 0x89, 0x12, 0x22, 0x48, 0x51, 0x08, 0x12,
  0x03, 0x80, 0x0E, 0x04, 0x41, 0x10, 0x84, 0x21, 0x08, 0x81, 0x40, 0x60,
  0x28, 0x12, 0x04, 0x46, 0x11, 0x82, 0xA0, 0xA8, 0x12, 0x0A, 0x7C, 0x80,
  0x56, 0x80, 0x04, 0x20, 0x84, 0x20, 0x82, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0x02, 0x00, 0x10, 0x20, 0x81, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08, 0x41,
  0x08, 0x00, 0x04, 0x02, 0x02, 0x19, 0x33, 0xE0, 0xC0, 0x50, 0x44, 0x42,
  0x00, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x43, 0xFE, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x25, 0x28, 0xF0, 0x40, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x0A, 0x05,
  0x02, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x14, 0x0A, 0x08, 0x88, 0x38,
  0x00, 0x1B, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x40,
  0x0F, 0x18, 0x48, 0x28, 0x14, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0xFF, 0x00, 0x0F, 0x08, 0x48, 0x28,
  0x14, 0x08, 0x04, 0x02, 0x02, 0x1E, 0x01, 0x00, 0x40, 0x28, 0x14, 0x0A,
  0x05, 0x04, 0x7C, 0x00, 0x00, 0x80, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x44,
  0x42, 0x22, 0x21, 0x20, 0x9F, 0xF0, 0x20, 0x10, 0x10, 0x08, 0x04, 0x00,
  0x1F, 0xC4, 0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xE0, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x02, 0x81, 0x20, 0x44, 0x11, 0x08, 0x3C, 0x00, 0x07, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x78, 0xC2, 0x41, 0x40, 0x60, 0x30, 0x18,
  0x14, 0x0A, 0x04, 0x84, 0x3C, 0x00, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x00, 0x07, 0x81, 0x08, 0x41, 0x08, 0x12, 0x02, 0x40, 0x88, 0x10,
  0x84, 0x0F, 0x02, 0x20, 0x82, 0x20, 0x24, 0x05, 0x01, 0x10, 0x22, 0x08,
  0x3E, 0x00, 0x1E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x85,
  0x7A, 0x02, 0x02, 0x04, 0x08, 0x10, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x44, 0x22, 0x00, 0x01,
  0x83, 0x06, 0x0C, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x06, 0x18,
  0x60, 0x80, 0x3C, 0x86, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xF8, 0x06, 0x04, 0x08, 0x02, 0x10,
  0x02, 0x20, 0x01, 0x21, 0xE1, 0x42, 0x21, 0x44, 0x21, 0x84, 0x21, 0x84,
  0x21, 0x88, 0x22, 0x88, 0x42, 0x88, 0x42, 0x88, 0x44, 0x88, 0xC4, 0x8F,
  0x38, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x00,
  0x80, 0x30, 0x06, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x22, 0x08, 0x41,
  0x08, 0x41, 0x0F, 0xE2, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x20, 0x1F,
  0x88, 0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x02, 0x7F, 0x10, 0x44,
  0x09, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0xFE, 0x00, 0x07, 0x83, 0x08,
  0x80, 0x90, 0x14, 0x02, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x05, 0x00, 0x90, 0x22, 0x08, 0x3E, 0x00, 0x1F, 0x84, 0x08,
  0x80, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01,
  0x20, 0x28, 0x05, 0x01, 0x20, 0x24, 0x18, 0xFC, 0x00, 0x1F, 0xE4, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x7F, 0x88, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0x00, 0x1F, 0xE4, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x7F, 0x88, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x0F, 0x82, 0x08,
  0x81, 0x20, 0x14, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0xFA, 0x01,
  0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x08, 0x7E, 0x00, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x24, 0x02, 0x7F, 0xE4, 0x02,
  0x40, 0x24, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x40, 0x11,
  0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x80, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x48, 0x09, 0x02, 0x20, 0x42, 0x10, 0x3C, 0x00, 0x20, 0x22, 0x04, 0x20,
  0x42, 0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x80, 0x58, 0x06, 0x40, 0x44,
  0x04, 0x20, 0x82, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0x80, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0xFE, 0x10, 0x02, 0x60, 0x04, 0xC0, 0x19, 0x80, 0x53, 0x00, 0xA5, 0x02,
  0x52, 0x05, 0x24, 0x12, 0x48, 0x24, 0x90, 0x89, 0x11, 0x12, 0x24, 0x28,
  0x48, 0x90, 0xA1, 0x21, 0x42, 0x43, 0x04, 0x82, 0x08, 0x10, 0x13, 0x01,
  0x30, 0x12, 0x81, 0x28, 0x12, 0x41, 0x44, 0x14, 0x42, 0x42, 0x24, 0x22,
  0x42, 0x24, 0x12, 0x81, 0x28, 0x0C, 0x80, 0xC8, 0x04, 0x80, 0x40, 0x07,
  0x83, 0x08, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x30,
  0x06, 0x00, 0xC0, 0x28, 0x05, 0x00, 0x90, 0x22, 0x08, 0x3E, 0x00, 0x1F,
  0x84, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x50, 0x12, 0x02, 0x40, 0x8F,
  0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x07,
  0x83, 0x08, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x30,
  0x06, 0x00, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x22, 0x08, 0x3E, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x1F, 0x84, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x50,
  0x12, 0x02, 0x40, 0x8F, 0xE1, 0x08, 0x21, 0x08, 0x11, 0x02, 0x20, 0x24,
  0x04, 0x80, 0x80, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x00, 0x48, 0x09, 0x01, 0x20, 0x24,
  0x08, 0x7E, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x00, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x24, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04,
  0x40, 0x84, 0x10, 0x3E, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x08,
  0x82, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x10, 0x22, 0x02, 0x80, 0x50,
  0x0C, 0x01, 0x80, 0x20, 0x00, 0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x44, 0x84, 0x48, 0x48, 0x48,
  0x48, 0x48, 0x48, 0x50, 0x50, 0x50, 0x50, 0x60, 0x50, 0x60, 0x60, 0x60,
  0x60, 0x40, 0x40, 0x20, 0x11, 0x02, 0x10, 0x20, 0x84, 0x08, 0x80, 0x88,
  0x05, 0x00, 0x60, 0x02, 0x00, 0x60, 0x09, 0x01, 0x10, 0x11, 0x02, 0x08,
  0x40, 0x84, 0x04, 0x80, 0x40, 0x80, 0x30, 0x09, 0x02, 0x20, 0x44, 0x10,
  0x44, 0x08, 0x81, 0x20, 0x14, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xC0, 0x0C, 0x41, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x0E,
  0x00, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22, 0x22, 0x22, 0x11, 0x1C, 0x10,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x8C, 0x00, 0x08, 0x61, 0x49, 0x25, 0x14, 0x61, 0xFF, 0x89,
  0x00, 0x0F, 0x08, 0x48, 0x20, 0x10, 0x08, 0xFD, 0x82, 0x82, 0x81, 0x40,
  0xA0, 0xCF, 0xA0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x78, 0xC2,
  0x40, 0xA0, 0x50, 0x30, 0x18, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x7E, 0x00,
  0x1E, 0x21, 0x41, 0x81, 0x80, 0x80, 0x80, 0x80, 0x82, 0x82, 0x84, 0x78,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x21, 0xE8, 0x86, 0x41, 0x10,
  0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x86, 0x1E, 0x80, 0x1E,
  0x21, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x82, 0x7C, 0x0E,
  0x20, 0x40, 0x82, 0x04, 0x1F, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x00, 0x0F, 0x44, 0x32, 0x04, 0x81, 0x40, 0x90, 0x24, 0x09,
  0x02, 0x40, 0x90, 0x44, 0x30, 0xF4, 0x01, 0x00, 0x40, 0x22, 0x08, 0x7C,
  0x00, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x4E, 0x51, 0x61, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x20, 0x02, 0x92, 0x4A, 0x49,
  0x24, 0x02, 0x00, 0x00, 0x00, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x8E, 0x00, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x04, 0x84, 0x44, 0x24, 0x14, 0x14, 0x05, 0x04, 0x42,
  0x21, 0x08, 0x84, 0x41, 0x00, 0x24, 0x92, 0x52, 0x49, 0x29, 0x24, 0x90,
  0x27, 0x1E, 0x28, 0xA1, 0x30, 0x41, 0x20, 0x41, 0x20, 0x81, 0x40, 0x81,
  0x40, 0x81, 0x40, 0x81, 0x40, 0x82, 0x41, 0x02, 0x41, 0x02, 0x81, 0x02,
  0x4E, 0x51, 0x61, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82,
  0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x41, 0x20,
  0x8F, 0x80, 0x2F, 0x0C, 0x22, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x02,
  0x40, 0x90, 0x24, 0x11, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00,
  0x1E, 0x90, 0xD0, 0x28, 0x18, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x21,
  0x8F, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x00, 0x5D, 0x84, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x1F, 0x10, 0x48, 0x24, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x01, 0x40, 0x90, 0x87, 0x80, 0x11, 0x09, 0xF2, 0x10, 0x88,
  0x42, 0x10, 0x88, 0x41, 0x80, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x14, 0x0A,
  0x05, 0x02, 0x82, 0x41, 0x21, 0x8F, 0x40, 0x80, 0xC0, 0x90, 0x48, 0x44,
  0x22, 0x21, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x04, 0x00, 0x82, 0x04, 0x30,
  0xA1, 0x85, 0x14, 0x48, 0xA2, 0x49, 0x22, 0x49, 0x14, 0x48, 0xA2, 0x85,
  0x0C, 0x10, 0x41, 0x02, 0x00, 0x20, 0x90, 0x84, 0x42, 0x40, 0xC0, 0x40,
  0x20, 0x28, 0x24, 0x21, 0x10, 0x90, 0x20, 0x20, 0x22, 0x08, 0x41, 0x08,
  0x41, 0x08, 0x22, 0x04, 0x40, 0x90, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0xE0, 0x02, 0x08, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x20, 0x41, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x0C, 0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x22,
  0x44, 0x44, 0x44, 0x88, 0x08, 0x04, 0x04, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x03, 0x06, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0xC0, 0x38, 0x28, 0x85, 0x09, 0x40, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 4, 0, -17 },
  { 10, 3, 5, 6, 3, -17 },
  { 12, 12, 17, 11, 0, -17 },
  { 38, 9, 21, 11, 1, -19 },
  { 62, 11, 17, 15, 2, -17 },
  { 86, 10, 17, 12, 1, -17 },
  { 108, 2, 5, 4, 2, -17 },
  { 110, 6, 23, 6, 1, -18 },
  { 128, 6, 23, 6, -1, -18 },
  { 146, 9, 9, 9, 1, -17 },
  { 157, 9, 13, 11, 1, -14 },
  { 172, 3, 5, 4, -1, -2 },
  { 174, 4, 1, 6, 1, -8 },
  { 175, 2, 1, 5, 0, -1 },
  { 176, 9, 18, 8, -1, -17 },
  { 197, 9, 17, 11, 1, -17 },
  { 217, 5, 17, 11, 3, -17 },
  { 228, 9, 17, 11, 1, -17 },
  { 248, 9, 17, 11, 1, -17 },
  { 268, 9, 17, 11, 1, -17 },
  { 288, 10, 17, 11, 1, -17 },
  { 310, 9, 17, 11, 1, -17 },
  { 330, 9, 17, 11, 2, -17 },
  { 350, 11, 17, 11, 0, -17 },
  { 374, 8, 17, 11, 2, -17 },
  { 391, 4, 12, 4, 0, -12 },
  { 397, 5, 15, 4, -1, -12 },
  { 407, 9, 9, 10, 1, -12 },
  { 418, 9, 6, 11, 1, -10 },
  { 425, 8, 9, 10, 1, -12 },
  { 434, 7, 17, 9, 2, -17 },
  { 449, 16, 21, 18, 1, -16 },
  { 491, 11, 17, 12, -1, -17 },
  { 515, 10, 17, 12, 1, -17 },
  { 537, 11, 17, 13, 1, -17 },
  { 561, 11, 17, 13, 1, -17 },
  { 585, 11, 17, 11, 1, -17 },
  { 609, 11, 17, 11, 1, -17 },
  { 633, 11, 17, 13, 2, -17 },
  { 657, 12, 17, 14, 1, -17 },
  { 683, 4, 17, 5, 1, -17 },
  { 692, 11, 17, 11, 0, -17 },
  { 716, 12, 17, 12, 1, -17 },
  { 742, 7, 17, 10, 1, -17 },
  { 757, 15, 17, 17, 1, -17 },
  { 789, 12, 17, 14, 1, -17 },
  { 815, 11, 17, 13, 1, -17 },
  { 839, 11, 17, 12, 1, -17 },
  { 863, 11, 20, 13, 1, -17 },
  { 891, 11, 17, 13, 1, -17 },
  { 915, 11, 17, 12, 1, -17 },
  { 939, 11, 17, 12, 2, -17 },
  { 963, 12, 17, 13, 1, -17 },
  { 989, 11, 17, 12, 2, -17 },
  { 1013, 16, 17, 18, 2, -17 },
  { 1047, 12, 17, 12, 0, -17 },
  { 1073, 11, 17, 12, 2, -17 },
  { 1097, 12, 17, 12, 0, -17 },
  { 1123, 6, 23, 5, 0, -19 },
  { 1141, 4, 18, 8, 2, -17 },
  { 1150, 6, 23, 5, -1, -19 },
  { 1168, 6, 8, 8, 1, -17 },
  { 1174, 8, 1, 8, -1, 0 },
  { 1175, 3, 3, 6, 3, -17 },
  { 1177, 9, 12, 10, 0, -12 },
  { 1191, 9, 18, 11, 1, -18 },
  { 1212, 8, 12, 10, 1, -12 },
  { 1224, 10, 18, 11, 1, -18 },
  { 1247, 8, 12, 10, 1, -12 },
  { 1259, 7, 18, 6, 1, -18 },
  { 1275, 10, 17, 11, 0, -12 },
  { 1297, 8, 18, 11, 1, -18 },
  { 1315, 3, 16, 4, 1, -16 },
  { 1321, 7, 21, 5, -3, -16 },
  { 1340, 9, 18, 9, 1, -18 },
  { 1361, 3, 18, 4, 1, -18 },
  { 1368, 16, 12, 17, 0, -12 },
  { 1392, 8, 12, 11, 1, -12 },
  { 1404, 9, 12, 11, 1, -12 },
  { 1418, 10, 17, 11, 0, -12 },
  { 1440, 9, 17, 11, 1, -12 },
  { 1460, 6, 12, 7, 1, -12 },
  { 1469, 9, 12, 10, 0, -12 },
  { 1483, 5, 15, 6, 1, -15 },
  { 1493, 9, 12, 11, 1, -12 },
  { 1507, 9, 12, 9, 1, -12 },
  { 1521, 13, 12, 15, 2, -12 },
  { 1541, 9, 12, 9, 0, -12 },
  { 1555, 11, 17, 9, -1, -12 },
  { 1579, 9, 12, 9, 0, -12 },
  { 1593, 7, 23, 7, 1, -18 },
  { 1614, 4, 20, 4, 0, -17 },
  { 1624, 8, 23, 7, -2, -18 },
  { 1647, 11, 4, 13, 1, -9 },
};

const GFXfont RobotoCondensed_ThinItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_THINITALIC23PT7B_H_
