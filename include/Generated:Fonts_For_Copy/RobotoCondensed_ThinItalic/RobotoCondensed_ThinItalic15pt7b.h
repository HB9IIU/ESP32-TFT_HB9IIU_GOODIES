#ifndef _ROBOTOCONDENSED_THINITALIC15PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x02, 0x00, 0xB4, 0x08, 0x0A, 0x12, 0x3F, 0x14,
  0x24, 0x28, 0x28, 0x5E, 0x48, 0x00, 0x00, 0xE4, 0x61, 0x81, 0x03, 0x02,
  0x08, 0x28, 0xBC, 0x00, 0x71, 0x26, 0x54, 0xA6, 0x82, 0x05, 0x95, 0x4A,
  0x14, 0x38, 0x1C, 0x48, 0x91, 0x41, 0x06, 0x14, 0x45, 0x85, 0x09, 0xE0,
  0x40, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88, 0x00, 0x01, 0x11, 0x11,
  0x11, 0x11, 0x22, 0x24, 0x80, 0x00, 0x8F, 0x88, 0x52, 0x00, 0x00, 0x42,
  0x1E, 0x20, 0x82, 0x00, 0x60, 0x00, 0x80, 0x00, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x81, 0x00, 0x00, 0x39, 0x18, 0x61, 0x86, 0x18, 0xA2,
  0x8A, 0x4E, 0x00, 0x74, 0x92, 0x52, 0x48, 0x00, 0x1C, 0x45, 0x08, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x83, 0xE0, 0x1C, 0x44, 0x08, 0x10, 0x43, 0x01,
  0x02, 0x85, 0x09, 0xE0, 0x00, 0x08, 0x30, 0xA2, 0x44, 0x91, 0x3E, 0x08,
  0x10, 0x20, 0x39, 0x04, 0x10, 0x78, 0x20, 0x42, 0x0A, 0x27, 0x00, 0x11,
  0x11, 0x0F, 0xC6, 0x31, 0x8C, 0x7C, 0x3C, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x41, 0x00, 0x00, 0x1C, 0x45, 0x0A, 0x14, 0x47, 0x11, 0x42, 0x85, 0x09,
  0xE0, 0x39, 0x18, 0x61, 0x86, 0x27, 0x82, 0x08, 0x4E, 0x00, 0x40, 0x02,
  0x40, 0x00, 0xA0, 0x09, 0xB1, 0x06, 0x08, 0x73, 0x80, 0x60, 0x40, 0xC2,
  0x33, 0x00, 0x72, 0x62, 0x11, 0x10, 0x88, 0x00, 0x00, 0x0F, 0xC2, 0x04,
  0x80, 0x93, 0x94, 0x82, 0x92, 0x64, 0x4C, 0x91, 0x92, 0x53, 0xB1, 0x00,
  0x20, 0x03, 0xC0, 0x08, 0x10, 0x50, 0xA2, 0x44, 0x91, 0x3E, 0x83, 0x04,
  0x08, 0x79, 0x14, 0x51, 0x86, 0xE8, 0x61, 0x86, 0x27, 0x00, 0x3C, 0x85,
  0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x09, 0xE0, 0x5C, 0x85, 0x0A, 0x18,
  0x30, 0x60, 0xC2, 0x85, 0x11, 0xC0, 0x5C, 0x81, 0x02, 0x08, 0x16, 0x20,
  0x40, 0x81, 0x01, 0xC0, 0x7C, 0x81, 0x02, 0x08, 0x16, 0x20, 0x40, 0x81,
  0x00, 0x00, 0x3C, 0x85, 0x04, 0x08, 0x10, 0xA0, 0x41, 0x85, 0x09, 0xE0,
  0x41, 0x41, 0x41, 0x42, 0x82, 0xBE, 0x82, 0x82, 0x82, 0x84, 0x00, 0x15,
  0x6A, 0xA0, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x85, 0x11, 0xC0,
  0x42, 0x89, 0x22, 0x8A, 0x1C, 0x24, 0x48, 0x89, 0x10, 0x10, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x84, 0x1C, 0x40, 0x50, 0x24, 0x15, 0x86, 0xA2, 0xA8,
  0xAA, 0x4A, 0x52, 0x98, 0xA6, 0x41, 0x10, 0x41, 0x41, 0x61, 0x62, 0x92,
  0x92, 0x8A, 0x8A, 0x8A, 0x84, 0x04, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x85, 0x09, 0xE0, 0x7C, 0x85, 0x0A, 0x18, 0x5F, 0x20, 0x40, 0x81,
  0x00, 0x00, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0,
  0x40, 0x00, 0x7C, 0x85, 0x0C, 0x18, 0x5F, 0x20, 0x44, 0x89, 0x10, 0x10,
  0x1E, 0x21, 0x40, 0x40, 0x20, 0x18, 0x04, 0x02, 0x82, 0x84, 0x78, 0x7C,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x00, 0x40, 0x85, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x85, 0x09, 0xE0, 0x81, 0x06, 0x12, 0x24, 0x49,
  0x12, 0x28, 0x50, 0xC0, 0x80, 0x04, 0x30, 0x86, 0x31, 0x45, 0x29, 0x24,
  0xA5, 0x14, 0xA3, 0x18, 0x63, 0x08, 0x41, 0x08, 0x00, 0x01, 0x22, 0x22,
  0x14, 0x18, 0x10, 0x18, 0x28, 0x44, 0x44, 0x80, 0x00, 0x85, 0x12, 0x42,
  0x86, 0x08, 0x10, 0x20, 0x40, 0x00, 0x1F, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x40, 0xF8, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88,
  0x2A, 0xAA, 0x95, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x26, 0x59,
  0x90, 0x78, 0x80, 0x3D, 0x10, 0x41, 0x76, 0x18, 0xBC, 0x20, 0x82, 0x10,
  0x7D, 0x14, 0x51, 0x46, 0x18, 0x7E, 0x39, 0x14, 0x20, 0x82, 0x08, 0x9C,
  0x00, 0x10, 0x41, 0x76, 0x28, 0xA2, 0x8A, 0x28, 0xBC, 0x39, 0x14, 0x6F,
  0x82, 0x08, 0x1E, 0x24, 0x44, 0x44, 0x88, 0x88, 0x80, 0x39, 0x14, 0x51,
  0x86, 0x18, 0x5F, 0x08, 0x27, 0x00, 0x20, 0x82, 0x10, 0x5D, 0x94, 0x51,
  0x46, 0x18, 0x60, 0x20, 0x04, 0x92, 0x50, 0x00, 0x08, 0x00, 0x01, 0x08,
  0x42, 0x11, 0x08, 0x42, 0x20, 0x20, 0x82, 0x10, 0x45, 0x25, 0x18, 0x52,
  0x48, 0xA2, 0x24, 0x94, 0x92, 0x4A, 0x00, 0x1D, 0xD8, 0x94, 0x45, 0x11,
  0x44, 0x61, 0x18, 0x46, 0x01, 0x1D, 0x94, 0x51, 0x45, 0x18, 0x60, 0x7C,
  0x63, 0x18, 0xC6, 0x3E, 0x3D, 0x14, 0x51, 0x46, 0x18, 0x7E, 0x82, 0x00,
  0x00, 0x74, 0x63, 0x18, 0xC6, 0x3F, 0x10, 0x84, 0x13, 0x10, 0x84, 0x22,
  0x10, 0x39, 0x14, 0x0C, 0x08, 0x28, 0x9C, 0x49, 0x29, 0x24, 0x90, 0x02,
  0x18, 0xA2, 0x8A, 0x29, 0x38, 0x04, 0x65, 0x29, 0x31, 0x08, 0x88, 0x44,
  0xA6, 0x55, 0x4A, 0xA6, 0x51, 0x10, 0x00, 0x45, 0x22, 0x84, 0x21, 0x44,
  0xA2, 0x00, 0x44, 0x89, 0x22, 0x43, 0x04, 0x08, 0x10, 0x41, 0x00, 0x3C,
  0x20, 0x84, 0x21, 0x04, 0x3C, 0x08, 0x84, 0x42, 0x10, 0x88, 0x02, 0x10,
  0x84, 0x20, 0x80, 0x24, 0xA4, 0x92, 0x4A, 0x48, 0x00, 0x84, 0x21, 0x08,
  0x40, 0x11, 0x08, 0x42, 0x22, 0x00, 0xE2, 0x38,
};

const GFXglyph RobotoCondensed_ThinItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 2, 3, 4, 2, -11 },
  { 7, 8, 11, 7, 0, -11 },
  { 18, 6, 13, 7, 1, -12 },
  { 28, 7, 11, 9, 1, -11 },
  { 38, 7, 11, 8, 0, -11 },
  { 48, 1, 3, 2, 2, -11 },
  { 49, 4, 15, 4, 1, -12 },
  { 57, 4, 15, 4, -1, -12 },
  { 65, 6, 6, 6, 1, -11 },
  { 70, 6, 8, 7, 1, -9 },
  { 76, 1, 3, 3, 0, -1 },
  { 77, 2, 1, 4, 1, -6 },
  { 78, 1, 1, 3, 0, -1 },
  { 79, 7, 12, 5, -1, -11 },
  { 90, 6, 11, 7, 1, -11 },
  { 99, 3, 11, 7, 2, -11 },
  { 104, 7, 11, 7, 0, -11 },
  { 114, 7, 11, 7, 0, -11 },
  { 124, 7, 11, 7, 0, -11 },
  { 134, 6, 11, 7, 1, -11 },
  { 143, 5, 11, 7, 1, -11 },
  { 150, 6, 11, 7, 1, -11 },
  { 159, 7, 11, 7, 0, -11 },
  { 169, 6, 11, 7, 1, -11 },
  { 178, 2, 8, 3, 0, -8 },
  { 180, 2, 10, 3, 0, -8 },
  { 183, 5, 6, 7, 1, -8 },
  { 187, 5, 2, 7, 1, -6 },
  { 189, 6, 6, 7, 0, -8 },
  { 194, 5, 11, 6, 1, -11 },
  { 201, 11, 13, 12, 0, -10 },
  { 219, 7, 11, 8, 0, -11 },
  { 229, 6, 11, 8, 1, -11 },
  { 238, 7, 11, 8, 1, -11 },
  { 248, 7, 11, 8, 1, -11 },
  { 258, 7, 11, 7, 1, -11 },
  { 268, 7, 11, 7, 1, -11 },
  { 278, 7, 11, 9, 1, -11 },
  { 288, 8, 11, 9, 1, -11 },
  { 299, 2, 11, 4, 1, -11 },
  { 302, 7, 11, 7, 0, -11 },
  { 312, 7, 11, 8, 1, -11 },
  { 322, 5, 11, 7, 1, -11 },
  { 329, 10, 11, 11, 1, -11 },
  { 343, 8, 11, 9, 1, -11 },
  { 354, 7, 11, 9, 1, -11 },
  { 364, 7, 11, 8, 1, -11 },
  { 374, 7, 13, 9, 1, -11 },
  { 386, 7, 11, 8, 1, -11 },
  { 396, 8, 11, 8, 0, -11 },
  { 407, 7, 11, 8, 1, -11 },
  { 417, 7, 11, 8, 1, -11 },
  { 427, 7, 11, 8, 1, -11 },
  { 437, 11, 11, 11, 1, -11 },
  { 453, 8, 11, 8, 0, -11 },
  { 464, 7, 11, 8, 1, -11 },
  { 474, 8, 11, 8, 0, -11 },
  { 485, 4, 14, 3, 0, -12 },
  { 492, 2, 12, 5, 2, -11 },
  { 495, 4, 14, 3, -1, -12 },
  { 502, 4, 5, 5, 1, -11 },
  { 505, 6, 1, 5, -1, 0 },
  { 506, 2, 2, 4, 2, -11 },
  { 507, 6, 8, 7, 0, -8 },
  { 513, 6, 12, 7, 0, -12 },
  { 522, 6, 8, 7, 0, -8 },
  { 528, 6, 12, 7, 1, -12 },
  { 537, 6, 8, 7, 0, -8 },
  { 543, 4, 12, 4, 1, -12 },
  { 549, 6, 11, 7, 0, -8 },
  { 558, 6, 12, 7, 0, -12 },
  { 567, 3, 11, 3, 0, -11 },
  { 572, 5, 14, 3, -2, -11 },
  { 581, 6, 12, 6, 0, -12 },
  { 590, 3, 12, 3, 0, -12 },
  { 595, 10, 8, 11, 0, -8 },
  { 605, 6, 8, 7, 0, -8 },
  { 611, 5, 8, 7, 1, -8 },
  { 616, 6, 11, 7, 0, -8 },
  { 625, 5, 11, 7, 1, -8 },
  { 632, 5, 8, 4, 0, -8 },
  { 637, 6, 8, 6, 0, -8 },
  { 643, 3, 10, 4, 1, -10 },
  { 647, 6, 8, 7, 1, -8 },
  { 653, 5, 8, 6, 1, -8 },
  { 658, 9, 8, 10, 1, -8 },
  { 667, 6, 8, 6, 0, -8 },
  { 673, 7, 11, 6, -1, -8 },
  { 683, 6, 8, 6, 0, -8 },
  { 689, 5, 15, 4, 0, -12 },
  { 699, 3, 13, 3, 0, -11 },
  { 704, 5, 15, 4, -1, -12 },
  { 714, 7, 2, 9, 1, -5 },
};

const GFXfont RobotoCondensed_ThinItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_THINITALIC15PT7B_H_
