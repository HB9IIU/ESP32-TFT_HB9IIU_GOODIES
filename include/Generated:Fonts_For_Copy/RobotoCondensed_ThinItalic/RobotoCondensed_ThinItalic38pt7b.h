#ifndef _ROBOTOCONDENSED_THINITALIC38PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x84, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x00, 0x45, 0x14,
  0x51, 0x4D, 0x28, 0xA2, 0x00, 0x20, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00,
  0x20, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x08, 0x10, 0x1F,
  0xFF, 0xE0, 0x20, 0x80, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x02, 0x03, 0xFF,
  0xFC, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x02,
  0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xF8, 0x03, 0x04, 0x06, 0x02, 0x04, 0x03, 0x08,
  0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0x40, 0x04, 0x40,
  0x08, 0x40, 0x08, 0x20, 0x10, 0x30, 0x60, 0x0F, 0x80, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x0F, 0x00, 0x04, 0x60, 0x02, 0x08, 0x00, 0x82, 0x00,
  0x40, 0x81, 0x10, 0x20, 0x44, 0x08, 0x21, 0x02, 0x10, 0x40, 0x8C, 0x10,
  0x42, 0x04, 0x11, 0x01, 0x88, 0x80, 0x3C, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x78, 0x06, 0x23, 0x01, 0x10, 0x40, 0x88, 0x10, 0x42, 0x04, 0x10, 0x81,
  0x08, 0x20, 0x44, 0x10, 0x13, 0x04, 0x04, 0x81, 0x02, 0x00, 0x20, 0x80,
  0x08, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x84, 0x00, 0x81, 0x00, 0xC0,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x20, 0x08, 0x10, 0x04, 0x10, 0x02,
  0x10, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x28, 0x00, 0x22, 0x00,
  0x21, 0x01, 0x20, 0x40, 0xA0, 0x30, 0x90, 0x08, 0x48, 0x02, 0x68, 0x01,
  0x24, 0x00, 0x62, 0x00, 0x30, 0x80, 0x18, 0x40, 0x16, 0x18, 0x31, 0x07,
  0xE0, 0x40, 0x55, 0x6A, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x18, 0x20, 0xCC, 0x4E, 0x07, 0xE0, 0x03, 0x00, 0x0F,
  0x00, 0x32, 0x00, 0x46, 0x01, 0x04, 0x04, 0x04, 0x10, 0x08, 0x00, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x11,
  0x32, 0x26, 0x48, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xF0, 0x04, 0x10, 0x10, 0x10, 0x40, 0x21, 0x00, 0x62, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00,
  0x48, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x24,
  0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x40, 0x40, 0x43,
  0x00, 0x7C, 0x00, 0x01, 0x0F, 0x31, 0xC1, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x01, 0xF8, 0x03, 0x0C, 0x04, 0x06,
  0x08, 0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xF8,
  0x00, 0xF8, 0x03, 0x04, 0x04, 0x02, 0x08, 0x02, 0x08, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x30, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0xC0, 0x08, 0x40, 0x08,
  0x60, 0x10, 0x30, 0x60, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0A,
  0x00, 0x14, 0x00, 0x14, 0x00, 0x24, 0x00, 0x44, 0x00, 0x44, 0x00, 0x84,
  0x01, 0x08, 0x03, 0x08, 0x02, 0x08, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0xFF, 0xFF, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x13, 0xE0, 0x1C, 0x30,
  0x30, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x80, 0x08, 0x80, 0x08, 0x40, 0x10, 0x40, 0x10,
  0x60, 0x20, 0x30, 0x40, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x8F, 0x84,
  0xC3, 0x14, 0x06, 0x60, 0x09, 0x00, 0x2C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x10, 0x08,
  0x40, 0x60, 0xC3, 0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x03,
  0x06, 0x06, 0x02, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x06, 0x08, 0x04, 0x04, 0x18, 0x03,
  0xE0, 0x0C, 0x10, 0x10, 0x08, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x08, 0x40, 0x10, 0x30,
  0x60, 0x1F, 0x80, 0x07, 0xE0, 0x30, 0xC1, 0x01, 0x88, 0x02, 0x20, 0x09,
  0x00, 0x34, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x68, 0x02, 0x90, 0x12, 0x60, 0x90, 0x7C, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x0F, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x30, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x81, 0x02,
  0x04, 0x10, 0x60, 0x80, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08,
  0x00, 0x00, 0x07, 0x81, 0x84, 0x30, 0x22, 0x02, 0x40, 0x24, 0x02, 0xC0,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0x81, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x02, 0x08, 0x03,
  0xC0, 0x21, 0x01, 0x84, 0x04, 0x40, 0x40, 0x80, 0x88, 0x10, 0x10, 0x12,
  0x02, 0x02, 0x02, 0x40, 0x80, 0x40, 0x48, 0x10, 0x10, 0x12, 0x04, 0x02,
  0x02, 0x40, 0x80, 0x40, 0x48, 0x10, 0x08, 0x09, 0x04, 0x02, 0x02, 0x40,
  0x80, 0x40, 0x48, 0x10, 0x08, 0x09, 0x02, 0x03, 0x02, 0x20, 0x40, 0xA0,
  0x44, 0x08, 0x14, 0x10, 0x80, 0x8C, 0x84, 0x08, 0x1E, 0x0F, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x04, 0x04, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x04, 0x04, 0x01, 0x03, 0x00, 0x40, 0xFF, 0xF8, 0x20, 0x02, 0x10,
  0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x38, 0x00, 0x04, 0x07, 0xFC, 0x02, 0x01, 0x81, 0x00, 0x40, 0x80, 0x10,
  0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x88, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x41, 0x00, 0xC0, 0xFF, 0x80, 0x40, 0x30, 0x40,
  0x04, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x12,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x40, 0x0C, 0x20, 0x0C, 0x1F, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x08, 0x00,
  0xC4, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x12, 0x00, 0x04, 0x80, 0x02,
  0x30, 0x00, 0x84, 0x00, 0x41, 0x00, 0x10, 0x20, 0x08, 0x0C, 0x0C, 0x00,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x80, 0x60, 0x10, 0x06, 0x04, 0x00, 0x60,
  0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x22,
  0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x82, 0x00, 0x20, 0x40,
  0x08, 0x08, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x3F, 0xFC, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0x80, 0x40, 0x10,
  0x20, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x04, 0x80, 0x01, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x01, 0xFC, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x0C, 0x0C, 0x0E, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41,
  0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00,
  0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x41, 0x00, 0x02, 0x0F, 0xFF, 0xF0, 0x40, 0x00, 0x84, 0x00, 0x08,
  0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00,
  0x04, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82,
  0x00, 0x04, 0x10, 0x00, 0x40, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x20, 0x40, 0x60, 0x60, 0xC0, 0x1F, 0x00, 0x04, 0x00, 0x30, 0x40,
  0x06, 0x04, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x03, 0x00, 0x80, 0x60, 0x08,
  0x0C, 0x00, 0x81, 0x80, 0x08, 0x30, 0x01, 0x06, 0x00, 0x10, 0xC0, 0x01,
  0x18, 0x00, 0x13, 0x00, 0x01, 0x68, 0x00, 0x1C, 0x80, 0x03, 0x04, 0x00,
  0x20, 0x60, 0x02, 0x02, 0x00, 0x20, 0x30, 0x02, 0x01, 0x00, 0x20, 0x08,
  0x04, 0x00, 0x80, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x02, 0x04, 0x00,
  0x20, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFE,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x28, 0x00,
  0x06, 0x0A, 0x00, 0x02, 0x82, 0x80, 0x00, 0xA0, 0x90, 0x00, 0x48, 0x24,
  0x00, 0x12, 0x09, 0x00, 0x09, 0x04, 0x40, 0x06, 0x41, 0x10, 0x01, 0x10,
  0x42, 0x00, 0x84, 0x10, 0x80, 0x21, 0x04, 0x20, 0x10, 0x41, 0x08, 0x04,
  0x20, 0x82, 0x02, 0x08, 0x20, 0x80, 0x82, 0x08, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x20, 0x81, 0x08, 0x08, 0x20, 0x42, 0x04, 0x10, 0x11, 0x01, 0x04,
  0x02, 0x40, 0x41, 0x00, 0xA0, 0x10, 0x40, 0x38, 0x04, 0x10, 0x0C, 0x01,
  0x04, 0x03, 0x00, 0x80, 0x04, 0x00, 0x08, 0x30, 0x00, 0x41, 0x80, 0x02,
  0x1C, 0x00, 0x10, 0x90, 0x01, 0x04, 0x80, 0x08, 0x22, 0x00, 0x41, 0x10,
  0x02, 0x08, 0x80, 0x10, 0xC2, 0x00, 0x84, 0x10, 0x08, 0x20, 0x40, 0x41,
  0x02, 0x02, 0x08, 0x10, 0x10, 0x40, 0x40, 0x84, 0x02, 0x0C, 0x20, 0x08,
  0x41, 0x00, 0x42, 0x08, 0x02, 0x10, 0x40, 0x08, 0x82, 0x00, 0x44, 0x20,
  0x02, 0x61, 0x00, 0x0A, 0x08, 0x00, 0x50, 0x40, 0x01, 0x82, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x60, 0x08, 0x30, 0x02,
  0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x34, 0x00,
  0x09, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x20, 0x08, 0x0C,
  0x0C, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0x00, 0xC0, 0x40, 0x08, 0x10,
  0x03, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x04, 0x00, 0x81,
  0x00, 0xC0, 0xFF, 0xE0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x60, 0x08,
  0x30, 0x02, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00,
  0x34, 0x00, 0x09, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x20,
  0x08, 0x0C, 0x0C, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x80, 0x20, 0x10, 0x02,
  0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x02,
  0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x30,
  0x20, 0x0C, 0x07, 0xFE, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x02,
  0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x04, 0x00, 0x00, 0xFE,
  0x00, 0xE0, 0xC0, 0x60, 0x08, 0x30, 0x02, 0x08, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8,
  0x00, 0x21, 0x00, 0x10, 0x60, 0x0C, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x40,
  0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00,
  0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0x60, 0x08, 0x06, 0x06, 0x00, 0x3F,
  0x00, 0x00, 0x80, 0x00, 0x50, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x80, 0x08, 0x20, 0x04, 0x08, 0x01,
  0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x10, 0x08, 0x04, 0x01, 0x02, 0x00,
  0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x00, 0x48, 0x02,
  0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88,
  0x08, 0x20, 0x43, 0x02, 0x08, 0x10, 0x41, 0x02, 0x0C, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x81, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00,
  0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x60, 0x12,
  0x00, 0x50, 0x05, 0x00, 0x14, 0x01, 0x40, 0x06, 0x00, 0x50, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x10, 0x00, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x80, 0x80, 0x0C, 0x06, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x40, 0x02,
  0x02, 0x00, 0x10, 0x20, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00,
  0x00, 0x50, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x09,
  0x00, 0x00, 0x88, 0x00, 0x08, 0x60, 0x00, 0x41, 0x00, 0x04, 0x08, 0x00,
  0x40, 0x20, 0x06, 0x01, 0x00, 0x20, 0x0C, 0x02, 0x00, 0x20, 0x20, 0x01,
  0x01, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x00, 0xC0, 0x00, 0xB0, 0x00,
  0xC8, 0x00, 0x44, 0x00, 0x42, 0x00, 0x60, 0x80, 0x20, 0x40, 0x20, 0x20,
  0x30, 0x08, 0x10, 0x04, 0x10, 0x02, 0x18, 0x00, 0x88, 0x00, 0x48, 0x00,
  0x2C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x0F, 0x80, 0x84, 0x21, 0x04, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10,
  0x84, 0x21, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x80, 0x07, 0xC0,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xF0, 0x00, 0x01, 0x00, 0xC0,
  0x30, 0x12, 0x04, 0x82, 0x20, 0x88, 0x42, 0x10, 0x88, 0x14, 0x05, 0x01,
  0x80, 0x40, 0xFF, 0xF8, 0x44, 0x22, 0x10, 0x01, 0xF8, 0x0C, 0x18, 0x30,
  0x18, 0x40, 0x11, 0x00, 0x22, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x07, 0xF8, 0x70, 0x11, 0x80, 0x26, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20,
  0x04, 0x40, 0x18, 0x80, 0x51, 0x83, 0x20, 0xF8, 0x40, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x23, 0xE0, 0x48, 0x30, 0xE0, 0x21, 0x80, 0x22, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x08, 0x80, 0x22, 0x80, 0xC4,
  0x83, 0x08, 0xF8, 0x00, 0x03, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x01, 0x20,
  0x04, 0x80, 0x14, 0x00, 0x50, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0xA0, 0x04, 0x40, 0x11, 0x00, 0x82,
  0x04, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x07, 0xC4, 0x08,
  0x34, 0x10, 0x14, 0x20, 0x0C, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x80,
  0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x60, 0x41, 0xA0, 0x3E,
  0x20, 0x03, 0xF0, 0x10, 0x60, 0x80, 0xC4, 0x01, 0x20, 0x04, 0x80, 0x14,
  0x00, 0x50, 0x01, 0x7F, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x43, 0x06, 0x07, 0xE0,
  0x01, 0xF0, 0x30, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x07, 0xF8, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x01, 0xF1, 0x02, 0x0D,
  0x04, 0x05, 0x08, 0x03, 0x18, 0x03, 0x10, 0x01, 0x10, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x14, 0x10, 0x68, 0x0F, 0x88,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x40, 0x20,
  0x20, 0xC0, 0x1F, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x43, 0xC1, 0x30, 0xC5,
  0x01, 0x14, 0x04, 0x60, 0x13, 0x00, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09,
  0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x10, 0x04, 0x30, 0x00, 0x00, 0x00,
  0x02, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x0C, 0x01, 0x80, 0xF0, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x0C, 0x40, 0x30, 0x80, 0x81, 0x02, 0x02, 0x08, 0x08,
  0x20, 0x10, 0x80, 0x22, 0x00, 0x48, 0x00, 0xB8, 0x01, 0x90, 0x06, 0x30,
  0x08, 0x20, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x82, 0x00, 0x84,
  0x01, 0x08, 0x01, 0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x61,
  0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04,
  0x20, 0x80, 0x10, 0xF0, 0x1E, 0x04, 0xC2, 0x18, 0x61, 0x40, 0x48, 0x08,
  0x60, 0x14, 0x02, 0x38, 0x06, 0x00, 0x8C, 0x01, 0x80, 0x33, 0x00, 0x40,
  0x08, 0x80, 0x10, 0x02, 0x20, 0x04, 0x00, 0x88, 0x01, 0x00, 0x26, 0x00,
  0x40, 0x09, 0x00, 0x20, 0x02, 0x40, 0x08, 0x01, 0x10, 0x02, 0x00, 0x44,
  0x00, 0x80, 0x11, 0x00, 0x20, 0x04, 0x80, 0x08, 0x01, 0x20, 0x04, 0x00,
  0x48, 0x01, 0x00, 0x22, 0x00, 0x40, 0x08, 0x10, 0xF0, 0x4C, 0x31, 0x40,
  0x45, 0x01, 0x18, 0x04, 0xC0, 0x13, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x01, 0xF0, 0x0C, 0x10, 0x20, 0x10,
  0x80, 0x31, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x2C, 0x00, 0x50, 0x00, 0x90, 0x02, 0x20, 0x04,
  0x40, 0x10, 0xC0, 0x60, 0xC1, 0x80, 0xFC, 0x00, 0x08, 0xF8, 0x09, 0x06,
  0x0E, 0x02, 0x0C, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x50, 0x18, 0x48, 0x30, 0x47, 0xC0,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x07, 0xC4, 0x20, 0xD1, 0x01, 0x48, 0x03, 0x60,
  0x05, 0x00, 0x14, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x32, 0x01, 0x84,
  0x1A, 0x0F, 0x88, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x11, 0xE2, 0x40, 0x50, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x30,
  0x41, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x20,
  0x04, 0x80, 0x22, 0x00, 0x86, 0x0C, 0x07, 0xC0, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x38, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02,
  0x40, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x0C, 0x80, 0x53, 0x01, 0x86, 0x1A, 0x0F, 0x88, 0x80, 0x05, 0x00,
  0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0xC4, 0x02, 0x08, 0x18, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x44, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x50, 0x01, 0x80, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0xE0, 0x18, 0x05, 0x00, 0xC0, 0x28, 0x0B, 0x02, 0x60, 0x48, 0x11,
  0x04, 0x41, 0x88, 0x22, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x10, 0x84,
  0x20, 0x88, 0x22, 0x04, 0x41, 0x10, 0x24, 0x09, 0x81, 0x20, 0x48, 0x0A,
  0x02, 0x40, 0x50, 0x0C, 0x02, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x10,
  0x00, 0x08, 0x01, 0x06, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x80, 0x20, 0x80,
  0x10, 0x80, 0x04, 0x40, 0x02, 0x40, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x28, 0x00, 0x24, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x20, 0x10,
  0x10, 0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x80, 0x04, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x08, 0x10, 0x02, 0x04, 0x01, 0x01, 0x00, 0x40, 0x20, 0x20,
  0x08, 0x08, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02,
  0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x30,
  0x82, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82,
  0x08, 0x61, 0x04, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x02, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x1E, 0x00, 0x4C, 0x40, 0x26,
  0x08, 0x09, 0x01, 0x02, 0x40, 0x21, 0x20, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_ThinItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 27, 7, 1, -27 },
  { 22, 6, 8, 10, 4, -29 },
  { 28, 19, 27, 18, 1, -27 },
  { 93, 16, 33, 18, 1, -30 },
  { 159, 18, 27, 24, 3, -27 },
  { 220, 17, 27, 20, 1, -27 },
  { 278, 2, 8, 6, 4, -29 },
  { 280, 10, 39, 10, 2, -30 },
  { 329, 10, 39, 10, -2, -30 },
  { 378, 15, 15, 15, 2, -27 },
  { 407, 15, 19, 18, 2, -22 },
  { 443, 4, 8, 7, -1, -3 },
  { 447, 8, 1, 10, 1, -13 },
  { 448, 2, 2, 8, 1, -2 },
  { 449, 15, 29, 13, -1, -27 },
  { 504, 15, 27, 18, 2, -27 },
  { 555, 8, 27, 18, 5, -27 },
  { 582, 16, 27, 18, 1, -27 },
  { 636, 16, 27, 18, 1, -27 },
  { 690, 16, 27, 18, 1, -27 },
  { 744, 16, 27, 18, 2, -27 },
  { 798, 14, 27, 18, 2, -27 },
  { 846, 15, 27, 18, 3, -27 },
  { 897, 16, 27, 18, 1, -27 },
  { 951, 14, 27, 18, 3, -27 },
  { 999, 6, 20, 7, 0, -20 },
  { 1014, 7, 25, 7, -1, -20 },
  { 1036, 14, 15, 17, 2, -20 },
  { 1063, 14, 9, 18, 2, -17 },
  { 1079, 14, 15, 17, 1, -20 },
  { 1106, 12, 27, 14, 3, -27 },
  { 1147, 27, 34, 30, 1, -26 },
  { 1262, 18, 27, 19, -1, -27 },
  { 1323, 17, 27, 20, 1, -27 },
  { 1381, 18, 27, 21, 2, -27 },
  { 1442, 19, 27, 21, 1, -27 },
  { 1507, 19, 27, 18, 1, -27 },
  { 1572, 19, 27, 19, 1, -27 },
  { 1637, 18, 27, 22, 3, -27 },
  { 1698, 21, 27, 23, 1, -27 },
  { 1769, 6, 27, 9, 2, -27 },
  { 1790, 16, 27, 18, 1, -27 },
  { 1844, 20, 27, 21, 1, -27 },
  { 1912, 13, 27, 17, 1, -27 },
  { 1956, 26, 27, 28, 1, -27 },
  { 2044, 21, 27, 23, 1, -27 },
  { 2115, 18, 27, 22, 2, -27 },
  { 2176, 18, 27, 20, 1, -27 },
  { 2237, 18, 32, 22, 2, -27 },
  { 2309, 19, 27, 21, 1, -27 },
  { 2374, 18, 27, 19, 1, -27 },
  { 2435, 17, 27, 19, 4, -27 },
  { 2493, 19, 27, 22, 2, -27 },
  { 2558, 18, 27, 19, 3, -27 },
  { 2619, 26, 27, 29, 4, -27 },
  { 2707, 21, 27, 19, -1, -27 },
  { 2778, 17, 27, 19, 4, -27 },
  { 2836, 20, 27, 19, 0, -27 },
  { 2904, 11, 37, 8, 0, -31 },
  { 2955, 5, 29, 13, 4, -27 },
  { 2974, 10, 37, 8, -2, -31 },
  { 3021, 10, 13, 14, 2, -27 },
  { 3038, 13, 1, 14, -2, 0 },
  { 3040, 4, 5, 10, 5, -29 },
  { 3043, 15, 20, 17, 0, -20 },
  { 3081, 15, 29, 18, 1, -29 },
  { 3136, 14, 20, 17, 1, -20 },
  { 3171, 16, 29, 18, 2, -29 },
  { 3229, 14, 20, 17, 1, -20 },
  { 3264, 12, 29, 11, 2, -29 },
  { 3308, 16, 28, 18, 0, -20 },
  { 3364, 14, 29, 18, 1, -29 },
  { 3415, 6, 27, 7, 1, -27 },
  { 3436, 12, 35, 8, -5, -27 },
  { 3489, 15, 29, 16, 1, -29 },
  { 3544, 6, 29, 7, 1, -29 },
  { 3566, 26, 20, 29, 1, -20 },
  { 3631, 14, 20, 18, 1, -20 },
  { 3666, 15, 20, 18, 1, -20 },
  { 3704, 16, 28, 18, 0, -20 },
  { 3760, 14, 28, 18, 2, -20 },
  { 3809, 11, 20, 11, 1, -20 },
  { 3837, 14, 20, 16, 1, -20 },
  { 3872, 8, 26, 11, 2, -26 },
  { 3898, 14, 20, 18, 2, -20 },
  { 3933, 14, 20, 16, 2, -20 },
  { 3968, 21, 20, 24, 3, -20 },
  { 4021, 17, 20, 16, -1, -20 },
  { 4064, 18, 28, 16, -2, -20 },
  { 4127, 15, 20, 16, 0, -20 },
  { 4165, 12, 38, 11, 1, -30 },
  { 4222, 6, 32, 7, 1, -27 },
  { 4246, 12, 38, 11, -3, -30 },
  { 4303, 18, 6, 22, 2, -14 },
};

const GFXfont RobotoCondensed_ThinItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_THINITALIC38PT7B_H_
