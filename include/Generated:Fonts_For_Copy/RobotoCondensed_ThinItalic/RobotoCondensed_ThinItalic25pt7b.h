#ifndef _ROBOTOCONDENSED_THINITALIC25PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x11, 0x22, 0x22, 0x22, 0x40, 0x00, 0x04, 0x99, 0xAA,
  0xA0, 0x01, 0x10, 0x08, 0x80, 0x88, 0x04, 0x40, 0x22, 0x1F, 0xFC, 0x11,
  0x00, 0x88, 0x08, 0x40, 0x44, 0x02, 0x20, 0x21, 0x0F, 0xFE, 0x08, 0x80,
  0x84, 0x04, 0x40, 0x22, 0x02, 0x10, 0x00, 0x01, 0x00, 0x80, 0xF8, 0x41,
  0x20, 0x48, 0x12, 0x04, 0x80, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x20, 0x0A, 0x02, 0x80, 0xA0, 0x44, 0x20, 0xF0, 0x10, 0x04, 0x00, 0x38,
  0x04, 0x40, 0x44, 0x28, 0x42, 0x84, 0x48, 0x48, 0x89, 0x07, 0x10, 0x02,
  0x00, 0x40, 0x04, 0xE0, 0x91, 0x11, 0x11, 0x21, 0x22, 0x14, 0x21, 0x02,
  0x20, 0x1C, 0x07, 0x01, 0x10, 0x42, 0x08, 0x41, 0x08, 0x22, 0x04, 0x80,
  0xA0, 0x18, 0x05, 0x01, 0x10, 0xA1, 0x18, 0x25, 0x02, 0xA0, 0x64, 0x0C,
  0x82, 0x8F, 0x88, 0xF8, 0x02, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x82, 0x10, 0x82, 0x00, 0x04,
  0x01, 0x00, 0x40, 0x11, 0x77, 0x83, 0x00, 0xC0, 0x48, 0x22, 0x10, 0x40,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x00, 0x24, 0xA8, 0xF8, 0x80, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x0F, 0x04,
  0x21, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x18, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x42, 0x0F, 0x00, 0x0D, 0xD8, 0x82,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x80, 0x0F,
  0x04, 0x22, 0x04, 0x81, 0x40, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x3F, 0xE0, 0x0F, 0x04,
  0x22, 0x04, 0x81, 0x40, 0x40, 0x10, 0x08, 0x06, 0x0E, 0x00, 0x40, 0x08,
  0x02, 0x00, 0xA0, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00, 0x00, 0x80, 0x20,
  0x18, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x44, 0x11, 0x08, 0x44, 0x12, 0x04,
  0xFF, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x1F, 0xC8, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0xF8, 0x41, 0x00, 0x40, 0x08, 0x02, 0x01,
  0x20, 0x48, 0x12, 0x08, 0x82, 0x1F, 0x00, 0x03, 0x82, 0x06, 0x02, 0x02,
  0x01, 0x01, 0x7C, 0xC1, 0x40, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x02, 0x42, 0x1E, 0x00, 0x7F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x40, 0x50, 0x12, 0x04,
  0x82, 0x1F, 0x08, 0x44, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x82,
  0x1F, 0x00, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xA0, 0xCF, 0xA0, 0x10, 0x10, 0x08, 0x08, 0x08, 0x78, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x42, 0x21, 0x10, 0x00, 0x81, 0x83, 0x06, 0x04, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x08, 0x18, 0x30, 0x60, 0x40, 0x00,
  0x3C, 0x42, 0x41, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00,
  0x41, 0x00, 0x11, 0x00, 0x09, 0x07, 0x84, 0x84, 0x22, 0x84, 0x21, 0x42,
  0x10, 0xA2, 0x08, 0x61, 0x04, 0x30, 0x84, 0x18, 0x82, 0x14, 0x41, 0x0A,
  0x21, 0x85, 0x11, 0x44, 0x87, 0x1C, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x02, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x0C, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x24, 0x02, 0x20, 0x42, 0x04, 0x20, 0x82, 0x08, 0x21,
  0x02, 0x1F, 0xE2, 0x01, 0x20, 0x14, 0x01, 0x40, 0x18, 0x01, 0x1F, 0x82,
  0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x06, 0x3F, 0x08, 0x11,
  0x01, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x04, 0x81, 0x1F, 0xC0, 0x07,
  0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x28, 0x02, 0x80, 0x44, 0x04, 0x40,
  0x83, 0xF0, 0x1F, 0x81, 0x06, 0x20, 0x22, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80,
  0x48, 0x08, 0x81, 0x0F, 0xE0, 0x1F, 0xF1, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xF1, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x3F, 0xC4, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F,
  0xC1, 0x02, 0x20, 0x22, 0x01, 0x40, 0x14, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x3E, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x41,
  0x83, 0xE0, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x02, 0x3F, 0xF2, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x00, 0x11, 0x11, 0x22, 0x22,
  0x22, 0x44, 0x44, 0x44, 0x88, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x09, 0x01,
  0x20, 0x22, 0x08, 0x42, 0x07, 0x80, 0x10, 0x10, 0x80, 0x88, 0x08, 0x40,
  0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0xA0, 0x19, 0x00,
  0x84, 0x04, 0x10, 0x20, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02, 0x00,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0xFF, 0x10, 0x00, 0x88, 0x00, 0x8A, 0x00,
  0xC5, 0x00, 0x62, 0x80, 0x51, 0x40, 0x28, 0xA0, 0x24, 0x50, 0x12, 0x44,
  0x12, 0x22, 0x09, 0x11, 0x08, 0x88, 0x84, 0x44, 0x44, 0x22, 0x12, 0x12,
  0x0A, 0x11, 0x05, 0x08, 0x83, 0x04, 0x41, 0x02, 0x00, 0x10, 0x04, 0x40,
  0x12, 0x80, 0x8A, 0x02, 0x24, 0x08, 0x90, 0x22, 0x40, 0x88, 0x82, 0x42,
  0x11, 0x08, 0x44, 0x11, 0x10, 0x44, 0x40, 0x91, 0x02, 0x88, 0x0A, 0x20,
  0x18, 0x80, 0x62, 0x00, 0x80, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x44, 0x04, 0x40, 0x83, 0xF0, 0x1F, 0xC1, 0x02, 0x20,
  0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40, 0x47, 0xF8, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07,
  0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x44, 0x04, 0x40,
  0x83, 0xF0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x1F, 0xC1, 0x02, 0x20, 0x12,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40, 0x47, 0xF8, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x08, 0x80, 0x88, 0x08, 0x80, 0x48, 0x04, 0x0F, 0xC1,
  0x02, 0x20, 0x22, 0x01, 0x40, 0x14, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x48, 0x04, 0x80, 0x48, 0x08, 0x41, 0x03,
  0xE0, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x02, 0x40, 0x12, 0x01, 0x08, 0x08, 0x40, 0x81, 0xF8, 0x00, 0x80, 0x18,
  0x02, 0x80, 0x24, 0x04, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x41, 0x04,
  0x10, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x30, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x28, 0x0C, 0x09, 0x05, 0x02, 0x41, 0x41,
  0x10, 0x90, 0x44, 0x24, 0x11, 0x09, 0x08, 0x44, 0x42, 0x11, 0x09, 0x04,
  0x82, 0x41, 0x20, 0x90, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x80,
  0xC0, 0x20, 0x30, 0x08, 0x08, 0x00, 0x10, 0x08, 0x80, 0x84, 0x04, 0x10,
  0x40, 0x84, 0x02, 0x20, 0x12, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x40,
  0x12, 0x01, 0x08, 0x08, 0x40, 0x81, 0x08, 0x08, 0x40, 0x44, 0x01, 0x00,
  0x80, 0x14, 0x02, 0x40, 0x44, 0x04, 0x20, 0x82, 0x10, 0x21, 0x01, 0x20,
  0x14, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x07, 0xFE, 0x00, 0x0E, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x70, 0x92, 0x49, 0x24, 0x49, 0x24, 0x91,
  0x24, 0x90, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x70, 0x04,
  0x18, 0x50, 0xA2, 0x44, 0x50, 0xA1, 0x42, 0xFF, 0x00, 0x48, 0x80, 0x0F,
  0x84, 0x12, 0x04, 0x81, 0x00, 0x40, 0x11, 0xF8, 0x82, 0x40, 0xA0, 0x28,
  0x1A, 0x0A, 0x7C, 0x80, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xBC,
  0xA1, 0x40, 0xA0, 0x50, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x61,
  0x2F, 0x00, 0x1F, 0x10, 0x50, 0x28, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80,
  0x40, 0xA0, 0x50, 0x47, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x87, 0xD1, 0x06, 0x40, 0x88, 0x11, 0x02, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x24, 0x08, 0x81, 0x10, 0x61, 0xF4, 0x00, 0x1F, 0x10, 0x50, 0x28,
  0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x47, 0xC0, 0x07,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x7C, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x0F, 0xA2, 0x0C, 0x81, 0x10, 0x22,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x11, 0x02, 0x20, 0xC3, 0xE8,
  0x01, 0x00, 0x40, 0x08, 0x82, 0x0F, 0x80, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xBC, 0xA1, 0x60, 0xB0, 0x50, 0x28, 0x14, 0x0C, 0x06, 0x03,
  0x02, 0x81, 0x40, 0xA0, 0x40, 0x10, 0x00, 0x22, 0x44, 0x44, 0x44, 0x88,
  0x88, 0x80, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x09, 0x04, 0x42, 0x11,
  0x04, 0x81, 0x40, 0x70, 0x22, 0x08, 0x82, 0x10, 0x84, 0x20, 0x88, 0x20,
  0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x80, 0x2F, 0x1E,
  0x50, 0xA1, 0x60, 0xC1, 0x40, 0xC1, 0x40, 0x81, 0x40, 0x81, 0x40, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x81, 0x01, 0x81, 0x02, 0x81, 0x02, 0x81, 0x02,
  0x2F, 0x28, 0x58, 0x28, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0xA0,
  0x50, 0x28, 0x10, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x80, 0x60, 0x18, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x11, 0x08, 0x3C, 0x00, 0x17, 0x8A, 0x12, 0x04,
  0x81, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x50, 0x14, 0x09, 0x84, 0x5E,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1F, 0x48, 0x34, 0x09, 0x02,
  0x40, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x0C, 0x7D, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x2E, 0xA1, 0x82, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x0F, 0x04, 0x22, 0x04, 0x80, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x28, 0x11, 0x04, 0x3E, 0x00, 0x10,
  0x41, 0x08, 0x7C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x10, 0x70,
  0x20, 0x50, 0x14, 0x05, 0x02, 0x40, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xA0,
  0x48, 0x11, 0x0C, 0x7D, 0x00, 0x80, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x22,
  0x10, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x02, 0x00, 0x82, 0x06, 0x08, 0x28,
  0x50, 0xA1, 0x42, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x41,
  0x85, 0x06, 0x14, 0x10, 0x20, 0x40, 0x80, 0x20, 0x48, 0x21, 0x10, 0x44,
  0x0A, 0x03, 0x00, 0x80, 0x30, 0x12, 0x08, 0x84, 0x21, 0x04, 0x81, 0x00,
  0x10, 0x11, 0x02, 0x10, 0x21, 0x04, 0x10, 0x41, 0x08, 0x08, 0x80, 0x90,
  0x09, 0x00, 0xA0, 0x0A, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x00, 0x3F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0xFF, 0x00, 0x03, 0x04, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x40, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x10, 0x11, 0x11, 0x11,
  0x12, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x80, 0x08, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x02, 0x01, 0x02, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x70, 0x31, 0x06, 0x11,
  0x41, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 18, 5, 0, -18 },
  { 10, 4, 5, 6, 3, -19 },
  { 13, 13, 18, 12, 0, -18 },
  { 43, 10, 22, 12, 1, -20 },
  { 71, 12, 18, 16, 2, -18 },
  { 98, 11, 18, 13, 1, -18 },
  { 123, 1, 5, 4, 3, -19 },
  { 124, 7, 26, 7, 1, -20 },
  { 147, 6, 26, 7, -1, -20 },
  { 167, 10, 10, 10, 1, -18 },
  { 180, 10, 13, 12, 1, -15 },
  { 197, 3, 5, 5, -1, -2 },
  { 199, 5, 1, 7, 1, -9 },
  { 200, 1, 1, 5, 1, -1 },
  { 201, 10, 20, 8, -1, -18 },
  { 226, 10, 18, 12, 1, -18 },
  { 249, 6, 18, 12, 3, -18 },
  { 263, 10, 18, 12, 1, -18 },
  { 286, 10, 18, 12, 1, -18 },
  { 309, 10, 18, 12, 1, -18 },
  { 332, 10, 18, 12, 2, -18 },
  { 355, 9, 18, 12, 1, -18 },
  { 376, 10, 18, 12, 2, -18 },
  { 399, 10, 18, 12, 1, -18 },
  { 422, 9, 18, 12, 2, -18 },
  { 443, 4, 13, 4, 0, -13 },
  { 450, 5, 16, 4, -1, -13 },
  { 460, 9, 10, 11, 1, -13 },
  { 472, 10, 6, 12, 1, -11 },
  { 480, 9, 10, 11, 1, -13 },
  { 492, 8, 18, 9, 2, -18 },
  { 510, 17, 23, 20, 1, -17 },
  { 559, 12, 18, 13, -1, -18 },
  { 586, 11, 18, 13, 1, -18 },
  { 611, 12, 18, 14, 1, -18 },
  { 638, 12, 18, 14, 1, -18 },
  { 665, 12, 18, 12, 1, -18 },
  { 692, 12, 18, 12, 1, -18 },
  { 719, 12, 18, 15, 2, -18 },
  { 746, 13, 18, 15, 1, -18 },
  { 776, 4, 18, 6, 1, -18 },
  { 785, 11, 18, 12, 0, -18 },
  { 810, 13, 18, 13, 1, -18 },
  { 840, 8, 18, 11, 1, -18 },
  { 858, 17, 18, 18, 1, -18 },
  { 897, 14, 18, 15, 1, -18 },
  { 929, 12, 18, 14, 1, -18 },
  { 956, 12, 18, 13, 1, -18 },
  { 983, 12, 21, 14, 1, -18 },
  { 1015, 12, 18, 14, 1, -18 },
  { 1042, 12, 18, 13, 1, -18 },
  { 1069, 12, 18, 13, 2, -18 },
  { 1096, 13, 18, 14, 1, -18 },
  { 1126, 12, 18, 13, 2, -18 },
  { 1153, 18, 18, 19, 2, -18 },
  { 1194, 13, 18, 13, 0, -18 },
  { 1224, 12, 18, 13, 2, -18 },
  { 1251, 13, 18, 13, 0, -18 },
  { 1281, 7, 24, 5, 0, -20 },
  { 1302, 3, 20, 8, 3, -18 },
  { 1310, 7, 24, 5, -2, -20 },
  { 1331, 7, 9, 9, 1, -18 },
  { 1339, 9, 1, 9, -1, 0 },
  { 1341, 3, 3, 6, 3, -19 },
  { 1343, 10, 13, 11, 0, -13 },
  { 1360, 9, 19, 12, 1, -19 },
  { 1382, 9, 13, 11, 1, -13 },
  { 1397, 11, 19, 12, 1, -19 },
  { 1424, 9, 13, 11, 1, -13 },
  { 1439, 8, 19, 7, 1, -19 },
  { 1458, 11, 18, 12, 0, -13 },
  { 1483, 9, 19, 12, 1, -19 },
  { 1505, 4, 17, 5, 1, -17 },
  { 1514, 8, 22, 5, -3, -17 },
  { 1536, 10, 19, 10, 1, -19 },
  { 1560, 4, 19, 5, 1, -19 },
  { 1570, 16, 13, 19, 1, -13 },
  { 1596, 9, 13, 12, 1, -13 },
  { 1611, 10, 13, 12, 1, -13 },
  { 1628, 10, 18, 12, 0, -13 },
  { 1651, 10, 18, 12, 1, -13 },
  { 1674, 7, 13, 7, 1, -13 },
  { 1686, 10, 13, 11, 0, -13 },
  { 1703, 6, 17, 7, 1, -17 },
  { 1716, 10, 13, 12, 1, -13 },
  { 1733, 9, 13, 10, 2, -13 },
  { 1748, 14, 13, 16, 2, -13 },
  { 1771, 10, 13, 10, 0, -13 },
  { 1788, 12, 18, 10, -1, -13 },
  { 1815, 10, 13, 10, 0, -13 },
  { 1832, 8, 25, 7, 1, -20 },
  { 1857, 4, 21, 5, 0, -18 },
  { 1868, 8, 24, 7, -2, -19 },
  { 1892, 11, 4, 15, 2, -9 },
};

const GFXfont RobotoCondensed_ThinItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_THINITALIC25PT7B_H_
