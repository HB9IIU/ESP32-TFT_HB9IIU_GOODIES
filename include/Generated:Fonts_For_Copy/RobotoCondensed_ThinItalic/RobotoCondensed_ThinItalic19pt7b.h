#ifndef _ROBOTOCONDENSED_THINITALIC19PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x92, 0x52, 0x48, 0x01, 0x00, 0xB6, 0xD0, 0x04, 0x01, 0x20,
  0x88, 0x7F, 0x09, 0x04, 0x41, 0x20, 0x48, 0x12, 0x09, 0x07, 0xF0, 0x90,
  0x44, 0x12, 0x00, 0x00, 0x00, 0x1C, 0x22, 0x41, 0x40, 0x40, 0x40, 0x30,
  0x08, 0x04, 0x02, 0x02, 0x84, 0x84, 0x58, 0x20, 0x20, 0x70, 0x48, 0x24,
  0x52, 0x49, 0x47, 0x20, 0x20, 0x20, 0x13, 0x12, 0x52, 0x29, 0x10, 0x90,
  0x30, 0x1C, 0x22, 0x22, 0x24, 0x24, 0x38, 0x20, 0x50, 0x89, 0x89, 0x86,
  0x82, 0x86, 0x7A, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x82, 0x10, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11,
  0x08, 0x44, 0x22, 0x20, 0x08, 0x13, 0x49, 0xE2, 0x89, 0x11, 0x00, 0x08,
  0x08, 0x08, 0x10, 0x7E, 0x10, 0x10, 0x10, 0x20, 0x20, 0x56, 0x40, 0xC0,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x1C, 0x45, 0x0A, 0x14, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x14, 0x28, 0x8E, 0x00, 0x3D, 0x22, 0x22, 0x22, 0x44, 0x44, 0x40, 0x0E,
  0x11, 0x21, 0x21, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFC, 0x1C, 0x45, 0x0A, 0x10, 0x20, 0x47, 0x02, 0x02, 0x06, 0x0C, 0x28,
  0x4F, 0x00, 0x01, 0x03, 0x05, 0x05, 0x0A, 0x12, 0x12, 0x22, 0x42, 0xFE,
  0x02, 0x04, 0x04, 0x04, 0x1E, 0x20, 0x20, 0x20, 0x40, 0x7C, 0x42, 0x02,
  0x02, 0x02, 0x82, 0x84, 0x84, 0x78, 0x0C, 0x20, 0x82, 0x04, 0x17, 0xB0,
  0xC1, 0x83, 0x06, 0x0C, 0x28, 0x4F, 0x00, 0x7E, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x00, 0x00, 0x0E, 0x08, 0x88, 0x24,
  0x12, 0x11, 0x08, 0x78, 0x44, 0x41, 0x20, 0xA0, 0x50, 0x24, 0x21, 0xE0,
  0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xA3, 0x3A, 0x04, 0x10, 0x20, 0x8E,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x00, 0x04, 0x44, 0x80,
  0x02, 0x18, 0xC6, 0x08, 0x0C, 0x06, 0x02, 0x3C, 0x01, 0xF0, 0x40, 0x40,
  0x60, 0x20, 0x43, 0x18, 0x40, 0x74, 0x62, 0x10, 0x84, 0x44, 0x40, 0x00,
  0x00, 0x40, 0x07, 0xE0, 0x40, 0x84, 0x04, 0x40, 0x14, 0x38, 0xA2, 0x06,
  0x22, 0x31, 0x11, 0x90, 0x8C, 0x88, 0xA4, 0x45, 0x26, 0x49, 0xCC, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x01, 0x01, 0x80, 0xC0, 0xA0, 0x50,
  0x48, 0x22, 0x21, 0x10, 0x97, 0x48, 0x28, 0x14, 0x0C, 0x04, 0x3E, 0x21,
  0x41, 0x41, 0x41, 0x42, 0x7C, 0x42, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C,
  0x1F, 0x10, 0x50, 0x28, 0x14, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x50, 0x28, 0x23, 0xE0, 0x1E, 0x10, 0x90, 0x28, 0x14, 0x0A, 0x05, 0x02,
  0x81, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x63, 0xC0, 0x1F, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xF0, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03, 0xE0,
  0x1F, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF0, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x00, 0x0F, 0x18, 0x48, 0x28, 0x14, 0x02, 0x01, 0x01,
  0x06, 0x80, 0x40, 0x60, 0x50, 0x24, 0x11, 0xF0, 0x00, 0x48, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x27, 0xF9, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81,
  0x00, 0x40, 0x24, 0xA4, 0x92, 0x52, 0x49, 0x00, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x20, 0x90, 0x48, 0x43, 0xC0,
  0x00, 0x88, 0x44, 0x21, 0x10, 0x48, 0x14, 0x05, 0x01, 0xC0, 0x88, 0x22,
  0x08, 0x42, 0x08, 0x82, 0x00, 0x40, 0x00, 0x84, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x81, 0xE0, 0x20, 0x02, 0x01, 0x60, 0x35, 0x03, 0x50,
  0x55, 0x05, 0x50, 0x95, 0x0A, 0x91, 0x28, 0x92, 0x8A, 0x28, 0xA2, 0x8C,
  0x20, 0x44, 0x20, 0x48, 0x15, 0x05, 0x41, 0x50, 0x52, 0x24, 0x89, 0x12,
  0x84, 0xA1, 0x28, 0x2A, 0x0C, 0x83, 0x20, 0x40, 0x1F, 0x10, 0x50, 0x28,
  0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x23, 0xE0,
  0x3E, 0x10, 0x90, 0x28, 0x14, 0x0A, 0x09, 0x04, 0xFC, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x00, 0x1F, 0x10, 0x50, 0x28, 0x14, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x23, 0xE0, 0x10, 0x04, 0x3E, 0x10,
  0x90, 0x28, 0x14, 0x0A, 0x09, 0x04, 0xFC, 0x84, 0x42, 0x20, 0x90, 0x48,
  0x20, 0x10, 0x0F, 0x04, 0x22, 0x04, 0x80, 0x20, 0x08, 0x01, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x0A, 0x04, 0x41, 0x0F, 0x80, 0x7E, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00, 0x10,
  0x14, 0x09, 0x02, 0x40, 0x90, 0x24, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x12,
  0x04, 0x82, 0x1F, 0x00, 0x80, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x10,
  0x90, 0x48, 0x24, 0x14, 0x0A, 0x02, 0x01, 0x00, 0x82, 0x0C, 0x10, 0x61,
  0x85, 0x0C, 0x28, 0xA1, 0x44, 0x92, 0x44, 0x92, 0x24, 0x91, 0x45, 0x0A,
  0x28, 0x51, 0x83, 0x04, 0x18, 0x00, 0x80, 0x20, 0x48, 0x21, 0x08, 0x44,
  0x0A, 0x02, 0x80, 0x40, 0x30, 0x14, 0x04, 0x82, 0x21, 0x08, 0x41, 0x20,
  0x40, 0x80, 0x40, 0xA0, 0x88, 0x44, 0x42, 0x40, 0xA0, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x3F, 0x80, 0x10,
  0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x00, 0x92,
  0x49, 0x12, 0x49, 0x24, 0x48, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88,
  0x42, 0x10, 0x84, 0x42, 0x00, 0x11, 0x8A, 0x54, 0xA6, 0x20, 0x7C, 0x90,
  0x1E, 0x21, 0x01, 0x01, 0x3E, 0x42, 0x82, 0x82, 0x84, 0x7A, 0x00, 0x20,
  0x20, 0x20, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0x3C,
  0x3C, 0x86, 0x0C, 0x08, 0x10, 0x20, 0x42, 0x84, 0xF0, 0x01, 0x01, 0x01,
  0x01, 0x3E, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x7C, 0x1E,
  0x21, 0x41, 0x41, 0x7F, 0x80, 0x80, 0x80, 0x40, 0x3C, 0x1C, 0x82, 0x08,
  0x71, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x00, 0x1E, 0x21, 0x41, 0x41,
  0x41, 0x41, 0x42, 0x42, 0x42, 0x3E, 0x02, 0x04, 0x84, 0x78, 0x10, 0x20,
  0x20, 0x20, 0x2E, 0x31, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x42, 0x82,
  0x20, 0x04, 0x94, 0x92, 0x49, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0xC0, 0x00, 0x20,
  0x20, 0x20, 0x21, 0x22, 0x24, 0x58, 0x70, 0x50, 0x48, 0x48, 0x84, 0x04,
  0x05, 0x24, 0x94, 0x92, 0x48, 0x00, 0x2E, 0x79, 0x8C, 0x48, 0x42, 0x82,
  0x14, 0x10, 0xA0, 0x85, 0x08, 0x28, 0x41, 0x82, 0x0C, 0x10, 0x00, 0x2E,
  0x31, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x42, 0x02, 0x3C, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x41,
  0x41, 0x42, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x00, 0x3C, 0x86, 0x0C, 0x18,
  0x30, 0x61, 0x42, 0x84, 0xF8, 0x10, 0x20, 0x81, 0x00, 0x38, 0x82, 0x10,
  0x41, 0x04, 0x10, 0x40, 0x00, 0x1C, 0x45, 0x03, 0x01, 0x80, 0x80, 0xC1,
  0x84, 0xF0, 0x22, 0x24, 0x44, 0x44, 0x88, 0x88, 0x60, 0x40, 0x85, 0x0C,
  0x18, 0x30, 0x61, 0x42, 0x8C, 0xE8, 0x83, 0x06, 0x12, 0x24, 0x89, 0x14,
  0x28, 0x20, 0x40, 0x88, 0x62, 0x19, 0x4A, 0x52, 0xA5, 0x29, 0x4C, 0x53,
  0x18, 0x86, 0x21, 0x00, 0x40, 0x22, 0x24, 0x18, 0x10, 0x10, 0x28, 0x48,
  0x44, 0x84, 0x20, 0x90, 0x48, 0x42, 0x21, 0x20, 0x90, 0x50, 0x28, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x00, 0x1D, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x40, 0xF8, 0x08, 0x41, 0x08, 0x20, 0x82, 0x08, 0x42, 0x04,
  0x10, 0x41, 0x04, 0x20, 0x81, 0x02, 0x00, 0x24, 0x92, 0x49, 0x49, 0x24,
  0xA4, 0x80, 0x10, 0x20, 0x82, 0x08, 0x21, 0x04, 0x08, 0x11, 0x84, 0x10,
  0x82, 0x08, 0x21, 0x08, 0x00, 0x70, 0xC4, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 3, 0, -14 },
  { 7, 3, 4, 5, 2, -14 },
  { 9, 10, 14, 9, 0, -14 },
  { 27, 8, 18, 9, 1, -16 },
  { 45, 9, 14, 12, 2, -14 },
  { 61, 8, 14, 10, 1, -14 },
  { 75, 1, 4, 3, 2, -14 },
  { 76, 5, 19, 5, 1, -15 },
  { 88, 5, 19, 5, -1, -15 },
  { 100, 7, 7, 8, 1, -14 },
  { 107, 8, 10, 9, 1, -11 },
  { 117, 2, 4, 3, -1, -1 },
  { 118, 3, 1, 5, 1, -7 },
  { 119, 2, 1, 4, 0, -1 },
  { 120, 8, 15, 6, -1, -14 },
  { 135, 7, 14, 9, 1, -14 },
  { 148, 4, 14, 9, 3, -14 },
  { 155, 8, 14, 9, 0, -14 },
  { 169, 7, 14, 9, 1, -14 },
  { 182, 8, 14, 9, 0, -14 },
  { 196, 8, 14, 9, 1, -14 },
  { 210, 7, 14, 9, 1, -14 },
  { 223, 7, 14, 9, 2, -14 },
  { 236, 9, 14, 9, 0, -14 },
  { 252, 7, 14, 9, 1, -14 },
  { 265, 3, 10, 3, 0, -10 },
  { 269, 4, 13, 3, -1, -10 },
  { 276, 7, 8, 8, 1, -10 },
  { 283, 7, 3, 9, 1, -8 },
  { 286, 7, 8, 8, 1, -10 },
  { 293, 5, 14, 7, 2, -14 },
  { 302, 13, 17, 15, 1, -13 },
  { 330, 9, 14, 10, -1, -14 },
  { 346, 8, 14, 10, 1, -14 },
  { 360, 9, 14, 10, 1, -14 },
  { 376, 9, 14, 11, 1, -14 },
  { 392, 9, 14, 9, 1, -14 },
  { 408, 9, 14, 9, 1, -14 },
  { 424, 9, 14, 11, 1, -14 },
  { 440, 10, 14, 11, 1, -14 },
  { 458, 3, 14, 4, 1, -14 },
  { 464, 9, 14, 9, 0, -14 },
  { 480, 10, 14, 10, 1, -14 },
  { 498, 6, 14, 8, 1, -14 },
  { 509, 12, 14, 14, 1, -14 },
  { 530, 10, 14, 11, 1, -14 },
  { 548, 9, 14, 11, 1, -14 },
  { 564, 9, 14, 10, 1, -14 },
  { 580, 9, 16, 11, 1, -14 },
  { 598, 9, 14, 11, 1, -14 },
  { 614, 10, 14, 10, 0, -14 },
  { 632, 8, 14, 10, 2, -14 },
  { 646, 10, 14, 11, 1, -14 },
  { 664, 9, 14, 10, 2, -14 },
  { 680, 13, 14, 14, 2, -14 },
  { 703, 10, 14, 10, 0, -14 },
  { 721, 9, 14, 10, 2, -14 },
  { 737, 10, 14, 10, 0, -14 },
  { 755, 5, 18, 4, 0, -15 },
  { 767, 3, 15, 6, 2, -14 },
  { 773, 5, 18, 4, -1, -15 },
  { 785, 5, 7, 7, 1, -14 },
  { 790, 7, 1, 7, -1, 0 },
  { 791, 2, 2, 5, 3, -14 },
  { 792, 8, 10, 9, 0, -10 },
  { 802, 8, 14, 9, 0, -14 },
  { 816, 7, 10, 8, 1, -10 },
  { 825, 8, 14, 9, 1, -14 },
  { 839, 8, 10, 8, 0, -10 },
  { 849, 6, 14, 5, 1, -14 },
  { 860, 8, 14, 9, 0, -10 },
  { 874, 8, 14, 9, 0, -14 },
  { 888, 3, 14, 4, 1, -14 },
  { 894, 7, 18, 4, -3, -14 },
  { 910, 8, 14, 8, 0, -14 },
  { 924, 3, 14, 4, 1, -14 },
  { 930, 13, 10, 14, 0, -10 },
  { 947, 8, 10, 9, 0, -10 },
  { 957, 7, 10, 9, 1, -10 },
  { 966, 8, 14, 9, 0, -10 },
  { 980, 7, 14, 9, 1, -10 },
  { 993, 6, 10, 6, 0, -10 },
  { 1001, 7, 10, 8, 0, -10 },
  { 1010, 4, 13, 5, 1, -13 },
  { 1017, 7, 10, 9, 1, -10 },
  { 1026, 7, 10, 8, 1, -10 },
  { 1035, 10, 10, 12, 2, -10 },
  { 1048, 8, 10, 8, 0, -10 },
  { 1058, 9, 14, 8, -1, -10 },
  { 1074, 8, 10, 8, 0, -10 },
  { 1084, 6, 19, 5, 1, -15 },
  { 1099, 3, 17, 4, 0, -14 },
  { 1106, 6, 19, 5, -1, -15 },
  { 1121, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_ThinItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_THINITALIC19PT7B_H_
