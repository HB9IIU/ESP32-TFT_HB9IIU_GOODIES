#ifndef _ROBOTOCONDENSED_THINITALIC60PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x21, 0xB0, 0xD8, 0x6C, 0x36, 0x12, 0x09, 0x0D, 0x86,
  0xC3, 0x61, 0xA0, 0x90, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x80,
  0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x04, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x02, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x01, 0x80, 0x60, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x04,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x00,
  0x20, 0x30, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00,
  0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0x60,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x18, 0x02, 0x00, 0x00, 0xC0, 0x10, 0x01, 0x04, 0x00, 0xC0, 0x18, 0x60,
  0x04, 0x01, 0x83, 0x00, 0x20, 0x08, 0x10, 0x01, 0x00, 0xC0, 0x80, 0x08,
  0x0C, 0x04, 0x00, 0xC0, 0x40, 0x20, 0x06, 0x06, 0x01, 0x00, 0x20, 0x60,
  0x08, 0x03, 0x02, 0x00, 0x60, 0x30, 0x30, 0x03, 0x01, 0x83, 0x00, 0x0C,
  0x38, 0x30, 0x00, 0x3F, 0x81, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x7E, 0x00, 0x06, 0x0E, 0x18, 0x00, 0x60, 0x60, 0x60,
  0x02, 0x06, 0x01, 0x00, 0x30, 0x60, 0x08, 0x03, 0x03, 0x00, 0x40, 0x10,
  0x10, 0x03, 0x01, 0x81, 0x80, 0x10, 0x18, 0x0C, 0x00, 0x80, 0x80, 0x40,
  0x04, 0x0C, 0x02, 0x00, 0x20, 0xC0, 0x10, 0x03, 0x0C, 0x00, 0x80, 0x18,
  0x40, 0x04, 0x00, 0x82, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x08, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x18,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x04, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x01, 0x00, 0x11, 0x80, 0x60, 0x0C, 0x40, 0x08, 0x03, 0x30, 0x03, 0x00,
  0x98, 0x00, 0x60, 0x66, 0x00, 0x18, 0x19, 0x00, 0x03, 0x04, 0xC0, 0x00,
  0xC3, 0x30, 0x00, 0x18, 0xCC, 0x00, 0x02, 0x63, 0x00, 0x00, 0xD8, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0xC1, 0x80, 0x01, 0xB0,
  0x60, 0x00, 0xC6, 0x0C, 0x00, 0x60, 0x81, 0xC0, 0x70, 0x30, 0x3F, 0xF0,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x33, 0x33, 0x26, 0x66, 0x64, 0xCC, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0xE0, 0x30, 0x1C, 0xF0, 0x61, 0xF0, 0x78, 0xCF,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x08, 0x30,
  0x60, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x82, 0x00, 0xFF, 0xF0, 0x27, 0xF4,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x0C,
  0x01, 0x00, 0x04, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x02,
  0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02,
  0x30, 0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x20, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x03, 0xC0, 0xF4, 0x1E, 0x23, 0x81, 0x70, 0x1A, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1E,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x02, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x88, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x60, 0x40, 0x00, 0x20, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x08, 0x00, 0x18, 0x04, 0x00, 0x18, 0x02,
  0x00, 0x18, 0x03, 0x00, 0x08, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x10, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x02, 0x00, 0x06, 0x03, 0x00, 0x02, 0x03, 0x00, 0x01, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x7E, 0x00, 0x0C, 0xFF, 0xC0,
  0x07, 0x80, 0x30, 0x03, 0x80, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x40,
  0x00, 0x18, 0x20, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x0F, 0xC0, 0x10, 0xFF, 0xC0, 0xC6, 0x01, 0x82,
  0x60, 0x03, 0x0B, 0x00, 0x06, 0x78, 0x00, 0x19, 0xC0, 0x00, 0x26, 0x00,
  0x00, 0x98, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0x40, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x78, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x10, 0x20, 0x00, 0x04, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x08, 0x18, 0x00, 0x06,
  0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0x01, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x06, 0x00, 0x30,
  0x00, 0xE0, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x01, 0xFF, 0x00, 0x1E, 0x0E, 0x00, 0xE0, 0x0C, 0x07, 0x00,
  0x18, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0xC0, 0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x01, 0x60, 0x00, 0x05, 0x80,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x64,
  0x00, 0x03, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x58, 0xC0, 0x03, 0x63, 0x00,
  0x19, 0x06, 0x01, 0xCC, 0x0F, 0xFC, 0x30, 0x0F, 0xC0, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x02, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xE0, 0x00, 0x00, 0x40, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x70, 0x70,
  0x30, 0x06, 0x18, 0x01, 0x84, 0x00, 0x23, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x03, 0xE0, 0x00, 0x80, 0xC0, 0x03, 0xFE, 0x00,
  0x20, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x00, 0xC0, 0x10, 0x03, 0x0C,
  0x00, 0x60, 0x04, 0x00, 0xC3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0x20, 0x03, 0x18, 0x03, 0x00, 0x08,
  0x00, 0xCC, 0x00, 0xC0, 0x06, 0x00, 0x23, 0x00, 0x60, 0x01, 0x80, 0x08,
  0x80, 0x18, 0x00, 0x60, 0x02, 0x20, 0x04, 0x00, 0x10, 0x01, 0x98, 0x03,
  0x00, 0x0C, 0x00, 0x66, 0x00, 0xC0, 0x03, 0x00, 0x19, 0x00, 0x20, 0x00,
  0xC0, 0x04, 0x40, 0x18, 0x00, 0x20, 0x01, 0x10, 0x06, 0x00, 0x18, 0x00,
  0xCC, 0x01, 0x80, 0x06, 0x00, 0x33, 0x00, 0x40, 0x01, 0x80, 0x08, 0xC0,
  0x10, 0x00, 0xC0, 0x06, 0x30, 0x04, 0x00, 0x30, 0x01, 0x0C, 0x01, 0x00,
  0x1C, 0x00, 0xC3, 0x00, 0x40, 0x07, 0x00, 0x20, 0xC0, 0x10, 0x02, 0xC0,
  0x18, 0x30, 0x06, 0x01, 0x90, 0x0C, 0x0C, 0x01, 0x80, 0xC6, 0x06, 0x03,
  0x00, 0x30, 0xE1, 0xC3, 0x00, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x10, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x10, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x22, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x81, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x01, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x00, 0x80, 0x01, 0x80, 0x08, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x04,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x08, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x40, 0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0xF8, 0x00, 0x30, 0x0F, 0xC0, 0x06, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x3F,
  0x00, 0x1F, 0xFF, 0xE0, 0x02, 0x00, 0x0F, 0x00, 0x40, 0x00, 0x70, 0x18,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x08, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C,
  0x10, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x07, 0x02, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x70, 0x08, 0x01, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0C, 0x03, 0xF0, 0x00, 0x60, 0x00, 0xE0, 0x03,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x0E,
  0x00, 0x40, 0x01, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xC2, 0x00, 0x1F, 0xFE, 0x10, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x10, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x00, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00,
  0xC7, 0x80, 0x00, 0x01, 0x99, 0x80, 0x00, 0x02, 0x63, 0x00, 0x00, 0x05,
  0x83, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x01, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x03, 0x00, 0x40, 0x00, 0x03, 0x00, 0x80, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x16, 0x00, 0x00, 0x00, 0xF0, 0x0B, 0x00, 0x00, 0x00, 0xD8,
  0x05, 0x80, 0x00, 0x00, 0x48, 0x06, 0x40, 0x00, 0x00, 0x64, 0x03, 0x20,
  0x00, 0x00, 0x22, 0x01, 0x90, 0x00, 0x00, 0x33, 0x00, 0x8C, 0x00, 0x00,
  0x11, 0x80, 0x46, 0x00, 0x00, 0x18, 0xC0, 0x21, 0x00, 0x00, 0x08, 0x40,
  0x30, 0x80, 0x00, 0x0C, 0x20, 0x18, 0x40, 0x00, 0x04, 0x30, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x04, 0x18, 0x00, 0x02, 0x0C, 0x02, 0x0C, 0x00, 0x03,
  0x06, 0x03, 0x02, 0x00, 0x01, 0x02, 0x01, 0x81, 0x00, 0x01, 0x81, 0x00,
  0xC0, 0x80, 0x01, 0x81, 0x80, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x20, 0x30,
  0x00, 0xC0, 0x60, 0x10, 0x08, 0x00, 0x60, 0x30, 0x18, 0x04, 0x00, 0x60,
  0x10, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x10,
  0x08, 0x01, 0x80, 0xC0, 0x08, 0x0C, 0x00, 0x80, 0x60, 0x04, 0x04, 0x00,
  0x40, 0x30, 0x03, 0x06, 0x00, 0x60, 0x10, 0x01, 0x82, 0x00, 0x30, 0x08,
  0x00, 0x43, 0x00, 0x18, 0x04, 0x00, 0x21, 0x00, 0x08, 0x06, 0x00, 0x11,
  0x80, 0x04, 0x03, 0x00, 0x08, 0x80, 0x02, 0x01, 0x80, 0x06, 0xC0, 0x03,
  0x00, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x40, 0x00, 0xE0, 0x00, 0xC0, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x3C,
  0x00, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x10, 0x09, 0x00, 0x00, 0x08, 0x0C,
  0xC0, 0x00, 0x0C, 0x06, 0x20, 0x00, 0x06, 0x03, 0x10, 0x00, 0x03, 0x01,
  0x8C, 0x00, 0x01, 0x00, 0xC2, 0x00, 0x00, 0x80, 0x41, 0x80, 0x00, 0xC0,
  0x60, 0xC0, 0x00, 0x60, 0x30, 0x20, 0x00, 0x30, 0x18, 0x18, 0x00, 0x18,
  0x0C, 0x04, 0x00, 0x08, 0x06, 0x03, 0x00, 0x04, 0x02, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x40, 0x03, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x08, 0x00,
  0xC0, 0x60, 0x04, 0x00, 0x40, 0x20, 0x03, 0x00, 0x20, 0x10, 0x00, 0x80,
  0x30, 0x18, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x10, 0x0C, 0x06, 0x00, 0x08,
  0x06, 0x03, 0x00, 0x06, 0x02, 0x01, 0x00, 0x01, 0x01, 0x00, 0x80, 0x00,
  0xC1, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x60, 0x00, 0x10, 0x60, 0x30, 0x00,
  0x0C, 0x30, 0x18, 0x00, 0x02, 0x10, 0x08, 0x00, 0x01, 0x18, 0x04, 0x00,
  0x00, 0xCC, 0x06, 0x00, 0x00, 0x26, 0x03, 0x00, 0x00, 0x1B, 0x01, 0x80,
  0x00, 0x05, 0x80, 0xC0, 0x00, 0x02, 0x80, 0x40, 0x00, 0x01, 0xC0, 0x20,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0xF8, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80,
  0x20, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x60,
  0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30,
  0x03, 0xF8, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x18, 0x01, 0x80, 0x01, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x80, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x50, 0x00, 0x04, 0xC0, 0x00, 0x34, 0x00, 0x03,
  0x30, 0x00, 0x09, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x23, 0x00,
  0x01, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x03, 0x04, 0x00, 0x08, 0x60, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00,
  0x20, 0x40, 0x01, 0x06, 0x00, 0x18, 0x10, 0x00, 0x41, 0x80, 0x06, 0x04,
  0x00, 0x30, 0x20, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x60, 0x06,
  0x02, 0x00, 0x30, 0x18, 0x01, 0x00, 0x80, 0x08, 0x06, 0x00, 0x40, 0x20,
  0x06, 0x01, 0x80, 0x30, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80,
  0x40, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00,
  0xC0, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80, 0x04, 0x08,
  0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0x41, 0x80, 0x03,
  0x08, 0x00, 0x10, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40, 0x00, 0x0A, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x01, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xC0, 0x60, 0x10, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08,
  0x04, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x28, 0x00, 0x68, 0x00, 0x48, 0x00, 0xCC, 0x00, 0x8C, 0x01,
  0x8C, 0x01, 0x04, 0x03, 0x04, 0x02, 0x04, 0x06, 0x06, 0x04, 0x06, 0x0C,
  0x06, 0x08, 0x02, 0x18, 0x02, 0x10, 0x02, 0x30, 0x03, 0x20, 0x03, 0x60,
  0x03, 0x40, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0xC0, 0xC1,
  0x81, 0x83, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0x80,
  0xE0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x81, 0x00, 0x01,
  0x06, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x0E, 0x00, 0x10, 0x70, 0x00, 0x61, 0xC0,
  0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x10, 0x00, 0x04, 0x60, 0x00,
  0x08, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x62, 0x00, 0x01, 0xC6, 0x00, 0x07,
  0x0C, 0x00, 0x1A, 0x18, 0x00, 0x64, 0x18, 0x01, 0x98, 0x18, 0x1E, 0x30,
  0x1F, 0xF0, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0xC3, 0xFE, 0x01, 0x1C,
  0x0E, 0x02, 0x60, 0x0E, 0x0D, 0x80, 0x0C, 0x1E, 0x00, 0x08, 0x38, 0x00,
  0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0x61, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x18,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x10,
  0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x70, 0x00,
  0x10, 0xE0, 0x00, 0x61, 0xE0, 0x01, 0x83, 0x60, 0x06, 0x04, 0x70, 0x38,
  0x08, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1C, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20,
  0xC0, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xC8, 0x00, 0x03, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10,
  0x60, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x30, 0x07, 0x03, 0x80, 0x0F,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x1F, 0xF0, 0xC0, 0x1C, 0x06, 0x30, 0x0E, 0x00, 0xCC, 0x07, 0x00, 0x1A,
  0x01, 0x80, 0x02, 0x80, 0xC0, 0x00, 0xE0, 0x20, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x20,
  0x00, 0x04, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x08, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x18, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x08, 0x00, 0x68, 0x03, 0x00, 0x36,
  0x00, 0x70, 0x39, 0x80, 0x0F, 0xF8, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0E, 0x07, 0x00, 0xE0, 0x0C, 0x06, 0x00,
  0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x10, 0x00, 0x0C,
  0xC0, 0x00, 0x32, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01, 0x03, 0x80, 0x18,
  0x07, 0x01, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x0F, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x30,
  0x07, 0x03, 0x8C, 0x03, 0x80, 0x33, 0x01, 0x80, 0x06, 0x80, 0x60, 0x00,
  0xA0, 0x30, 0x00, 0x38, 0x08, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x02,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x10, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x30,
  0x00, 0x0C, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x70,
  0x18, 0x00, 0x38, 0x02, 0x00, 0x1A, 0x00, 0xC0, 0x0D, 0x80, 0x1C, 0x0E,
  0x60, 0x03, 0xFE, 0x18, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x01, 0x00, 0x40, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x70,
  0x00, 0x3C, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x7F, 0xC0, 0x43,
  0x83, 0x81, 0x18, 0x02, 0x0C, 0xC0, 0x0C, 0x36, 0x00, 0x10, 0xD0, 0x00,
  0x43, 0x80, 0x01, 0x0E, 0x00, 0x04, 0x30, 0x00, 0x11, 0xC0, 0x00, 0x46,
  0x00, 0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x31, 0x00, 0x00, 0xC4, 0x00,
  0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x88, 0x00, 0x06,
  0x20, 0x00, 0x18, 0x80, 0x00, 0x66, 0x00, 0x01, 0x18, 0x00, 0x04, 0x60,
  0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00,
  0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00, 0x60,
  0x01, 0x81, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC1,
  0x00, 0x03, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x30,
  0x07, 0x00, 0x60, 0x1C, 0x00, 0x80, 0x70, 0x01, 0x01, 0xC0, 0x06, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x00, 0x46, 0x00,
  0x00, 0x9E, 0x00, 0x03, 0x6C, 0x00, 0x07, 0x8C, 0x00, 0x0E, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x30, 0x01, 0x80, 0x60, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x20,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x06, 0x04, 0x00,
  0x06, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0x86, 0x07, 0x03, 0x81, 0x80,
  0xCE, 0x01, 0x83, 0x00, 0x60, 0x64, 0x00, 0x63, 0x00, 0x10, 0x34, 0x00,
  0x33, 0x00, 0x0C, 0x16, 0x00, 0x0B, 0x00, 0x06, 0x0A, 0x00, 0x05, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x87, 0x00, 0x01, 0x80, 0x00, 0xC3,
  0x00, 0x00, 0x80, 0x00, 0x61, 0x80, 0x00, 0x40, 0x00, 0x30, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x40, 0x00, 0x30, 0x00, 0x08, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x08, 0x00, 0x06, 0x18, 0x00, 0x04, 0x00, 0x03, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x84, 0x00, 0x03, 0x00, 0x00, 0xC2, 0x00, 0x01,
  0x80, 0x00, 0x43, 0x00, 0x00, 0xC0, 0x00, 0x21, 0x80, 0x00, 0x40, 0x00,
  0x30, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x86, 0x00, 0x01, 0x00, 0x00,
  0xC3, 0x00, 0x01, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x80,
  0x00, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x3F, 0xC0, 0x43, 0x83, 0x81, 0x18, 0x02, 0x0C, 0xC0, 0x0C,
  0x36, 0x00, 0x10, 0xD0, 0x00, 0x43, 0x80, 0x01, 0x0E, 0x00, 0x04, 0x30,
  0x00, 0x11, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00,
  0x31, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x23,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x20,
  0x00, 0x18, 0x80, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0x81, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x04, 0xC0, 0x00,
  0x09, 0x80, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0x58, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0E, 0x00, 0xE0, 0x0E, 0x07,
  0x80, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x20,
  0xFF, 0x00, 0x08, 0xE0, 0x70, 0x02, 0x60, 0x04, 0x01, 0xB0, 0x01, 0x80,
  0x70, 0x00, 0x20, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x08, 0x10, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x70,
  0x00, 0x10, 0x1C, 0x00, 0x0C, 0x07, 0x80, 0x06, 0x01, 0x30, 0x03, 0x00,
  0x47, 0x03, 0x80, 0x10, 0x7F, 0xC0, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC3, 0x01, 0xC0, 0xE3, 0x03, 0x80, 0x33, 0x06, 0x00,
  0x1A, 0x06, 0x00, 0x0A, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00,
  0x08, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00,
  0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x20, 0x01, 0xA0, 0x30, 0x03, 0x60, 0x1C, 0x0E, 0x60, 0x0F, 0xF8,
  0x60, 0x01, 0x80, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x0F, 0xC1, 0x1C, 0x00, 0x98, 0x00, 0xD8, 0x00,
  0x68, 0x00, 0x38, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1E, 0x07, 0x00, 0xC0, 0x06, 0x06,
  0x00, 0x18, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x8C,
  0x00, 0x02, 0x30, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00,
  0x38, 0x07, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xE0, 0x08, 0x00,
  0x08, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x21,
  0x80, 0x00, 0x43, 0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC2, 0x00,
  0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x10, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x01, 0xC3, 0x00, 0x07, 0x02, 0x00, 0x0A, 0x06, 0x00, 0x34, 0x0C,
  0x01, 0xD8, 0x0E, 0x07, 0x30, 0x0F, 0xF8, 0x60, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x02,
  0x20, 0x00, 0x31, 0x00, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x40, 0x06, 0x02, 0x00, 0x30, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x80, 0x40, 0x04, 0x06,
  0x00, 0x20, 0x20, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x80, 0x01,
  0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xD8,
  0x00, 0x78, 0x00, 0x6C, 0x00, 0x2C, 0x00, 0x26, 0x00, 0x36, 0x00, 0x33,
  0x00, 0x1B, 0x00, 0x19, 0x80, 0x09, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x0C,
  0x20, 0x04, 0x60, 0x04, 0x10, 0x06, 0x10, 0x06, 0x08, 0x02, 0x08, 0x03,
  0x04, 0x03, 0x04, 0x03, 0x02, 0x01, 0x82, 0x01, 0x81, 0x81, 0x81, 0x81,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x40, 0x60, 0x40, 0x30, 0x60, 0x30,
  0x60, 0x18, 0x20, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x02,
  0x18, 0x03, 0x18, 0x01, 0x08, 0x01, 0x8C, 0x00, 0x8C, 0x00, 0xC4, 0x00,
  0x46, 0x00, 0x26, 0x00, 0x26, 0x00, 0x12, 0x00, 0x13, 0x00, 0x0B, 0x00,
  0x0D, 0x00, 0x05, 0x00, 0x07, 0x80, 0x02, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x20,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x9C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xDC,
  0x00, 0x04, 0xE0, 0xC0, 0x01, 0x98, 0x0C, 0x00, 0x36, 0x00, 0xC0, 0x04,
  0x80, 0x0C, 0x01, 0xB0, 0x00, 0xC0, 0x26, 0x00, 0x0C, 0x0C, 0x80, 0x00,
  0xEF, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ThinItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 44, 11, 1, -43 },
  { 51, 9, 12, 15, 7, -45 },
  { 65, 30, 43, 28, 1, -43 },
  { 227, 25, 56, 28, 2, -49 },
  { 402, 29, 45, 38, 5, -44 },
  { 566, 26, 45, 31, 2, -44 },
  { 713, 4, 12, 10, 6, -45 },
  { 719, 16, 62, 16, 3, -48 },
  { 843, 16, 61, 16, -3, -47 },
  { 965, 23, 23, 24, 4, -43 },
  { 1032, 24, 31, 29, 3, -35 },
  { 1125, 7, 12, 11, -2, -5 },
  { 1136, 12, 1, 16, 2, -20 },
  { 1138, 4, 4, 13, 1, -3 },
  { 1140, 24, 47, 20, -2, -43 },
  { 1281, 24, 45, 28, 3, -44 },
  { 1416, 13, 43, 28, 8, -43 },
  { 1486, 25, 44, 28, 1, -44 },
  { 1624, 25, 45, 28, 2, -44 },
  { 1765, 25, 43, 28, 1, -43 },
  { 1900, 25, 44, 28, 4, -43 },
  { 2038, 22, 44, 28, 3, -43 },
  { 2159, 24, 43, 28, 5, -43 },
  { 2288, 26, 45, 28, 1, -44 },
  { 2435, 22, 44, 28, 4, -44 },
  { 2556, 8, 32, 10, 1, -31 },
  { 2588, 11, 38, 10, -2, -31 },
  { 2641, 22, 23, 26, 3, -31 },
  { 2705, 23, 15, 29, 3, -27 },
  { 2749, 22, 23, 27, 2, -31 },
  { 2813, 18, 45, 23, 5, -44 },
  { 2915, 42, 54, 47, 2, -41 },
  { 3199, 28, 43, 31, -2, -43 },
  { 3350, 27, 43, 31, 2, -43 },
  { 3496, 29, 45, 33, 3, -44 },
  { 3660, 29, 43, 33, 2, -43 },
  { 3816, 29, 43, 29, 2, -43 },
  { 3972, 29, 43, 29, 2, -43 },
  { 4128, 29, 45, 35, 4, -44 },
  { 4292, 33, 43, 36, 2, -43 },
  { 4470, 9, 43, 14, 3, -43 },
  { 4519, 26, 44, 28, 1, -43 },
  { 4662, 31, 43, 32, 2, -43 },
  { 4829, 20, 43, 27, 2, -43 },
  { 4937, 41, 43, 43, 2, -43 },
  { 5158, 33, 43, 36, 2, -43 },
  { 5336, 29, 45, 34, 3, -44 },
  { 5500, 29, 43, 31, 2, -43 },
  { 5656, 29, 52, 34, 3, -44 },
  { 5845, 29, 43, 33, 2, -43 },
  { 6001, 29, 45, 30, 1, -44 },
  { 6165, 27, 43, 31, 6, -43 },
  { 6311, 29, 44, 34, 4, -43 },
  { 6471, 28, 43, 31, 5, -43 },
  { 6622, 42, 43, 46, 6, -43 },
  { 6848, 33, 43, 31, -1, -43 },
  { 7026, 28, 43, 31, 6, -43 },
  { 7177, 31, 43, 31, 0, -43 },
  { 7344, 16, 58, 12, 1, -49 },
  { 7460, 9, 47, 20, 6, -43 },
  { 7513, 16, 58, 12, -4, -49 },
  { 7629, 16, 21, 22, 3, -43 },
  { 7671, 21, 2, 22, -3, 0 },
  { 7677, 7, 8, 15, 8, -45 },
  { 7684, 23, 34, 27, 1, -33 },
  { 7782, 23, 46, 28, 2, -45 },
  { 7915, 22, 34, 26, 2, -33 },
  { 8009, 26, 46, 28, 2, -45 },
  { 8159, 22, 34, 26, 2, -33 },
  { 8253, 18, 46, 17, 4, -46 },
  { 8357, 26, 45, 28, 0, -33 },
  { 8504, 22, 45, 28, 2, -45 },
  { 8628, 9, 43, 11, 2, -43 },
  { 8677, 20, 55, 12, -8, -43 },
  { 8815, 23, 45, 25, 2, -45 },
  { 8945, 9, 45, 11, 2, -45 },
  { 8996, 41, 33, 45, 1, -33 },
  { 9166, 22, 33, 28, 2, -33 },
  { 9257, 23, 34, 28, 2, -33 },
  { 9355, 26, 45, 28, -1, -33 },
  { 9502, 24, 45, 28, 2, -33 },
  { 9637, 17, 33, 18, 2, -33 },
  { 9708, 22, 34, 26, 1, -33 },
  { 9802, 12, 41, 17, 4, -40 },
  { 9864, 23, 33, 28, 3, -32 },
  { 9959, 21, 32, 25, 4, -32 },
  { 10043, 33, 32, 38, 5, -32 },
  { 10175, 26, 32, 25, -1, -32 },
  { 10279, 28, 44, 25, -2, -32 },
  { 10433, 24, 32, 25, 0, -32 },
  { 10529, 19, 60, 17, 2, -47 },
  { 10672, 10, 51, 12, 1, -43 },
  { 10736, 19, 60, 17, -4, -47 },
  { 10879, 27, 10, 35, 4, -23 },
};

const GFXfont RobotoCondensed_ThinItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_THINITALIC60PT7B_H_
