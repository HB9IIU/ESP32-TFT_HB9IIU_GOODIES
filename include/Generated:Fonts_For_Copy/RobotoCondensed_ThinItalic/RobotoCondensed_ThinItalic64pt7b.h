#ifndef _ROBOTOCONDENSED_THINITALIC64PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x04, 0x00,
  0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x20, 0xD8, 0x26, 0x19, 0x86, 0x61, 0x90,
  0x6C, 0x13, 0x04, 0xC3, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x08, 0x01, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x80, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0x60, 0x03,
  0x80, 0x07, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x02, 0x18, 0x01,
  0x80, 0x18, 0x40, 0x06, 0x00, 0xC1, 0x00, 0x18, 0x03, 0x0C, 0x00, 0x60,
  0x18, 0x30, 0x01, 0x00, 0xC0, 0xC0, 0x04, 0x03, 0x03, 0x00, 0x30, 0x18,
  0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x01,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x03, 0x00, 0x0E, 0xF0, 0x18, 0x00, 0x1F,
  0x80, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x01, 0xF8, 0x00, 0x18, 0x1E, 0x70, 0x00, 0xC0, 0xE0,
  0x60, 0x02, 0x03, 0x00, 0x80, 0x18, 0x18, 0x02, 0x00, 0xC0, 0x40, 0x0C,
  0x02, 0x03, 0x00, 0x30, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x20, 0x03, 0x02,
  0x01, 0x80, 0x0C, 0x18, 0x06, 0x00, 0x20, 0xC0, 0x18, 0x00, 0x82, 0x00,
  0x60, 0x06, 0x18, 0x01, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x42, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x04, 0x1C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x03, 0x0C, 0x03,
  0x00, 0x31, 0x80, 0x18, 0x03, 0x30, 0x01, 0x80, 0x23, 0x00, 0x0C, 0x06,
  0x60, 0x00, 0xC0, 0x66, 0x00, 0x06, 0x04, 0x40, 0x00, 0x30, 0xCC, 0x00,
  0x03, 0x0C, 0xC0, 0x00, 0x19, 0x8C, 0x00, 0x01, 0x98, 0xC0, 0x00, 0x0F,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x1B, 0x07, 0x00, 0x02, 0x18, 0x38, 0x00, 0xC1, 0x81, 0xE0, 0x38,
  0x0C, 0x07, 0xFE, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x33, 0x66, 0x66, 0x64,
  0xCC, 0xCC, 0x80, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x01, 0xF0, 0x18, 0x0F, 0x7C,
  0x18, 0x7C, 0x0F, 0x19, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x30, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x61, 0xC3, 0x04, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x27, 0xF6, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x04, 0x06, 0x00,
  0x03, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x02, 0x30,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x08, 0x80, 0x00, 0x04,
  0x40, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x60, 0x40, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x70, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x08, 0x03, 0xC0, 0x7E, 0x1E,
  0x33, 0xC1, 0xF8, 0x0A, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x38, 0x01, 0x80,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x04, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x40, 0x00, 0x30, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x02,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x02, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x87, 0xF0, 0x00, 0x37, 0xFF, 0x00, 0x05, 0xC0,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x04, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x1F, 0xC0,
  0x18, 0x7F, 0xE0, 0x11, 0xC0, 0x38, 0x33, 0x00, 0x18, 0x36, 0x00, 0x0C,
  0x3C, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x08, 0x40, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x68, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x0E, 0xC0, 0x00, 0x3D, 0x80, 0x00, 0x59, 0x80, 0x01, 0xA3,
  0x00, 0x06, 0xC3, 0x00, 0x39, 0x83, 0x00, 0xE3, 0x03, 0xFF, 0x04, 0x01,
  0xF8, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0x03,
  0xC1, 0xE0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0xC0, 0xE0, 0x60,
  0x00, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x18,
  0x0C, 0x0E, 0x00, 0xC1, 0x80, 0x08, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x08, 0x06, 0x00, 0x0F, 0xF8, 0x00,
  0x40, 0x60, 0x01, 0xC0, 0xE0, 0x02, 0x06, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC1, 0x00, 0x08, 0x00, 0x40, 0x06, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x8C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x60, 0x06, 0x00, 0x08, 0x00, 0x42, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x30, 0x03, 0x00, 0x06, 0x00, 0x11, 0x80, 0x18, 0x00,
  0x30, 0x01, 0x88, 0x00, 0x80, 0x01, 0x00, 0x0C, 0x40, 0x0C, 0x00, 0x18,
  0x00, 0x66, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x30, 0x02, 0x00, 0x06, 0x00,
  0x11, 0x80, 0x30, 0x00, 0x20, 0x01, 0x88, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x40, 0x0C, 0x00, 0x18, 0x00, 0x46, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x30,
  0x02, 0x00, 0x0C, 0x00, 0x31, 0x80, 0x10, 0x00, 0x60, 0x01, 0x0C, 0x00,
  0x80, 0x07, 0x00, 0x18, 0x60, 0x04, 0x00, 0x38, 0x00, 0x83, 0x00, 0x20,
  0x03, 0xC0, 0x0C, 0x18, 0x01, 0x00, 0x16, 0x00, 0x40, 0xC0, 0x08, 0x01,
  0x30, 0x06, 0x06, 0x00, 0x60, 0x10, 0x80, 0x60, 0x10, 0x01, 0x83, 0x86,
  0x0E, 0x00, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x06, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x01, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20,
  0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x70, 0x01, 0x00, 0x01, 0xC0, 0x08,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x08,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0x40, 0x00, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0x80, 0x01, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xC3, 0x00,
  0x0F, 0xFF, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x04, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x18, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x01, 0x0F, 0x00, 0x00, 0x00, 0xC6,
  0xC0, 0x00, 0x00, 0x33, 0x18, 0x00, 0x00, 0x0D, 0x82, 0x00, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x10, 0x00, 0x30, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x02, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x50,
  0x00, 0x00, 0x00, 0xF0, 0x0A, 0x00, 0x00, 0x00, 0x16, 0x03, 0x60, 0x00,
  0x00, 0x06, 0x80, 0x6C, 0x00, 0x00, 0x00, 0x90, 0x0D, 0x80, 0x00, 0x00,
  0x36, 0x01, 0x30, 0x00, 0x00, 0x04, 0xC0, 0x22, 0x00, 0x00, 0x01, 0x98,
  0x0C, 0x40, 0x00, 0x00, 0x63, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x31,
  0x80, 0x00, 0x03, 0x08, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x82, 0x00,
  0x00, 0x18, 0x60, 0x10, 0x40, 0x00, 0x03, 0x0C, 0x06, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0xC1, 0x80, 0x00, 0x18, 0x20, 0x18, 0x30, 0x00, 0x06, 0x04,
  0x03, 0x06, 0x00, 0x00, 0x81, 0x80, 0x40, 0x40, 0x00, 0x30, 0x30, 0x08,
  0x08, 0x00, 0x04, 0x06, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x00, 0x20, 0x10, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x00, 0x60, 0x18, 0x04, 0x01, 0x00, 0x08, 0x03,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x06,
  0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x60, 0x10, 0x01,
  0x00, 0xC0, 0x0C, 0x02, 0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x18, 0x00, 0xC1, 0x80, 0x04, 0x03, 0x00, 0x08, 0x30, 0x01,
  0x80, 0x60, 0x01, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x21, 0x80, 0x06, 0x01,
  0x00, 0x06, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xCC, 0x00, 0x10, 0x0C, 0x00,
  0x0B, 0x00, 0x02, 0x01, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x1B, 0x00, 0x00, 0x06,
  0x03, 0x60, 0x00, 0x00, 0x80, 0x64, 0x00, 0x00, 0x10, 0x0C, 0xC0, 0x00,
  0x06, 0x01, 0x88, 0x00, 0x00, 0xC0, 0x21, 0x80, 0x00, 0x18, 0x0C, 0x30,
  0x00, 0x03, 0x01, 0x82, 0x00, 0x00, 0x40, 0x30, 0x60, 0x00, 0x08, 0x06,
  0x04, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x10, 0x18, 0x00, 0x0C,
  0x06, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x06, 0x00,
  0x04, 0x03, 0x00, 0x40, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x30, 0x08, 0x00,
  0x80, 0x06, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x10, 0x0C,
  0x00, 0x20, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18,
  0x04, 0x00, 0x0C, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x30, 0x00, 0x10,
  0x08, 0x06, 0x00, 0x03, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x18, 0x00,
  0x04, 0x0C, 0x02, 0x00, 0x00, 0xC1, 0x80, 0xC0, 0x00, 0x08, 0x30, 0x18,
  0x00, 0x01, 0x84, 0x03, 0x00, 0x00, 0x31, 0x80, 0x60, 0x00, 0x02, 0x30,
  0x08, 0x00, 0x00, 0x66, 0x01, 0x00, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x00,
  0xD8, 0x0C, 0x00, 0x00, 0x1A, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x38, 0x04, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x03, 0x80, 0x04, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x07, 0x00, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x02,
  0x00, 0x03, 0x80, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x03, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x06, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x03, 0x00, 0x00, 0x80,
  0x08, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x64, 0x00, 0x00, 0xB0, 0x00, 0x06, 0x20, 0x00, 0x04, 0x80, 0x00, 0x31,
  0x00, 0x00, 0x64, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x20, 0x00, 0x18, 0x60,
  0x00, 0x31, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x08, 0x00, 0x04, 0x18, 0x00,
  0x08, 0x40, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x04,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80,
  0x06, 0x03, 0x00, 0x08, 0x04, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x20, 0x03,
  0x00, 0x40, 0x06, 0x01, 0x00, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x60, 0x06,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0xC0, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00,
  0x20, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x08,
  0x30, 0x00, 0x30, 0x40, 0x00, 0x41, 0x80, 0x01, 0x86, 0x00, 0x03, 0x08,
  0x00, 0x04, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x18, 0x00, 0x06, 0x20, 0x00, 0x08, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x4C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x40, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x80, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20,
  0x20, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x06,
  0x60, 0x02, 0x30, 0x03, 0x18, 0x01, 0x04, 0x01, 0x82, 0x00, 0xC1, 0x00,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18, 0x30, 0x04, 0x18, 0x02,
  0x18, 0x01, 0x8C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xC1, 0xC1, 0x81, 0x83,
  0x03, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x1C, 0x01,
  0xC0, 0x06, 0x03, 0x00, 0x02, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0x06, 0x0E,
  0x00, 0x04, 0x18, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0xD8, 0x40,
  0x01, 0x98, 0x60, 0x03, 0x18, 0x38, 0x1E, 0x18, 0x1F, 0xF8, 0x18, 0x07,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x1E, 0x00, 0x18, 0x7F,
  0xE0, 0x0C, 0x70, 0x18, 0x06, 0xE0, 0x06, 0x03, 0xC0, 0x01, 0x81, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x20, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08,
  0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x1E, 0x00, 0x06, 0x0D, 0x00, 0x06, 0x06, 0x60,
  0x07, 0x03, 0x18, 0x0E, 0x01, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x02,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x30, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x3E, 0x03, 0x00,
  0x3F, 0xF0, 0x60, 0x0E, 0x03, 0x8C, 0x03, 0x00, 0x19, 0x00, 0xC0, 0x01,
  0x20, 0x30, 0x00, 0x3C, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x20,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x1B, 0x00, 0xC0, 0x06, 0x40, 0x0E,
  0x03, 0x88, 0x00, 0xFF, 0xC3, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x20, 0x18, 0x00,
  0xE0, 0x1E, 0x03, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xF0,
  0x7F, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0x83, 0x00, 0x38, 0x0E, 0x20, 0x06, 0x00, 0x32, 0x00, 0xC0, 0x01,
  0x60, 0x18, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x08, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x20, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x60, 0x0C,
  0x00, 0x64, 0x00, 0x70, 0x1C, 0x40, 0x03, 0xFF, 0x0C, 0x00, 0x07, 0x80,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x01,
  0xE0, 0x06, 0x0F, 0xF8, 0x06, 0x18, 0x0C, 0x06, 0x30, 0x06, 0x06, 0x40,
  0x02, 0x04, 0x80, 0x03, 0x05, 0x80, 0x03, 0x0D, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x06, 0x10, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x08, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x4D, 0x80, 0x00, 0x38, 0x40,
  0x00, 0x38, 0x30, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x01,
  0x00, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x30, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x33, 0x00, 0x30, 0xE0,
  0x06, 0x02, 0x60, 0x03, 0x1C, 0x00, 0x60, 0x6C, 0x00, 0x19, 0x80, 0x02,
  0x06, 0x80, 0x01, 0xB0, 0x00, 0x20, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x30, 0x00, 0x06, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x30, 0x00, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x06, 0x0F, 0xF8, 0x06, 0x18,
  0x0C, 0x06, 0x30, 0x06, 0x06, 0x40, 0x02, 0x04, 0xC0, 0x03, 0x05, 0x80,
  0x03, 0x0D, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x02, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00,
  0x03, 0x08, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0C, 0x3F,
  0xF0, 0x00, 0xC7, 0x01, 0x80, 0x0D, 0xC0, 0x0C, 0x00, 0xF0, 0x00, 0x60,
  0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x20, 0x1C, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x08, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x1E, 0x00, 0x06, 0x01, 0xA0, 0x00, 0xC0, 0x1B, 0x80,
  0x18, 0x01, 0x8C, 0x07, 0x00, 0x10, 0x7F, 0xE0, 0x01, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0,
  0xC0, 0x70, 0x1C, 0x40, 0x60, 0x03, 0x20, 0x60, 0x00, 0x90, 0x60, 0x00,
  0x78, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x10, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18,
  0x40, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0x40, 0x60, 0x03,
  0x20, 0x1C, 0x07, 0x30, 0x07, 0xFE, 0x18, 0x00, 0x78, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xC1, 0x87, 0xF0, 0x63, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x01,
  0x60, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x1C, 0x07,
  0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x07, 0xFF, 0xFF,
  0xFE, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x18, 0x00, 0x02, 0x08,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x18, 0x20, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x04, 0x00,
  0x07, 0x03, 0x00, 0x05, 0x81, 0x80, 0x06, 0xC0, 0x60, 0x06, 0x40, 0x38,
  0x0E, 0x60, 0x0F, 0xFC, 0x30, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0x40,
  0x00, 0xC0, 0x80, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x10, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x01, 0x03, 0x00,
  0x02, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x90, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0x00,
  0x6C, 0x00, 0x0E, 0x00, 0x0C, 0x40, 0x01, 0xA0, 0x00, 0xC4, 0x00, 0x12,
  0x00, 0x0C, 0x40, 0x03, 0x20, 0x01, 0x84, 0x00, 0x32, 0x00, 0x18, 0x60,
  0x06, 0x30, 0x03, 0x06, 0x00, 0x63, 0x00, 0x30, 0x60, 0x04, 0x30, 0x02,
  0x06, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x0C, 0x30, 0x06, 0x06, 0x01, 0x83,
  0x00, 0xC0, 0x60, 0x18, 0x30, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x10, 0x18, 0x06, 0x02, 0x01, 0x01, 0x80, 0x60, 0x60, 0x10, 0x30,
  0x02, 0x04, 0x01, 0x03, 0x00, 0x20, 0xC0, 0x18, 0x60, 0x02, 0x0C, 0x01,
  0x86, 0x00, 0x31, 0x80, 0x18, 0x60, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x33,
  0x00, 0x18, 0xC0, 0x03, 0x30, 0x01, 0x98, 0x00, 0x32, 0x00, 0x19, 0x80,
  0x03, 0x60, 0x00, 0x90, 0x00, 0x34, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00,
  0xB0, 0x00, 0x3C, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x20, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x03, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x40, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x20, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x46, 0x07, 0x00, 0x06, 0x60, 0x1C, 0x00, 0x36, 0x00, 0x60,
  0x01, 0x30, 0x01, 0x80, 0x19, 0x00, 0x06, 0x01, 0x98, 0x00, 0x18, 0x18,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 47, 12, 1, -46 },
  { 60, 10, 13, 16, 7, -48 },
  { 77, 32, 46, 30, 1, -46 },
  { 261, 27, 60, 30, 2, -53 },
  { 464, 30, 48, 40, 6, -47 },
  { 644, 28, 48, 33, 2, -47 },
  { 812, 4, 13, 10, 7, -48 },
  { 819, 17, 66, 17, 3, -51 },
  { 960, 18, 66, 17, -4, -51 },
  { 1109, 24, 25, 26, 4, -46 },
  { 1184, 26, 34, 31, 3, -38 },
  { 1295, 7, 13, 12, -2, -5 },
  { 1307, 13, 2, 17, 2, -22 },
  { 1311, 4, 4, 13, 1, -3 },
  { 1313, 26, 50, 21, -2, -46 },
  { 1476, 25, 48, 30, 3, -47 },
  { 1626, 13, 46, 30, 9, -46 },
  { 1701, 26, 47, 30, 2, -47 },
  { 1854, 27, 48, 30, 2, -47 },
  { 2016, 26, 46, 30, 2, -46 },
  { 2166, 27, 47, 30, 4, -46 },
  { 2325, 24, 47, 30, 3, -46 },
  { 2466, 25, 46, 30, 6, -46 },
  { 2610, 28, 48, 30, 1, -47 },
  { 2778, 23, 47, 30, 5, -47 },
  { 2914, 9, 34, 11, 1, -33 },
  { 2953, 12, 41, 11, -2, -33 },
  { 3015, 24, 25, 28, 3, -33 },
  { 3090, 24, 15, 31, 3, -28 },
  { 3135, 24, 25, 28, 2, -33 },
  { 3210, 19, 48, 24, 6, -47 },
  { 3324, 45, 58, 50, 2, -44 },
  { 3651, 30, 46, 33, -2, -46 },
  { 3824, 29, 46, 33, 2, -46 },
  { 3991, 30, 48, 35, 4, -47 },
  { 4171, 32, 46, 36, 2, -46 },
  { 4355, 31, 46, 31, 2, -46 },
  { 4534, 32, 46, 31, 2, -46 },
  { 4718, 31, 48, 37, 4, -47 },
  { 4904, 35, 46, 38, 2, -46 },
  { 5106, 10, 46, 15, 3, -46 },
  { 5164, 28, 47, 30, 1, -46 },
  { 5329, 34, 46, 35, 2, -46 },
  { 5525, 21, 46, 28, 2, -46 },
  { 5646, 43, 46, 46, 2, -46 },
  { 5894, 35, 46, 38, 2, -46 },
  { 6096, 31, 48, 36, 3, -47 },
  { 6282, 31, 46, 33, 2, -46 },
  { 6461, 31, 55, 36, 3, -47 },
  { 6675, 31, 46, 35, 2, -46 },
  { 6854, 30, 48, 32, 2, -47 },
  { 7034, 29, 46, 33, 6, -46 },
  { 7201, 32, 47, 36, 4, -46 },
  { 7389, 30, 46, 33, 6, -46 },
  { 7562, 45, 46, 49, 6, -46 },
  { 7821, 35, 46, 33, -1, -46 },
  { 8023, 30, 46, 33, 6, -46 },
  { 8196, 33, 46, 33, 0, -46 },
  { 8386, 17, 62, 13, 1, -52 },
  { 8518, 8, 50, 21, 7, -46 },
  { 8568, 17, 62, 13, -4, -52 },
  { 8700, 17, 23, 23, 4, -46 },
  { 8749, 22, 2, 23, -3, 0 },
  { 8755, 7, 8, 16, 9, -48 },
  { 8762, 24, 36, 29, 1, -35 },
  { 8870, 25, 49, 30, 2, -48 },
  { 9024, 24, 36, 28, 2, -35 },
  { 9132, 27, 49, 30, 3, -48 },
  { 9298, 24, 36, 28, 2, -35 },
  { 9406, 19, 49, 18, 4, -49 },
  { 9523, 28, 48, 30, 0, -35 },
  { 9691, 24, 48, 30, 2, -48 },
  { 9835, 10, 46, 12, 2, -46 },
  { 9893, 20, 59, 13, -8, -46 },
  { 10041, 25, 48, 26, 2, -48 },
  { 10191, 10, 48, 12, 2, -48 },
  { 10251, 44, 35, 48, 1, -35 },
  { 10444, 24, 35, 30, 2, -35 },
  { 10549, 25, 36, 30, 2, -35 },
  { 10662, 28, 48, 30, -1, -35 },
  { 10830, 25, 48, 30, 3, -35 },
  { 10980, 18, 35, 19, 2, -35 },
  { 11059, 24, 36, 27, 1, -35 },
  { 11167, 13, 44, 18, 4, -43 },
  { 11239, 25, 35, 30, 3, -34 },
  { 11349, 23, 34, 26, 4, -34 },
  { 11447, 36, 34, 41, 5, -34 },
  { 11600, 27, 34, 26, -1, -34 },
  { 11715, 30, 47, 26, -3, -34 },
  { 11892, 26, 34, 26, 0, -34 },
  { 12003, 20, 64, 18, 2, -50 },
  { 12163, 10, 54, 12, 1, -46 },
  { 12231, 20, 64, 18, -4, -50 },
  { 12391, 29, 10, 38, 4, -24 },
};

const GFXfont RobotoCondensed_ThinItalic64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_THINITALIC64PT7B_H_
