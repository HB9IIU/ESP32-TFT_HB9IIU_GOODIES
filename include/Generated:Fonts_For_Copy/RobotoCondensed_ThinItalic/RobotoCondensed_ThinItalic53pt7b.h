#ifndef _ROBOTOCONDENSED_THINITALIC53PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x21, 0x61, 0x63, 0x63, 0x43, 0x42, 0x42, 0xC2,
  0xC6, 0xC6, 0x86, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x60,
  0x30, 0x00, 0x10, 0x08, 0x00, 0x04, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x40, 0x00, 0x20, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x30, 0x18, 0x00, 0x08, 0x04,
  0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x10,
  0x08, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x60, 0x30, 0x00, 0x10, 0x08, 0x00, 0x04, 0x02, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x80, 0x40, 0x0F, 0xFF, 0xFF, 0xC0, 0x18, 0x0C, 0x00, 0x06, 0x02,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x10, 0x00, 0x08,
  0x04, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x20, 0x00,
  0x10, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xFC, 0x00, 0x38, 0x18, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x60, 0x20,
  0x00, 0x81, 0x80, 0x02, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC2, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00,
  0x63, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x60, 0x01, 0x80,
  0xC0, 0x0C, 0x01, 0x80, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0x80, 0x21, 0x00, 0x40, 0x10, 0x80,
  0x20, 0x18, 0xC0, 0x10, 0x18, 0x60, 0x08, 0x08, 0x20, 0x0C, 0x0C, 0x10,
  0x06, 0x0C, 0x08, 0x02, 0x04, 0x04, 0x03, 0x06, 0x03, 0x01, 0x06, 0x00,
  0x81, 0x82, 0x00, 0x61, 0x82, 0x00, 0x1F, 0x83, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x81,
  0xF8, 0x00, 0xC1, 0x86, 0x00, 0xC1, 0x01, 0x00, 0x41, 0x80, 0x80, 0x60,
  0x80, 0x60, 0x60, 0xC0, 0x30, 0x20, 0x40, 0x18, 0x30, 0x20, 0x08, 0x30,
  0x10, 0x04, 0x10, 0x18, 0x02, 0x10, 0x0C, 0x01, 0x18, 0x06, 0x01, 0x88,
  0x03, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x30, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x10,
  0x00, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x30, 0x01, 0x00, 0x20,
  0x01, 0x00, 0x60, 0x01, 0x00, 0x40, 0x01, 0x80, 0x80, 0x01, 0x81, 0x00,
  0x00, 0x82, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x58, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x10, 0x00, 0x02, 0x18, 0x00,
  0x04, 0x08, 0x00, 0x08, 0x0C, 0x03, 0x18, 0x04, 0x03, 0x30, 0x06, 0x02,
  0x20, 0x03, 0x02, 0x60, 0x01, 0x06, 0x60, 0x01, 0x84, 0x40, 0x00, 0x8C,
  0x40, 0x00, 0xC8, 0x40, 0x00, 0x58, 0x40, 0x00, 0x70, 0x40, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x20, 0x00, 0x98, 0x30, 0x01, 0x08, 0x1C, 0x06, 0x0C,
  0x0F, 0xF8, 0x04, 0x00, 0x80, 0x00, 0x33, 0x32, 0x26, 0x66, 0x44, 0x40,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x0E, 0x02, 0x07, 0x3C, 0x23, 0xC0, 0x76, 0xE0, 0x01,
  0xF8, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x31, 0x00, 0x02, 0x18, 0x00,
  0x40, 0x80, 0x0C, 0x0C, 0x01, 0x80, 0x60, 0x30, 0x06, 0x02, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0xC6, 0x21, 0x18, 0xCC, 0x66, 0x20, 0xFF, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x02, 0x03, 0x00, 0x18, 0x10,
  0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00, 0x04,
  0x60, 0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00,
  0x02, 0x60, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x44,
  0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00,
  0x64, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x40,
  0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x01, 0x80, 0x80, 0x18, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00, 0x7F,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x20, 0x3C, 0x1C, 0x8E, 0x1E, 0x07, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0x80, 0x06, 0x07, 0x00, 0x30, 0x06, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0x20, 0x20, 0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x40, 0x00, 0x83, 0x00, 0x02, 0x08, 0x00, 0x08, 0x60, 0x00,
  0x21, 0x80, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x43, 0x00, 0x03, 0x04, 0x00, 0x18, 0x18, 0x00, 0x40,
  0x30, 0x06, 0x00, 0x60, 0x30, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x58, 0x00, 0x02, 0x40, 0x00, 0x19, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x02, 0x08, 0x00, 0x10, 0x20, 0x00,
  0xC0, 0x80, 0x06, 0x06, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x01,
  0x00, 0x10, 0x04, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0x80, 0x08, 0x06, 0x00, 0x20, 0x30, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00,
  0x18, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xFC, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x8F,
  0xC0, 0x02, 0xF1, 0xC0, 0x1E, 0x01, 0x80, 0x60, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20,
  0x40, 0x01, 0x81, 0x80, 0x04, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x83, 0xE0, 0x11, 0xE3, 0x81, 0x30, 0x0C,
  0x34, 0x00, 0x62, 0x80, 0x06, 0x30, 0x00, 0x23, 0x00, 0x03, 0x20, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00,
  0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x06, 0x40,
  0x00, 0x44, 0x00, 0x0C, 0x60, 0x00, 0x82, 0x00, 0x18, 0x30, 0x03, 0x01,
  0x80, 0x60, 0x1C, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x20, 0x00, 0x80, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x02, 0x08,
  0x00, 0x04, 0x10, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x40, 0x80,
  0x01, 0x81, 0x00, 0x02, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x01,
  0xC0, 0x03, 0x9E, 0x00, 0x07, 0xF8, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x10, 0x40, 0x00, 0x21,
  0x80, 0x00, 0x62, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x18, 0x00, 0x02, 0x30,
  0x00, 0x04, 0x60, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x80,
  0x01, 0x01, 0x00, 0x04, 0x03, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x0C, 0x0E, 0x03,
  0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x03, 0x20,
  0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x14, 0x80, 0x07, 0x98, 0x01, 0xB1, 0x80,
  0x64, 0x1C, 0x70, 0x81, 0xF8, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x23, 0x00, 0x6C, 0x00, 0x50, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x3E, 0x00, 0x20, 0x60, 0x07,
  0x98, 0x01, 0x06, 0x00, 0x60, 0x20, 0x0C, 0x20, 0x06, 0x01, 0x80, 0x63,
  0x00, 0x60, 0x08, 0x03, 0x10, 0x06, 0x00, 0x40, 0x18, 0x80, 0x20, 0x06,
  0x00, 0xCC, 0x03, 0x00, 0x30, 0x04, 0x40, 0x10, 0x01, 0x00, 0x26, 0x01,
  0x80, 0x08, 0x01, 0x30, 0x0C, 0x00, 0xC0, 0x09, 0x00, 0x40, 0x06, 0x00,
  0xC8, 0x06, 0x00, 0x20, 0x06, 0x40, 0x20, 0x01, 0x00, 0x26, 0x01, 0x00,
  0x18, 0x01, 0x30, 0x08, 0x00, 0xC0, 0x19, 0x00, 0xC0, 0x04, 0x00, 0x88,
  0x06, 0x00, 0x60, 0x04, 0x40, 0x30, 0x03, 0x00, 0x62, 0x01, 0x80, 0x38,
  0x02, 0x10, 0x0C, 0x01, 0xC0, 0x30, 0x80, 0x60, 0x16, 0x03, 0x04, 0x01,
  0x01, 0x10, 0x10, 0x20, 0x0C, 0x30, 0xC3, 0x01, 0x80, 0x3F, 0x03, 0xF0,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x04, 0x40, 0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0x40,
  0x40, 0x00, 0x60, 0x20, 0x00, 0x20, 0x10, 0x00, 0x30, 0x08, 0x00, 0x10,
  0x04, 0x00, 0x18, 0x03, 0x00, 0x08, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x06, 0x00, 0x10, 0x02, 0x00, 0x08, 0x03, 0x00, 0x04, 0x01,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x60,
  0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02,
  0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x04, 0x03, 0xFF, 0xC0, 0x03, 0x00,
  0xF0, 0x02, 0x00, 0x1C, 0x02, 0x00, 0x04, 0x02, 0x00, 0x06, 0x02, 0x00,
  0x02, 0x06, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0x70, 0x08, 0x03,
  0xC0, 0x1F, 0xFF, 0x80, 0x18, 0x00, 0xE0, 0x10, 0x00, 0x30, 0x10, 0x00,
  0x18, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00,
  0x08, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00,
  0x60, 0x40, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x0F, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0x20, 0x18, 0x00, 0x18, 0x18, 0x00, 0x04, 0x08,
  0x00, 0x02, 0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18, 0x18,
  0x00, 0x08, 0x04, 0x00, 0x08, 0x01, 0x00, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x1E,
  0x00, 0x20, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x40, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x04, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x10,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x04, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x30, 0x10, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x03,
  0x00, 0x0E, 0x00, 0xC0, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x81, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x18, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x30, 0x00, 0x20, 0x30, 0x00, 0x18, 0x10, 0x00, 0x04, 0x18,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x3F,
  0xF9, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x04, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x3C, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x07,
  0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x00,
  0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0x80, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x0C, 0x00,
  0x04, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x60, 0x00, 0x40, 0xC0, 0x01,
  0x80, 0x80, 0x06, 0x01, 0x80, 0x08, 0x03, 0x00, 0x20, 0x03, 0x81, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x02, 0x00, 0x06,
  0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x8E, 0x00, 0x00, 0x19, 0xB0,
  0x00, 0x01, 0xB3, 0x00, 0x00, 0x16, 0x18, 0x00, 0x01, 0xC0, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x20, 0x03, 0x00, 0x02, 0x00, 0x10, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x28, 0x00, 0x00, 0x0A, 0x02,
  0x80, 0x00, 0x01, 0xE0, 0x28, 0x00, 0x00, 0x16, 0x06, 0xC0, 0x00, 0x03,
  0x40, 0x6C, 0x00, 0x00, 0x24, 0x04, 0x40, 0x00, 0x06, 0x40, 0x44, 0x00,
  0x00, 0x44, 0x04, 0x40, 0x00, 0x08, 0xC0, 0x44, 0x00, 0x00, 0x8C, 0x0C,
  0x60, 0x00, 0x10, 0x80, 0xC2, 0x00, 0x03, 0x08, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x82, 0x00, 0x06, 0x08, 0x08, 0x20, 0x00, 0x41, 0x80, 0x83, 0x00,
  0x0C, 0x18, 0x18, 0x30, 0x00, 0x81, 0x01, 0x81, 0x00, 0x18, 0x10, 0x10,
  0x10, 0x01, 0x01, 0x01, 0x01, 0x00, 0x30, 0x30, 0x10, 0x10, 0x02, 0x03,
  0x01, 0x01, 0x80, 0x60, 0x30, 0x30, 0x08, 0x04, 0x02, 0x03, 0x00, 0x80,
  0xC0, 0x20, 0x20, 0x08, 0x08, 0x02, 0x02, 0x00, 0x81, 0x80, 0x60, 0x20,
  0x0C, 0x10, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x04, 0x20, 0x04,
  0x06, 0x00, 0x44, 0x00, 0x40, 0x40, 0x04, 0xC0, 0x04, 0x04, 0x00, 0x48,
  0x00, 0xC0, 0x40, 0x07, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x05, 0x00, 0x00, 0x20, 0x2C,
  0x00, 0x01, 0x01, 0x20, 0x00, 0x08, 0x19, 0x00, 0x00, 0xC0, 0xCC, 0x00,
  0x06, 0x06, 0x20, 0x00, 0x30, 0x21, 0x80, 0x01, 0x01, 0x04, 0x00, 0x08,
  0x08, 0x20, 0x00, 0x40, 0xC1, 0x80, 0x06, 0x06, 0x04, 0x00, 0x30, 0x30,
  0x20, 0x01, 0x81, 0x00, 0x80, 0x08, 0x08, 0x04, 0x00, 0x40, 0xC0, 0x30,
  0x02, 0x06, 0x00, 0x80, 0x30, 0x30, 0x04, 0x01, 0x81, 0x00, 0x30, 0x0C,
  0x08, 0x00, 0x80, 0x40, 0x40, 0x06, 0x02, 0x06, 0x00, 0x10, 0x30, 0x30,
  0x00, 0x81, 0x81, 0x80, 0x06, 0x0C, 0x08, 0x00, 0x10, 0x60, 0x40, 0x00,
  0x82, 0x02, 0x00, 0x02, 0x10, 0x30, 0x00, 0x11, 0x81, 0x80, 0x00, 0xCC,
  0x0C, 0x00, 0x02, 0x60, 0x40, 0x00, 0x12, 0x02, 0x00, 0x00, 0xD0, 0x10,
  0x00, 0x02, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x18, 0x00, 0x04,
  0x08, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x38,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0x80,
  0x3C, 0x00, 0x80, 0x03, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x10,
  0x00, 0x08, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x82,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10,
  0x60, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00, 0x06,
  0x04, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x01, 0x00, 0x3E,
  0x00, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x18, 0x00,
  0x08, 0x18, 0x00, 0x04, 0x08, 0x00, 0x03, 0x08, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x22, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x22, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x18, 0x20, 0x00, 0x18, 0x18, 0x00, 0x08, 0x04, 0x00, 0x08, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0x80, 0x1C,
  0x00, 0x80, 0x03, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00, 0x30, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x40,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x02, 0x00, 0x06, 0x01, 0x00, 0x1E, 0x00,
  0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x10, 0x00, 0x40, 0x08, 0x00, 0x30, 0x04, 0x00, 0x18, 0x02, 0x00, 0x04,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x40, 0x40, 0x00,
  0x30, 0x20, 0x00, 0x18, 0x10, 0x00, 0x04, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0x80, 0xE0, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00,
  0x60, 0x20, 0x00, 0x18, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x08, 0x20, 0x00, 0x02, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x02, 0x0C, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x40, 0x40, 0x00, 0x30, 0x18, 0x00, 0x18, 0x02,
  0x00, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20, 0x00, 0x40, 0x20, 0x00,
  0xC0, 0x20, 0x00, 0x80, 0x30, 0x01, 0x80, 0x30, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x10, 0x06, 0x00, 0x10, 0x04,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x08, 0x18, 0x00, 0x08, 0x10,
  0x00, 0x08, 0x30, 0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x40,
  0x00, 0x0C, 0x40, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x05, 0x80,
  0x00, 0x05, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x05,
  0x80, 0x00, 0xA0, 0x00, 0x6C, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x48,
  0x00, 0x11, 0x00, 0x06, 0x40, 0x01, 0x88, 0x00, 0x22, 0x00, 0x08, 0x40,
  0x01, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0x84, 0x00,
  0x20, 0x80, 0x0C, 0x20, 0x03, 0x04, 0x00, 0x41, 0x80, 0x10, 0x30, 0x02,
  0x0C, 0x00, 0x81, 0x80, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x01, 0x00, 0x40,
  0x60, 0x18, 0x08, 0x02, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0xC0, 0x40, 0x10, 0x18, 0x02, 0x02, 0x00, 0x80, 0xC0, 0x10,
  0x30, 0x04, 0x04, 0x00, 0x81, 0x00, 0x20, 0x60, 0x04, 0x18, 0x01, 0x82,
  0x00, 0x20, 0xC0, 0x0C, 0x10, 0x01, 0x04, 0x00, 0x61, 0x80, 0x08, 0x60,
  0x03, 0x08, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x03, 0x30, 0x00, 0x46, 0x00,
  0x19, 0x80, 0x02, 0x20, 0x00, 0xC8, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x00,
  0x90, 0x00, 0x34, 0x00, 0x04, 0x80, 0x01, 0xA0, 0x00, 0x2C, 0x00, 0x0F,
  0x00, 0x01, 0x40, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x40, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x20, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x20,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x01, 0x90,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x20,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x30, 0x00, 0x80, 0x10, 0x00, 0x60, 0x18,
  0x00, 0x10, 0x18, 0x00, 0x08, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x66, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xC0, 0x00, 0x40,
  0x40, 0x40, 0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30,
  0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08,
  0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02,
  0x02, 0x02, 0x03, 0x03, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x28, 0x01, 0xB0, 0x04, 0xC0, 0x31, 0x00, 0x84,
  0x06, 0x10, 0x10, 0x40, 0xC1, 0x82, 0x06, 0x18, 0x08, 0x40, 0x23, 0x00,
  0x88, 0x02, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0x41,
  0x83, 0x0C, 0x18, 0x20, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0x80,
  0xC0, 0x70, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x03, 0x08, 0x00, 0x31, 0x80,
  0x03, 0x10, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x0F, 0xFE, 0x07, 0xE0, 0x60, 0xC0, 0x04, 0x38, 0x00, 0x42,
  0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x08,
  0x80, 0x01, 0x88, 0x00, 0x18, 0x80, 0x02, 0x8C, 0x00, 0x78, 0x40, 0x0D,
  0x86, 0x03, 0x18, 0x3F, 0xE1, 0x80, 0x60, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x04, 0x00, 0x43, 0xFC, 0x02, 0x70, 0x30, 0x16, 0x00, 0xC0,
  0xE0, 0x02, 0x0E, 0x00, 0x18, 0x60, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00,
  0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x60, 0x00, 0x23, 0x00, 0x01, 0x10,
  0x00, 0x18, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x01,
  0x18, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x23, 0x00,
  0x03, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x85, 0x00, 0x18, 0x2C, 0x01, 0x81,
  0x30, 0x18, 0x18, 0x7F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x0C, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xC4, 0x00,
  0x09, 0x80, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x64, 0x00, 0x08, 0xC0, 0x03, 0x08, 0x00, 0xC1, 0x80, 0x30,
  0x18, 0x0C, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x1F, 0xE0, 0x80, 0x60, 0x33,
  0x01, 0x80, 0x36, 0x06, 0x00, 0x28, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x40, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x03, 0x04, 0x00, 0x04, 0x18,
  0x00, 0x08, 0x30, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x00,
  0x01, 0x86, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x03, 0x00, 0x02,
  0x02, 0x00, 0x0C, 0x04, 0x00, 0x38, 0x0C, 0x00, 0xB0, 0x0C, 0x06, 0x40,
  0x0F, 0xF0, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01,
  0xC0, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x11,
  0x80, 0x01, 0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01,
  0x60, 0x00, 0x17, 0xFF, 0xFF, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x01, 0x81, 0xC0, 0x60, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x3F, 0x00, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x7F,
  0xF0, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x0C, 0x03, 0x01, 0x98, 0x0C, 0x01, 0xB0, 0x30, 0x01, 0x40, 0x40, 0x01,
  0x81, 0x80, 0x03, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18,
  0x20, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04,
  0x00, 0x06, 0x08, 0x00, 0x08, 0x30, 0x00, 0x10, 0x60, 0x00, 0x20, 0xC0,
  0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00,
  0x08, 0x18, 0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x01, 0xC0, 0x60, 0x05,
  0x80, 0x60, 0x32, 0x00, 0x7F, 0x84, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x18, 0x06, 0x00, 0x20, 0x06, 0x01, 0x80, 0x07, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x61, 0xFC,
  0x02, 0x30, 0x30, 0x13, 0x00, 0xC0, 0xB0, 0x02, 0x0D, 0x00, 0x10, 0x70,
  0x00, 0xC2, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x04, 0x00, 0x08,
  0x60, 0x00, 0x43, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80, 0x01, 0x84, 0x00,
  0x0C, 0x20, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x10, 0x80, 0x01, 0x84,
  0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x10, 0xC0, 0x00,
  0x84, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x02, 0x18, 0x00, 0x10, 0x03,
  0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x01, 0x18, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x01, 0x82, 0x00, 0x18, 0x10,
  0x01, 0x80, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x02, 0x01, 0x80,
  0x10, 0x18, 0x00, 0x81, 0x00, 0x04, 0x10, 0x00, 0x63, 0x00, 0x03, 0x30,
  0x00, 0x13, 0x80, 0x00, 0xB6, 0x00, 0x07, 0x10, 0x00, 0x30, 0xC0, 0x03,
  0x02, 0x00, 0x18, 0x18, 0x00, 0x80, 0x40, 0x04, 0x03, 0x00, 0x20, 0x08,
  0x03, 0x00, 0x60, 0x18, 0x01, 0x00, 0xC0, 0x0C, 0x04, 0x00, 0x20, 0x20,
  0x01, 0x81, 0x00, 0x04, 0x18, 0x00, 0x30, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x43, 0xFC, 0x03, 0xFC, 0x04, 0x60, 0x60, 0xE0,
  0x60, 0x4C, 0x03, 0x18, 0x02, 0x0D, 0x80, 0x13, 0x00, 0x30, 0xF0, 0x01,
  0x60, 0x03, 0x0A, 0x00, 0x14, 0x00, 0x10, 0xC0, 0x01, 0xC0, 0x01, 0x0C,
  0x00, 0x18, 0x00, 0x11, 0x80, 0x01, 0x00, 0x03, 0x18, 0x00, 0x10, 0x00,
  0x31, 0x80, 0x01, 0x00, 0x03, 0x10, 0x00, 0x10, 0x00, 0x21, 0x00, 0x03,
  0x00, 0x02, 0x10, 0x00, 0x30, 0x00, 0x23, 0x00, 0x02, 0x00, 0x06, 0x30,
  0x00, 0x20, 0x00, 0x63, 0x00, 0x02, 0x00, 0x06, 0x20, 0x00, 0x60, 0x00,
  0x42, 0x00, 0x06, 0x00, 0x04, 0x20, 0x00, 0x60, 0x00, 0x46, 0x00, 0x04,
  0x00, 0x0C, 0x60, 0x00, 0x40, 0x00, 0xC6, 0x00, 0x04, 0x00, 0x0C, 0x40,
  0x00, 0xC0, 0x00, 0x84, 0x00, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x80, 0x00,
  0x8C, 0x00, 0x08, 0x00, 0x18, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x20, 0xFE, 0x01, 0x1C, 0x18, 0x09, 0x80, 0x60, 0x58, 0x01, 0x06,
  0x80, 0x08, 0x38, 0x00, 0x61, 0x40, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0x82, 0x00, 0x04, 0x30, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00, 0x18, 0x40,
  0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x21, 0x80, 0x01, 0x0C, 0x00, 0x08,
  0x40, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00,
  0x08, 0x60, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80, 0x01, 0x0C,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0xC0, 0x60,
  0x06, 0x0C, 0x00, 0x20, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x01, 0x30,
  0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02,
  0xC0, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04, 0xC0, 0x00,
  0xCC, 0x00, 0x18, 0x40, 0x01, 0x86, 0x00, 0x30, 0x30, 0x06, 0x03, 0x81,
  0xC0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x08, 0x7F, 0x80,
  0x27, 0x03, 0x00, 0xB0, 0x06, 0x03, 0x80, 0x08, 0x1C, 0x00, 0x30, 0x60,
  0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0xC0, 0x00,
  0x43, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC2,
  0x00, 0x03, 0x08, 0x00, 0x08, 0x60, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00,
  0x06, 0x10, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x08,
  0x30, 0x00, 0x60, 0xE0, 0x03, 0x02, 0xC0, 0x18, 0x09, 0x80, 0xC0, 0x61,
  0xFE, 0x01, 0x80, 0x80, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x40, 0xE0, 0x66, 0x0C, 0x01, 0xB0, 0xC0, 0x05, 0x04, 0x00, 0x18,
  0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00,
  0x08, 0xC0, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x88,
  0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x01,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x10, 0x40,
  0x01, 0x82, 0x00, 0x1C, 0x18, 0x01, 0x60, 0x60, 0x32, 0x01, 0xFE, 0x10,
  0x01, 0x80, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x3F, 0x04, 0x60, 0x04,
  0x80, 0x05, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0E, 0x07, 0x03, 0x00,
  0x20, 0xC0, 0x06, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x30, 0x00, 0x26, 0x00, 0x0C,
  0xC0, 0x01, 0x08, 0x00, 0x61, 0x80, 0x18, 0x18, 0x0E, 0x01, 0xFF, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0xFF, 0xE1, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x1F, 0x00, 0x80, 0x10, 0x00, 0x11, 0x00, 0x03, 0x10,
  0x00, 0x31, 0x00, 0x02, 0x30, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x62,
  0x00, 0x06, 0x20, 0x00, 0x46, 0x00, 0x04, 0x60, 0x00, 0x46, 0x00, 0x04,
  0x40, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00,
  0x30, 0x80, 0x03, 0x08, 0x00, 0x50, 0xC0, 0x0F, 0x04, 0x01, 0xB0, 0x60,
  0x32, 0x03, 0xFC, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x0D,
  0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x41,
  0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x18, 0x02, 0x03,
  0x00, 0xC0, 0x20, 0x10, 0x04, 0x06, 0x00, 0x80, 0x80, 0x10, 0x30, 0x03,
  0x04, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02,
  0x60, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x70,
  0x01, 0x90, 0x01, 0x40, 0x04, 0x40, 0x0D, 0x00, 0x31, 0x00, 0x24, 0x00,
  0xC4, 0x00, 0x90, 0x06, 0x10, 0x06, 0x40, 0x18, 0x40, 0x11, 0x00, 0x41,
  0x00, 0xC6, 0x03, 0x04, 0x02, 0x18, 0x08, 0x18, 0x18, 0x60, 0x60, 0x60,
  0x41, 0x81, 0x81, 0x83, 0x06, 0x04, 0x06, 0x08, 0x08, 0x30, 0x18, 0x20,
  0x20, 0x80, 0x61, 0x80, 0x86, 0x00, 0x84, 0x02, 0x18, 0x02, 0x30, 0x08,
  0xC0, 0x08, 0x80, 0x23, 0x00, 0x26, 0x00, 0x88, 0x00, 0x90, 0x03, 0x60,
  0x02, 0x40, 0x0D, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x28, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x04, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x08, 0x01, 0x80, 0x18,
  0x02, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x60, 0x40, 0x00, 0x41,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x98, 0x00, 0x01, 0x20, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x4C, 0x00,
  0x01, 0x88, 0x00, 0x06, 0x18, 0x00, 0x08, 0x10, 0x00, 0x20, 0x20, 0x00,
  0xC0, 0x60, 0x03, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x60,
  0x01, 0x81, 0x80, 0x01, 0x02, 0x00, 0x03, 0x00, 0x02, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x20, 0x04, 0x00, 0x30, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x18, 0x06,
  0x00, 0x04, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04,
  0x60, 0x00, 0x02, 0x20, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x00, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x08,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x70, 0x00, 0xCC, 0x0C, 0x00, 0x44,
  0x03, 0x00, 0x26, 0x00, 0x80, 0x32, 0x00, 0x60, 0x11, 0x00, 0x18, 0x11,
  0x80, 0x07, 0x30, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 39, 10, 1, -38 },
  { 40, 8, 11, 13, 6, -40 },
  { 51, 26, 38, 25, 1, -38 },
  { 175, 22, 50, 25, 2, -44 },
  { 313, 25, 40, 33, 5, -39 },
  { 438, 24, 40, 28, 1, -39 },
  { 558, 4, 11, 9, 5, -40 },
  { 564, 14, 54, 14, 3, -42 },
  { 659, 14, 54, 14, -3, -42 },
  { 754, 20, 20, 22, 3, -38 },
  { 804, 22, 27, 25, 2, -31 },
  { 879, 5, 11, 10, -1, -4 },
  { 886, 10, 1, 14, 2, -18 },
  { 888, 3, 3, 11, 1, -2 },
  { 890, 22, 41, 18, -2, -38 },
  { 1003, 21, 40, 25, 3, -39 },
  { 1108, 11, 38, 25, 7, -38 },
  { 1161, 22, 39, 25, 1, -39 },
  { 1269, 22, 40, 25, 2, -39 },
  { 1379, 22, 38, 25, 1, -38 },
  { 1484, 22, 39, 25, 3, -38 },
  { 1592, 20, 39, 25, 2, -38 },
  { 1690, 20, 38, 25, 5, -38 },
  { 1785, 23, 40, 25, 1, -39 },
  { 1900, 19, 39, 25, 4, -39 },
  { 1993, 7, 28, 9, 1, -27 },
  { 2018, 10, 34, 9, -2, -27 },
  { 2061, 20, 21, 23, 2, -28 },
  { 2114, 20, 11, 25, 3, -23 },
  { 2142, 20, 21, 23, 1, -28 },
  { 2195, 15, 40, 20, 5, -39 },
  { 2270, 37, 48, 41, 2, -36 },
  { 2492, 25, 38, 27, -2, -38 },
  { 2611, 24, 38, 27, 2, -38 },
  { 2725, 25, 40, 29, 3, -39 },
  { 2850, 26, 38, 29, 2, -38 },
  { 2974, 25, 38, 26, 2, -38 },
  { 3093, 26, 38, 26, 2, -38 },
  { 3217, 25, 40, 31, 4, -39 },
  { 3342, 29, 38, 32, 2, -38 },
  { 3480, 8, 38, 12, 3, -38 },
  { 3518, 23, 39, 25, 1, -38 },
  { 3631, 28, 38, 29, 2, -38 },
  { 3764, 17, 38, 24, 2, -38 },
  { 3845, 36, 38, 38, 2, -38 },
  { 4016, 29, 38, 32, 2, -38 },
  { 4154, 25, 40, 30, 3, -39 },
  { 4279, 25, 38, 27, 2, -38 },
  { 4398, 25, 46, 30, 3, -39 },
  { 4542, 25, 38, 29, 2, -38 },
  { 4661, 26, 40, 27, 1, -39 },
  { 4791, 24, 38, 27, 5, -38 },
  { 4905, 26, 39, 30, 3, -38 },
  { 5032, 24, 38, 27, 5, -38 },
  { 5146, 37, 38, 40, 5, -38 },
  { 5322, 30, 38, 27, -1, -38 },
  { 5465, 25, 38, 27, 5, -38 },
  { 5584, 28, 38, 27, 0, -38 },
  { 5717, 14, 51, 10, 1, -43 },
  { 5807, 8, 41, 18, 5, -38 },
  { 5848, 14, 51, 10, -3, -43 },
  { 5938, 14, 19, 19, 3, -38 },
  { 5972, 18, 1, 19, -2, 0 },
  { 5975, 6, 7, 14, 7, -40 },
  { 5981, 20, 30, 24, 1, -29 },
  { 6056, 21, 41, 25, 1, -40 },
  { 6164, 19, 30, 23, 2, -29 },
  { 6236, 23, 41, 25, 2, -40 },
  { 6354, 20, 30, 23, 1, -29 },
  { 6429, 16, 41, 15, 3, -41 },
  { 6511, 23, 40, 25, 0, -29 },
  { 6626, 21, 40, 25, 1, -40 },
  { 6731, 8, 38, 10, 2, -38 },
  { 6769, 17, 49, 10, -7, -38 },
  { 6874, 21, 40, 22, 1, -40 },
  { 6979, 8, 40, 10, 2, -40 },
  { 7019, 36, 29, 40, 1, -29 },
  { 7150, 21, 29, 25, 1, -29 },
  { 7227, 20, 30, 25, 2, -29 },
  { 7302, 22, 40, 25, 0, -29 },
  { 7412, 21, 40, 25, 2, -29 },
  { 7517, 16, 29, 16, 1, -29 },
  { 7575, 19, 30, 23, 1, -29 },
  { 7647, 11, 37, 15, 3, -36 },
  { 7698, 20, 29, 25, 3, -28 },
  { 7771, 19, 28, 22, 3, -28 },
  { 7838, 30, 28, 34, 4, -28 },
  { 7943, 23, 28, 22, -1, -28 },
  { 8024, 25, 39, 22, -2, -28 },
  { 8146, 21, 28, 22, 0, -28 },
  { 8220, 16, 52, 15, 2, -41 },
  { 8324, 9, 45, 10, 1, -38 },
  { 8375, 17, 52, 15, -4, -41 },
  { 8486, 25, 9, 31, 3, -20 },
};

const GFXfont RobotoCondensed_ThinItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_THINITALIC53PT7B_H_
