#ifndef _ROBOTOCONDENSED_THINITALIC41PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x22,
  0x44, 0x9B, 0x24, 0x48, 0x91, 0x22, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00,
  0x20, 0x40, 0x02, 0x04, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80,
  0x08, 0x10, 0x1F, 0xFF, 0xF0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x10, 0x20,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x06, 0x08,
  0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0xC1, 0x00, 0xFF, 0xFF, 0x80, 0x81,
  0x00, 0x08, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x01, 0x06, 0x00, 0x20,
  0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x07, 0xC0, 0x0C, 0x10, 0x08, 0x04, 0x08, 0x03,
  0x04, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x43, 0x00, 0x60, 0x80,
  0x60, 0x30, 0x60, 0x0F, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x0F, 0x00, 0x06, 0x20, 0x00, 0x82, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x09, 0x01, 0x02, 0x20, 0x20, 0x44, 0x04, 0x10, 0x80, 0x84, 0x10,
  0x31, 0x82, 0x04, 0x20, 0x41, 0x88, 0x04, 0x62, 0x00, 0x78, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x3C, 0x01, 0x8C, 0x40, 0x22, 0x08, 0x08, 0x40, 0x82,
  0x10, 0x10, 0x42, 0x02, 0x10, 0x40, 0x44, 0x08, 0x09, 0x82, 0x02, 0x20,
  0x40, 0x48, 0x04, 0x08, 0x00, 0x82, 0x00, 0x18, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x21, 0x00, 0x10, 0x20, 0x08, 0x08, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x86, 0x00, 0x23, 0x00,
  0x09, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x23, 0x00, 0x18,
  0x40, 0x4C, 0x08, 0x12, 0x02, 0x05, 0x00, 0x42, 0x40, 0x10, 0x90, 0x02,
  0x68, 0x00, 0xD2, 0x00, 0x18, 0xC0, 0x06, 0x10, 0x03, 0x86, 0x01, 0x90,
  0xC1, 0x84, 0x0F, 0x80, 0x80, 0x2D, 0x24, 0xB4, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x81, 0x70, 0x8E, 0x0C, 0xB0, 0x03, 0xC0, 0x03, 0x80, 0x02, 0xC0,
  0x04, 0x40, 0x08, 0x60, 0x10, 0x20, 0x30, 0x10, 0x60, 0x10, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x11, 0x32, 0x26, 0x48, 0x7F, 0xF0, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x00, 0xF8, 0x03, 0x04, 0x06, 0x02, 0x0C, 0x02, 0x08, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x02,
  0x80, 0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08,
  0xC0, 0x10, 0x40, 0x30, 0x40, 0x60, 0x30, 0xC0, 0x1F, 0x00, 0x01, 0x0F,
  0x31, 0xC1, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x00, 0xFC, 0x00, 0xC3, 0x00, 0x80, 0xC0, 0x80, 0x20,
  0x80, 0x18, 0x40, 0x04, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0xC3, 0x00, 0x80, 0x40,
  0x80, 0x30, 0x80, 0x08, 0x40, 0x04, 0x60, 0x02, 0x20, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0xC0, 0x07,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x30, 0x06,
  0x08, 0x06, 0x03, 0x06, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x40, 0x01, 0xA0, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x42, 0x00, 0x41, 0x00, 0x61, 0x00, 0x20, 0x80, 0x20, 0x40, 0x20,
  0x20, 0x30, 0x10, 0x10, 0x08, 0x10, 0x08, 0x18, 0x04, 0x18, 0x02, 0x08,
  0x01, 0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x82,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0xFC, 0x03, 0x83,
  0x01, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x44, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x10, 0x40, 0x08, 0x10, 0x08, 0x04, 0x18, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x87, 0xC1, 0x30, 0xC4, 0x80, 0xCA,
  0x00, 0x98, 0x01, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40, 0x06, 0xC0, 0x08, 0x80, 0x21,
  0x80, 0xC1, 0x83, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x20, 0x10, 0x10,
  0x02, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x21, 0x80, 0x10, 0x20, 0x0C, 0x0C, 0x06, 0x01, 0x83, 0x00,
  0x3F, 0x00, 0x30, 0x60, 0x10, 0x04, 0x08, 0x00, 0x86, 0x00, 0x21, 0x00,
  0x04, 0xC0, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04,
  0x10, 0x03, 0x06, 0x01, 0x80, 0xC1, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x0C, 0x30, 0x20, 0x30, 0x80, 0x22, 0x00, 0x64, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xA0, 0x03, 0x60, 0x06, 0x40, 0x14, 0xC0, 0x58, 0xC3, 0x20, 0xF8, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x70, 0x0F, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x41, 0x83, 0x04, 0x08, 0x20, 0xC1, 0x00, 0x00, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x10, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x0F, 0x81, 0x84, 0x20, 0x24, 0x02, 0x40, 0x38, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x02, 0x04, 0x01, 0xE0, 0x08, 0x60, 0x30, 0xC0, 0x42, 0x03,
  0x02, 0x02, 0x30, 0x10, 0x10, 0x11, 0x01, 0x00, 0x80, 0x98, 0x10, 0x08,
  0x04, 0x80, 0x80, 0x40, 0x24, 0x0C, 0x02, 0x01, 0x20, 0x40, 0x10, 0x12,
  0x02, 0x01, 0x00, 0x90, 0x20, 0x08, 0x04, 0x81, 0x00, 0x40, 0x24, 0x08,
  0x02, 0x02, 0x20, 0x40, 0x20, 0x13, 0x02, 0x01, 0x00, 0x90, 0x10, 0x18,
  0x08, 0xC0, 0x81, 0x40, 0xC6, 0x04, 0x0A, 0x04, 0x10, 0x31, 0x88, 0xC0,
  0x80, 0xF0, 0x38, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x04, 0x80, 0x00,
  0x90, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08,
  0x20, 0x01, 0x04, 0x00, 0x40, 0x40, 0x08, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x80, 0x10, 0x10, 0x01, 0x07, 0xFF,
  0xE0, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00, 0x11, 0x80, 0x02, 0x20, 0x00,
  0x44, 0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x02, 0x07, 0xFC,
  0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x11,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x18, 0x40,
  0x04, 0x30, 0x02, 0x08, 0x03, 0x03, 0xFF, 0x80, 0x80, 0x30, 0x20, 0x02,
  0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0xC2, 0x00,
  0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x18, 0x03, 0x00, 0x40,
  0x40, 0x06, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x03,
  0x30, 0x00, 0x32, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0x40,
  0x00, 0x84, 0x00, 0x10, 0x40, 0x03, 0x06, 0x00, 0x20, 0x20, 0x04, 0x01,
  0x81, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0x00, 0x60, 0x20, 0x02,
  0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0x82, 0x00, 0x60, 0x40, 0x38, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F,
  0xFF, 0x81, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x81, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x30,
  0x30, 0x18, 0x03, 0x02, 0x00, 0x20, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x7F,
  0xD0, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x64, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x20, 0x80, 0x18,
  0x0C, 0x1E, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x20, 0x80,
  0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x04,
  0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x83, 0xFF, 0xFE, 0x08, 0x00,
  0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00,
  0x80, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x0C, 0x20, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x04, 0x30, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x20, 0x01,
  0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x30, 0x04, 0x04, 0x02, 0x00,
  0x83, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00,
  0x10, 0x10, 0x01, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x60, 0x10, 0x02,
  0x01, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x04, 0x10, 0x00, 0x21, 0x00,
  0x02, 0x10, 0x00, 0x11, 0x80, 0x00, 0x96, 0x00, 0x05, 0x10, 0x00, 0x30,
  0x40, 0x01, 0x02, 0x00, 0x10, 0x08, 0x00, 0x80, 0x40, 0x04, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x30, 0x20, 0x00, 0x81, 0x00, 0x06, 0x08, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0x04, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x02, 0x85, 0x00, 0x00, 0x60,
  0xA0, 0x00, 0x14, 0x14, 0x00, 0x02, 0x84, 0x80, 0x00, 0x90, 0x90, 0x00,
  0x12, 0x11, 0x00, 0x04, 0x42, 0x20, 0x01, 0x90, 0x44, 0x00, 0x22, 0x08,
  0x80, 0x0C, 0x42, 0x10, 0x01, 0x08, 0x41, 0x00, 0x41, 0x08, 0x20, 0x08,
  0x61, 0x04, 0x02, 0x08, 0x20, 0x80, 0x41, 0x04, 0x10, 0x10, 0x21, 0x02,
  0x02, 0x04, 0x20, 0x20, 0x80, 0x84, 0x04, 0x10, 0x30, 0x80, 0x84, 0x04,
  0x10, 0x10, 0x80, 0x82, 0x02, 0x20, 0x10, 0x80, 0x2C, 0x02, 0x10, 0x05,
  0x00, 0x42, 0x00, 0xE0, 0x10, 0x40, 0x18, 0x02, 0x08, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x04, 0x30, 0x00, 0x10, 0xA0, 0x00, 0xC2, 0x80, 0x02, 0x0A,
  0x00, 0x08, 0x24, 0x00, 0x21, 0x90, 0x00, 0x84, 0x20, 0x02, 0x10, 0x80,
  0x18, 0x42, 0x00, 0x41, 0x04, 0x01, 0x04, 0x10, 0x04, 0x30, 0x20, 0x10,
  0x80, 0x80, 0xC2, 0x02, 0x02, 0x08, 0x04, 0x08, 0x20, 0x10, 0x20, 0x80,
  0x40, 0x86, 0x00, 0x82, 0x10, 0x02, 0x18, 0x40, 0x04, 0x41, 0x00, 0x11,
  0x04, 0x00, 0x44, 0x10, 0x00, 0x90, 0x80, 0x02, 0x42, 0x00, 0x07, 0x08,
  0x00, 0x18, 0x20, 0x00, 0x60, 0x80, 0x00, 0x80, 0x00, 0x7F, 0x00, 0x1C,
  0x18, 0x03, 0x00, 0x40, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x03, 0x10,
  0x00, 0x11, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12,
  0x00, 0x03, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x06, 0xC0, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00,
  0x48, 0x00, 0x08, 0xC0, 0x00, 0x84, 0x00, 0x10, 0x40, 0x01, 0x06, 0x00,
  0x20, 0x20, 0x04, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x01,
  0x00, 0x70, 0x20, 0x02, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0xC6,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x62, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x63, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0xC1, 0x00, 0x60, 0x3F,
  0xF0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x18, 0x03,
  0x00, 0x40, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x03, 0x10, 0x00, 0x11,
  0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x03,
  0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x24, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x08, 0x80, 0x00, 0x84, 0x00, 0x10, 0x40, 0x01, 0x06, 0x00, 0x20, 0x20,
  0x04, 0x01, 0x81, 0x80, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x07, 0xFF, 0x00, 0x40, 0x1C,
  0x04, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x10, 0x00, 0x41, 0x00, 0x0C, 0x10, 0x01, 0x81, 0x00, 0x20, 0x1F,
  0xFC, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x20, 0x04, 0x02,
  0x00, 0x60, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x03, 0x04, 0x00, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x18, 0x40, 0x00, 0x80, 0x00, 0x7F, 0x00, 0x1C,
  0x18, 0x03, 0x00, 0x40, 0x40, 0x06, 0x08, 0x00, 0x20, 0x80, 0x02, 0x18,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00,
  0x20, 0x20, 0x06, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x08, 0x40, 0x00, 0xC2,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00,
  0x42, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40,
  0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08,
  0x60, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00,
  0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x03, 0x03,
  0x00, 0x10, 0x08, 0x03, 0x00, 0x30, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x19, 0x80,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x81, 0x00,
  0x10, 0x20, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x01,
  0x80, 0x20, 0x20, 0x04, 0x04, 0x00, 0x81, 0x00, 0x08, 0x20, 0x01, 0x08,
  0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x12, 0x00, 0x01, 0x40,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x80, 0x02, 0x00, 0x14,
  0x00, 0x30, 0x00, 0xA0, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x48, 0x00,
  0xA0, 0x02, 0x60, 0x05, 0x00, 0x33, 0x00, 0x44, 0x01, 0x08, 0x02, 0x20,
  0x08, 0x40, 0x21, 0x00, 0x82, 0x01, 0x08, 0x04, 0x10, 0x18, 0x40, 0x60,
  0x80, 0x82, 0x02, 0x04, 0x04, 0x10, 0x10, 0x20, 0x40, 0x81, 0x81, 0x02,
  0x04, 0x08, 0x08, 0x30, 0x20, 0x40, 0x41, 0x01, 0x04, 0x02, 0x08, 0x0C,
  0x20, 0x10, 0x80, 0x23, 0x00, 0x84, 0x01, 0x10, 0x04, 0x60, 0x08, 0x80,
  0x32, 0x00, 0x48, 0x00, 0x90, 0x02, 0x40, 0x05, 0x00, 0x12, 0x00, 0x28,
  0x00, 0xA0, 0x01, 0x80, 0x05, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x06, 0x04, 0x00, 0x08,
  0x0C, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x10, 0x04, 0x00,
  0x20, 0x10, 0x00, 0x60, 0x60, 0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x00,
  0x88, 0x00, 0x01, 0x30, 0x00, 0x01, 0x40, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x88, 0x00, 0x02, 0x10,
  0x00, 0x0C, 0x10, 0x00, 0x10, 0x20, 0x00, 0x40, 0x60, 0x01, 0x00, 0x40,
  0x06, 0x00, 0x80, 0x08, 0x00, 0x80, 0x20, 0x01, 0x00, 0x80, 0x01, 0x03,
  0x00, 0x02, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x78, 0x00, 0x09, 0x00,
  0x02, 0x20, 0x00, 0xC6, 0x00, 0x10, 0x40, 0x04, 0x08, 0x01, 0x81, 0x00,
  0x20, 0x10, 0x08, 0x02, 0x03, 0x00, 0x40, 0x40, 0x04, 0x10, 0x00, 0x86,
  0x00, 0x10, 0x80, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x3E, 0x00, 0x83, 0x04, 0x10, 0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x20,
  0x82, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x30, 0x41, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x3E, 0x00, 0x01, 0x80, 0x30, 0x0A,
  0x01, 0x40, 0x68, 0x08, 0x83, 0x10, 0x42, 0x18, 0x42, 0x08, 0x41, 0x10,
  0x32, 0x02, 0x80, 0x50, 0x08, 0xFF, 0xFC, 0x84, 0x62, 0x30, 0x00, 0xF8,
  0x03, 0x06, 0x04, 0x03, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x03, 0xFE, 0x0E, 0x02, 0x10, 0x02,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x1C,
  0x40, 0x34, 0x20, 0xC4, 0x1F, 0x04, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0xF8, 0x0B, 0x06, 0x16, 0x02, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x08, 0xE0, 0x18, 0x98, 0x30, 0x87, 0xC0, 0x01, 0xF0, 0x06, 0x0C,
  0x0C, 0x06, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x04, 0x80, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x60, 0x30,
  0x30, 0x60, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x01,
  0xF0, 0x83, 0x06, 0x43, 0x01, 0x41, 0x00, 0x61, 0x00, 0x10, 0x80, 0x08,
  0x80, 0x04, 0x40, 0x06, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x03, 0x04, 0x03, 0x03, 0x06, 0x80, 0xFC, 0x40, 0x01, 0xF8,
  0x06, 0x0C, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x7F, 0xFE, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x18, 0x30, 0x70, 0x0F, 0xC0, 0x00, 0xF8, 0x0C, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x03, 0xFE, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x40,
  0xC1, 0xA0, 0x60, 0x28, 0x10, 0x06, 0x08, 0x01, 0x86, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x04, 0x10, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x01, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x60, 0xC0, 0x30, 0x18, 0x34, 0x03, 0xF1, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x01, 0x00, 0xC0,
  0x30, 0x60, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x78, 0x09, 0x86, 0x1A, 0x02, 0x14, 0x03, 0x14, 0x01, 0x18, 0x01, 0x10,
  0x01, 0x10, 0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x20, 0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x04, 0xC0, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x06, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0x81,
  0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x04, 0x10, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x78, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x03, 0x08, 0x06, 0x10, 0x0C,
  0x10, 0x18, 0x10, 0x30, 0x10, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x23, 0x00,
  0x26, 0x00, 0x2A, 0x00, 0x33, 0x00, 0x21, 0x00, 0x21, 0x80, 0x40, 0x80,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x20, 0x40, 0x20, 0xC0, 0x10, 0x80, 0x10,
  0x80, 0x08, 0x02, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x02, 0x04, 0x08, 0x20, 0x00, 0x08, 0xF8, 0x0F, 0x81, 0x18, 0x61,
  0x86, 0x12, 0x02, 0x60, 0x21, 0x40, 0x24, 0x02, 0x18, 0x01, 0x80, 0x31,
  0x80, 0x10, 0x03, 0x30, 0x03, 0x00, 0x33, 0x00, 0x20, 0x02, 0x20, 0x02,
  0x00, 0x22, 0x00, 0x20, 0x02, 0x20, 0x02, 0x00, 0x22, 0x00, 0x20, 0x02,
  0x60, 0x02, 0x00, 0x24, 0x00, 0x40, 0x04, 0x40, 0x04, 0x00, 0x44, 0x00,
  0x40, 0x04, 0x40, 0x04, 0x00, 0x44, 0x00, 0x40, 0x04, 0xC0, 0x04, 0x00,
  0x48, 0x00, 0x80, 0x08, 0x80, 0x08, 0x00, 0x88, 0x00, 0x80, 0x08, 0x08,
  0x78, 0x09, 0x86, 0x12, 0x02, 0x14, 0x02, 0x14, 0x01, 0x18, 0x01, 0x10,
  0x01, 0x10, 0x03, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x60, 0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x04, 0xC0, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x03, 0xF0, 0x1C, 0x10, 0x60,
  0x10, 0x80, 0x32, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x09, 0x00, 0x32, 0x00, 0x42, 0x01, 0x06, 0x0C, 0x03, 0xF0,
  0x00, 0x04, 0x7C, 0x02, 0xC1, 0x82, 0xC0, 0x41, 0x80, 0x10, 0x80, 0x08,
  0x40, 0x04, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x02, 0x10, 0x01, 0x08, 0x01, 0x0A, 0x01, 0x84, 0xC1, 0x82, 0x1F, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE1, 0x0C, 0x1A, 0x18, 0x0A, 0x10,
  0x06, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x30, 0x60, 0xD0, 0x3F,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x08, 0xF0, 0x90, 0x12, 0x01, 0x40, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x03, 0xF0, 0x18, 0x30, 0x60, 0x10, 0x80, 0x22, 0x00, 0x64,
  0x00, 0xC8, 0x00, 0x08, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x42, 0x01, 0x86, 0x0C, 0x03, 0xF0, 0x00, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x41, 0xFE, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x18, 0x07, 0x80, 0x10, 0x01, 0x30, 0x03, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x18, 0x80, 0x18, 0xC0, 0x28, 0x40, 0x70, 0x60, 0x90, 0x3F, 0x10,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x13, 0x00, 0x44, 0x02,
  0x10, 0x08, 0x40, 0x41, 0x01, 0x04, 0x08, 0x18, 0x20, 0x21, 0x80, 0x84,
  0x02, 0x10, 0x08, 0x80, 0x22, 0x00, 0x90, 0x01, 0x40, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x00, 0xC0, 0x10, 0x03, 0x80, 0x20, 0x0D, 0x00, 0xC0, 0x12,
  0x01, 0xC0, 0x64, 0x04, 0x80, 0x88, 0x09, 0x01, 0x10, 0x32, 0x04, 0x20,
  0x44, 0x08, 0x40, 0x88, 0x30, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x10,
  0x42, 0x04, 0x20, 0x84, 0x08, 0xC1, 0x18, 0x11, 0x02, 0x20, 0x36, 0x02,
  0x40, 0x68, 0x05, 0x00, 0x50, 0x0A, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x81, 0x00, 0x60,
  0x40, 0x10, 0x08, 0x08, 0x02, 0x06, 0x00, 0xC1, 0x00, 0x10, 0x80, 0x04,
  0x40, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0xA0,
  0x00, 0x48, 0x00, 0x23, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x30, 0x60, 0x04, 0x10, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x40, 0x02, 0x04, 0x00, 0x40, 0x40, 0x04, 0x06, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x20, 0x10, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11,
  0x00, 0x01, 0x30, 0x00, 0x1A, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x86,
  0x10, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10,
  0x43, 0x0C, 0x20, 0x82, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x48, 0x40, 0x14, 0x08, 0x05, 0x03, 0x02, 0x80, 0x40, 0xA0,
  0x08, 0x48, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ThinItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 29, 7, 1, -29 },
  { 23, 7, 8, 10, 4, -31 },
  { 30, 20, 29, 19, 1, -29 },
  { 103, 17, 37, 19, 1, -33 },
  { 182, 19, 29, 26, 4, -29 },
  { 251, 18, 29, 21, 1, -29 },
  { 317, 3, 8, 7, 4, -31 },
  { 320, 11, 41, 11, 2, -32 },
  { 377, 11, 41, 11, -2, -32 },
  { 434, 16, 16, 17, 2, -29 },
  { 466, 16, 21, 20, 2, -24 },
  { 508, 4, 8, 7, -1, -3 },
  { 512, 8, 1, 11, 1, -14 },
  { 513, 2, 2, 9, 1, -2 },
  { 514, 16, 31, 14, -1, -29 },
  { 576, 16, 29, 19, 2, -29 },
  { 634, 8, 29, 19, 6, -29 },
  { 663, 17, 29, 19, 1, -29 },
  { 725, 17, 29, 19, 1, -29 },
  { 787, 17, 29, 19, 1, -29 },
  { 849, 17, 29, 19, 3, -29 },
  { 911, 15, 29, 19, 2, -29 },
  { 966, 16, 29, 19, 4, -29 },
  { 1024, 18, 29, 19, 1, -29 },
  { 1090, 15, 29, 19, 3, -29 },
  { 1145, 6, 21, 7, 0, -21 },
  { 1161, 7, 26, 7, -1, -21 },
  { 1184, 15, 16, 18, 2, -21 },
  { 1214, 16, 9, 20, 2, -18 },
  { 1232, 15, 16, 18, 1, -21 },
  { 1262, 12, 29, 16, 4, -29 },
  { 1306, 29, 37, 32, 1, -28 },
  { 1441, 19, 29, 21, -1, -29 },
  { 1510, 18, 29, 21, 2, -29 },
  { 1576, 20, 29, 23, 2, -29 },
  { 1649, 19, 29, 23, 2, -29 },
  { 1718, 19, 29, 20, 2, -29 },
  { 1787, 19, 29, 20, 2, -29 },
  { 1856, 19, 29, 24, 3, -29 },
  { 1925, 22, 29, 24, 2, -29 },
  { 2005, 6, 29, 10, 2, -29 },
  { 2027, 18, 29, 19, 1, -29 },
  { 2093, 21, 29, 22, 2, -29 },
  { 2170, 13, 29, 18, 2, -29 },
  { 2218, 27, 29, 30, 2, -29 },
  { 2316, 22, 29, 25, 2, -29 },
  { 2396, 20, 29, 23, 2, -29 },
  { 2469, 19, 29, 21, 2, -29 },
  { 2538, 20, 34, 23, 2, -29 },
  { 2623, 20, 29, 23, 1, -29 },
  { 2696, 20, 29, 21, 1, -29 },
  { 2769, 19, 29, 21, 4, -29 },
  { 2838, 21, 29, 23, 2, -29 },
  { 2915, 19, 29, 21, 4, -29 },
  { 2984, 29, 29, 31, 4, -29 },
  { 3090, 23, 29, 21, -1, -29 },
  { 3174, 19, 29, 21, 4, -29 },
  { 3243, 21, 29, 21, 0, -29 },
  { 3320, 11, 39, 8, 0, -33 },
  { 3374, 6, 32, 14, 4, -29 },
  { 3398, 11, 39, 8, -3, -33 },
  { 3452, 11, 15, 15, 2, -29 },
  { 3473, 14, 1, 15, -2, 0 },
  { 3475, 4, 5, 11, 6, -30 },
  { 3478, 16, 22, 19, 0, -22 },
  { 3522, 16, 31, 19, 1, -31 },
  { 3584, 16, 22, 18, 1, -22 },
  { 3628, 17, 31, 19, 2, -31 },
  { 3694, 16, 22, 18, 1, -22 },
  { 3738, 13, 31, 11, 2, -31 },
  { 3789, 18, 30, 19, 0, -22 },
  { 3857, 16, 31, 19, 1, -31 },
  { 3919, 7, 30, 8, 1, -30 },
  { 3946, 13, 38, 8, -5, -30 },
  { 4008, 16, 31, 17, 1, -31 },
  { 4070, 7, 31, 8, 1, -31 },
  { 4098, 28, 22, 31, 1, -22 },
  { 4175, 16, 22, 19, 1, -22 },
  { 4219, 15, 22, 19, 2, -22 },
  { 4261, 17, 30, 19, 0, -22 },
  { 4325, 16, 30, 19, 2, -22 },
  { 4385, 12, 22, 12, 1, -22 },
  { 4418, 15, 22, 18, 1, -22 },
  { 4460, 9, 28, 11, 2, -28 },
  { 4492, 16, 22, 19, 2, -22 },
  { 4536, 14, 22, 17, 3, -22 },
  { 4575, 23, 22, 26, 3, -22 },
  { 4639, 18, 22, 17, -1, -22 },
  { 4689, 20, 30, 17, -2, -22 },
  { 4764, 16, 22, 17, 0, -22 },
  { 4808, 13, 41, 12, 1, -32 },
  { 4875, 6, 34, 8, 1, -29 },
  { 4901, 13, 41, 12, -3, -32 },
  { 4968, 18, 7, 24, 3, -16 },
};

const GFXfont RobotoCondensed_ThinItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_THINITALIC41PT7B_H_
