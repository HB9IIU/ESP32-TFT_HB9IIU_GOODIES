#ifndef _ROBOTOCONDENSED_THINITALIC70PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x01, 0x80, 0x00,
  0x30, 0x66, 0x0C, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x61,
  0x98, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x82, 0x00, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x00, 0xC0, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x20, 0x01, 0x80, 0x0C, 0x30, 0x00, 0xC0, 0x0C,
  0x18, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0x20, 0x06, 0x06, 0x00, 0x10, 0x06,
  0x02, 0x00, 0x18, 0x06, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x80, 0x06, 0x03,
  0x00, 0x40, 0x06, 0x03, 0x00, 0x30, 0x03, 0x01, 0x80, 0x18, 0x03, 0x01,
  0x80, 0x0C, 0x03, 0x81, 0x80, 0x03, 0x03, 0x80, 0xC0, 0x00, 0xFF, 0x80,
  0xC0, 0x00, 0x3F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x00,
  0x18, 0x0F, 0xF8, 0x00, 0x18, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x02, 0x00, 0x30,
  0x06, 0x03, 0x00, 0x18, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x80, 0x06,
  0x03, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x60, 0x01, 0x83, 0x00, 0x30, 0x00,
  0xC1, 0x80, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x00,
  0x30, 0x80, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x18, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0xC3, 0x80, 0x30, 0x01, 0x86, 0x00, 0x60, 0x02, 0x18, 0x00,
  0x60, 0x0C, 0x60, 0x00, 0xC0, 0x18, 0xC0, 0x00, 0xC0, 0x33, 0x00, 0x01,
  0x80, 0xC6, 0x00, 0x01, 0x81, 0x8C, 0x00, 0x03, 0x86, 0x10, 0x00, 0x03,
  0x0C, 0x60, 0x00, 0x03, 0x38, 0xC0, 0x00, 0x06, 0x61, 0x80, 0x00, 0x07,
  0x83, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x3C,
  0x0C, 0x00, 0x00, 0xD8, 0x1C, 0x00, 0x03, 0x18, 0x1C, 0x00, 0x0C, 0x30,
  0x1C, 0x00, 0x70, 0x30, 0x1E, 0x03, 0x80, 0x60, 0x1F, 0xFE, 0x00, 0x60,
  0x03, 0xC0, 0x00, 0x00, 0x19, 0xCC, 0x63, 0x18, 0xCC, 0x63, 0x18, 0xCC,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x1F, 0xE0, 0x18, 0x0F, 0x1F, 0x02, 0x0F, 0x80, 0x7C, 0xCF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x38, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06,
  0x18, 0x30, 0xC3, 0x8E, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x33, 0xDC,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F,
  0xC1, 0xF3, 0x1E, 0x0F, 0xE0, 0x2C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x03, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x87, 0xF0, 0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x7E, 0x00, 0x60, 0xFF, 0xE0, 0x18, 0x70, 0x1E, 0x06,
  0x70, 0x01, 0x81, 0x30, 0x00, 0x30, 0xD8, 0x00, 0x0E, 0x3C, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x70, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x38, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0x90, 0x00, 0x01, 0x46, 0x00, 0x00, 0xF1, 0x80, 0x00,
  0x6C, 0x30, 0x00, 0x3B, 0x0C, 0x00, 0x1C, 0xC1, 0x80, 0x0E, 0x60, 0x38,
  0x0E, 0x18, 0x07, 0xFF, 0x06, 0x00, 0x7E, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0F, 0x03,
  0xC0, 0x40, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x70, 0x0C, 0x00, 0xC0, 0xC0, 0x07,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x02, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x04,
  0x01, 0x80, 0x01, 0xFF, 0x80, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x01,
  0x81, 0xC0, 0x01, 0x80, 0x38, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x30, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x8C, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x66, 0x00, 0x10, 0x00, 0x18, 0x00, 0x23, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x31, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x04, 0x00, 0x06,
  0x00, 0x0C, 0x40, 0x06, 0x00, 0x03, 0x00, 0x06, 0x60, 0x03, 0x00, 0x01,
  0x00, 0x02, 0x30, 0x01, 0x80, 0x01, 0x80, 0x03, 0x18, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x8C, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC4, 0x00, 0x60, 0x00,
  0x20, 0x00, 0xC2, 0x00, 0x30, 0x00, 0x30, 0x00, 0x61, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x21, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0xC0, 0x04, 0x00,
  0x0E, 0x00, 0x18, 0x60, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x30, 0x01, 0x80,
  0x0D, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0x04, 0xC0, 0x0C, 0x04, 0x00, 0x60,
  0x06, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x0E, 0x30, 0x0C, 0x01, 0x80, 0x0E,
  0x0E, 0x0E, 0x1C, 0x00, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x08, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x03, 0x80, 0x04, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x38, 0x03, 0x00,
  0x03, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0x30, 0x00, 0x07, 0x00, 0x40, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x02,
  0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xC3, 0x00, 0x07, 0xFF, 0xE1, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0x70, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00,
  0x40, 0xE0, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0xC3, 0xC0, 0x00,
  0x00, 0x0C, 0x76, 0x00, 0x00, 0x00, 0xCE, 0x70, 0x00, 0x00, 0x09, 0xC3,
  0x00, 0x00, 0x00, 0xB0, 0x38, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x05, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1B, 0x00,
  0x00, 0x00, 0x02, 0xC0, 0x36, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x6C, 0x00,
  0x00, 0x00, 0x13, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x6C, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x98, 0x02, 0x20, 0x00, 0x00, 0x03, 0x30, 0x0C, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x31, 0x80, 0x00,
  0x00, 0x61, 0x80, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0xC2, 0x00, 0x00,
  0x03, 0x0C, 0x01, 0x06, 0x00, 0x00, 0x06, 0x18, 0x06, 0x0C, 0x00, 0x00,
  0x18, 0x30, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x18, 0x30, 0x00, 0x00,
  0xC0, 0x80, 0x30, 0x20, 0x00, 0x01, 0x83, 0x00, 0x60, 0x40, 0x00, 0x06,
  0x06, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x06, 0x03, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0x40, 0x18, 0x04, 0x00, 0x02, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x40, 0x18, 0x00, 0x30, 0x06, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x06, 0x00, 0x40, 0x03, 0x00, 0x20,
  0x0C, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x20, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x08, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x10, 0x18, 0x00, 0x60, 0x08, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0x86, 0x00, 0x06, 0x01, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x30, 0x00, 0x30, 0x04, 0x00, 0x06, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0D, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x1C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x06, 0x01,
  0xB0, 0x00, 0x00, 0x18, 0x06, 0xC0, 0x00, 0x00, 0x60, 0x19, 0x80, 0x00,
  0x01, 0x80, 0x66, 0x00, 0x00, 0x06, 0x01, 0x88, 0x00, 0x00, 0x10, 0x06,
  0x30, 0x00, 0x00, 0xC0, 0x30, 0xC0, 0x00, 0x03, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x03, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x08, 0x00, 0x00, 0xC0, 0x30,
  0x30, 0x00, 0x02, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x06, 0x01, 0x00, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x18,
  0x02, 0x00, 0x06, 0x00, 0x60, 0x18, 0x00, 0x18, 0x01, 0x80, 0x60, 0x00,
  0x20, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x00,
  0x20, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x30, 0x00, 0x03, 0x03, 0x00,
  0xC0, 0x00, 0x06, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x60, 0x18, 0x00, 0x00,
  0x21, 0x80, 0x60, 0x00, 0x00, 0xC6, 0x01, 0x80, 0x00, 0x03, 0x18, 0x06,
  0x00, 0x00, 0x06, 0x60, 0x18, 0x00, 0x00, 0x1B, 0x80, 0x60, 0x00, 0x00,
  0x2C, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x10, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x01, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x20, 0x00,
  0x1E, 0x00, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x08, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x10,
  0x00, 0x06, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x04, 0x00, 0x03, 0x03, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x40, 0x60, 0x00, 0x40, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x00, 0x08, 0x01, 0x00, 0x0C,
  0x01, 0x80, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x02, 0x00, 0x10, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x20, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x10, 0x00, 0x18, 0x18, 0x00, 0x08,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x11, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x38, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x30,
  0x06, 0x0C, 0x03, 0x01, 0x00, 0xC0, 0x40, 0x60, 0x18, 0x18, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x02, 0x30, 0x00, 0xCC, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x06, 0x06, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x1C, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0xF0, 0xC0, 0x00,
  0x36, 0x08, 0x00, 0x0C, 0xC1, 0x80, 0x03, 0x18, 0x38, 0x01, 0xC3, 0x03,
  0xC0, 0xF0, 0xE0, 0x3F, 0xF8, 0x1C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x07, 0x80, 0x03, 0x07, 0xFE, 0x00, 0x63, 0xC0, 0xE0, 0x08,
  0xC0, 0x06, 0x01, 0x30, 0x00, 0x60, 0x6C, 0x00, 0x0C, 0x0F, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x60, 0x50, 0x00, 0x0C, 0x1B, 0x00, 0x03, 0x03, 0x38,
  0x01, 0xC0, 0x63, 0xC0, 0xF0, 0x0C, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x80, 0xE0, 0x03,
  0x80, 0x1C, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x1C,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x03,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x08, 0x00, 0x3F, 0xF0, 0x60,
  0x03, 0xC0, 0xE1, 0x80, 0x1C, 0x00, 0xC6, 0x00, 0xE0, 0x01, 0x98, 0x07,
  0x00, 0x03, 0x60, 0x18, 0x00, 0x05, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x07, 0x00, 0x60, 0x00, 0x3C, 0x01,
  0x80, 0x01, 0xB0, 0x03, 0x00, 0x1C, 0x80, 0x07, 0x01, 0xC6, 0x00, 0x0F,
  0xFE, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x03, 0x80,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0xC0, 0x0F, 0x03, 0x86, 0x00,
  0xE0, 0x06, 0x30, 0x0C, 0x00, 0x19, 0x80, 0xC0, 0x00, 0x6C, 0x06, 0x00,
  0x01, 0x40, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x78, 0x07, 0x00, 0x06, 0xC0, 0x18, 0x00, 0xE4, 0x00, 0x70,
  0x1C, 0x60, 0x01, 0xFF, 0xC3, 0x00, 0x01, 0xF0, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x03, 0xC0, 0x03, 0x03, 0xFE, 0x00, 0x61, 0xC0, 0x60, 0x0C, 0x60,
  0x06, 0x01, 0x18, 0x00, 0x60, 0x66, 0x00, 0x0C, 0x0D, 0x80, 0x01, 0x81,
  0xA0, 0x00, 0x10, 0x3C, 0x00, 0x02, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x08, 0x38, 0x00, 0x01, 0x07, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x20, 0x00, 0x70,
  0x06, 0x00, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x60,
  0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x40, 0x1C, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x9B, 0x00,
  0x00, 0x1B, 0x30, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x07,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x20, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x06, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0C, 0x38, 0x1C,
  0x03, 0xC0, 0xE0, 0x30, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x63, 0x00, 0x18,
  0x30, 0x00, 0xC0, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x81, 0xB0, 0x00, 0x33,
  0x00, 0x01, 0x83, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x07, 0x00, 0x00, 0x50,
  0x00, 0x06, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x78, 0x00, 0x60, 0x7F, 0xC0,
  0x0C, 0x38, 0x1C, 0x01, 0x8C, 0x00, 0xC0, 0x23, 0x00, 0x0C, 0x0C, 0xC0,
  0x01, 0x81, 0xB0, 0x00, 0x30, 0x34, 0x00, 0x06, 0x07, 0x80, 0x00, 0x40,
  0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x07, 0x00, 0x00, 0x20, 0xE0, 0x00,
  0x04, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x08,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x81, 0xE0,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x01, 0x83, 0xFF, 0x00, 0x06, 0x3C, 0x0E, 0x00, 0x19, 0xC0, 0x0C,
  0x00, 0x4C, 0x00, 0x18, 0x03, 0x60, 0x00, 0x60, 0x0F, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x01,
  0x80, 0x28, 0x00, 0x06, 0x01, 0xB0, 0x00, 0x30, 0x06, 0x70, 0x03, 0x80,
  0x18, 0xF0, 0x3C, 0x00, 0x60, 0xFF, 0xE0, 0x01, 0x00, 0x7C, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x04, 0x03, 0xC0, 0xE1, 0x80, 0xE0,
  0x07, 0x30, 0x30, 0x00, 0x66, 0x0E, 0x00, 0x06, 0x81, 0x80, 0x00, 0x50,
  0x60, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x01, 0xA0, 0x18, 0x00,
  0xE4, 0x01, 0xC0, 0xF1, 0x80, 0x1F, 0xFC, 0x30, 0x00, 0x78, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x30,
  0x7F, 0x03, 0x1C, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x6C, 0x00, 0x06,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0x81, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x10, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x83, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0xD8, 0x18, 0x00, 0x66, 0x07, 0x00,
  0x31, 0x00, 0xE0, 0x38, 0xC0, 0x1F, 0xF8, 0x30, 0x01, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x04, 0x00, 0x18, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x20, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0xC0, 0x00, 0x76, 0x00, 0x02, 0x80, 0x00, 0xCC, 0x00, 0x0D, 0x00,
  0x01, 0x98, 0x00, 0x1A, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x60,
  0x00, 0xCC, 0x00, 0x38, 0xC0, 0x01, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x04,
  0x00, 0x61, 0x80, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x18, 0x03, 0x06,
  0x00, 0xE0, 0x30, 0x0C, 0x04, 0x01, 0x80, 0x60, 0x18, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80,
  0x60, 0x70, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x18, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x00, 0x86, 0x00, 0x10, 0xC0,
  0x01, 0x18, 0x00, 0x23, 0x00, 0x03, 0x30, 0x00, 0x46, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x1A, 0x00, 0x03, 0x60,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x0C, 0x0E,
  0x00, 0x03, 0x18, 0x07, 0x00, 0x03, 0x30, 0x03, 0x80, 0x02, 0x30, 0x01,
  0xC0, 0x06, 0x60, 0x00, 0xC0, 0x04, 0x60, 0x00, 0x60, 0x0C, 0x40, 0x00,
  0x38, 0x38, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 51, 13, 1, -50 },
  { 72, 11, 14, 18, 8, -53 },
  { 92, 35, 50, 33, 1, -50 },
  { 311, 28, 64, 33, 3, -57 },
  { 535, 33, 52, 44, 6, -51 },
  { 750, 31, 52, 36, 2, -51 },
  { 952, 5, 14, 11, 7, -53 },
  { 961, 19, 71, 19, 3, -55 },
  { 1130, 19, 71, 19, -4, -55 },
  { 1299, 27, 27, 28, 4, -50 },
  { 1391, 28, 36, 34, 3, -41 },
  { 1517, 7, 14, 13, -2, -5 },
  { 1530, 13, 2, 18, 3, -24 },
  { 1534, 5, 4, 15, 1, -3 },
  { 1537, 29, 54, 23, -3, -50 },
  { 1733, 28, 52, 33, 3, -51 },
  { 1915, 14, 50, 33, 10, -50 },
  { 2003, 29, 51, 33, 2, -51 },
  { 2188, 29, 52, 33, 2, -51 },
  { 2377, 29, 50, 33, 2, -50 },
  { 2559, 30, 51, 33, 4, -50 },
  { 2751, 26, 51, 33, 3, -50 },
  { 2917, 28, 50, 33, 6, -50 },
  { 3092, 31, 52, 33, 1, -51 },
  { 3294, 26, 51, 33, 5, -51 },
  { 3460, 10, 37, 12, 1, -36 },
  { 3507, 13, 45, 12, -2, -36 },
  { 3581, 26, 28, 31, 3, -37 },
  { 3672, 26, 16, 33, 4, -31 },
  { 3724, 26, 28, 31, 2, -37 },
  { 3815, 21, 52, 26, 6, -51 },
  { 3952, 49, 63, 55, 2, -48 },
  { 4338, 33, 50, 36, -2, -50 },
  { 4545, 31, 50, 36, 3, -50 },
  { 4739, 33, 52, 39, 4, -51 },
  { 4954, 34, 50, 39, 3, -50 },
  { 5167, 33, 50, 34, 3, -50 },
  { 5374, 34, 50, 34, 3, -50 },
  { 5587, 33, 52, 41, 5, -51 },
  { 5802, 38, 50, 42, 3, -50 },
  { 6040, 10, 50, 16, 4, -50 },
  { 6103, 31, 51, 33, 1, -50 },
  { 6301, 36, 50, 38, 3, -50 },
  { 6526, 23, 50, 31, 3, -50 },
  { 6670, 47, 50, 51, 3, -50 },
  { 6964, 38, 50, 42, 3, -50 },
  { 7202, 34, 52, 40, 4, -51 },
  { 7423, 33, 50, 36, 3, -50 },
  { 7630, 34, 60, 40, 4, -51 },
  { 7885, 33, 50, 39, 3, -50 },
  { 8092, 33, 52, 35, 2, -51 },
  { 8307, 32, 50, 36, 7, -50 },
  { 8507, 35, 51, 40, 4, -50 },
  { 8731, 33, 50, 36, 6, -50 },
  { 8938, 49, 50, 53, 7, -50 },
  { 9245, 39, 50, 36, -1, -50 },
  { 9489, 32, 50, 36, 7, -50 },
  { 9689, 37, 50, 36, 0, -50 },
  { 9921, 18, 68, 14, 1, -57 },
  { 10074, 10, 54, 23, 7, -50 },
  { 10142, 18, 68, 14, -4, -57 },
  { 10295, 18, 25, 25, 4, -50 },
  { 10352, 24, 2, 25, -3, 0 },
  { 10358, 7, 9, 18, 10, -52 },
  { 10366, 27, 39, 32, 1, -38 },
  { 10498, 27, 54, 33, 2, -53 },
  { 10681, 26, 39, 31, 2, -38 },
  { 10808, 30, 54, 33, 3, -53 },
  { 11011, 26, 39, 31, 2, -38 },
  { 11138, 21, 54, 20, 4, -54 },
  { 11280, 29, 52, 33, 1, -38 },
  { 11469, 27, 53, 33, 2, -53 },
  { 11648, 11, 51, 13, 2, -51 },
  { 11719, 23, 65, 14, -9, -51 },
  { 11906, 28, 53, 29, 2, -53 },
  { 12092, 11, 53, 13, 2, -53 },
  { 12165, 47, 38, 53, 2, -38 },
  { 12389, 27, 38, 33, 2, -38 },
  { 12518, 26, 39, 33, 3, -38 },
  { 12645, 30, 52, 33, -1, -38 },
  { 12840, 27, 52, 33, 3, -38 },
  { 13016, 20, 38, 21, 2, -38 },
  { 13111, 26, 39, 30, 1, -38 },
  { 13238, 15, 48, 20, 4, -47 },
  { 13328, 26, 38, 33, 4, -37 },
  { 13452, 26, 37, 29, 4, -37 },
  { 13573, 39, 37, 45, 6, -37 },
  { 13754, 30, 37, 29, -1, -37 },
  { 13893, 33, 51, 29, -3, -37 },
  { 14104, 29, 37, 29, -1, -37 },
  { 14239, 22, 70, 20, 2, -55 },
  { 14432, 12, 59, 14, 1, -50 },
  { 14521, 22, 70, 20, -5, -55 },
  { 14714, 32, 11, 41, 4, -26 },
};

const GFXfont RobotoCondensed_ThinItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_THINITALIC70PT7B_H_
