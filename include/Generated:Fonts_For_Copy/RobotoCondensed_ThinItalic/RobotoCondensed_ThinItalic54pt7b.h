#ifndef _ROBOTOCONDENSED_THINITALIC54PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x21, 0x10, 0x98, 0x4C, 0x66, 0x32, 0x19, 0x08,
  0x84, 0xC2, 0x63, 0x21, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x30,
  0x00, 0x08, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x08,
  0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40, 0x30, 0x00, 0x08, 0x04, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x40, 0x30, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x08, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x08, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x08,
  0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x30, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x04, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x08, 0x04, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x18, 0x1C,
  0x01, 0xC0, 0x18, 0x04, 0x00, 0x60, 0x30, 0x00, 0x81, 0x80, 0x03, 0x04,
  0x00, 0x04, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00,
  0x04, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x23, 0x00, 0x00, 0x88,
  0x00, 0x02, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x84, 0x00,
  0x04, 0x10, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0x80, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x06, 0x08, 0x00, 0x02, 0x06, 0x00, 0x02, 0x01, 0x00, 0x03,
  0x00, 0x80, 0x11, 0x00, 0x60, 0x18, 0x80, 0x30, 0x08, 0x40, 0x10, 0x08,
  0x60, 0x08, 0x0C, 0x30, 0x04, 0x0C, 0x10, 0x02, 0x04, 0x08, 0x03, 0x06,
  0x06, 0x01, 0x06, 0x03, 0x01, 0x82, 0x00, 0x81, 0x83, 0x00, 0x61, 0x83,
  0x00, 0x1F, 0x81, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0xC1, 0xF8, 0x00, 0xC1, 0x86, 0x00,
  0x41, 0x81, 0x80, 0x60, 0x80, 0x40, 0x60, 0xC0, 0x20, 0x20, 0x40, 0x10,
  0x20, 0x60, 0x08, 0x30, 0x30, 0x04, 0x10, 0x10, 0x02, 0x10, 0x08, 0x03,
  0x18, 0x04, 0x01, 0x98, 0x02, 0x00, 0x88, 0x01, 0x00, 0xC0, 0x00, 0x80,
  0x40, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x10, 0x00, 0x80,
  0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x30, 0x01, 0x80, 0x20, 0x01, 0x80,
  0x60, 0x01, 0x80, 0xC0, 0x00, 0x81, 0x80, 0x00, 0x83, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x10, 0x00, 0x02, 0x18, 0x00, 0x04, 0x0C, 0x01, 0x0C, 0x04,
  0x01, 0x18, 0x06, 0x03, 0x10, 0x02, 0x03, 0x30, 0x03, 0x02, 0x20, 0x01,
  0x06, 0x60, 0x01, 0x86, 0x40, 0x00, 0xCC, 0x40, 0x00, 0x4C, 0x40, 0x00,
  0x78, 0x40, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x78, 0x30, 0x00,
  0xD8, 0x30, 0x01, 0x0C, 0x1C, 0x06, 0x04, 0x07, 0xF8, 0x06, 0x00, 0x80,
  0x00, 0x6D, 0xB4, 0xB6, 0xD2, 0x00, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x08, 0x06, 0x07, 0x78, 0x20, 0xF0, 0xF1, 0x3C, 0x00, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0x60, 0x00,
  0xC1, 0x00, 0x04, 0x0C, 0x00, 0x60, 0x20, 0x06, 0x01, 0x80, 0x60, 0x06,
  0x02, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xCC,
  0x66, 0x20, 0xFF, 0xC0, 0xFD, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x03, 0xFC, 0x00, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x03,
  0x03, 0x00, 0x08, 0x10, 0x00, 0x41, 0x80, 0x03, 0x08, 0x00, 0x18, 0xC0,
  0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x0C,
  0x80, 0x00, 0x64, 0x00, 0x03, 0x60, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00,
  0x04, 0x80, 0x00, 0x64, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x98,
  0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x00,
  0x88, 0x00, 0x0C, 0x40, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80,
  0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80, 0x0C, 0x06, 0x00, 0xC0,
  0x18, 0x1C, 0x00, 0x7F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x30, 0x0F, 0x07,
  0x21, 0xC2, 0x70, 0x28, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0x80, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x60, 0x01, 0x80, 0x80,
  0x01, 0x03, 0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00, 0x08, 0x30, 0x00,
  0x10, 0x40, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x0E, 0x07, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18,
  0x18, 0x00, 0x20, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20,
  0x00, 0x31, 0x80, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x04, 0x00, 0x08, 0x18, 0x00,
  0x60, 0x30, 0x03, 0x00, 0x60, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0x88, 0x00,
  0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x41, 0x80, 0x01,
  0x83, 0x00, 0x06, 0x04, 0x00, 0x08, 0x08, 0x00, 0x30, 0x10, 0x00, 0xC0,
  0x60, 0x03, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x18, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x08, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x80,
  0x40, 0x01, 0x01, 0x80, 0x02, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x1F, 0x80, 0x05, 0xE3, 0x80,
  0x1E, 0x01, 0x80, 0x30, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x00,
  0x80, 0xC0, 0x03, 0x00, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x83, 0xF0, 0x10, 0xE3, 0x81, 0x30, 0x0C, 0x36,
  0x00, 0x63, 0xC0, 0x02, 0x38, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x16,
  0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01,
  0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x66, 0x00, 0x04, 0x60, 0x00, 0xC2, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80,
  0x30, 0x0C, 0x0E, 0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0x38, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x04, 0x01, 0x00, 0x06, 0x03, 0x00, 0x02, 0x02, 0x00,
  0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x30, 0x01, 0x80, 0x60, 0x00, 0xE3, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0x81, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00,
  0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x60, 0x00, 0x60, 0x20, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x03, 0x81, 0x80, 0x60, 0x0C, 0x0C,
  0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x36,
  0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x0E, 0x40, 0x01, 0xE6, 0x00, 0x34, 0x60, 0x06, 0x43, 0x00,
  0xCC, 0x1E, 0x78, 0xC0, 0x7E, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x08,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF8, 0x0C,
  0x0C, 0x18, 0x06, 0x30, 0x02, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03, 0xC0,
  0x03, 0x80, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x04, 0x00, 0x3E, 0x00, 0x10, 0x60,
  0x03, 0x9C, 0x00, 0x82, 0x00, 0x60, 0x30, 0x04, 0x30, 0x06, 0x00, 0x80,
  0x21, 0x00, 0x20, 0x0C, 0x01, 0x18, 0x02, 0x00, 0x60, 0x08, 0x80, 0x30,
  0x02, 0x00, 0x4C, 0x01, 0x00, 0x10, 0x02, 0x60, 0x18, 0x01, 0x80, 0x12,
  0x00, 0x80, 0x0C, 0x00, 0xB0, 0x0C, 0x00, 0x40, 0x0D, 0x80, 0x60, 0x02,
  0x00, 0x68, 0x02, 0x00, 0x10, 0x02, 0x40, 0x30, 0x01, 0x80, 0x16, 0x01,
  0x80, 0x08, 0x00, 0xB0, 0x08, 0x00, 0x40, 0x0D, 0x80, 0x40, 0x02, 0x00,
  0x48, 0x02, 0x00, 0x30, 0x02, 0x40, 0x10, 0x01, 0x00, 0x32, 0x01, 0x80,
  0x18, 0x01, 0x10, 0x0C, 0x00, 0xC0, 0x18, 0x80, 0x60, 0x0A, 0x00, 0x84,
  0x01, 0x00, 0xD0, 0x0C, 0x20, 0x08, 0x0C, 0xC0, 0xC1, 0x80, 0x60, 0xC2,
  0x0C, 0x0C, 0x01, 0xF8, 0x1F, 0xC0, 0x60, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x18, 0x10, 0x00, 0x04, 0x04, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x00,
  0x80, 0x02, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x00, 0x80, 0x08, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x40, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x04, 0x06, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x60,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xE0, 0x03, 0x00, 0x78,
  0x03, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x02, 0x00, 0x02, 0x02, 0x00, 0x03,
  0x02, 0x00, 0x03, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x04, 0x00, 0x03,
  0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x0C, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x08, 0x00, 0x70, 0x08, 0x03, 0xC0,
  0x1F, 0xFF, 0xC0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x10, 0x00, 0x18,
  0x10, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x30, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30,
  0x40, 0x00, 0x60, 0x40, 0x01, 0xC0, 0xC0, 0x0F, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x18, 0x10,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08,
  0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x18,
  0x00, 0x04, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xC0, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x02,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x20, 0x00, 0x08, 0x18, 0x00, 0x02,
  0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x20,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08,
  0x60, 0x00, 0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x40, 0x00, 0x30, 0x10, 0x00, 0x18,
  0x04, 0x00, 0x0C, 0x01, 0x00, 0x0E, 0x00, 0xC0, 0x3E, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x10,
  0x00, 0x30, 0x10, 0x00, 0x08, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xF9, 0x80, 0x00,
  0x04, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x18, 0x00, 0x06, 0x04,
  0x00, 0x06, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x07, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0x00, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x00, 0x03, 0x03, 0x02,
  0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0,
  0x01, 0x80, 0x40, 0x01, 0x00, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x38,
  0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x02, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x40,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x08, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x18,
  0xB0, 0x00, 0x01, 0x91, 0x00, 0x00, 0x12, 0x18, 0x00, 0x01, 0x40, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x20, 0x01, 0x00, 0x02, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x04, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x28, 0x00, 0x00, 0x0F, 0x02, 0x80, 0x00, 0x00, 0xB0, 0x2C, 0x00,
  0x00, 0x1A, 0x02, 0xC0, 0x00, 0x01, 0x20, 0x64, 0x00, 0x00, 0x32, 0x06,
  0x40, 0x00, 0x02, 0x60, 0x44, 0x00, 0x00, 0x66, 0x04, 0x60, 0x00, 0x04,
  0x40, 0x46, 0x00, 0x00, 0xC4, 0x04, 0x20, 0x00, 0x08, 0x40, 0xC2, 0x00,
  0x01, 0x04, 0x0C, 0x20, 0x00, 0x30, 0xC0, 0x82, 0x00, 0x02, 0x0C, 0x08,
  0x30, 0x00, 0x60, 0x80, 0x83, 0x00, 0x04, 0x08, 0x18, 0x10, 0x00, 0xC0,
  0x81, 0x81, 0x00, 0x08, 0x18, 0x10, 0x10, 0x01, 0x81, 0x81, 0x01, 0x80,
  0x10, 0x18, 0x10, 0x18, 0x03, 0x01, 0x01, 0x00, 0x80, 0x20, 0x10, 0x30,
  0x08, 0x06, 0x01, 0x03, 0x00, 0x80, 0x40, 0x30, 0x20, 0x08, 0x0C, 0x03,
  0x02, 0x00, 0xC1, 0x80, 0x30, 0x20, 0x04, 0x10, 0x02, 0x02, 0x00, 0x43,
  0x00, 0x20, 0x60, 0x04, 0x20, 0x02, 0x06, 0x00, 0x46, 0x00, 0x60, 0x40,
  0x06, 0x40, 0x06, 0x04, 0x00, 0x6C, 0x00, 0x40, 0x40, 0x02, 0x80, 0x04,
  0x04, 0x00, 0x38, 0x00, 0x40, 0xC0, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x08, 0x0E, 0x00, 0x00, 0x20, 0x38, 0x00,
  0x00, 0x80, 0xE0, 0x00, 0x02, 0x02, 0xC0, 0x00, 0x18, 0x09, 0x00, 0x00,
  0x60, 0x26, 0x00, 0x01, 0x01, 0x88, 0x00, 0x04, 0x06, 0x20, 0x00, 0x10,
  0x18, 0xC0, 0x00, 0xC0, 0x41, 0x00, 0x03, 0x01, 0x06, 0x00, 0x0C, 0x0C,
  0x08, 0x00, 0x20, 0x30, 0x20, 0x00, 0x80, 0xC0, 0xC0, 0x02, 0x02, 0x01,
  0x00, 0x18, 0x08, 0x06, 0x00, 0x60, 0x20, 0x08, 0x01, 0x81, 0x80, 0x20,
  0x04, 0x06, 0x00, 0xC0, 0x10, 0x18, 0x01, 0x00, 0x40, 0x40, 0x06, 0x03,
  0x01, 0x00, 0x08, 0x0C, 0x04, 0x00, 0x20, 0x30, 0x30, 0x00, 0xC0, 0x80,
  0xC0, 0x01, 0x02, 0x03, 0x00, 0x04, 0x18, 0x08, 0x00, 0x18, 0x60, 0x20,
  0x00, 0x21, 0x80, 0x80, 0x00, 0xC4, 0x06, 0x00, 0x01, 0x10, 0x18, 0x00,
  0x04, 0x40, 0x40, 0x00, 0x1B, 0x01, 0x00, 0x00, 0x2C, 0x04, 0x00, 0x00,
  0xF0, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x40, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08,
  0x10, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x00, 0x60, 0x08, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x20, 0x00, 0x18, 0x18, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10,
  0x00, 0x02, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10,
  0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x02, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x40, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x06, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x18, 0x10, 0x00, 0x04, 0x06, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xC0, 0x0F, 0x00, 0x30, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x60, 0x60, 0x00, 0x08, 0x18, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20, 0x00,
  0x0C, 0x08, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x10, 0x01, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x0C,
  0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x02, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x10, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x20, 0x20, 0x00, 0x08,
  0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x30,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x03, 0x80, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x04, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x18, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x10, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x02,
  0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0x80, 0x01, 0x00, 0x60, 0x01, 0x80,
  0x30, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x60,
  0x01, 0x00, 0x20, 0x00, 0x80, 0x30, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08,
  0x00, 0x08, 0x0C, 0x00, 0x04, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x2C, 0x00, 0x07, 0x00, 0x01, 0x90,
  0x00, 0x14, 0x00, 0x06, 0x40, 0x00, 0x50, 0x00, 0x11, 0x00, 0x02, 0x40,
  0x00, 0xC4, 0x00, 0x09, 0x00, 0x02, 0x10, 0x00, 0x66, 0x00, 0x08, 0x40,
  0x01, 0x18, 0x00, 0x61, 0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80,
  0x0C, 0x18, 0x00, 0x82, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0x81, 0x80,
  0x10, 0x20, 0x06, 0x06, 0x00, 0xC0, 0x80, 0x10, 0x18, 0x02, 0x02, 0x00,
  0x40, 0x60, 0x08, 0x08, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x02, 0x01,
  0x00, 0xC0, 0x60, 0x08, 0x0C, 0x03, 0x01, 0x80, 0x20, 0x20, 0x0C, 0x04,
  0x00, 0x80, 0x80, 0x10, 0x30, 0x02, 0x06, 0x00, 0x40, 0x80, 0x08, 0x10,
  0x01, 0x02, 0x00, 0x20, 0xC0, 0x04, 0x18, 0x00, 0x82, 0x00, 0x10, 0x40,
  0x03, 0x18, 0x00, 0x43, 0x00, 0x0C, 0x60, 0x01, 0x08, 0x00, 0x31, 0x00,
  0x06, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x64, 0x00,
  0x0C, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x18, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x60, 0x10, 0x00,
  0x20, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0xC0,
  0x18, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x3F, 0x00, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x40,
  0x81, 0x83, 0x06, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x02, 0x04,
  0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20,
  0x40, 0xC1, 0x83, 0x02, 0x00, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x3F, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x0E, 0x00, 0x2C, 0x01, 0x90, 0x04, 0x40, 0x31, 0x00,
  0x84, 0x06, 0x18, 0x10, 0x60, 0xC1, 0x82, 0x02, 0x18, 0x08, 0x40, 0x23,
  0x00, 0xC8, 0x03, 0x60, 0x0D, 0x00, 0x1C, 0x00, 0x40, 0x7F, 0xFF, 0xE0,
  0x61, 0x83, 0x04, 0x18, 0x20, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01,
  0xC0, 0xE0, 0x30, 0x02, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x11,
  0x80, 0x01, 0x10, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xE0, 0x7E, 0x02, 0x0C, 0x00,
  0x63, 0x80, 0x06, 0x30, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00,
  0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x38, 0xC0,
  0x06, 0x84, 0x00, 0xC8, 0x60, 0x38, 0x83, 0xFE, 0x08, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x80, 0x06, 0x3F, 0xE0,
  0x11, 0x81, 0xC0, 0x48, 0x01, 0x01, 0x40, 0x06, 0x06, 0x00, 0x08, 0x30,
  0x00, 0x20, 0xC0, 0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x30, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x21,
  0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80, 0x00, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x40, 0x02, 0x05, 0x80, 0x18, 0x13,
  0x81, 0xC0, 0xC3, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0x81, 0xC0, 0x60, 0x04, 0x0C, 0x00, 0x61, 0x80, 0x02, 0x10,
  0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00,
  0x10, 0x40, 0x02, 0x06, 0x00, 0x60, 0x38, 0x1C, 0x01, 0xFF, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0x08, 0x03, 0x81, 0x88, 0x06, 0x00, 0x48, 0x0C,
  0x00, 0x78, 0x08, 0x00, 0x38, 0x18, 0x00, 0x38, 0x10, 0x00, 0x10, 0x30,
  0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60,
  0x00, 0x20, 0x60, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x40, 0xC0,
  0x00, 0x40, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x40,
  0x00, 0x80, 0x40, 0x01, 0x80, 0x60, 0x03, 0x80, 0x20, 0x06, 0x80, 0x30,
  0x19, 0x80, 0x1F, 0xF1, 0x80, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03,
  0xFC, 0x00, 0x70, 0x38, 0x06, 0x00, 0x40, 0x60, 0x03, 0x02, 0x00, 0x08,
  0x30, 0x00, 0x43, 0x00, 0x03, 0x10, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x40, 0x00, 0x32, 0x00, 0x01, 0x3F, 0xFF, 0xF9, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x30, 0x03, 0x01, 0xC0, 0x70,
  0x03, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x7F, 0xF8, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x84,
  0x03, 0x81, 0x88, 0x0C, 0x01, 0x90, 0x30, 0x01, 0xE0, 0x40, 0x01, 0xC1,
  0x80, 0x03, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x20,
  0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00,
  0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x41, 0x80, 0x00, 0x83, 0x00, 0x01, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x60, 0x03, 0x80,
  0x40, 0x0D, 0x00, 0xC0, 0x66, 0x00, 0xFF, 0x8C, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x0E, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x61, 0xFE, 0x03, 0x18, 0x18, 0x13, 0x00, 0x40, 0x90, 0x03, 0x05, 0x00,
  0x18, 0x78, 0x00, 0x43, 0x80, 0x02, 0x18, 0x00, 0x10, 0xC0, 0x00, 0x84,
  0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x10, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x18,
  0xC0, 0x00, 0x86, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00,
  0x18, 0xC0, 0x00, 0xC0, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60,
  0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x4E, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x40, 0x06, 0x01, 0x00, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0,
  0x60, 0x02, 0x03, 0x00, 0x08, 0x18, 0x00, 0x20, 0xC0, 0x00, 0x86, 0x00,
  0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x4F, 0x00, 0x01, 0x64, 0x00, 0x06,
  0x18, 0x00, 0x10, 0x20, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x00, 0x08, 0x06,
  0x00, 0x20, 0x08, 0x00, 0x80, 0x30, 0x02, 0x00, 0x40, 0x18, 0x01, 0x80,
  0x60, 0x02, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x10, 0x00, 0x60, 0xC0,
  0x00, 0x80, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x20, 0xFE, 0x01, 0xFE, 0x01, 0x18, 0x18, 0x18, 0x18, 0x09, 0x80, 0x61,
  0x80, 0x60, 0xD8, 0x01, 0x10, 0x01, 0x06, 0x80, 0x0D, 0x00, 0x08, 0x38,
  0x00, 0x78, 0x00, 0x61, 0xC0, 0x03, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x60, 0x00, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x06, 0x30, 0x00,
  0x30, 0x00, 0x21, 0x80, 0x01, 0x00, 0x01, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x40, 0x00, 0xC2, 0x00, 0x06, 0x00, 0x06, 0x30, 0x00, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x40,
  0x00, 0x40, 0x00, 0x42, 0x00, 0x02, 0x00, 0x06, 0x10, 0x00, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x00, 0x08, 0x60, 0x00,
  0x40, 0x00, 0x42, 0x00, 0x02, 0x00, 0x02, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x80, 0x01, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0xFF, 0x01, 0x0C, 0x0C, 0x09, 0x80,
  0x20, 0x48, 0x01, 0x82, 0x80, 0x0C, 0x3C, 0x00, 0x21, 0xC0, 0x01, 0x0C,
  0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x43, 0x00, 0x02, 0x10, 0x00,
  0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x60, 0x30, 0x0E, 0x00, 0xC0, 0x40, 0x03, 0x06, 0x00,
  0x18, 0x60, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00,
  0x48, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18,
  0x40, 0x00, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x81,
  0xC0, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0x8F,
  0xF0, 0x01, 0x18, 0x1C, 0x01, 0x20, 0x04, 0x01, 0x40, 0x06, 0x01, 0x80,
  0x02, 0x03, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00, 0x03, 0x02, 0x00,
  0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00,
  0x0C, 0x08, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00,
  0x30, 0x14, 0x00, 0x20, 0x16, 0x00, 0x40, 0x13, 0x81, 0x80, 0x30, 0xFF,
  0x00, 0x30, 0x10, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x40, 0xE0, 0x62, 0x0C, 0x01, 0x90, 0xC0, 0x07, 0x84,
  0x00, 0x1C, 0x60, 0x00, 0xC2, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00,
  0x88, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00,
  0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x11,
  0x80, 0x00, 0x8C, 0x00, 0x04, 0x60, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0x82, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0x40, 0x0F, 0x03,
  0x01, 0x98, 0x0F, 0xF8, 0xC0, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x06, 0x3F, 0x04, 0x60, 0x04, 0x80, 0x05, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x03, 0x81, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x20, 0x80,
  0x02, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x00,
  0x8C, 0x00, 0x18, 0x40, 0x03, 0x06, 0x00, 0x60, 0x38, 0x1C, 0x00, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x07, 0xFF, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x1F, 0x00, 0x80, 0x18, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x11, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x02, 0x30, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x04, 0x60, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x08, 0xC0, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x88,
  0x00, 0x18, 0x80, 0x01, 0x88, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0xD0,
  0x60, 0x1B, 0x07, 0x03, 0x30, 0x3F, 0xE3, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x34, 0x00, 0x02, 0x40, 0x00, 0x64, 0x00, 0x04, 0x60, 0x00, 0xC6, 0x00,
  0x08, 0x60, 0x01, 0x82, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x30,
  0x02, 0x03, 0x00, 0x60, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x10, 0x08, 0x01,
  0x01, 0x80, 0x10, 0x10, 0x01, 0x83, 0x00, 0x18, 0x20, 0x00, 0x86, 0x00,
  0x08, 0x40, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x00,
  0x00, 0xD0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x34, 0x00, 0x30, 0x00, 0x90, 0x01,
  0xC0, 0x06, 0x40, 0x05, 0x00, 0x19, 0x00, 0x36, 0x00, 0x44, 0x00, 0x98,
  0x03, 0x10, 0x06, 0x60, 0x08, 0x40, 0x19, 0x80, 0x61, 0x80, 0x46, 0x01,
  0x86, 0x03, 0x08, 0x0C, 0x18, 0x08, 0x20, 0x30, 0x60, 0x60, 0x80, 0x81,
  0x81, 0x02, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x20, 0xC0, 0x20,
  0x80, 0x83, 0x00, 0x86, 0x03, 0x08, 0x02, 0x10, 0x0C, 0x60, 0x08, 0xC0,
  0x31, 0x00, 0x22, 0x00, 0xCC, 0x00, 0x98, 0x01, 0x30, 0x02, 0x40, 0x04,
  0x80, 0x09, 0x00, 0x16, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x06, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x08, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x10, 0x00, 0x60, 0x60, 0x00,
  0x41, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x88, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x88, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x40, 0x60, 0x01, 0x80, 0x40, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x80,
  0x20, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x20, 0x18, 0x00, 0x30, 0x04, 0x00, 0x10, 0x02, 0x00,
  0x18, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x30,
  0x06, 0x00, 0x08, 0x02, 0x00, 0x04, 0x03, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x08, 0x60, 0x00, 0x04, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x10, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x44, 0x0C, 0x00, 0x64, 0x03, 0x00, 0x26, 0x00, 0xC0, 0x12, 0x00, 0x20,
  0x19, 0x00, 0x08, 0x19, 0x80, 0x07, 0x38, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ThinItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 39, 10, 1, -38 },
  { 40, 9, 11, 14, 6, -41 },
  { 53, 27, 38, 25, 1, -38 },
  { 182, 22, 50, 25, 2, -44 },
  { 320, 25, 40, 34, 5, -39 },
  { 445, 24, 40, 28, 1, -39 },
  { 565, 3, 11, 9, 6, -41 },
  { 570, 14, 55, 14, 3, -43 },
  { 667, 14, 55, 15, -3, -43 },
  { 764, 21, 21, 22, 3, -38 },
  { 820, 22, 27, 26, 2, -31 },
  { 895, 5, 11, 10, -1, -4 },
  { 902, 10, 1, 14, 2, -18 },
  { 904, 3, 3, 11, 1, -2 },
  { 906, 22, 41, 18, -2, -38 },
  { 1019, 21, 40, 25, 3, -39 },
  { 1124, 12, 38, 25, 7, -38 },
  { 1181, 23, 39, 25, 1, -39 },
  { 1294, 22, 40, 25, 2, -39 },
  { 1404, 23, 38, 25, 1, -38 },
  { 1514, 23, 39, 25, 3, -38 },
  { 1627, 20, 39, 25, 2, -38 },
  { 1725, 21, 38, 25, 5, -38 },
  { 1825, 24, 40, 25, 1, -39 },
  { 1945, 20, 39, 25, 4, -39 },
  { 2043, 7, 28, 9, 1, -27 },
  { 2068, 10, 34, 9, -2, -27 },
  { 2111, 21, 21, 24, 2, -28 },
  { 2167, 20, 11, 26, 3, -23 },
  { 2195, 21, 21, 24, 1, -28 },
  { 2251, 16, 40, 20, 5, -39 },
  { 2331, 37, 49, 42, 2, -37 },
  { 2558, 26, 38, 28, -2, -38 },
  { 2682, 24, 38, 28, 2, -38 },
  { 2796, 26, 40, 30, 3, -39 },
  { 2926, 26, 38, 30, 2, -38 },
  { 3050, 26, 38, 26, 2, -38 },
  { 3174, 26, 38, 26, 2, -38 },
  { 3298, 25, 40, 32, 4, -39 },
  { 3423, 29, 38, 32, 2, -38 },
  { 3561, 8, 38, 13, 3, -38 },
  { 3599, 24, 39, 25, 1, -38 },
  { 3716, 28, 38, 29, 2, -38 },
  { 3849, 18, 38, 24, 2, -38 },
  { 3935, 36, 38, 39, 2, -38 },
  { 4106, 30, 38, 32, 2, -38 },
  { 4249, 26, 40, 31, 3, -39 },
  { 4379, 26, 38, 28, 2, -38 },
  { 4503, 26, 46, 31, 3, -39 },
  { 4653, 26, 38, 30, 2, -38 },
  { 4777, 26, 40, 27, 1, -39 },
  { 4907, 25, 38, 28, 5, -38 },
  { 5026, 27, 39, 31, 3, -38 },
  { 5158, 25, 38, 28, 5, -38 },
  { 5277, 38, 38, 41, 5, -38 },
  { 5458, 30, 38, 28, -1, -38 },
  { 5601, 25, 38, 28, 5, -38 },
  { 5720, 28, 38, 28, 0, -38 },
  { 5853, 14, 52, 11, 1, -44 },
  { 5944, 7, 41, 18, 6, -38 },
  { 5980, 14, 52, 11, -3, -44 },
  { 6071, 14, 19, 19, 3, -38 },
  { 6105, 19, 1, 19, -3, 0 },
  { 6108, 6, 7, 14, 7, -40 },
  { 6114, 20, 31, 25, 1, -30 },
  { 6192, 22, 42, 25, 1, -41 },
  { 6308, 20, 31, 24, 2, -30 },
  { 6386, 24, 42, 25, 2, -41 },
  { 6512, 21, 31, 24, 1, -30 },
  { 6594, 16, 42, 15, 3, -42 },
  { 6678, 23, 41, 25, 0, -30 },
  { 6796, 21, 41, 25, 1, -41 },
  { 6904, 8, 40, 10, 2, -40 },
  { 6944, 17, 51, 11, -7, -40 },
  { 7053, 22, 41, 22, 1, -41 },
  { 7166, 8, 41, 10, 2, -41 },
  { 7207, 37, 30, 41, 1, -30 },
  { 7346, 21, 30, 25, 1, -30 },
  { 7425, 21, 31, 25, 2, -30 },
  { 7507, 24, 41, 25, -1, -30 },
  { 7630, 21, 41, 25, 2, -30 },
  { 7738, 16, 30, 16, 1, -30 },
  { 7798, 20, 31, 23, 1, -30 },
  { 7876, 11, 37, 15, 3, -36 },
  { 7927, 20, 30, 25, 3, -29 },
  { 8002, 20, 29, 22, 3, -29 },
  { 8075, 30, 29, 35, 4, -29 },
  { 8184, 23, 29, 22, -1, -29 },
  { 8268, 25, 40, 22, -2, -29 },
  { 8393, 22, 29, 22, 0, -29 },
  { 8473, 17, 54, 15, 2, -42 },
  { 8588, 9, 45, 11, 1, -38 },
  { 8639, 17, 54, 15, -4, -42 },
  { 8754, 25, 9, 32, 3, -21 },
};

const GFXfont RobotoCondensed_ThinItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_THINITALIC54PT7B_H_
