#ifndef _ROBOTOCONDENSED_THINITALIC9PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x16, 0x08, 0x00, 0x21, 0xD4, 0xA6, 0x38, 0x00, 0x07, 0x44, 0x21,
  0x9E, 0x00, 0xCD, 0xE4, 0x73, 0x30, 0x75, 0x64, 0xA9, 0xF0, 0x00, 0x29,
  0x49, 0x24, 0x00, 0x04, 0x92, 0x4A, 0x00, 0x4A, 0x00, 0x26, 0x20, 0x80,
  0x00, 0x00, 0x04, 0xA5, 0x20, 0x75, 0x99, 0x99, 0xE0, 0x55, 0x50, 0x71,
  0x12, 0x24, 0xC0, 0x71, 0x13, 0x19, 0xE0, 0x13, 0x55, 0xE2, 0x00, 0x52,
  0x32, 0x70, 0x24, 0x79, 0x99, 0xE0, 0x64, 0xA5, 0x00, 0x75, 0x57, 0x99,
  0xE0, 0xF6, 0xDE, 0x70, 0x00, 0x10, 0x34, 0x42, 0x26, 0x42, 0x2C, 0xD5,
  0x80, 0x3C, 0x85, 0x6D, 0x5A, 0xB7, 0xA0, 0x30, 0x22, 0x55, 0xB9, 0x00,
  0x75, 0x57, 0x89, 0xE0, 0x79, 0x88, 0x88, 0xE0, 0x52, 0x52, 0x98, 0xCA,
  0x80, 0x72, 0x10, 0xC8, 0x43, 0x80, 0x72, 0x10, 0xC8, 0x42, 0x00, 0x78,
  0x88, 0x89, 0xE0, 0x42, 0x52, 0xF8, 0xC6, 0x00, 0x55, 0xA0, 0x01, 0x11,
  0x11, 0xE0, 0x4A, 0x98, 0x8A, 0x4A, 0x00, 0x49, 0x29, 0x30, 0x41, 0x14,
  0xD3, 0xB6, 0xDA, 0x00, 0x42, 0x5A, 0xD9, 0xCA, 0x00, 0x3A, 0x63, 0x18,
  0xC5, 0xC0, 0x7A, 0x52, 0xE8, 0x42, 0x00, 0x3A, 0x63, 0x18, 0xC5, 0xC2,
  0x7A, 0x53, 0x68, 0x4A, 0x00, 0x72, 0x10, 0x41, 0x0B, 0xC0, 0x64, 0x44,
  0x44, 0x00, 0x89, 0x99, 0x9A, 0xE0, 0x09, 0xAA, 0xC4, 0x00, 0x02, 0x9A,
  0x76, 0x9A, 0x49, 0x00, 0x0A, 0x88, 0x46, 0x48, 0x40, 0x1A, 0xAC, 0x44,
  0x00, 0x38, 0x88, 0x44, 0x41, 0x80, 0x49, 0x49, 0x20, 0x7E, 0x04, 0x94,
  0x92, 0x4C, 0x00, 0x40, 0x80, 0x31, 0x59, 0xE0, 0x44, 0x79, 0x99, 0xE0,
  0x79, 0x88, 0xE0, 0x01, 0x79, 0x99, 0xA0, 0x7B, 0x88, 0xC0, 0x2A, 0xA0,
  0x79, 0x99, 0xA2, 0xE0, 0x44, 0x79, 0x99, 0x80, 0x0A, 0xA0, 0x01, 0x24,
  0x90, 0x44, 0x4A, 0x8A, 0x80, 0x56, 0xA8, 0x7E, 0x59, 0x65, 0x80, 0x79,
  0x99, 0x80, 0x79, 0x99, 0xA0, 0x79, 0x99, 0xE8, 0x00, 0x79, 0x99, 0xA2,
  0x00, 0x52, 0x48, 0x51, 0x9E, 0xF8, 0x09, 0x99, 0xE0, 0x37, 0x48, 0x0E,
  0x6D, 0x40, 0x00, 0x06, 0x44, 0xA0, 0x19, 0x64, 0x44, 0x00, 0x32, 0x44,
  0x40, 0x29, 0x20, 0x14, 0x00, 0x56, 0xAA, 0x04, 0x92, 0x12, 0x00, 0x97,
};

const GFXglyph RobotoCondensed_ThinItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 1, 2, 2, 1, -7 },
  { 4, 5, 7, 4, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 4, 7, 6, 1, -7 },
  { 18, 4, 7, 5, 0, -7 },
  { 22, 1, 2, 1, 1, -7 },
  { 23, 3, 9, 2, 0, -7 },
  { 27, 3, 9, 2, -1, -7 },
  { 31, 3, 3, 4, 1, -7 },
  { 33, 4, 4, 4, 0, -5 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 2, 1, 2, 0, -4 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 3, 8, 3, 0, -7 },
  { 41, 4, 7, 4, 0, -7 },
  { 45, 2, 7, 4, 1, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 3, 7, 4, 1, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 3, 7, 4, 1, -7 },
  { 69, 4, 7, 4, 0, -7 },
  { 73, 3, 7, 4, 1, -7 },
  { 76, 1, 4, 2, 0, -4 },
  { 77, 1, 5, 2, 0, -4 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 4, 2, 4, 0, -4 },
  { 81, 4, 4, 4, 0, -5 },
  { 83, 2, 7, 3, 1, -7 },
  { 85, 7, 8, 7, 0, -6 },
  { 92, 4, 7, 5, 0, -7 },
  { 96, 4, 7, 5, 0, -7 },
  { 100, 4, 7, 5, 1, -7 },
  { 104, 5, 7, 5, 0, -7 },
  { 109, 5, 7, 4, 0, -7 },
  { 114, 5, 7, 4, 0, -7 },
  { 119, 4, 7, 5, 1, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 2, 7, 2, 0, -7 },
  { 130, 4, 7, 4, 0, -7 },
  { 134, 5, 7, 5, 0, -7 },
  { 139, 3, 7, 4, 0, -7 },
  { 142, 6, 7, 7, 0, -7 },
  { 148, 5, 7, 5, 0, -7 },
  { 153, 5, 7, 5, 0, -7 },
  { 158, 5, 7, 5, 0, -7 },
  { 163, 5, 8, 5, 0, -7 },
  { 168, 5, 7, 5, 0, -7 },
  { 173, 5, 7, 5, 0, -7 },
  { 178, 4, 7, 5, 1, -7 },
  { 182, 4, 7, 5, 1, -7 },
  { 186, 4, 7, 5, 1, -7 },
  { 190, 6, 7, 7, 1, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 4, 7, 5, 1, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 3, 8, 2, 0, -7 },
  { 213, 1, 8, 3, 1, -7 },
  { 214, 3, 8, 2, -1, -7 },
  { 217, 3, 3, 3, 0, -7 },
  { 219, 3, 1, 3, 0, 0 },
  { 220, 1, 2, 2, 1, -8 },
  { 221, 4, 5, 4, 0, -5 },
  { 224, 4, 7, 4, 0, -7 },
  { 228, 4, 5, 4, 0, -5 },
  { 231, 4, 7, 4, 0, -7 },
  { 235, 4, 5, 4, 0, -5 },
  { 238, 2, 7, 3, 1, -7 },
  { 240, 4, 7, 4, 0, -5 },
  { 244, 4, 7, 4, 0, -7 },
  { 248, 2, 6, 2, 0, -6 },
  { 250, 3, 8, 2, -1, -6 },
  { 253, 4, 7, 4, 0, -7 },
  { 257, 2, 7, 2, 0, -7 },
  { 259, 6, 5, 7, 0, -5 },
  { 263, 4, 5, 4, 0, -5 },
  { 266, 4, 5, 4, 0, -5 },
  { 269, 4, 7, 4, 0, -5 },
  { 273, 4, 7, 4, 0, -5 },
  { 277, 3, 5, 3, 0, -5 },
  { 279, 3, 5, 4, 0, -5 },
  { 281, 1, 6, 3, 1, -6 },
  { 282, 4, 5, 4, 0, -5 },
  { 285, 3, 5, 4, 1, -5 },
  { 287, 5, 5, 6, 1, -5 },
  { 291, 4, 5, 4, 0, -5 },
  { 294, 4, 7, 4, 0, -5 },
  { 298, 4, 5, 4, 0, -5 },
  { 301, 3, 9, 3, 0, -7 },
  { 305, 2, 8, 2, 0, -7 },
  { 307, 3, 9, 3, -1, -7 },
  { 311, 4, 2, 5, 1, -4 },
};

const GFXfont RobotoCondensed_ThinItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_THINITALIC9PT7B_H_
