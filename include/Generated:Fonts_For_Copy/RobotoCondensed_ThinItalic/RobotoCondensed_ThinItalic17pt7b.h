#ifndef _ROBOTOCONDENSED_THINITALIC17PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x40, 0x40, 0x94, 0x00, 0x00, 0x04, 0x82, 0x43,
  0xF1, 0x20, 0x90, 0x90, 0x48, 0x7E, 0x14, 0x12, 0x08, 0x00, 0x08, 0x10,
  0xD2, 0x14, 0x28, 0x50, 0x10, 0x18, 0x08, 0x14, 0x28, 0x8A, 0x08, 0x00,
  0x60, 0x90, 0x92, 0x94, 0xA8, 0xD0, 0x16, 0x29, 0x51, 0x51, 0x92, 0x0C,
  0x0C, 0x12, 0x22, 0x24, 0x18, 0x10, 0x28, 0x49, 0x85, 0x86, 0x86, 0x79,
  0xC0, 0x11, 0x24, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88, 0x40, 0x00, 0x84,
  0x10, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x88, 0x80, 0x10, 0x20, 0x53,
  0xC3, 0x09, 0x22, 0x00, 0x00, 0x20, 0x43, 0xE1, 0x04, 0x08, 0x10, 0xE0,
  0x40, 0x80, 0x00, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02,
  0x00, 0x00, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x85, 0x0A, 0x23,
  0x80, 0x3D, 0x11, 0x22, 0x22, 0x22, 0x44, 0x1E, 0x44, 0x88, 0x10, 0x20,
  0x81, 0x04, 0x10, 0x41, 0x07, 0xC0, 0x1E, 0x21, 0x01, 0x01, 0x02, 0x1C,
  0x04, 0x02, 0x02, 0x82, 0x44, 0x38, 0x02, 0x04, 0x18, 0x51, 0x22, 0x89,
  0x22, 0xFC, 0x08, 0x10, 0x00, 0x3C, 0x41, 0x02, 0x07, 0x80, 0x81, 0x02,
  0x05, 0x0A, 0x23, 0x80, 0x18, 0x84, 0x10, 0xBB, 0x18, 0x61, 0x86, 0x18,
  0x9C, 0x3E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x00, 0x00,
  0x1E, 0x21, 0x21, 0x41, 0x22, 0x1C, 0x24, 0x42, 0x82, 0x82, 0x84, 0x78,
  0x3D, 0x14, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x21, 0x38, 0x20, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x44, 0x80, 0x04, 0x66, 0x20, 0x40, 0xC0,
  0x80, 0x38, 0x07, 0x80, 0x20, 0x20, 0x30, 0x10, 0xC6, 0x30, 0x00, 0x74,
  0x42, 0x11, 0x10, 0x88, 0x00, 0x01, 0x00, 0x0F, 0xC2, 0x04, 0x80, 0xA3,
  0x94, 0x83, 0x22, 0x64, 0x4C, 0x89, 0xA2, 0x34, 0x46, 0x89, 0x4E, 0xC8,
  0x01, 0x00, 0x20, 0x03, 0xE0, 0x04, 0x18, 0x30, 0x91, 0x24, 0x48, 0xAF,
  0x43, 0x06, 0x08, 0x00, 0x7C, 0x85, 0x0A, 0x14, 0x37, 0xA1, 0x41, 0x83,
  0x06, 0x13, 0xC0, 0x1E, 0x21, 0x41, 0x41, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x82, 0x84, 0x78, 0x1C, 0x42, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x78, 0x1E, 0x40, 0x40, 0x40, 0x40, 0xB8, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x78, 0x1E, 0x40, 0x40, 0x40, 0x40, 0xB8, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x00, 0x1E, 0x21, 0x40, 0x40, 0x40, 0x80, 0x86, 0x80, 0x81,
  0x82, 0x82, 0x7C, 0x00, 0xA0, 0x50, 0x28, 0x14, 0x15, 0xFA, 0x05, 0x02,
  0x81, 0x41, 0x20, 0x80, 0x40, 0x15, 0x56, 0xA8, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x84, 0x84, 0x78, 0x01, 0x42, 0x44, 0x48,
  0x50, 0xA0, 0x50, 0x90, 0x88, 0x84, 0x84, 0x02, 0x02, 0x10, 0x84, 0x42,
  0x10, 0x84, 0x20, 0xE0, 0x00, 0x2C, 0x05, 0x81, 0xB0, 0x56, 0x0B, 0x22,
  0xA4, 0x54, 0x92, 0x92, 0x52, 0x8A, 0x22, 0x04, 0x00, 0x40, 0xB0, 0x58,
  0x2A, 0x15, 0x12, 0x4A, 0x25, 0x12, 0x85, 0x42, 0xA0, 0x80, 0x40, 0x1E,
  0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x7E,
  0x41, 0x41, 0x41, 0x41, 0x82, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x00, 0x1E,
  0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x04,
  0x04, 0x7E, 0x41, 0x41, 0x41, 0x41, 0x82, 0xB4, 0x88, 0x84, 0x84, 0x84,
  0x00, 0x1F, 0x10, 0x48, 0x08, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x81, 0x40,
  0x90, 0x87, 0x80, 0x7C, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x00, 0x00, 0x41, 0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x84, 0x78, 0x00, 0x81, 0x41, 0x42, 0x42, 0x44, 0x44, 0x48, 0x28, 0x30,
  0x30, 0x20, 0x04, 0x08, 0xC2, 0x8C, 0x28, 0xC4, 0x92, 0x49, 0x24, 0xA2,
  0x8A, 0x28, 0xA2, 0x8C, 0x30, 0xC3, 0x08, 0x20, 0x20, 0x90, 0x84, 0x42,
  0x41, 0x40, 0x40, 0x20, 0x28, 0x24, 0x21, 0x10, 0x90, 0x40, 0x80, 0x82,
  0x84, 0x88, 0x48, 0x50, 0x60, 0x20, 0x20, 0x40, 0x40, 0x40, 0x1F, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0x80,
  0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x80, 0x2A,
  0xA9, 0x55, 0x00, 0x11, 0x11, 0x11, 0x11, 0x22, 0x22, 0x22, 0x24, 0x40,
  0x13, 0x55, 0x98, 0x78, 0x90, 0x3C, 0x85, 0x08, 0x13, 0xA8, 0xA1, 0x46,
  0x74, 0x00, 0x40, 0x81, 0x03, 0xC4, 0x50, 0xA1, 0x42, 0x85, 0x0E, 0x23,
  0x80, 0x7A, 0x18, 0x60, 0x82, 0x08, 0x22, 0xF0, 0x00, 0x04, 0x08, 0x13,
  0xA8, 0xA1, 0x42, 0x85, 0x0A, 0x14, 0x4F, 0x80, 0x1C, 0x45, 0x0B, 0xF8,
  0x10, 0x20, 0x20, 0x38, 0x11, 0x08, 0x86, 0x21, 0x08, 0x84, 0x21, 0x08,
  0x00, 0x1C, 0x45, 0x0A, 0x14, 0x30, 0x61, 0x22, 0x7C, 0x0A, 0x23, 0x80,
  0x00, 0x40, 0x81, 0x03, 0xEC, 0x50, 0xA1, 0x42, 0x85, 0x0C, 0x20, 0x40,
  0x40, 0x6A, 0xA8, 0x08, 0x00, 0x00, 0x88, 0x42, 0x10, 0x88, 0x42, 0x11,
  0x00, 0x00, 0x40, 0x81, 0x02, 0x28, 0x92, 0x28, 0x60, 0xA1, 0x24, 0x40,
  0x40, 0x15, 0x5A, 0xAA, 0x00, 0x1C, 0xE2, 0x31, 0x42, 0x14, 0x21, 0x42,
  0x14, 0x21, 0x42, 0x28, 0x42, 0x84, 0x20, 0x1C, 0xC5, 0x0A, 0x14, 0x28,
  0x50, 0xC2, 0x04, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x1C, 0x45,
  0x0A, 0x14, 0x28, 0x60, 0xE2, 0xB9, 0x02, 0x00, 0x00, 0x39, 0x18, 0x61,
  0x86, 0x18, 0xA2, 0xF8, 0x20, 0x80, 0x11, 0x10, 0x84, 0x21, 0x10, 0x00,
  0x3C, 0x81, 0x01, 0x01, 0x80, 0x81, 0x42, 0x78, 0x04, 0x64, 0x44, 0x88,
  0x88, 0x80, 0x02, 0x18, 0x61, 0x86, 0x18, 0xA2, 0xF8, 0x82, 0x18, 0xA2,
  0x51, 0x46, 0x18, 0x40, 0x80, 0x62, 0x28, 0xCA, 0x52, 0x95, 0x29, 0x46,
  0x61, 0x08, 0x40, 0x00, 0x42, 0x48, 0xA0, 0x81, 0x06, 0x12, 0x24, 0x84,
  0x20, 0x21, 0x22, 0x22, 0x14, 0x14, 0x18, 0x10, 0x10, 0x10, 0x20, 0x40,
  0x1E, 0x08, 0x20, 0x41, 0x04, 0x10, 0x20, 0xF8, 0x08, 0x88, 0x42, 0x11,
  0x08, 0x80, 0x10, 0x88, 0x42, 0x10, 0x40, 0x24, 0x92, 0x92, 0x49, 0x49,
  0x00, 0x00, 0x82, 0x11, 0x08, 0x42, 0x08, 0x84, 0x42, 0x10, 0x88, 0x80,
  0x71, 0x91, 0x8E,
};

const GFXglyph RobotoCondensed_ThinItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 3, 0, -12 },
  { 6, 3, 3, 4, 2, -13 },
  { 8, 9, 12, 8, 0, -12 },
  { 22, 7, 16, 8, 1, -14 },
  { 36, 8, 12, 11, 2, -12 },
  { 48, 8, 12, 9, 0, -12 },
  { 60, 1, 3, 3, 2, -13 },
  { 61, 4, 17, 5, 1, -13 },
  { 70, 5, 17, 5, -1, -13 },
  { 81, 7, 7, 7, 1, -12 },
  { 88, 7, 8, 8, 1, -9 },
  { 95, 1, 3, 3, 0, -1 },
  { 96, 3, 1, 4, 1, -6 },
  { 97, 1, 1, 4, 0, -1 },
  { 98, 7, 13, 6, -1, -12 },
  { 110, 7, 12, 8, 1, -12 },
  { 121, 4, 12, 8, 2, -12 },
  { 127, 7, 12, 8, 0, -12 },
  { 138, 8, 12, 8, 0, -12 },
  { 150, 7, 12, 8, 0, -12 },
  { 161, 7, 12, 8, 1, -12 },
  { 172, 6, 12, 8, 1, -12 },
  { 181, 7, 12, 8, 1, -12 },
  { 192, 8, 12, 8, 0, -12 },
  { 204, 6, 12, 8, 1, -12 },
  { 213, 3, 9, 3, 0, -9 },
  { 217, 4, 11, 3, -1, -9 },
  { 223, 6, 7, 8, 1, -9 },
  { 229, 6, 3, 8, 1, -7 },
  { 232, 7, 7, 8, 0, -9 },
  { 239, 5, 12, 6, 2, -12 },
  { 247, 11, 16, 13, 1, -12 },
  { 269, 7, 12, 9, 0, -12 },
  { 280, 7, 12, 9, 1, -12 },
  { 291, 8, 12, 9, 1, -12 },
  { 303, 8, 12, 9, 1, -12 },
  { 315, 8, 12, 8, 1, -12 },
  { 327, 8, 12, 8, 1, -12 },
  { 339, 8, 12, 10, 1, -12 },
  { 351, 9, 12, 10, 1, -12 },
  { 365, 2, 12, 4, 1, -12 },
  { 368, 8, 12, 8, 0, -12 },
  { 380, 8, 12, 9, 1, -12 },
  { 392, 5, 12, 8, 1, -12 },
  { 400, 11, 12, 12, 1, -12 },
  { 417, 9, 12, 10, 1, -12 },
  { 431, 8, 12, 10, 1, -12 },
  { 443, 8, 12, 9, 1, -12 },
  { 455, 8, 14, 10, 1, -12 },
  { 469, 8, 12, 9, 1, -12 },
  { 481, 9, 12, 9, 0, -12 },
  { 495, 7, 12, 9, 2, -12 },
  { 506, 8, 12, 10, 1, -12 },
  { 518, 8, 12, 9, 1, -12 },
  { 530, 12, 12, 13, 2, -12 },
  { 548, 9, 12, 9, 0, -12 },
  { 562, 8, 12, 9, 2, -12 },
  { 574, 9, 12, 9, 0, -12 },
  { 588, 5, 17, 3, 0, -14 },
  { 599, 2, 13, 6, 2, -12 },
  { 603, 4, 17, 3, -1, -14 },
  { 612, 4, 6, 6, 1, -12 },
  { 615, 6, 1, 6, -1, 0 },
  { 616, 2, 2, 4, 2, -13 },
  { 617, 7, 9, 8, 0, -9 },
  { 625, 7, 13, 8, 0, -13 },
  { 637, 6, 9, 7, 1, -9 },
  { 644, 7, 13, 8, 1, -13 },
  { 656, 7, 9, 7, 0, -9 },
  { 664, 5, 13, 5, 1, -13 },
  { 673, 7, 12, 8, 0, -9 },
  { 684, 7, 13, 8, 0, -13 },
  { 696, 2, 12, 3, 1, -12 },
  { 699, 5, 15, 3, -2, -12 },
  { 709, 7, 13, 7, 0, -13 },
  { 721, 2, 13, 3, 1, -13 },
  { 725, 12, 9, 13, 0, -9 },
  { 739, 7, 9, 8, 0, -9 },
  { 747, 6, 9, 8, 1, -9 },
  { 754, 7, 12, 8, 0, -9 },
  { 765, 6, 12, 8, 1, -9 },
  { 774, 5, 9, 5, 0, -9 },
  { 780, 7, 9, 7, 0, -9 },
  { 788, 4, 11, 5, 1, -11 },
  { 794, 6, 9, 8, 1, -9 },
  { 801, 6, 9, 7, 1, -9 },
  { 808, 10, 9, 11, 1, -9 },
  { 820, 7, 9, 7, 0, -9 },
  { 828, 8, 12, 7, -1, -9 },
  { 840, 7, 9, 7, 0, -9 },
  { 848, 5, 17, 5, 1, -13 },
  { 859, 3, 14, 3, 0, -12 },
  { 865, 5, 17, 5, -1, -13 },
  { 876, 8, 3, 10, 1, -7 },
};

const GFXfont RobotoCondensed_ThinItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_THINITALIC17PT7B_H_
