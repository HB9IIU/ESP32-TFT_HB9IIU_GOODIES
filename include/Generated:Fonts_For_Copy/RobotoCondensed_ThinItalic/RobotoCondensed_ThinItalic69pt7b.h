#ifndef _ROBOTOCONDENSED_THINITALIC69PT7B_H_
#define _ROBOTOCONDENSED_THINITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ThinItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ThinItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x30, 0x46,
  0x18, 0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0x41, 0x98, 0x33,
  0x06, 0x60, 0xCC, 0x11, 0x86, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x18, 0x20, 0x01, 0x00, 0x18, 0x30, 0x00, 0x80, 0x0C, 0x18,
  0x00, 0x40, 0x0C, 0x0C, 0x00, 0x60, 0x0C, 0x04, 0x00, 0x30, 0x0C, 0x02,
  0x00, 0x18, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x40, 0x06, 0x03, 0x00, 0x20, 0x02, 0x03, 0x00, 0x18, 0x03, 0x03, 0x00,
  0x0C, 0x03, 0x01, 0x80, 0x03, 0x03, 0x01, 0x80, 0x00, 0xFF, 0x81, 0x80,
  0x00, 0x3F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0x30,
  0x18, 0x18, 0x00, 0x30, 0x18, 0x06, 0x00, 0x18, 0x18, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x30, 0x0C,
  0x02, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x08, 0x06, 0x01, 0x80, 0x04, 0x06,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x40, 0x03, 0x02, 0x00, 0x20, 0x01, 0x83,
  0x00, 0x10, 0x00, 0x83, 0x00, 0x08, 0x00, 0xC1, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x10, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x30,
  0x03, 0x18, 0x00, 0x60, 0x0C, 0xC0, 0x01, 0x80, 0x62, 0x00, 0x03, 0x01,
  0x98, 0x00, 0x0E, 0x06, 0x60, 0x00, 0x18, 0x31, 0x00, 0x00, 0x30, 0xCC,
  0x00, 0x00, 0xC6, 0x30, 0x00, 0x01, 0x98, 0xC0, 0x00, 0x06, 0xC3, 0x00,
  0x00, 0x0F, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x06, 0xC1, 0xC0, 0x00, 0x33, 0x03, 0x80, 0x01, 0x86, 0x07, 0x00, 0x1C,
  0x18, 0x0F, 0x01, 0xC0, 0x30, 0x1F, 0xFE, 0x00, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x11, 0x8C, 0x63, 0x18, 0xCC, 0x63, 0x18, 0x8C, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x10, 0x01, 0x80, 0x3F, 0x80, 0xC0, 0x7C,
  0xF8, 0x30, 0x78, 0x07, 0x8C, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x0C,
  0x03, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x0C,
  0x18, 0x30, 0xE1, 0x83, 0x06, 0x18, 0x30, 0xC3, 0x8E, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x33, 0x9C, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1E, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xD8, 0x1E, 0x21,
  0xF0, 0x4F, 0x01, 0x98, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0x60,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x87, 0xF0,
  0x00, 0x08, 0xFF, 0xE0, 0x00, 0xDC, 0x03, 0x80, 0x07, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x03, 0xF8, 0x01, 0x83, 0xFF, 0x80, 0x63, 0xC0, 0x70, 0x19,
  0x80, 0x0E, 0x04, 0xC0, 0x01, 0xC3, 0x60, 0x00, 0x30, 0xF0, 0x00, 0x06,
  0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x70, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x3C, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x38, 0x00, 0x38,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x32, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x03, 0x98, 0x00, 0x03, 0xCC, 0x00, 0x03, 0x47, 0x00, 0x03, 0x61,
  0x80, 0x03, 0x30, 0x60, 0x03, 0x18, 0x38, 0x07, 0x0C, 0x07, 0xFF, 0x0C,
  0x01, 0xFC, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3C,
  0x0F, 0x01, 0x00, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x08,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x70, 0x1C,
  0x01, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x03,
  0x00, 0x07, 0x00, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x06,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x30,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x30, 0x01, 0x80, 0x01, 0x80, 0x03, 0x30,
  0x01, 0x00, 0x01, 0x80, 0x02, 0x20, 0x03, 0x00, 0x01, 0x00, 0x06, 0x60,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x60, 0x03, 0x00, 0x03, 0x00, 0x06, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x04, 0x60, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x40,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x40, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x40,
  0x04, 0x00, 0x06, 0x00, 0x18, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x18, 0xC0,
  0x04, 0x00, 0x0C, 0x00, 0x10, 0xC0, 0x04, 0x00, 0x1C, 0x00, 0x30, 0xC0,
  0x04, 0x00, 0x1C, 0x00, 0x20, 0xC0, 0x04, 0x00, 0x3C, 0x00, 0x60, 0xC0,
  0x06, 0x00, 0x64, 0x00, 0xC0, 0x40, 0x06, 0x00, 0xC4, 0x01, 0xC0, 0x60,
  0x06, 0x01, 0x86, 0x03, 0x80, 0x60, 0x03, 0x07, 0x03, 0x07, 0x00, 0x60,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x60, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x04, 0x01, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x08,
  0x00, 0x1E, 0x00, 0x20, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x38, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x0F, 0xFF, 0xC2, 0x00, 0x07, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0F, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x06, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x02,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x61, 0xE0, 0x00, 0x00, 0x0C,
  0x66, 0x00, 0x00, 0x01, 0x18, 0xE0, 0x00, 0x00, 0x26, 0x0C, 0x00, 0x00,
  0x0D, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x00, 0x0A, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x78, 0x06, 0xC0, 0x00,
  0x00, 0x03, 0x60, 0x1B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x6C, 0x00, 0x00,
  0x00, 0x66, 0x01, 0x30, 0x00, 0x00, 0x01, 0x90, 0x0C, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x31, 0x00, 0x00, 0x00, 0x33, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x8C, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x0C, 0x60, 0x00, 0x00, 0x30,
  0xC0, 0x21, 0x80, 0x00, 0x00, 0x82, 0x01, 0x82, 0x00, 0x00, 0x06, 0x18,
  0x06, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x60, 0xC0, 0x00, 0x02, 0x06, 0x01, 0x03, 0x00, 0x00, 0x18, 0x18, 0x04,
  0x04, 0x00, 0x00, 0xC0, 0x40, 0x30, 0x10, 0x00, 0x03, 0x03, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x0C, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x00, 0x60, 0x08, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x18, 0x04, 0x00, 0x40, 0x06, 0x00, 0x40, 0x30, 0x01, 0x00, 0x30,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x80, 0xC0, 0x03,
  0x00, 0x80, 0x02, 0x06, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x01,
  0x80, 0x03, 0x18, 0x00, 0x18, 0x06, 0x00, 0x04, 0x60, 0x00, 0x60, 0x10,
  0x00, 0x13, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x06,
  0x03, 0xC0, 0x00, 0x00, 0x30, 0x1B, 0x00, 0x00, 0x01, 0x80, 0xD8, 0x00,
  0x00, 0x08, 0x06, 0x40, 0x00, 0x00, 0xC0, 0x33, 0x00, 0x00, 0x06, 0x01,
  0x98, 0x00, 0x00, 0x30, 0x18, 0x60, 0x00, 0x01, 0x80, 0xC3, 0x00, 0x00,
  0x0C, 0x06, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x06, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x0C,
  0x06, 0x01, 0x00, 0x00, 0x60, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x40, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x60, 0x00, 0x60, 0x30, 0x01, 0x80, 0x02, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x60, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0x30, 0x03, 0x01, 0x80, 0x01, 0x80, 0x10,
  0x0C, 0x00, 0x04, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x30, 0x00, 0x06, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x0C,
  0x00, 0x00, 0x81, 0x80, 0x60, 0x00, 0x06, 0x0C, 0x03, 0x00, 0x00, 0x30,
  0x60, 0x18, 0x00, 0x00, 0x83, 0x01, 0x80, 0x00, 0x06, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x60, 0x00, 0x00, 0xCC, 0x03, 0x00, 0x00, 0x06, 0x60,
  0x18, 0x00, 0x00, 0x13, 0x00, 0x80, 0x00, 0x00, 0xD8, 0x0C, 0x00, 0x00,
  0x06, 0xC0, 0x60, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x70, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x08, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x8C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x30, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x40, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01,
  0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x20, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x20, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x11, 0x80, 0x00, 0x31, 0x80, 0x00, 0x11, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x02, 0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x58, 0x00, 0x36, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C,
  0x0C, 0x03, 0x03, 0x01, 0x80, 0x40, 0x60, 0x10, 0x30, 0x06, 0x0C, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x00, 0x98, 0x00, 0x36,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC1, 0xC1,
  0x81, 0x83, 0x03, 0x07, 0x06, 0x06, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0x80, 0xF0, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0xE0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0x00, 0x04, 0x0F,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xD0, 0xC0, 0x00, 0x6C, 0x18, 0x00, 0x33, 0x07, 0x00, 0x38, 0xC0,
  0xE0, 0x3C, 0x30, 0x1F, 0xFC, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x07, 0x80, 0x03, 0x07, 0xFE, 0x00, 0x43, 0x80, 0xE0, 0x09,
  0xC0, 0x06, 0x03, 0x70, 0x00, 0xE0, 0x78, 0x00, 0x0C, 0x0E, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x03,
  0x02, 0x80, 0x00, 0xE0, 0xD8, 0x00, 0x38, 0x19, 0x80, 0x0E, 0x03, 0x1C,
  0x07, 0x80, 0x60, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0x81, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x03, 0xE0,
  0x18, 0x00, 0x7F, 0xF0, 0x60, 0x03, 0x80, 0xE1, 0x80, 0x18, 0x00, 0xC4,
  0x00, 0xC0, 0x01, 0xB0, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x60, 0x01, 0xC0, 0x71, 0x80,
  0x03, 0xFF, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE6, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x08, 0x0E, 0x00, 0x06, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x30, 0x01, 0xC0, 0x70, 0xC0, 0x0C, 0x00, 0x62, 0x00,
  0x60, 0x00, 0xD8, 0x03, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x07, 0x80, 0x60,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xB0, 0x00, 0xE0, 0x38, 0xC0, 0x01,
  0xFF, 0x83, 0x00, 0x01, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x03, 0xE0,
  0x03, 0x07, 0xFE, 0x00, 0xC3, 0x81, 0xC0, 0x21, 0x80, 0x18, 0x18, 0xC0,
  0x06, 0x06, 0x60, 0x00, 0xC1, 0xB0, 0x00, 0x30, 0x68, 0x00, 0x0C, 0x1C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x08, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x40, 0x1C,
  0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x38, 0x08, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x04,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x10, 0x70, 0x00, 0x02, 0x1C, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x19, 0xE0, 0x00, 0x03, 0x66, 0x00, 0x00, 0x78, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0C, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x61, 0xE0,
  0x70, 0x1E, 0x07, 0x01, 0x8E, 0x00, 0xE0, 0xE0, 0x06, 0x06, 0x60, 0x01,
  0x87, 0x00, 0x18, 0x19, 0x00, 0x02, 0x30, 0x00, 0x30, 0x6C, 0x00, 0x0D,
  0x80, 0x00, 0xC1, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x0D, 0x00, 0x00, 0xF0,
  0x00, 0x0C, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x60, 0x00, 0x02, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x20, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xC1,
  0xFF, 0x80, 0x30, 0xE0, 0x70, 0x08, 0x60, 0x06, 0x06, 0x30, 0x01, 0x81,
  0x98, 0x00, 0x30, 0x6C, 0x00, 0x0C, 0x1A, 0x00, 0x03, 0x07, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x18,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x84, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x08, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0x01, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0x83, 0xFF, 0x00, 0x06, 0x38, 0x0E, 0x00,
  0x13, 0x80, 0x0C, 0x00, 0xDC, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x60, 0x0E,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60,
  0x0A, 0x00, 0x03, 0x80, 0x6C, 0x00, 0x1C, 0x01, 0x98, 0x00, 0xE0, 0x06,
  0x3C, 0x0F, 0x00, 0x18, 0x3F, 0xF0, 0x00, 0x40, 0x3E, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x0C, 0x03, 0xC0, 0xE1, 0x80, 0xE0,
  0x06, 0x20, 0x30, 0x00, 0x64, 0x0C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x38, 0x0C, 0x00, 0x0F, 0x00, 0xC0, 0x07, 0x60, 0x0E, 0x07,
  0x8C, 0x00, 0xFF, 0xC1, 0x80, 0x07, 0xC0, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x30, 0xFF, 0x03, 0x1C,
  0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x06, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x10, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x04, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x38, 0x30, 0x00, 0x1E, 0x0C, 0x00, 0x05, 0x83, 0x00, 0x03,
  0x40, 0x60, 0x01, 0xB0, 0x1C, 0x00, 0xCC, 0x03, 0x81, 0xE3, 0x00, 0x7F,
  0xE0, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0x80,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x08, 0x00,
  0x02, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x05, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x00,
  0x01, 0xB0, 0x00, 0x3C, 0x00, 0x0E, 0xC0, 0x00, 0xF0, 0x00, 0x33, 0x00,
  0x02, 0xC0, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x00, 0x4C, 0x00,
  0x18, 0xC0, 0x03, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x40, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x1C, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01,
  0x81, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x30, 0x18, 0x06,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x02, 0x03, 0x00, 0x60, 0x60,
  0x08, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x80,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x03, 0x30, 0x00,
  0x26, 0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x13, 0x00, 0x02, 0xC0, 0x00,
  0x58, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x60, 0x01, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0x0C, 0x0E, 0x00, 0x03, 0x18, 0x07, 0x00, 0x02, 0x30,
  0x03, 0x00, 0x06, 0x30, 0x01, 0x80, 0x04, 0x60, 0x00, 0xC0, 0x0C, 0x60,
  0x00, 0x60, 0x18, 0x40, 0x00, 0x30, 0x38, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_ThinItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 50, 12, 1, -49 },
  { 70, 11, 14, 17, 8, -52 },
  { 90, 35, 49, 33, 1, -49 },
  { 305, 29, 63, 32, 2, -56 },
  { 534, 33, 51, 44, 6, -50 },
  { 745, 30, 51, 36, 2, -50 },
  { 937, 5, 14, 11, 7, -52 },
  { 946, 19, 71, 18, 3, -55 },
  { 1115, 19, 71, 19, -4, -55 },
  { 1284, 26, 27, 28, 4, -49 },
  { 1372, 28, 36, 33, 3, -41 },
  { 1498, 7, 14, 13, -2, -5 },
  { 1511, 13, 2, 18, 3, -24 },
  { 1515, 5, 4, 14, 1, -3 },
  { 1518, 27, 53, 23, -2, -49 },
  { 1697, 28, 51, 32, 3, -50 },
  { 1876, 15, 49, 32, 9, -49 },
  { 1968, 28, 50, 32, 2, -50 },
  { 2143, 29, 51, 32, 2, -50 },
  { 2328, 28, 49, 32, 2, -49 },
  { 2500, 29, 50, 32, 4, -49 },
  { 2682, 26, 50, 32, 3, -49 },
  { 2845, 27, 49, 32, 6, -49 },
  { 3011, 31, 51, 32, 1, -50 },
  { 3209, 25, 50, 32, 5, -50 },
  { 3366, 10, 36, 12, 1, -35 },
  { 3411, 13, 44, 12, -2, -35 },
  { 3483, 26, 27, 30, 3, -36 },
  { 3571, 26, 16, 33, 4, -30 },
  { 3623, 26, 27, 30, 2, -36 },
  { 3711, 21, 51, 26, 6, -50 },
  { 3845, 48, 63, 54, 2, -48 },
  { 4223, 32, 49, 35, -2, -49 },
  { 4419, 30, 49, 36, 3, -49 },
  { 4603, 32, 51, 38, 4, -50 },
  { 4807, 33, 49, 38, 3, -49 },
  { 5010, 33, 49, 34, 3, -49 },
  { 5213, 33, 49, 34, 3, -49 },
  { 5416, 33, 51, 40, 5, -50 },
  { 5627, 37, 49, 41, 3, -49 },
  { 5854, 10, 49, 16, 4, -49 },
  { 5916, 31, 50, 32, 1, -49 },
  { 6110, 35, 49, 37, 3, -49 },
  { 6325, 22, 49, 31, 3, -49 },
  { 6460, 46, 49, 50, 3, -49 },
  { 6742, 37, 49, 41, 3, -49 },
  { 6969, 33, 51, 39, 4, -50 },
  { 7180, 32, 49, 35, 3, -49 },
  { 7376, 33, 59, 39, 4, -50 },
  { 7620, 32, 49, 38, 3, -49 },
  { 7816, 33, 51, 35, 2, -50 },
  { 8027, 31, 49, 35, 7, -49 },
  { 8217, 34, 50, 39, 4, -49 },
  { 8430, 32, 49, 35, 6, -49 },
  { 8626, 48, 49, 53, 7, -49 },
  { 8920, 38, 49, 35, -1, -49 },
  { 9153, 33, 49, 35, 6, -49 },
  { 9356, 36, 49, 35, 0, -49 },
  { 9577, 18, 67, 14, 1, -56 },
  { 9728, 10, 53, 23, 7, -49 },
  { 9795, 18, 67, 14, -4, -56 },
  { 9946, 18, 24, 25, 4, -49 },
  { 10000, 24, 2, 25, -3, 0 },
  { 10006, 7, 9, 18, 10, -52 },
  { 10014, 26, 38, 31, 1, -37 },
  { 10138, 27, 53, 32, 2, -52 },
  { 10317, 26, 38, 30, 2, -37 },
  { 10441, 30, 53, 32, 3, -52 },
  { 10640, 26, 38, 30, 2, -37 },
  { 10764, 21, 53, 19, 4, -53 },
  { 10904, 30, 51, 32, 0, -37 },
  { 11096, 26, 52, 32, 2, -52 },
  { 11265, 11, 50, 13, 2, -50 },
  { 11334, 22, 64, 14, -9, -50 },
  { 11510, 27, 52, 28, 2, -52 },
  { 11686, 11, 52, 13, 2, -52 },
  { 11758, 46, 37, 52, 2, -37 },
  { 11971, 26, 37, 32, 2, -37 },
  { 12092, 26, 38, 32, 3, -37 },
  { 12216, 30, 51, 32, -1, -37 },
  { 12408, 27, 51, 32, 3, -37 },
  { 12581, 20, 37, 20, 2, -37 },
  { 12674, 26, 38, 30, 1, -37 },
  { 12798, 14, 47, 19, 4, -46 },
  { 12881, 26, 37, 32, 4, -36 },
  { 13002, 25, 36, 28, 4, -36 },
  { 13115, 38, 36, 44, 6, -36 },
  { 13286, 29, 36, 28, -1, -36 },
  { 13417, 33, 50, 28, -3, -36 },
  { 13624, 29, 36, 28, -1, -36 },
  { 13755, 22, 69, 20, 2, -54 },
  { 13945, 11, 58, 13, 1, -49 },
  { 14025, 22, 69, 20, -5, -54 },
  { 14215, 32, 11, 40, 4, -26 },
};

const GFXfont RobotoCondensed_ThinItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ThinItalic69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ThinItalic69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_THINITALIC69PT7B_H_
