#ifndef _NOTOSANS_MEDIUMITALIC31PT7B_H_
#define _NOTOSANS_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0xF0, 0xE0, 0x79,
  0xDC, 0x77, 0x1D, 0xCE, 0x63, 0x98, 0xEE, 0x33, 0x8C, 0x00, 0xE1, 0x80,
  0x18, 0x70, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x70, 0x03, 0x0E, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xE1, 0x80, 0x1C, 0x30, 0x03,
  0x0E, 0x00, 0x61, 0xC1, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x1C,
  0x30, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x03, 0x86, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xC7, 0xB0, 0x8E, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x7B, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xDE, 0x03, 0x1C, 0x06, 0x3A,
  0x0C, 0xE7, 0x1B, 0xCF, 0xFF, 0x1F, 0xFC, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x1F, 0x80, 0x78, 0xFF, 0x01, 0x83, 0x9C, 0x0E, 0x1C,
  0x70, 0x70, 0x71, 0xC3, 0x81, 0x87, 0x0E, 0x0E, 0x1C, 0x70, 0x38, 0x73,
  0x80, 0xE1, 0x8C, 0x63, 0x8E, 0x77, 0xEE, 0x33, 0xBF, 0xDF, 0xDD, 0xE7,
  0x7E, 0x67, 0x1C, 0x03, 0x98, 0x70, 0x1C, 0xE1, 0xC0, 0xE3, 0x87, 0x03,
  0x0E, 0x18, 0x1C, 0x38, 0xE0, 0xE0, 0xE3, 0x87, 0x03, 0x9C, 0x18, 0x07,
  0xF1, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1E, 0x38, 0x03,
  0x87, 0x80, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0xC7, 0x80, 0x39, 0xE0, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x73, 0xCE, 0x0E, 0xF1,
  0xE3, 0xBC, 0x1E, 0xF7, 0x01, 0xDC, 0xE0, 0x3F, 0x1C, 0x03, 0xC3, 0xC0,
  0xFC, 0x3E, 0xFF, 0x87, 0xFF, 0x78, 0x7F, 0x87, 0x80, 0x7B, 0x9C, 0xE6,
  0x33, 0x9C, 0x01, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C,
  0x0E, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x10, 0x60, 0x61, 0x83, 0xE6,
  0x07, 0xF7, 0xC3, 0xFF, 0x07, 0xFC, 0x36, 0x03, 0xDC, 0x1E, 0x70, 0x30,
  0xE0, 0x43, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0xF3,
  0x9E, 0x71, 0xCE, 0x30, 0xFF, 0xFF, 0xFE, 0x73, 0xFE, 0xE0, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7C, 0xF1, 0xE0, 0xE3,
  0x81, 0xCF, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3B, 0x80,
  0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1C, 0xE0, 0x79,
  0xC0, 0xE3, 0xC3, 0xC7, 0xDF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xC1,
  0xF1, 0xFC, 0xFE, 0xFB, 0x9C, 0xE4, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x9F, 0x06, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xF8,
  0x3F, 0xF8, 0x78, 0xF8, 0x40, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x72, 0x01, 0xE7, 0xDF, 0x8F,
  0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x07, 0x9E, 0x03,
  0x8E, 0x03, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC3, 0xC1, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x80, 0x78, 0xFB, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x3F, 0x08, 0xF8, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x73, 0xE0, 0xEF, 0xE3, 0xFF, 0xE7, 0xC1, 0xCF, 0x03, 0xDC,
  0x07, 0xB8, 0x0F, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0xC1, 0xC3, 0xFF,
  0x87, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x1E, 0x0E, 0x0F, 0x1E, 0x07, 0x1E,
  0x07, 0x1E, 0x0F, 0x0E, 0x1E, 0x0F, 0x3C, 0x07, 0xF8, 0x07, 0xE0, 0x1F,
  0xF0, 0x3C, 0x78, 0x78, 0x3C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x1C, 0xF0, 0x3C, 0x7C, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF8, 0x7C, 0xF8, 0xE0, 0xF3, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x07,
  0x78, 0x0E, 0x70, 0x3C, 0xF0, 0xF9, 0xFF, 0x71, 0xFD, 0xC1, 0xF3, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC7, 0xBF, 0x0F, 0xFC,
  0x1F, 0xE0, 0x00, 0x0E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x1E, 0x7C, 0x70, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x30, 0x00, 0x40, 0x00, 0x3F, 0xE7, 0xFF,
  0x78, 0xF2, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x07, 0x80, 0xF8, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0,
  0x07, 0xE0, 0xF8, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x3F, 0x86, 0x70, 0x7F, 0xC7, 0x61, 0xE1, 0x87, 0xE1, 0xC3, 0x87,
  0xE3, 0x83, 0x87, 0xC3, 0x83, 0x87, 0xC3, 0x03, 0x06, 0xC7, 0x07, 0x0E,
  0xC7, 0x07, 0x0E, 0xC7, 0x0F, 0x1C, 0xC3, 0xBB, 0xF8, 0xE3, 0xF3, 0xF0,
  0xE0, 0xE1, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1C, 0xC0, 0x07,
  0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x0E, 0x0E,
  0x07, 0x83, 0x81, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1E, 0x01, 0xC7,
  0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x07, 0x78, 0x01, 0xFC, 0x00, 0x70, 0x07,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1C,
  0x78, 0x0E, 0x3C, 0x0F, 0x1C, 0x0F, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFF,
  0x83, 0x81, 0xE1, 0xC0, 0x78, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x0F, 0x38,
  0x07, 0x9C, 0x07, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0xFE, 0xF8, 0x3C, 0x02, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x40, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x03, 0xE0, 0xE0, 0x3C,
  0x1C, 0x03, 0x87, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x3C,
  0x70, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xF1,
  0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x03, 0xE1, 0xC0, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xDF, 0x07, 0x80, 0x21, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0xFF, 0x78,
  0x1F, 0xCF, 0x07, 0xF9, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xF0,
  0x07, 0x0F, 0x00, 0xE1, 0xF0, 0x3C, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x0F,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x1E, 0x1C, 0x01,
  0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x38, 0x03, 0xC3, 0x80,
  0x3C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x78, 0x70,
  0x07, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0x01,
  0xF0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xE3,
  0xC0, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3E, 0xE0, 0x03, 0x8F, 0x00, 0x38, 0x70, 0x03,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x03, 0x80, 0x70, 0x3C, 0x07, 0x01, 0xC0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC1, 0xDC, 0x07,
  0x70, 0x77, 0x01, 0xDC, 0x1C, 0xC0, 0xE7, 0x07, 0x30, 0x33, 0xC1, 0xCC,
  0x1C, 0xE0, 0xE3, 0x8E, 0x38, 0x38, 0xE3, 0x8E, 0x0E, 0x39, 0xC7, 0x83,
  0x8E, 0x71, 0xC1, 0xE3, 0xB8, 0x70, 0x70, 0xEE, 0x1C, 0x1C, 0x3F, 0x07,
  0x07, 0x07, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x38, 0x1C,
  0x0E, 0x00, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xE0, 0xF8, 0x03, 0x83, 0xF0,
  0x0E, 0x0F, 0xC0, 0x78, 0x3F, 0x01, 0xC1, 0xCE, 0x07, 0x07, 0x38, 0x1C,
  0x1C, 0xF0, 0x70, 0x71, 0xC3, 0xC1, 0xC7, 0x0E, 0x0E, 0x1E, 0x38, 0x38,
  0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0xDC, 0x1E, 0x07, 0x70, 0x70, 0x1D,
  0xC1, 0xC0, 0x3F, 0x07, 0x00, 0xFC, 0x1C, 0x03, 0xE0, 0xF0, 0x07, 0x83,
  0x80, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xBF, 0x0F, 0x81,
  0xE1, 0xE0, 0x1E, 0x78, 0x01, 0xCE, 0x00, 0x3B, 0xC0, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0xF1, 0xF0, 0x3C,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xC0, 0xF0, 0xE0, 0x78, 0x70, 0x1C, 0x78, 0x0E, 0x3C,
  0x0F, 0x1C, 0x07, 0x8E, 0x07, 0x87, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0x81,
  0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xBF, 0x0F, 0x81, 0xE1, 0xE0, 0x1E, 0x78, 0x01, 0xCE, 0x00, 0x3B,
  0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0xCF,
  0x00, 0xF1, 0xF0, 0x3C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xC0, 0xF0, 0xE0, 0x78, 0x70,
  0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xF0, 0x78, 0x38,
  0x38, 0x1E, 0x1C, 0x0F, 0x0E, 0x03, 0x8F, 0x01, 0xE7, 0x80, 0xF0, 0x03,
  0xFC, 0x1F, 0xFC, 0x7E, 0xF8, 0xF0, 0x23, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF2, 0x03, 0xC7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x78,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x71, 0xE0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80,
  0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xC1, 0xE0, 0x78, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01,
  0xCE, 0x01, 0xE7, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x78, 0x38,
  0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xCF, 0x00,
  0xE7, 0x00, 0x37, 0x80, 0x1B, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x7B, 0x80, 0x78,
  0x0E, 0x70, 0x1F, 0x01, 0xCE, 0x03, 0xE0, 0x79, 0xE0, 0xFC, 0x0E, 0x3C,
  0x1F, 0x83, 0xC7, 0x87, 0x30, 0x70, 0x70, 0xE6, 0x1E, 0x0E, 0x38, 0xC3,
  0x81, 0xC7, 0x18, 0x70, 0x39, 0xC3, 0x1C, 0x07, 0x38, 0x63, 0x80, 0xEE,
  0x0E, 0xF0, 0x1D, 0xC1, 0xDC, 0x03, 0xB8, 0x3B, 0x80, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x0E, 0x01, 0xC0,
  0x3C, 0x0F, 0x00, 0x70, 0x78, 0x01, 0xC3, 0xC0, 0x03, 0x8E, 0x00, 0x0E,
  0x70, 0x00, 0x3B, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x70, 0x0F, 0x01,
  0xE0, 0x78, 0x07, 0x83, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0x1E, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0x78, 0x70, 0x70, 0x38, 0xF0, 0x39, 0xE0, 0x39,
  0xC0, 0x3B, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xFE, 0x0F, 0xC0, 0xFC,
  0x00, 0xE0, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x66, 0x01,
  0xCE, 0x03, 0x0C, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x38, 0xC0, 0x73, 0x80,
  0x66, 0x00, 0xFC, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0x1C, 0xE3,
  0x80, 0x03, 0xE3, 0x0F, 0xF7, 0x1F, 0xFF, 0x1E, 0x1F, 0x3C, 0x1E, 0x38,
  0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x7C, 0x70, 0x7C, 0x7D, 0xF8, 0x7F, 0xB8, 0x3F, 0x38, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x78, 0x1D, 0xFC, 0x1F, 0xFE, 0x1F, 0x0E, 0x3E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70,
  0x1E, 0x70, 0x3C, 0x78, 0x3C, 0xFE, 0xF8, 0xEF, 0xF0, 0xC7, 0xE0, 0x03,
  0xFC, 0x1F, 0xE1, 0xFF, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0xEE, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x9C, 0x0F,
  0xF7, 0x07, 0xFD, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x38, 0x0E, 0x1E, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x3C, 0x07, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0x70, 0x78, 0x1F, 0x7E, 0x07, 0xFB, 0x80, 0xFC, 0xE0, 0x03,
  0xF0, 0x1F, 0xE1, 0xFF, 0xC7, 0x87, 0x3C, 0x1C, 0xE0, 0x77, 0x83, 0xDF,
  0xFE, 0x7F, 0xE3, 0xFE, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x47,
  0xC7, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x0B, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x03,
  0xE3, 0x0F, 0xF7, 0x1F, 0xFF, 0x1E, 0x1F, 0x3C, 0x1E, 0x38, 0x0E, 0x78,
  0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0,
  0x7C, 0x70, 0x7C, 0x7D, 0xF8, 0x7F, 0xB8, 0x3F, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x80, 0xF0, 0xC1, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x3C, 0x1D, 0xFE, 0x3F, 0xFC, 0x7C, 0x39, 0xF0, 0x73, 0xC0, 0xE7,
  0x81, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x80,
  0xE7, 0x03, 0xDE, 0x07, 0xB8, 0x0E, 0x70, 0x1C, 0x06, 0x0F, 0x0F, 0x06,
  0x00, 0x00, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x30, 0x03, 0xC0, 0x1E,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x81, 0x3C, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x0F,
  0x1C, 0x1E, 0x1C, 0x3C, 0x1C, 0x78, 0x3C, 0xF0, 0x39, 0xE0, 0x3B, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x79, 0xC0, 0x71, 0xE0, 0x70, 0xE0,
  0xF0, 0xF0, 0xF0, 0x70, 0xE0, 0x78, 0xE0, 0x78, 0x07, 0x07, 0x0F, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x1C, 0x78, 0x3E, 0x0E,
  0xFE, 0x3F, 0x87, 0xFF, 0xBF, 0xC3, 0xE1, 0xF0, 0xF3, 0xE0, 0xF0, 0x79,
  0xE0, 0x78, 0x3C, 0xF0, 0x38, 0x1C, 0x70, 0x3C, 0x0E, 0x38, 0x1C, 0x07,
  0x3C, 0x0E, 0x03, 0x9C, 0x07, 0x03, 0xCE, 0x03, 0x81, 0xC7, 0x03, 0xC0,
  0xE3, 0x81, 0xC0, 0x73, 0xC0, 0xE0, 0x79, 0xC0, 0x70, 0x3C, 0xE0, 0x78,
  0x1C, 0x00, 0x1C, 0x7C, 0x1D, 0xFE, 0x1F, 0xFE, 0x1F, 0x0E, 0x3E, 0x0F,
  0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x38, 0xE0, 0x38,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF0, 0xF3, 0xC0, 0xEF, 0x01, 0xDE,
  0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xE7, 0x03,
  0xCF, 0x0F, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x07, 0x1E, 0x01, 0xDF,
  0xC0, 0x7F, 0xF8, 0x1F, 0x0E, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x38, 0x0F, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x1C,
  0x0F, 0x07, 0x83, 0xC3, 0xFB, 0xE0, 0xEF, 0xF0, 0x39, 0xF8, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE3, 0x0F, 0xF7, 0x1F, 0xFF, 0x1E, 0x1F, 0x3C, 0x1E,
  0x38, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x78, 0x7D, 0xF8, 0x7F, 0xB8, 0x3F, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x1C, 0x78, 0xEF, 0x87, 0xFC, 0x3E, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0xC7, 0xFE, 0x78,
  0x23, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x40, 0x73, 0xCF, 0x9F, 0xF8, 0x7F, 0x80, 0x06, 0x01,
  0xC0, 0x38, 0x1F, 0xF7, 0xFF, 0xFF, 0x87, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x21, 0xFC,
  0x1F, 0x80, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xEE,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0, 0x3D, 0xC0, 0x73, 0x80, 0xE7, 0x03,
  0xCE, 0x0F, 0x9C, 0x1F, 0x3C, 0xFC, 0x7F, 0xB8, 0x7E, 0x70, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x78,
  0xF1, 0xC1, 0xCF, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0xFE, 0x0F, 0x83,
  0xB8, 0x3E, 0x1E, 0xE1, 0xF8, 0x73, 0x86, 0xE1, 0xCE, 0x3B, 0x8E, 0x38,
  0xEE, 0x38, 0xE7, 0x39, 0xC3, 0x9C, 0xE7, 0x0E, 0xE3, 0xBC, 0x3B, 0x86,
  0xE0, 0xEC, 0x1B, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x87, 0x03, 0x83, 0xC3, 0xC0, 0xE3, 0xC0,
  0x73, 0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xEE, 0x01, 0xE7, 0x00, 0xE3, 0xC0, 0xF0, 0xE0, 0xF0,
  0x78, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x03,
  0x81, 0xE0, 0x70, 0x38, 0x0E, 0x0F, 0x01, 0xE1, 0xC0, 0x1C, 0x78, 0x03,
  0x8E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x03, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x00, 0x78, 0x0F, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xF0, 0x0F, 0x03, 0xE0,
  0x78, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0xF8, 0x0F, 0x80, 0xE0, 0x00, 0x7E, 0x03, 0xFF, 0x9F, 0xBF, 0xFC,
  0x0F, 0xE0,
};

const GFXglyph NotoSans_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 22, 8, 1, -22 },
  { 23, 10, 8, 13, 3, -22 },
  { 33, 19, 22, 20, 1, -22 },
  { 86, 15, 26, 17, 1, -24 },
  { 135, 22, 22, 25, 2, -22 },
  { 196, 19, 22, 21, 1, -22 },
  { 249, 5, 8, 7, 3, -22 },
  { 254, 11, 27, 9, 1, -22 },
  { 292, 10, 27, 9, -2, -22 },
  { 326, 14, 15, 17, 3, -24 },
  { 353, 15, 15, 18, 2, -18 },
  { 382, 6, 8, 8, -1, -4 },
  { 388, 8, 3, 10, 1, -10 },
  { 391, 5, 4, 8, 0, -4 },
  { 394, 15, 22, 12, -1, -22 },
  { 436, 15, 22, 17, 2, -22 },
  { 478, 10, 22, 17, 4, -22 },
  { 506, 16, 22, 17, 0, -22 },
  { 550, 15, 22, 17, 1, -22 },
  { 592, 17, 22, 17, 0, -22 },
  { 639, 16, 22, 17, 1, -22 },
  { 683, 15, 22, 17, 2, -22 },
  { 725, 16, 22, 17, 2, -22 },
  { 769, 16, 22, 17, 1, -22 },
  { 813, 15, 22, 17, 1, -22 },
  { 855, 7, 17, 8, 0, -17 },
  { 870, 9, 21, 8, -2, -17 },
  { 894, 15, 16, 18, 2, -19 },
  { 924, 15, 8, 18, 2, -15 },
  { 939, 15, 16, 18, 2, -19 },
  { 969, 12, 22, 14, 2, -22 },
  { 1002, 24, 25, 26, 2, -22 },
  { 1077, 18, 22, 18, -2, -22 },
  { 1127, 17, 22, 19, 1, -22 },
  { 1174, 18, 22, 18, 2, -22 },
  { 1224, 19, 22, 21, 1, -22 },
  { 1277, 16, 22, 16, 1, -22 },
  { 1321, 16, 22, 15, 1, -22 },
  { 1365, 19, 22, 21, 2, -22 },
  { 1418, 20, 22, 21, 1, -22 },
  { 1473, 13, 22, 11, -1, -22 },
  { 1509, 14, 28, 9, -5, -22 },
  { 1558, 20, 22, 18, 1, -22 },
  { 1613, 12, 22, 15, 1, -22 },
  { 1646, 26, 22, 26, 1, -22 },
  { 1718, 22, 22, 22, 1, -22 },
  { 1779, 19, 22, 22, 2, -22 },
  { 1832, 17, 22, 18, 1, -22 },
  { 1879, 19, 27, 22, 2, -22 },
  { 1944, 17, 22, 18, 1, -22 },
  { 1991, 15, 22, 16, 1, -22 },
  { 2033, 15, 22, 16, 3, -22 },
  { 2075, 19, 22, 21, 2, -22 },
  { 2128, 17, 22, 17, 3, -22 },
  { 2175, 27, 22, 27, 3, -22 },
  { 2250, 22, 22, 17, -2, -22 },
  { 2311, 16, 22, 16, 3, -22 },
  { 2355, 19, 22, 16, -1, -22 },
  { 2408, 12, 27, 9, 0, -22 },
  { 2449, 7, 22, 12, 3, -22 },
  { 2469, 12, 27, 9, -2, -22 },
  { 2510, 15, 14, 18, 1, -22 },
  { 2537, 13, 2, 12, -3, 3 },
  { 2541, 5, 5, 9, 5, -24 },
  { 2545, 16, 17, 18, 1, -17 },
  { 2579, 16, 24, 18, 1, -24 },
  { 2627, 14, 17, 14, 1, -17 },
  { 2657, 18, 24, 18, 1, -24 },
  { 2711, 14, 17, 16, 1, -17 },
  { 2741, 17, 31, 10, -3, -24 },
  { 2807, 16, 24, 18, 1, -17 },
  { 2855, 15, 24, 18, 1, -24 },
  { 2900, 8, 23, 8, 1, -23 },
  { 2923, 13, 30, 8, -4, -23 },
  { 2972, 16, 24, 16, 1, -24 },
  { 3020, 8, 24, 8, 1, -24 },
  { 3044, 25, 17, 27, 1, -17 },
  { 3098, 16, 17, 18, 1, -17 },
  { 3132, 15, 17, 18, 1, -17 },
  { 3164, 18, 24, 18, -1, -17 },
  { 3218, 16, 24, 18, 1, -17 },
  { 3266, 13, 17, 13, 1, -17 },
  { 3294, 13, 17, 14, 0, -17 },
  { 3322, 11, 20, 11, 1, -20 },
  { 3350, 15, 17, 18, 2, -17 },
  { 3382, 14, 17, 15, 2, -17 },
  { 3412, 22, 17, 23, 2, -17 },
  { 3459, 17, 17, 15, -1, -17 },
  { 3496, 19, 24, 15, -3, -17 },
  { 3553, 15, 17, 14, -1, -17 },
  { 3585, 13, 27, 11, 0, -22 },
  { 3629, 2, 31, 17, 8, -24 },
  { 3637, 12, 27, 11, -1, -22 },
  { 3678, 15, 4, 18, 2, -13 },
};

const GFXfont NotoSans_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_MEDIUMITALIC31PT7B_H_
