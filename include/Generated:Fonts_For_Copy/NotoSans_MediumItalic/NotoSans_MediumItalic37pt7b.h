#ifndef _NOTOSANS_MEDIUMITALIC37PT7B_H_
#define _NOTOSANS_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x04, 0x00, 0x78,
  0xF7, 0x8E, 0x71, 0xE7, 0x1E, 0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1,
  0x80, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x7F, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xEE, 0xF0, 0x79, 0xC2, 0x1E,
  0x30, 0x03, 0xC6, 0x00, 0x79, 0xC0, 0x0F, 0xB8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x19, 0xE0, 0x03,
  0x1E, 0x00, 0x63, 0xC0, 0x1C, 0x71, 0x03, 0x9E, 0x38, 0x67, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x01, 0x07, 0xF0, 0x03, 0x83, 0xFE,
  0x01, 0xE0, 0xE3, 0x80, 0x70, 0x78, 0xE0, 0x38, 0x1C, 0x38, 0x1C, 0x0F,
  0x0E, 0x0F, 0x03, 0x83, 0x83, 0x80, 0xE0, 0xE1, 0xC0, 0x38, 0x38, 0xE0,
  0x0E, 0x1E, 0x78, 0x03, 0x87, 0x1C, 0xFC, 0xE1, 0xCE, 0x7F, 0xB8, 0xE7,
  0xBF, 0xEF, 0xFB, 0xDE, 0x3D, 0xFC, 0xE7, 0x0F, 0x1C, 0x71, 0xC3, 0xC0,
  0x3C, 0xF0, 0xF0, 0x1E, 0x38, 0x38, 0x07, 0x0E, 0x0E, 0x03, 0x83, 0x83,
  0x81, 0xE0, 0xE1, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x0E, 0x3C, 0x1C, 0x03,
  0xFE, 0x0F, 0x00, 0x7F, 0x87, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x9E, 0x00, 0x3C, 0x1E, 0x00, 0xF0,
  0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x8F,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xFE, 0x07, 0x9F, 0x3C, 0x0F, 0x7C, 0x3C, 0x3C, 0xF0, 0x3C, 0x7B,
  0xC0, 0x7D, 0xE7, 0x80, 0x7F, 0x8F, 0x00, 0x7F, 0x1E, 0x00, 0xFC, 0x3E,
  0x01, 0xF8, 0x3E, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xF9, 0xF0, 0x7F,
  0xC1, 0xF0, 0x7B, 0xDC, 0xE7, 0x73, 0x9C, 0xE0, 0x00, 0x78, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x10, 0x1C, 0x0E, 0x1C, 0x07, 0xCE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC3, 0xB0, 0x03, 0xDC, 0x03, 0xCE, 0x03, 0xC3, 0x80,
  0xC1, 0xC0, 0x20, 0xF0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x1F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x7F, 0xFF, 0xEF,
  0xFB, 0xFE, 0x77, 0xFF, 0xFF, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x3C,
  0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xE1,
  0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x7F,
  0x0F, 0xE3, 0xFE, 0x7F, 0xEF, 0x9E, 0x71, 0xC4, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x81,
  0xE0, 0x20, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x60, 0x3C, 0x08, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x20, 0x07, 0xC7, 0x01, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xDC, 0x00, 0x79, 0xC0, 0x07, 0xBC, 0x00, 0xF3, 0xC0,
  0x1E, 0x3C, 0x03, 0xC3, 0x80, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF1, 0x00, 0x3E, 0x38, 0x0F,
  0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xF7, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x87, 0x01, 0xE7, 0xF8, 0x7F,
  0xFE, 0x1F, 0xCF, 0xC7, 0xC0, 0xF3, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xC7, 0x81, 0xE1,
  0xF0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xF3, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x01, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0xF8, 0xF8, 0x3C, 0x0F,
  0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xE0, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9,
  0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xBC, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0xFB, 0xE0, 0xFC, 0xFF, 0xFE, 0x3F, 0xEF, 0x0F,
  0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xF1, 0x03, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F,
  0x1F, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x40, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x60, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC7, 0x80, 0xFF,
  0x8E, 0x38, 0x1F, 0xF8, 0x73, 0xC1, 0xF3, 0xC1, 0xDC, 0x1E, 0x0E, 0x0E,
  0xE1, 0xE0, 0xF0, 0x7F, 0x0E, 0x07, 0x07, 0xF0, 0xF0, 0x38, 0x3B, 0x87,
  0x01, 0xC1, 0xDC, 0x38, 0x1E, 0x0E, 0xE1, 0xC0, 0xE0, 0xF7, 0x0E, 0x0F,
  0x07, 0x38, 0x70, 0x78, 0x79, 0xC3, 0xFE, 0xFF, 0x8F, 0x0F, 0xE7, 0xF8,
  0x38, 0x3E, 0x1F, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x03,
  0xCE, 0x00, 0x0F, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x07, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xF0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x3B, 0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0x03, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC3, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80,
  0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFC, 0x02, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3C,
  0x0F, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF0, 0x01,
  0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0x83,
  0xC0, 0x3E, 0x0F, 0x01, 0xFC, 0x1E, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x08, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xC0, 0x38, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x7F, 0xCF, 0x01, 0xFF, 0x3C, 0x07, 0xFC, 0xF0,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x3C, 0x1F, 0x81, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x1E, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x78, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x04, 0x7E, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x03, 0x80,
  0x7C, 0x07, 0x80, 0xF8, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xE0, 0x07, 0x87,
  0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0xF0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x7F, 0xFD,
  0xFF, 0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x77, 0x00, 0x3F, 0xC0, 0xEE, 0x00,
  0x77, 0x03, 0xDC, 0x01, 0xEE, 0x07, 0xB8, 0x03, 0xBC, 0x0F, 0x70, 0x0F,
  0x78, 0x1C, 0xE0, 0x1C, 0xF0, 0x39, 0xC0, 0x71, 0xC0, 0xF3, 0xC1, 0xE7,
  0x81, 0xE7, 0x83, 0x8F, 0x03, 0xC7, 0x0F, 0x1E, 0x07, 0x0E, 0x1C, 0x3C,
  0x0E, 0x1C, 0x78, 0x70, 0x3C, 0x38, 0xE1, 0xE0, 0x78, 0x73, 0xC3, 0xC0,
  0xF0, 0xE7, 0x07, 0x81, 0xC1, 0xDE, 0x0F, 0x07, 0x83, 0xB8, 0x3C, 0x0F,
  0x07, 0xF0, 0x78, 0x1E, 0x0F, 0xC0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x70,
  0x1E, 0x03, 0x81, 0xE0, 0x38, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0xF8,
  0x00, 0xF0, 0x7E, 0x00, 0x38, 0x1F, 0xC0, 0x1E, 0x07, 0xF0, 0x07, 0x81,
  0xDC, 0x01, 0xE0, 0xF7, 0x80, 0x70, 0x3D, 0xE0, 0x3C, 0x0F, 0x38, 0x0F,
  0x03, 0x8F, 0x03, 0xC0, 0xE3, 0xC0, 0xF0, 0x78, 0x78, 0x38, 0x1E, 0x1E,
  0x1E, 0x07, 0x87, 0x87, 0x81, 0xC0, 0xF1, 0xE0, 0x70, 0x3C, 0x78, 0x3C,
  0x07, 0x1C, 0x0F, 0x01, 0xEF, 0x03, 0xC0, 0x7B, 0xC0, 0xE0, 0x0E, 0xF0,
  0x78, 0x03, 0xFC, 0x1E, 0x00, 0xFE, 0x07, 0x80, 0x1F, 0x81, 0xE0, 0x07,
  0xE0, 0x70, 0x01, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x0F, 0x83, 0xE0,
  0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0x03,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F,
  0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x3C, 0x07, 0xC1, 0xE1, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8,
  0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01,
  0xE3, 0xC0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0xF0,
  0x38, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x7C, 0x78, 0x03,
  0xCF, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x0F, 0x80, 0x87, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x88, 0x03, 0xE3, 0x81, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F,
  0x87, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x3F, 0x07, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0xFB,
  0x80, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E,
  0x07, 0xC0, 0x70, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F,
  0x80, 0x7F, 0xC0, 0x3F, 0x00, 0xF7, 0x80, 0x7E, 0x01, 0xEF, 0x01, 0xFC,
  0x07, 0x9E, 0x03, 0xF8, 0x0F, 0x3C, 0x0F, 0xF0, 0x3C, 0x78, 0x1D, 0xE0,
  0x78, 0xF0, 0x39, 0xC1, 0xE1, 0xE0, 0xF3, 0x83, 0xC3, 0xC1, 0xC7, 0x07,
  0x07, 0x87, 0x8E, 0x1E, 0x0F, 0x0E, 0x1C, 0x3C, 0x1E, 0x3C, 0x38, 0xF0,
  0x3C, 0x70, 0x71, 0xE0, 0x79, 0xE0, 0xE7, 0x80, 0xF3, 0x81, 0xCF, 0x01,
  0xEF, 0x03, 0x9C, 0x01, 0xDC, 0x07, 0x78, 0x03, 0xB8, 0x0E, 0xE0, 0x07,
  0xF0, 0x1D, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x0F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF7,
  0x80, 0x3E, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x1C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF1, 0xE3,
  0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x8F, 0x1E,
  0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x60, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x00,
  0xE7, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x3C, 0x0E,
  0x03, 0x81, 0xC0, 0x78, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x0E, 0xF0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF0, 0xE0,
  0xE1, 0xC0, 0x03, 0xF1, 0xE1, 0xFF, 0x38, 0x7F, 0xF7, 0x0F, 0x87, 0xE3,
  0xE0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C,
  0x07, 0xC7, 0x81, 0xF0, 0xF8, 0x7E, 0x0F, 0xFD, 0xC1, 0xFF, 0x78, 0x1F,
  0x8F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x3F, 0x01,
  0xEF, 0xF0, 0x3B, 0xFF, 0x0F, 0xE1, 0xE1, 0xF8, 0x3E, 0x3E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x7C, 0x7E,
  0x1F, 0x1F, 0xFF, 0xC3, 0x9F, 0xF0, 0x71, 0xFC, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x7F, 0xF8, 0xF8, 0x23, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x18, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xF1, 0xE0, 0xFF, 0x9C,
  0x1F, 0xFF, 0xC1, 0xF0, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF8,
  0x7E, 0x07, 0xFE, 0xE0, 0x7F, 0xDE, 0x03, 0xF1, 0xE0, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x1F, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78,
  0x3E, 0xF3, 0xFE, 0xFF, 0xF8, 0xFF, 0xF0, 0xFE, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x04, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x7F, 0xCE, 0x0F, 0xFE, 0xE0, 0xF8,
  0x7E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x87, 0x81, 0xF0, 0x7C, 0x3F, 0x03, 0xFF, 0xF0,
  0x3F, 0xEF, 0x01, 0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x80, 0x3C, 0x0F, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x1F, 0x81, 0xEF, 0xF8, 0x3B, 0xFF, 0x0F, 0xE1, 0xF1, 0xF8, 0x1E, 0x3E,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0x07,
  0x81, 0xF0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x9F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x38, 0x3E, 0x0F,
  0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xE7, 0x80, 0x3D,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0x78, 0x07, 0xCF, 0x80, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC0, 0x0E, 0x3F, 0x03, 0xF0, 0x39, 0xFE, 0x3F, 0xE0, 0xEF,
  0xFD, 0xFF, 0x87, 0xF0, 0xFF, 0x1F, 0x1F, 0x83, 0xF0, 0x3C, 0x7C, 0x0F,
  0x80, 0xF1, 0xE0, 0x3E, 0x03, 0xC7, 0x80, 0xF0, 0x1E, 0x3E, 0x03, 0xC0,
  0x78, 0xF0, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x07, 0x8F, 0x01, 0xE0, 0x1E,
  0x38, 0x07, 0x80, 0xF1, 0xE0, 0x1E, 0x03, 0xC7, 0x80, 0x70, 0x0F, 0x1E,
  0x03, 0xC0, 0x3C, 0x78, 0x0F, 0x00, 0xF3, 0xC0, 0x3C, 0x07, 0x8F, 0x00,
  0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x78, 0x0E, 0x3F, 0x81, 0xCF, 0xF8, 0x3B,
  0xFF, 0x0F, 0xE1, 0xF1, 0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x79, 0xF0,
  0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x9E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC3, 0xE1, 0xE3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x3C, 0x78, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0x8F, 0xC0, 0x1C, 0xFF, 0x00, 0xEF, 0xFC, 0x0F, 0xE1, 0xE0,
  0x7E, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x0F,
  0x00, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x87, 0xC1, 0xEF, 0xFC,
  0x0F, 0x7F, 0xC0, 0x79, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xE1, 0xFF, 0x38, 0x7F,
  0xF7, 0x0F, 0x87, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x81, 0xF0, 0xF8, 0x7E, 0x0F, 0xFF,
  0xC1, 0xFF, 0x78, 0x1F, 0x8F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x0E, 0x3E, 0x1C, 0xFC, 0x3B, 0xF8, 0xFF, 0x11, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x1E,
  0x06, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0xC0, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF8, 0x7F, 0x83, 0xF8, 0x1E, 0x01, 0xE3,
  0xC0, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x81, 0xF0, 0xF8,
  0x6E, 0x1F, 0xFD, 0xC1, 0xFF, 0x38, 0x1F, 0x8F, 0x00, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x03,
  0xC1, 0xC0, 0xF0, 0x70, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x70, 0x07, 0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0,
  0x7B, 0xC0, 0xFC, 0x0F, 0x78, 0x1F, 0x83, 0xCF, 0x07, 0x70, 0x79, 0xE0,
  0xEE, 0x0E, 0x3C, 0x3D, 0xC3, 0xC7, 0x87, 0x38, 0x78, 0x71, 0xE7, 0x1E,
  0x0E, 0x38, 0xE3, 0xC1, 0xC7, 0x1C, 0xF0, 0x39, 0xC3, 0x9E, 0x07, 0x38,
  0x73, 0x80, 0xEE, 0x0E, 0xF0, 0x1D, 0xC1, 0xDC, 0x03, 0xF8, 0x3F, 0x80,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0,
  0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0x78, 0x00, 0x78, 0xE0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F,
  0x00, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x70, 0x1E, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x39,
  0xC0, 0x00, 0x77, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x01, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x80, 0x3C, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x5F, 0xF0,
  0x1F, 0xFF, 0xBF, 0xCF, 0xFF, 0xC0, 0x7F, 0xA0, 0x01, 0x00,
};

const GFXglyph NotoSans_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 27, 10, 1, -26 },
  { 35, 12, 9, 15, 4, -26 },
  { 49, 23, 26, 24, 1, -26 },
  { 124, 19, 30, 20, 1, -28 },
  { 196, 26, 27, 30, 3, -27 },
  { 284, 23, 27, 25, 1, -27 },
  { 362, 5, 9, 9, 4, -26 },
  { 368, 13, 32, 11, 1, -26 },
  { 420, 13, 33, 11, -3, -27 },
  { 474, 17, 17, 20, 4, -28 },
  { 511, 18, 18, 21, 2, -22 },
  { 552, 8, 9, 10, -2, -4 },
  { 561, 10, 4, 12, 1, -12 },
  { 566, 5, 6, 10, 1, -5 },
  { 570, 19, 26, 14, -2, -26 },
  { 632, 18, 27, 20, 2, -27 },
  { 693, 12, 26, 20, 5, -26 },
  { 732, 20, 27, 20, 0, -27 },
  { 800, 19, 27, 20, 1, -27 },
  { 865, 20, 26, 20, 0, -26 },
  { 930, 19, 26, 20, 1, -26 },
  { 992, 18, 27, 20, 2, -27 },
  { 1053, 18, 26, 20, 3, -26 },
  { 1112, 19, 27, 20, 1, -27 },
  { 1177, 17, 27, 20, 2, -27 },
  { 1235, 8, 21, 10, 1, -20 },
  { 1256, 11, 25, 10, -2, -20 },
  { 1291, 18, 19, 21, 2, -23 },
  { 1334, 17, 10, 21, 3, -18 },
  { 1356, 18, 19, 21, 2, -23 },
  { 1399, 14, 28, 16, 3, -27 },
  { 1448, 29, 29, 31, 2, -26 },
  { 1554, 22, 26, 22, -2, -26 },
  { 1626, 21, 26, 22, 1, -26 },
  { 1695, 21, 27, 22, 3, -27 },
  { 1766, 23, 26, 25, 1, -26 },
  { 1841, 20, 26, 19, 1, -26 },
  { 1906, 20, 26, 18, 1, -26 },
  { 1971, 22, 27, 25, 3, -27 },
  { 2046, 25, 26, 25, 1, -26 },
  { 2128, 16, 26, 13, -1, -26 },
  { 2180, 17, 33, 11, -6, -26 },
  { 2251, 24, 26, 21, 1, -26 },
  { 2329, 15, 26, 18, 1, -26 },
  { 2378, 31, 26, 32, 1, -26 },
  { 2479, 26, 26, 27, 1, -26 },
  { 2564, 23, 27, 27, 3, -27 },
  { 2642, 21, 26, 21, 1, -26 },
  { 2711, 23, 33, 27, 3, -27 },
  { 2806, 20, 26, 22, 1, -26 },
  { 2871, 18, 27, 19, 1, -27 },
  { 2932, 19, 26, 19, 3, -26 },
  { 2994, 23, 26, 25, 3, -26 },
  { 3069, 21, 26, 21, 3, -26 },
  { 3138, 31, 26, 32, 4, -26 },
  { 3239, 25, 26, 20, -2, -26 },
  { 3321, 20, 26, 19, 3, -26 },
  { 3386, 22, 26, 20, -1, -26 },
  { 3458, 14, 32, 11, 0, -26 },
  { 3514, 7, 26, 14, 4, -26 },
  { 3537, 15, 32, 11, -3, -26 },
  { 3597, 19, 17, 21, 1, -27 },
  { 3638, 15, 3, 15, -3, 3 },
  { 3644, 7, 6, 11, 5, -28 },
  { 3650, 19, 20, 21, 2, -20 },
  { 3698, 19, 28, 22, 1, -28 },
  { 3765, 15, 20, 17, 2, -20 },
  { 3803, 20, 28, 22, 2, -28 },
  { 3873, 16, 20, 19, 2, -20 },
  { 3913, 21, 37, 12, -4, -28 },
  { 4011, 20, 29, 22, 1, -20 },
  { 4084, 19, 28, 22, 1, -28 },
  { 4151, 10, 27, 10, 1, -27 },
  { 4185, 16, 36, 10, -5, -27 },
  { 4257, 19, 28, 19, 1, -28 },
  { 4324, 10, 28, 10, 1, -28 },
  { 4359, 30, 20, 33, 1, -20 },
  { 4434, 19, 20, 22, 1, -20 },
  { 4482, 17, 20, 21, 2, -20 },
  { 4525, 21, 29, 22, -1, -20 },
  { 4602, 19, 29, 22, 2, -20 },
  { 4671, 15, 20, 15, 1, -20 },
  { 4709, 16, 20, 16, 0, -20 },
  { 4749, 12, 24, 13, 2, -24 },
  { 4785, 19, 20, 22, 2, -20 },
  { 4833, 18, 20, 18, 2, -20 },
  { 4878, 27, 20, 27, 2, -20 },
  { 4946, 22, 20, 18, -2, -20 },
  { 5001, 23, 29, 18, -3, -20 },
  { 5085, 18, 20, 17, -1, -20 },
  { 5130, 15, 32, 13, 0, -26 },
  { 5190, 3, 37, 20, 9, -28 },
  { 5204, 15, 32, 13, -2, -26 },
  { 5264, 18, 6, 21, 2, -16 },
};

const GFXfont NotoSans_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_MEDIUMITALIC37PT7B_H_
