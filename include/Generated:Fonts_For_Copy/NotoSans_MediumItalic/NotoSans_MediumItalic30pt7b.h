#ifndef _NOTOSANS_MEDIUMITALIC30PT7B_H_
#define _NOTOSANS_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0xF0, 0xE0, 0x73, 0xDC,
  0xE7, 0x39, 0x8E, 0x63, 0x38, 0xCC, 0x30, 0x00, 0xC3, 0x80, 0x38, 0x60,
  0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x0F, 0xFF, 0xF9,
  0xFF, 0xFE, 0x07, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x07, 0x0C, 0x00,
  0xE3, 0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xE1, 0x80, 0x18, 0x70, 0x03,
  0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFB, 0x87, 0x30, 0x1C, 0x60,
  0x38, 0xC0, 0x3B, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xCE, 0x01, 0x9C, 0x03, 0x38, 0x06, 0x73, 0x19, 0xE7, 0xFF, 0x8F, 0xFC,
  0x03, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x10, 0xFC,
  0x03, 0x0F, 0xE0, 0x38, 0xE3, 0x83, 0x87, 0x1C, 0x38, 0x30, 0xE1, 0x83,
  0x87, 0x1C, 0x1C, 0x31, 0xC0, 0xE1, 0x9C, 0x07, 0x1C, 0xCF, 0xB8, 0xCE,
  0xFE, 0xFE, 0xEE, 0x77, 0xEE, 0x61, 0x8C, 0x67, 0x0C, 0x07, 0x38, 0xE0,
  0x71, 0x87, 0x07, 0x0C, 0x38, 0x30, 0x61, 0xC3, 0x83, 0x1C, 0x38, 0x1C,
  0xE3, 0x80, 0xFE, 0x38, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x1F,
  0xF8, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0x71,
  0xE0, 0x07, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x73, 0xDE,
  0x1C, 0xF1, 0xC3, 0xBC, 0x3C, 0xE7, 0x03, 0xFC, 0xE0, 0x3F, 0x1C, 0x03,
  0xC3, 0xC0, 0xF8, 0x7E, 0xFF, 0x87, 0xFF, 0x70, 0x7F, 0x8F, 0x80, 0x77,
  0x76, 0x6E, 0xC0, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x00,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x10, 0xE0, 0xF3, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF,
  0x0F, 0x84, 0x76, 0x03, 0x98, 0x1C, 0x70, 0x30, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x3C, 0xE7, 0x9C, 0x73, 0x8C, 0x00, 0xFF, 0xFE, 0x73, 0xFE,
  0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x78,
  0xF1, 0xE1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xEE, 0x03, 0xBC, 0x07, 0x38, 0x1E, 0x70,
  0x38, 0xE0, 0xF1, 0xC1, 0xC3, 0xEF, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x03,
  0xC3, 0xE3, 0xF9, 0xFE, 0xF3, 0x99, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x0F, 0x04, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x01, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xF0, 0x81, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x01, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x72, 0x01, 0xE7, 0x9F, 0x8F,
  0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xEE, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x1C,
  0x1C, 0x3C, 0x38, 0x38, 0x78, 0x38, 0x70, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xFE,
  0x1F, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x63, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x39, 0x00, 0xF3, 0xCF, 0xC7, 0xFF, 0x07,
  0xF8, 0x00, 0x00, 0x3E, 0x07, 0xF8, 0x1F, 0xF0, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x80, 0xEF, 0xE3, 0xBF, 0xC7, 0xC3,
  0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xE3,
  0x83, 0xC3, 0xDF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFC,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x70, 0xF1, 0xE0, 0xE3, 0x81, 0xC7,
  0x03, 0x8F, 0x0F, 0x0E, 0x3C, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x03, 0xEF,
  0x8F, 0x07, 0x1C, 0x0F, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0xC0, 0xE3,
  0xC7, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xF1, 0xE3, 0xC1, 0xC7, 0x01, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xF0,
  0x3C, 0xE0, 0xF1, 0xE7, 0xE1, 0xFD, 0xC1, 0xF3, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC7, 0x3F, 0x0F, 0xFC, 0x1F, 0xE0, 0x00,
  0x04, 0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x1E, 0x7C, 0x70, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0x38, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x30, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x03,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00,
  0x00, 0x07, 0x03, 0xFE, 0x7F, 0xE3, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x70, 0x01, 0xE1, 0xC0, 0x01,
  0xC7, 0x01, 0x01, 0x9C, 0x1F, 0xE3, 0xB0, 0x7F, 0xC7, 0xE1, 0xC3, 0x8F,
  0xC7, 0x06, 0x1F, 0x0C, 0x1C, 0x3E, 0x38, 0x38, 0x7C, 0x70, 0x60, 0xD8,
  0xE1, 0xC3, 0xB1, 0xC3, 0x86, 0x63, 0xCF, 0xBC, 0xC3, 0xF7, 0xF1, 0xC3,
  0xC7, 0x83, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x10, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x03,
  0x9C, 0x01, 0xC7, 0x00, 0xF0, 0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x78, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xE3,
  0x80, 0x3D, 0xE0, 0x07, 0xF0, 0x01, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x83,
  0x83, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1C, 0x38, 0x1E,
  0x1C, 0x7E, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0x07, 0xC3, 0x80, 0xE1, 0xC0,
  0x71, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0,
  0x61, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xE1, 0xF8, 0x38, 0x1E,
  0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0xE7, 0x80,
  0x79, 0xC0, 0x3C, 0x70, 0x1F, 0x1C, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3E, 0x06,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x03, 0xFB, 0xC1, 0xFE, 0xF0, 0x7F, 0xB8, 0x01, 0xCE, 0x00,
  0x73, 0xC0, 0x1C, 0xF0, 0x0F, 0x1C, 0x03, 0x87, 0x80, 0xE0, 0xFD, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xE1, 0xE0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0,
  0x1C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0x80, 0x38, 0x38,
  0x03, 0x83, 0x80, 0x38, 0x78, 0x07, 0x87, 0x80, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x0E, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE1,
  0xC0, 0xF0, 0x38, 0x3C, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x3C, 0x70, 0x07,
  0x1C, 0x00, 0xE7, 0x80, 0x1D, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0x8E, 0x00, 0x71, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0x80, 0x70,
  0x78, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x78, 0x0E, 0x0E, 0x01, 0xE0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x87, 0xC0,
  0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xDC, 0x07, 0x70, 0xEE,
  0x03, 0xF0, 0x77, 0x03, 0xB8, 0x3B, 0x81, 0xDC, 0x1D, 0xC1, 0xCE, 0x1C,
  0xE0, 0xC7, 0x0E, 0x30, 0xE7, 0x07, 0x18, 0x63, 0x83, 0x8C, 0x71, 0xC1,
  0xC6, 0x30, 0xE1, 0xC3, 0xB8, 0xF0, 0xE1, 0xF8, 0x70, 0x70, 0xFC, 0x38,
  0x38, 0x7C, 0x1C, 0x1C, 0x3E, 0x0E, 0x1C, 0x1E, 0x0F, 0x0E, 0x07, 0x07,
  0x00, 0x0F, 0x00, 0x38, 0x7C, 0x03, 0x83, 0xE0, 0x1C, 0x1F, 0x80, 0xE0,
  0xDC, 0x07, 0x0E, 0xE0, 0x38, 0x73, 0x83, 0x83, 0x9C, 0x1C, 0x1C, 0xE0,
  0xE1, 0xE3, 0x87, 0x0E, 0x1C, 0x78, 0x70, 0xE3, 0x83, 0x83, 0x9C, 0x1C,
  0x1C, 0xE1, 0xC0, 0xE7, 0x0E, 0x03, 0xB0, 0x70, 0x1F, 0x83, 0x80, 0xFC,
  0x1C, 0x03, 0xE1, 0xC0, 0x1F, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0x8E,
  0x00, 0x7B, 0xC0, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x07, 0x8E, 0x00, 0xF1, 0xE0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1F, 0x0E, 0x07, 0x0E, 0x07,
  0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x1E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xC0, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0x8E, 0x00,
  0x7B, 0xC0, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x1C, 0xF0, 0x07,
  0x8E, 0x00, 0xE1, 0xE0, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1F, 0x0E, 0x07, 0x0E, 0x07, 0x1E,
  0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x7E, 0x3F, 0xFC, 0x3F,
  0xF0, 0x38, 0xF0, 0x38, 0x70, 0x78, 0x70, 0x78, 0x78, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x3C, 0xF0, 0x1C, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0xF0, 0x63, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE2, 0x03, 0xC7, 0xBF, 0x0F, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C,
  0x78, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x71,
  0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x00, 0x70, 0xF0, 0x1E, 0x0E, 0x07, 0x81,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0xB8,
  0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE0, 0xE0, 0xF0,
  0x70, 0x70, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0xF8, 0x0F, 0x00, 0xEE, 0x03,
  0xE0, 0x73, 0x81, 0xF8, 0x1C, 0xE0, 0x7E, 0x0E, 0x38, 0x1B, 0x83, 0x8E,
  0x0E, 0xE1, 0xE3, 0x83, 0xB8, 0x70, 0xE1, 0xCE, 0x1C, 0x38, 0x73, 0x8E,
  0x0E, 0x38, 0xE3, 0x81, 0x8E, 0x39, 0xC0, 0x67, 0x0E, 0x70, 0x19, 0xC3,
  0xB8, 0x06, 0xE0, 0xEE, 0x01, 0xB8, 0x3B, 0x80, 0x6C, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x1C, 0x07, 0x00, 0xF0, 0x78, 0x03, 0x87, 0x80,
  0x1C, 0x38, 0x00, 0x73, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x01,
  0xEE, 0x00, 0x1E, 0x78, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x78,
  0x0F, 0x01, 0xC0, 0xF0, 0x0E, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x1F, 0xE0,
  0x1C, 0x70, 0x3C, 0x70, 0x78, 0x70, 0x70, 0x70, 0xE0, 0x39, 0xE0, 0x39,
  0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0x07, 0xE0, 0xFC, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0xE0, 0xFC, 0x1F, 0x80,
  0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xE3, 0x8E, 0x38, 0xE1, 0x86,
  0x1C, 0x71, 0xC7, 0x1C, 0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x6E, 0x01, 0xCC, 0x03, 0x1C, 0x0E, 0x38, 0x18, 0x30,
  0x70, 0x70, 0xC0, 0x63, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xF1, 0xC3, 0x86, 0x1C, 0x07, 0xE7, 0x0F, 0xF6, 0x1F, 0x3E,
  0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x70, 0xF8, 0x79, 0xF8, 0x7F, 0xB8,
  0x3F, 0x30, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x7C, 0x1D, 0xFC, 0x3E, 0x3C, 0xF8, 0x39, 0xE0,
  0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x0F, 0x70, 0x1C, 0xE0, 0x39,
  0xC0, 0xF7, 0xC3, 0xCF, 0xCF, 0x9D, 0xFE, 0x31, 0xF0, 0x00, 0x07, 0xF8,
  0x7F, 0xC7, 0x84, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3E, 0x70, 0xFF, 0x83, 0xF8,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x0F, 0xCE, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x07, 0x87,
  0x03, 0xC7, 0x81, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x3C,
  0x78, 0x1C, 0x3C, 0x1E, 0x0E, 0x1F, 0x07, 0x9F, 0x83, 0xFD, 0xC0, 0xFC,
  0xC0, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0xCF, 0x07, 0x38, 0x3D, 0xE0, 0xE7,
  0x1F, 0x9F, 0xF8, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE1, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07, 0xF8, 0x07, 0xFC,
  0x04, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x17, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xE7, 0x0F,
  0xF6, 0x1E, 0x3E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x70, 0xF8, 0x79,
  0xF8, 0x7F, 0xB8, 0x3E, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x80,
  0xE0, 0xE7, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x7E, 0x1D, 0xFC,
  0x3E, 0x3C, 0xF8, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x03, 0xCE, 0x07, 0x3C,
  0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF7, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x1E, 0x00, 0x0E, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0xE0, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x2F, 0x81, 0xF8, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x01, 0x1C, 0x1E, 0x1C, 0x3C, 0x1C, 0x78, 0x3C, 0xF0, 0x39,
  0xE0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7B, 0xC0, 0x71,
  0xC0, 0x71, 0xE0, 0xF0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0x07,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0x1C, 0xF8,
  0x7E, 0x1D, 0xFC, 0xFE, 0x1B, 0x1D, 0xCF, 0x3E, 0x1F, 0x07, 0x3C, 0x1E,
  0x07, 0x3C, 0x1E, 0x07, 0x38, 0x1C, 0x0F, 0x38, 0x1C, 0x0E, 0x78, 0x1C,
  0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x38, 0x1E, 0x70, 0x38, 0x1C, 0xF0, 0x38,
  0x1C, 0xE0, 0x38, 0x1C, 0xE0, 0x78, 0x1C, 0xE0, 0x70, 0x3C, 0x00, 0x20,
  0x39, 0xF8, 0x77, 0xF8, 0xDC, 0xF3, 0xE0, 0xE7, 0x81, 0xCF, 0x03, 0x9C,
  0x0F, 0x78, 0x1C, 0xF0, 0x39, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0xDE, 0x07,
  0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x78, 0x07, 0xF0, 0x1F, 0xF0, 0x78, 0xF1,
  0xE0, 0xE3, 0x81, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0xF0, 0x1D, 0xE0,
  0x3B, 0xC0, 0x73, 0x81, 0xC7, 0x07, 0x8F, 0xBE, 0x0F, 0xF8, 0x0F, 0xE0,
  0x07, 0x3E, 0x03, 0xBF, 0x81, 0xB1, 0xE1, 0xF0, 0x70, 0xF0, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC3,
  0x81, 0xE1, 0xE1, 0xE1, 0xF9, 0xF0, 0xEF, 0xF0, 0x73, 0xE0, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x07, 0xE7, 0x0F, 0xF6, 0x1E, 0x3E, 0x3C, 0x1E, 0x38, 0x1E, 0x78,
  0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0,
  0x78, 0x70, 0xF8, 0x79, 0xF8, 0x7F, 0xB8, 0x3E, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0xF1, 0xDF, 0x1B, 0xF3, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F,
  0xF8, 0xFF, 0x8F, 0x0C, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC8, 0x0E, 0x70, 0xF3, 0xFF, 0x0F,
  0xF0, 0x06, 0x01, 0x80, 0xE0, 0x70, 0x7F, 0xFF, 0xF1, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x47,
  0xF0, 0xFC, 0x38, 0x0E, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE,
  0x07, 0x9C, 0x0E, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xE7, 0x07,
  0x8E, 0x1F, 0x1E, 0x7E, 0x3F, 0xDC, 0x3F, 0x38, 0xF0, 0x1E, 0xE0, 0x39,
  0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x71,
  0xC0, 0x67, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0xE0, 0xF0, 0x3F, 0x83, 0xC1, 0xEE, 0x0F, 0x07, 0x38, 0x7C,
  0x1C, 0xE1, 0xB0, 0xE3, 0x8E, 0xC3, 0x8E, 0x33, 0x1C, 0x39, 0xCE, 0x70,
  0xE6, 0x3B, 0x83, 0xB8, 0xEE, 0x0E, 0xE3, 0xB8, 0x3B, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x00, 0x1E, 0x07,
  0x87, 0x07, 0x83, 0xC7, 0x80, 0xE7, 0x80, 0x73, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xCE, 0x01,
  0xC7, 0x01, 0xC1, 0xC1, 0xE0, 0xE1, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0xE0,
  0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC3,
  0x80, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x09, 0xF0, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xF0, 0x1F, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x07,
  0xC0, 0xF0, 0x0F, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x81,
  0xF0, 0x0F, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0E, 0x01, 0xF0, 0x0E, 0x07, 0xC1, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0x18, 0x07,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x80, 0x20,
};

const GFXglyph NotoSans_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 21, 8, 1, -21 },
  { 22, 10, 7, 12, 3, -21 },
  { 31, 19, 21, 19, 1, -21 },
  { 81, 15, 25, 17, 1, -23 },
  { 128, 21, 22, 24, 2, -22 },
  { 186, 19, 22, 20, 1, -22 },
  { 239, 4, 7, 7, 3, -21 },
  { 243, 10, 26, 9, 1, -21 },
  { 276, 10, 27, 9, -2, -22 },
  { 310, 14, 14, 16, 3, -23 },
  { 335, 14, 15, 17, 2, -18 },
  { 362, 6, 7, 8, -1, -3 },
  { 368, 8, 2, 9, 1, -9 },
  { 370, 5, 4, 8, 0, -4 },
  { 373, 15, 21, 11, -1, -21 },
  { 413, 15, 22, 17, 1, -22 },
  { 455, 10, 21, 17, 4, -21 },
  { 482, 16, 22, 17, 0, -22 },
  { 526, 15, 22, 17, 1, -22 },
  { 568, 16, 21, 17, 0, -21 },
  { 610, 15, 21, 17, 1, -21 },
  { 650, 15, 22, 17, 2, -22 },
  { 692, 15, 21, 17, 2, -21 },
  { 732, 15, 22, 17, 1, -22 },
  { 774, 15, 22, 17, 1, -22 },
  { 816, 7, 17, 8, 0, -17 },
  { 831, 9, 21, 8, -2, -17 },
  { 855, 14, 15, 17, 2, -18 },
  { 882, 14, 9, 17, 2, -15 },
  { 898, 14, 15, 17, 2, -18 },
  { 925, 12, 22, 13, 2, -22 },
  { 958, 23, 24, 26, 2, -21 },
  { 1027, 18, 21, 17, -2, -21 },
  { 1075, 17, 21, 18, 1, -21 },
  { 1120, 17, 22, 18, 2, -22 },
  { 1167, 18, 21, 20, 1, -21 },
  { 1215, 16, 21, 16, 1, -21 },
  { 1257, 16, 21, 15, 1, -21 },
  { 1299, 18, 22, 20, 2, -22 },
  { 1349, 20, 21, 21, 1, -21 },
  { 1402, 13, 21, 10, -1, -21 },
  { 1437, 14, 27, 9, -5, -21 },
  { 1485, 19, 21, 17, 1, -21 },
  { 1535, 12, 21, 15, 1, -21 },
  { 1567, 25, 21, 26, 1, -21 },
  { 1633, 21, 21, 22, 1, -21 },
  { 1689, 19, 22, 22, 2, -22 },
  { 1742, 16, 21, 17, 1, -21 },
  { 1784, 19, 27, 22, 2, -22 },
  { 1849, 16, 21, 18, 1, -21 },
  { 1891, 15, 22, 15, 1, -22 },
  { 1933, 15, 21, 15, 3, -21 },
  { 1973, 19, 21, 20, 2, -21 },
  { 2023, 17, 21, 17, 3, -21 },
  { 2068, 26, 21, 26, 3, -21 },
  { 2137, 21, 21, 17, -2, -21 },
  { 2193, 16, 21, 16, 3, -21 },
  { 2235, 17, 21, 16, 0, -21 },
  { 2280, 11, 26, 9, 0, -21 },
  { 2316, 6, 21, 11, 3, -21 },
  { 2332, 12, 26, 9, -2, -21 },
  { 2371, 15, 14, 17, 1, -22 },
  { 2398, 13, 2, 12, -3, 3 },
  { 2402, 6, 5, 9, 4, -23 },
  { 2406, 16, 16, 17, 1, -16 },
  { 2438, 15, 23, 18, 1, -23 },
  { 2482, 13, 16, 14, 1, -16 },
  { 2508, 17, 23, 17, 1, -23 },
  { 2557, 14, 16, 15, 1, -16 },
  { 2585, 17, 30, 10, -3, -23 },
  { 2649, 16, 23, 18, 1, -16 },
  { 2695, 15, 23, 18, 1, -23 },
  { 2739, 8, 22, 8, 1, -22 },
  { 2761, 13, 29, 8, -4, -22 },
  { 2809, 16, 23, 16, 1, -23 },
  { 2855, 8, 23, 8, 1, -23 },
  { 2878, 24, 16, 27, 1, -16 },
  { 2926, 15, 17, 18, 1, -17 },
  { 2958, 15, 16, 17, 1, -16 },
  { 2988, 17, 23, 18, -1, -16 },
  { 3037, 16, 23, 17, 1, -16 },
  { 3083, 12, 16, 12, 1, -16 },
  { 3107, 13, 16, 13, 0, -16 },
  { 3133, 10, 20, 11, 1, -20 },
  { 3158, 15, 16, 18, 2, -16 },
  { 3188, 15, 16, 14, 1, -16 },
  { 3218, 22, 16, 22, 2, -16 },
  { 3262, 17, 16, 15, -1, -16 },
  { 3296, 19, 23, 14, -3, -16 },
  { 3351, 14, 16, 14, 0, -16 },
  { 3379, 12, 26, 11, 0, -21 },
  { 3418, 3, 30, 17, 7, -23 },
  { 3430, 11, 26, 11, -1, -21 },
  { 3466, 14, 5, 17, 2, -13 },
};

const GFXfont NotoSans_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_MEDIUMITALIC30PT7B_H_
