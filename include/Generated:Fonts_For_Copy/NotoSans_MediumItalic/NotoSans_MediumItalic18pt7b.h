#ifndef _NOTOSANS_MEDIUMITALIC18PT7B_H_
#define _NOTOSANS_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x60, 0x01, 0xCE, 0x00, 0xCF, 0x2D,
  0xA6, 0x90, 0x06, 0x60, 0x44, 0x04, 0xC0, 0xCC, 0x3F, 0xF0, 0x88, 0x09,
  0x81, 0x90, 0x7F, 0xE9, 0x30, 0x33, 0x03, 0x20, 0x26, 0x00, 0x04, 0x02,
  0x07, 0xEE, 0xA6, 0x83, 0x41, 0xE0, 0x78, 0x1E, 0x09, 0x84, 0x9B, 0xCF,
  0xC1, 0x80, 0x80, 0x38, 0x33, 0x61, 0x13, 0x10, 0x99, 0x8C, 0xD8, 0x64,
  0xBB, 0x6B, 0x6E, 0xD3, 0x0D, 0x98, 0x4C, 0xC6, 0x64, 0x63, 0x66, 0x0E,
  0x00, 0x0F, 0x03, 0x60, 0xC6, 0x18, 0x83, 0x30, 0x3C, 0x0E, 0x03, 0x63,
  0xC6, 0xD8, 0xF3, 0x0C, 0x77, 0xC7, 0xCC, 0xFE, 0x80, 0x0C, 0x63, 0x08,
  0x61, 0x0C, 0x30, 0xC2, 0x08, 0x20, 0xC3, 0x0C, 0x10, 0x18, 0x20, 0x83,
  0x0C, 0x30, 0xC3, 0x08, 0x61, 0x84, 0x31, 0x86, 0x30, 0x0C, 0x08, 0x88,
  0xE8, 0x1F, 0x38, 0xE8, 0x4C, 0x08, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x36, 0x6C, 0x7F, 0xC0, 0xFC, 0x01, 0x80,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C,
  0x00, 0x1E, 0x1F, 0x9C, 0xCC, 0x36, 0x1E, 0x0F, 0x05, 0x86, 0xC3, 0x61,
  0xB1, 0x9D, 0xC7, 0xC0, 0x0C, 0xFF, 0xD3, 0x18, 0x61, 0x86, 0x10, 0xC3,
  0x0C, 0x30, 0x0F, 0x0F, 0xE1, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0x0F, 0xE1, 0x1C, 0x02,
  0x01, 0x81, 0xC1, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x33, 0x9C, 0xFE, 0x00,
  0x01, 0xC0, 0xE0, 0x78, 0x16, 0x0D, 0x86, 0x43, 0x31, 0x8C, 0xC3, 0x7F,
  0xE0, 0x60, 0x18, 0x06, 0x00, 0x3F, 0x9F, 0x8C, 0x04, 0x06, 0x03, 0xE1,
  0xF8, 0x06, 0x03, 0x01, 0x81, 0x99, 0xCF, 0xC0, 0x0F, 0x8F, 0xCC, 0x0C,
  0x06, 0x02, 0xF3, 0xDD, 0x86, 0xC3, 0x61, 0xB0, 0xCD, 0xC7, 0xC0, 0x7F,
  0xBF, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0C,
  0x0E, 0x00, 0x1F, 0x1D, 0xCC, 0x6C, 0x33, 0x31, 0xF0, 0xF0, 0xCC, 0xC3,
  0x61, 0xB0, 0xDC, 0xC7, 0xC0, 0x1E, 0x3F, 0x63, 0x41, 0xC1, 0xC3, 0x67,
  0x7F, 0x03, 0x06, 0x06, 0x9C, 0xF8, 0x33, 0x30, 0x00, 0x00, 0xEE, 0x18,
  0xC6, 0x00, 0x00, 0x00, 0x33, 0x19, 0x80, 0x00, 0x81, 0xC3, 0x87, 0x0E,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x38, 0xF1, 0xE0, 0x80, 0x00, 0x3C,
  0xFC, 0x18, 0x30, 0x61, 0x86, 0x18, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x03,
  0xE0, 0x3F, 0xC3, 0x01, 0x88, 0x03, 0x67, 0xCF, 0x31, 0x3C, 0x8C, 0xF6,
  0x33, 0x98, 0x8B, 0x66, 0x6C, 0xEF, 0x10, 0x00, 0x60, 0x00, 0xFF, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x4C, 0x19, 0x86, 0x30,
  0xC6, 0x3F, 0xC6, 0x19, 0x83, 0x30, 0x6C, 0x06, 0x3F, 0x0F, 0xE3, 0x1C,
  0xC3, 0x61, 0x99, 0xE7, 0xE1, 0x8C, 0x61, 0xB0, 0x6C, 0x3B, 0xFC, 0xFE,
  0x00, 0x07, 0xC7, 0xF3, 0x81, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0xC3, 0x18, 0x66,
  0x0C, 0xC1, 0xD8, 0x33, 0x06, 0x60, 0xD8, 0x3B, 0x0E, 0x7F, 0x8F, 0xC0,
  0x3F, 0x9F, 0xCC, 0x06, 0x06, 0x03, 0xF9, 0xF8, 0xC0, 0x60, 0x60, 0x30,
  0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0xCC, 0x06, 0x06, 0x03, 0x01, 0xFC, 0xFC,
  0x60, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x07, 0xC3, 0xFC, 0xE0, 0x38, 0x06,
  0x00, 0xC0, 0x30, 0xF6, 0x1E, 0xC0, 0xD8, 0x19, 0x86, 0x3F, 0xC3, 0xF8,
  0x30, 0x66, 0x0C, 0xC1, 0x98, 0x36, 0x06, 0xFF, 0x9F, 0xF3, 0x06, 0x60,
  0xD8, 0x13, 0x06, 0x60, 0xCC, 0x18, 0x3E, 0x38, 0x60, 0xC1, 0x83, 0x0C,
  0x18, 0x30, 0x60, 0x83, 0x0F, 0x80, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0xF0, 0x40, 0x30,
  0xE6, 0x38, 0xCE, 0x19, 0x86, 0x60, 0xD8, 0x1F, 0x03, 0x60, 0x66, 0x18,
  0xC3, 0x18, 0x61, 0x8C, 0x30, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30,
  0x61, 0x83, 0x07, 0xFF, 0xC0, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xCA, 0x0B,
  0x68, 0x69, 0xB1, 0x66, 0xCD, 0x9B, 0x26, 0x4D, 0x9B, 0x34, 0x4C, 0x73,
  0x31, 0x8C, 0xC6, 0x30, 0x38, 0x33, 0x83, 0x38, 0x32, 0xC2, 0x6C, 0x66,
  0x46, 0x66, 0x66, 0x66, 0x42, 0x4C, 0x3C, 0xC3, 0xCC, 0x1C, 0xC1, 0x80,
  0x0F, 0x83, 0xF8, 0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1D, 0x83, 0x3F, 0xC3, 0xF0, 0x3F, 0x1F, 0xCC, 0x66, 0x16, 0x1B,
  0x0D, 0xFC, 0xFC, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x0F, 0x83, 0xF8,
  0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1D, 0x83,
  0x3F, 0xC3, 0xF0, 0x0E, 0x00, 0xC0, 0x0C, 0x3F, 0x1F, 0xCC, 0x66, 0x36,
  0x1B, 0x0D, 0xFC, 0xF8, 0x66, 0x63, 0x31, 0xD8, 0x6C, 0x30, 0x0F, 0x8F,
  0xCC, 0x06, 0x03, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x01, 0x80, 0xDD, 0xCF,
  0xC0, 0xFF, 0xFF, 0x86, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x0C, 0x06, 0x00, 0x30, 0x66, 0x0C, 0xC1, 0x90, 0x36, 0x06, 0xC1,
  0x98, 0x33, 0x06, 0xC0, 0xD8, 0x33, 0x86, 0x3F, 0x83, 0xE0, 0xC0, 0xF0,
  0x6C, 0x1B, 0x0C, 0xC2, 0x31, 0x8C, 0xC3, 0x30, 0xD8, 0x16, 0x05, 0x01,
  0xC0, 0x60, 0x00, 0xC3, 0x07, 0x86, 0x0F, 0x1E, 0x36, 0x3C, 0x6C, 0x59,
  0x99, 0xB3, 0x32, 0x6C, 0x6C, 0xD8, 0xD1, 0xA1, 0xE3, 0xC3, 0xC7, 0x87,
  0x0E, 0x0E, 0x1C, 0x00, 0x18, 0x30, 0x86, 0x0C, 0xE0, 0xCC, 0x05, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0x98, 0x31, 0x86, 0x18, 0xE0, 0xC0,
  0xC1, 0xE1, 0xB1, 0x88, 0xC6, 0xC3, 0xC1, 0xE0, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x06, 0x00, 0x1F, 0xCF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x0C, 0x06, 0x03, 0xFC, 0xFF, 0x00, 0x1E, 0x3C, 0x41, 0x83,
  0x06, 0x0C, 0x10, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x3C, 0x78, 0xCC, 0xCC,
  0x44, 0x66, 0x66, 0x22, 0x30, 0x1E, 0x38, 0x30, 0x60, 0xC1, 0x82, 0x0C,
  0x18, 0x30, 0x60, 0x83, 0x06, 0x3C, 0x70, 0x08, 0x0E, 0x07, 0x06, 0x82,
  0x63, 0x13, 0x0D, 0x83, 0xFF, 0xD9, 0x80, 0x1D, 0x9F, 0xD8, 0xFC, 0x6C,
  0x36, 0x1B, 0x0D, 0x8E, 0xEA, 0x3B, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x33, 0x0F, 0xE3, 0x8C, 0xC3, 0x30, 0xD8, 0x66, 0x19, 0x86, 0x77, 0x37,
  0x80, 0x1E, 0x7D, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE4, 0xF8, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x1D, 0x8F, 0xE6, 0x3B, 0x8C, 0xC3, 0x30, 0xCC, 0x33,
  0x18, 0xEA, 0x1D, 0x80, 0x1E, 0x3F, 0x63, 0xC3, 0xFE, 0xF8, 0xC0, 0xC0,
  0xE6, 0x7C, 0x01, 0xC0, 0xF0, 0x60, 0x18, 0x0F, 0x87, 0xC0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x38,
  0x00, 0x0E, 0x47, 0xF3, 0x1D, 0xC6, 0x61, 0x98, 0x66, 0x19, 0x8E, 0x75,
  0x0E, 0xC0, 0x30, 0x0C, 0xC6, 0x3F, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x33, 0x8F, 0xE3, 0x8C, 0xC3, 0x31, 0x98, 0x66, 0x19, 0x86, 0x61, 0x30,
  0xC0, 0x18, 0xC0, 0x63, 0x18, 0xC6, 0x63, 0x18, 0xCC, 0x00, 0x06, 0x0C,
  0x00, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x38,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0xCC, 0x63, 0x30, 0xD8, 0x2C,
  0x1F, 0x06, 0x61, 0x98, 0x63, 0x30, 0xC0, 0x18, 0xC6, 0x33, 0x18, 0xC6,
  0x33, 0x18, 0xC6, 0x60, 0x33, 0x1C, 0x7F, 0x7C, 0xE7, 0x19, 0x8E, 0x33,
  0x18, 0x6C, 0x30, 0x98, 0x63, 0x30, 0x86, 0x63, 0x0D, 0x86, 0x18, 0x33,
  0x8F, 0xE3, 0x8C, 0xC3, 0x31, 0x98, 0x66, 0x19, 0x86, 0x61, 0x30, 0xC0,
  0x1E, 0x3F, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xEE, 0x7C, 0x33, 0x0F,
  0xE3, 0x8C, 0xC3, 0x30, 0xD8, 0x66, 0x19, 0x86, 0x77, 0x17, 0x8C, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x1C, 0x9F, 0xD8, 0xFC, 0x6C, 0x36, 0x1B, 0x0D,
  0x8E, 0xEA, 0x3B, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x37, 0x3F, 0x38, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x1F, 0x3E, 0x60, 0x60, 0x38, 0x1C,
  0x0E, 0x06, 0xCC, 0xFC, 0x10, 0xC7, 0xFF, 0x61, 0x86, 0x30, 0xC3, 0x0D,
  0x3C, 0x61, 0xB0, 0xD8, 0x6C, 0x24, 0x36, 0x1B, 0x0D, 0x8E, 0xCA, 0x39,
  0x00, 0xC3, 0xE1, 0xB1, 0x98, 0xCC, 0xC6, 0x61, 0x60, 0xB0, 0x70, 0x38,
  0x00, 0xC7, 0x1E, 0x38, 0xF3, 0xCD, 0x9E, 0x6C, 0xB6, 0x6D, 0xB3, 0x4F,
  0x1E, 0x78, 0xE3, 0x87, 0x1C, 0x00, 0x30, 0xE3, 0x38, 0x66, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x81, 0x98, 0x33, 0x1C, 0x30, 0x18, 0x71, 0x86, 0x18,
  0xC1, 0x8C, 0x19, 0x80, 0x98, 0x0B, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x18, 0x0F, 0x00, 0x3F, 0x3F, 0x06, 0x0C, 0x1C, 0x18, 0x30,
  0x60, 0xC2, 0xFC, 0x06, 0x1C, 0x20, 0xC1, 0x83, 0x0C, 0x70, 0xE0, 0x60,
  0xC1, 0x06, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x38,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0x0E, 0x30, 0x40, 0x83, 0x06, 0x38, 0x60,
  0x20, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 6, 5, 7, 2, -13 },
  { 14, 12, 13, 12, 0, -13 },
  { 34, 9, 15, 10, 1, -14 },
  { 51, 13, 13, 15, 1, -13 },
  { 73, 11, 13, 12, 1, -13 },
  { 91, 2, 5, 4, 2, -13 },
  { 93, 6, 16, 5, 1, -13 },
  { 105, 6, 16, 5, -1, -13 },
  { 117, 8, 9, 10, 2, -14 },
  { 126, 9, 9, 10, 1, -11 },
  { 137, 4, 4, 5, -1, -2 },
  { 139, 5, 2, 6, 0, -6 },
  { 141, 3, 2, 5, 0, -2 },
  { 142, 9, 13, 7, -1, -13 },
  { 157, 9, 13, 10, 1, -13 },
  { 172, 6, 13, 10, 2, -13 },
  { 182, 10, 13, 10, 0, -13 },
  { 199, 10, 13, 10, 0, -13 },
  { 216, 10, 13, 10, 0, -13 },
  { 233, 9, 13, 10, 1, -13 },
  { 248, 9, 13, 10, 1, -13 },
  { 263, 9, 13, 10, 1, -13 },
  { 278, 9, 13, 10, 1, -13 },
  { 293, 8, 13, 10, 1, -13 },
  { 306, 4, 10, 5, 0, -10 },
  { 311, 5, 12, 5, -1, -10 },
  { 319, 9, 9, 10, 1, -11 },
  { 330, 9, 5, 10, 1, -9 },
  { 336, 9, 9, 10, 1, -11 },
  { 347, 7, 13, 8, 1, -13 },
  { 359, 14, 15, 15, 1, -13 },
  { 386, 11, 13, 10, -1, -13 },
  { 404, 10, 13, 11, 1, -13 },
  { 421, 10, 13, 11, 1, -13 },
  { 438, 11, 13, 12, 1, -13 },
  { 456, 9, 13, 9, 1, -13 },
  { 471, 9, 13, 9, 1, -13 },
  { 486, 11, 13, 12, 1, -13 },
  { 504, 11, 13, 12, 1, -13 },
  { 522, 7, 13, 6, 0, -13 },
  { 534, 8, 17, 5, -3, -13 },
  { 551, 11, 13, 10, 1, -13 },
  { 569, 7, 13, 9, 1, -13 },
  { 581, 14, 13, 15, 1, -13 },
  { 604, 12, 13, 13, 1, -13 },
  { 624, 11, 13, 13, 1, -13 },
  { 642, 9, 13, 10, 1, -13 },
  { 657, 11, 16, 13, 1, -13 },
  { 679, 9, 13, 11, 1, -13 },
  { 694, 9, 13, 9, 0, -13 },
  { 709, 9, 13, 9, 2, -13 },
  { 724, 11, 13, 12, 1, -13 },
  { 742, 10, 13, 10, 2, -13 },
  { 759, 15, 13, 16, 2, -13 },
  { 784, 12, 13, 10, -1, -13 },
  { 804, 9, 13, 9, 2, -13 },
  { 819, 10, 13, 10, 0, -13 },
  { 836, 7, 16, 5, 0, -13 },
  { 850, 4, 13, 7, 2, -13 },
  { 857, 7, 16, 5, -1, -13 },
  { 871, 9, 8, 10, 1, -13 },
  { 880, 8, 1, 7, -2, 2 },
  { 881, 3, 3, 5, 3, -14 },
  { 883, 9, 10, 10, 1, -10 },
  { 895, 10, 14, 11, 0, -14 },
  { 913, 7, 10, 8, 1, -10 },
  { 922, 10, 14, 11, 1, -14 },
  { 940, 8, 10, 9, 1, -10 },
  { 950, 10, 18, 6, -2, -14 },
  { 973, 10, 14, 11, 0, -10 },
  { 991, 10, 14, 11, 0, -14 },
  { 1009, 5, 13, 5, 0, -13 },
  { 1018, 7, 17, 5, -2, -13 },
  { 1033, 10, 14, 9, 0, -14 },
  { 1051, 5, 14, 5, 0, -14 },
  { 1060, 15, 10, 16, 0, -10 },
  { 1079, 10, 10, 11, 0, -10 },
  { 1092, 8, 10, 10, 1, -10 },
  { 1102, 10, 14, 11, 0, -10 },
  { 1120, 9, 14, 11, 1, -10 },
  { 1136, 8, 10, 7, 0, -10 },
  { 1146, 8, 10, 8, 0, -10 },
  { 1156, 6, 12, 6, 1, -12 },
  { 1165, 9, 10, 11, 1, -10 },
  { 1177, 9, 10, 9, 1, -10 },
  { 1189, 13, 10, 13, 1, -10 },
  { 1206, 11, 10, 9, -1, -10 },
  { 1220, 12, 14, 9, -2, -10 },
  { 1241, 8, 10, 8, 0, -10 },
  { 1251, 7, 16, 6, 0, -13 },
  { 1265, 2, 18, 10, 4, -14 },
  { 1270, 7, 16, 6, -1, -13 },
  { 1284, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_MEDIUMITALIC18PT7B_H_
