#ifndef _NOTOSANS_MEDIUMITALIC32PT7B_H_
#define _NOTOSANS_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xE0,
  0x79, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x18, 0xC3, 0x18, 0xE7, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x30, 0x01, 0x87, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x30, 0x60,
  0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x61, 0xC0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3,
  0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x66, 0x1C, 0x60, 0x1C,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x01, 0xBC, 0x01, 0x9C, 0x03, 0x9C, 0x03, 0x1C, 0x83, 0x3C, 0xF3,
  0x78, 0xFF, 0xF0, 0x7F, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x38, 0x3F, 0x80, 0x60, 0xF7, 0x01, 0xC1, 0xC6, 0x07,
  0x07, 0x0E, 0x1C, 0x0E, 0x18, 0x30, 0x18, 0x30, 0xE0, 0x70, 0xE3, 0x80,
  0xE1, 0xCE, 0x01, 0xC3, 0x9C, 0xF3, 0x8E, 0x77, 0xF3, 0xBD, 0xDE, 0xE7,
  0xF7, 0x38, 0xE7, 0xCE, 0xE1, 0xC0, 0x39, 0xC3, 0x80, 0xE3, 0x87, 0x03,
  0x87, 0x0C, 0x07, 0x0C, 0x38, 0x1C, 0x18, 0x70, 0x70, 0x30, 0xC1, 0xC0,
  0x73, 0x83, 0x80, 0xFE, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x07,
  0x0F, 0x00, 0x71, 0xE0, 0x07, 0x3C, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xE0, 0xF7, 0xCF, 0x0E, 0x70, 0x79, 0xEF, 0x07, 0x9C,
  0xF0, 0x3F, 0x8E, 0x01, 0xF8, 0xF0, 0x0F, 0x0F, 0x03, 0xF0, 0x7F, 0xFF,
  0x87, 0xFF, 0x3C, 0x1F, 0xC3, 0xE0, 0x7B, 0xDC, 0xE7, 0x31, 0x9C, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03,
  0x80, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x03, 0x0C, 0x07, 0x98, 0x1F, 0xF0,
  0x07, 0xFF, 0x83, 0xFF, 0x0F, 0x82, 0x3B, 0x80, 0xF3, 0x03, 0xC7, 0x03,
  0x0E, 0x02, 0x1E, 0x00, 0x20, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C,
  0xF3, 0x9E, 0x71, 0xCE, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0xF0, 0xF3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xB8, 0x07,
  0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0x73, 0x81, 0xE7, 0x87, 0x87, 0xFE, 0x0F,
  0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x3F, 0x1F, 0xE7, 0xFD, 0xF7,
  0x18, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xC0, 0xF0, 0x40, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x0C, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x80, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xB8,
  0x03, 0xBC, 0x03, 0x9C, 0x03, 0xCE, 0x03, 0xC7, 0x03, 0xC7, 0x81, 0xC3,
  0xC1, 0xC1, 0xC1, 0xC0, 0xE1, 0xC0, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x80, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x80, 0x73, 0xF0, 0x7F, 0xF8, 0xFC, 0x7C, 0xF8, 0x3C,
  0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38,
  0xF0, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF,
  0x0F, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x0E, 0x0F, 0x0F, 0x1E,
  0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x3C, 0x3C, 0x78, 0x1C,
  0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x70, 0x3C, 0x7C, 0x7C,
  0x3F, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E,
  0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0F,
  0x38, 0x1F, 0x3C, 0x3E, 0x1F, 0xEE, 0x1F, 0xEE, 0x03, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0x00, 0x08, 0x3C, 0xF9, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0xF1, 0xC0, 0x01, 0x00, 0xF0, 0x7C, 0x1E, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x3E,
  0x00, 0x60, 0x00, 0x1F, 0xC3, 0xFF, 0x9F, 0xFC, 0x40, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0xE0, 0x38, 0x1C, 0x60, 0x7F, 0x86, 0x70, 0xFF, 0xC3, 0x30, 0xF0, 0xE1,
  0xF8, 0x70, 0x70, 0xFC, 0x70, 0x70, 0x6E, 0x38, 0x38, 0x36, 0x1C, 0x1C,
  0x3B, 0x0C, 0x0C, 0x1D, 0x86, 0x0E, 0x1C, 0xE3, 0x8F, 0x0E, 0x71, 0xFF,
  0xFE, 0x38, 0x7E, 0x7E, 0x1C, 0x0C, 0x18, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x02, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3,
  0x80, 0x3C, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07,
  0x1E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x38, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0x80, 0xF0,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x07, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3C, 0x7E, 0x0F, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1E, 0x38, 0x07,
  0x9E, 0x01, 0xC7, 0x80, 0xF1, 0xC0, 0x7C, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3E, 0x02, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x10, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x07, 0x83, 0xE0, 0xF0, 0x3E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0xF0,
  0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0xC0,
  0x1E, 0x78, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x1E, 0x38, 0x03, 0xCF, 0x00,
  0xF1, 0xE0, 0x3E, 0x38, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xE0,
  0x61, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x1F, 0xEF, 0x03, 0xFD, 0xE0, 0x7F,
  0xBC, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0xF1, 0xE0, 0x1E,
  0x3E, 0x03, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0x00,
  0x38, 0x38, 0x03, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x07,
  0x00, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1E, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1C, 0x1E, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0x00, 0xF0, 0x70, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x0E, 0x0F, 0x00,
  0xE1, 0xE0, 0x0E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xCF, 0x00,
  0x1D, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x80, 0x38, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xC0, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xEC, 0x03, 0xB8, 0x7B, 0x01,
  0xCE, 0x1C, 0xE0, 0x77, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73,
  0x87, 0x1C, 0x3C, 0xE1, 0xC7, 0x0E, 0x38, 0xE3, 0xC3, 0x8E, 0x38, 0xE0,
  0xE3, 0x9C, 0x38, 0x38, 0x67, 0x0E, 0x1C, 0x1B, 0x87, 0x87, 0x07, 0xE1,
  0xE1, 0xC1, 0xF0, 0x70, 0x70, 0x78, 0x1C, 0x3C, 0x1E, 0x07, 0x0E, 0x07,
  0x03, 0xC0, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0xFC, 0x01, 0xC3, 0xF0,
  0x0F, 0x0F, 0xC0, 0x38, 0x3F, 0x80, 0xE0, 0xEE, 0x03, 0x87, 0xB8, 0x1E,
  0x1C, 0xF0, 0x78, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x0E, 0x1C, 0x3C,
  0x38, 0xF0, 0xE0, 0xF3, 0x83, 0x81, 0xCE, 0x0E, 0x07, 0x38, 0x38, 0x1E,
  0xE1, 0xC0, 0x3F, 0x87, 0x00, 0xFC, 0x1C, 0x03, 0xF0, 0x70, 0x07, 0xC3,
  0xC0, 0x1F, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xF8, 0x3E, 0x1E, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xE7, 0x00, 0x3C, 0x78, 0x07, 0xC7, 0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C,
  0x1E, 0x0F, 0x03, 0x83, 0x80, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03,
  0x87, 0x01, 0xE1, 0xC0, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1E, 0x01, 0xE3, 0xC0, 0x0F, 0x3C,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xE7, 0x00, 0x3C, 0x78, 0x07, 0x87, 0xC0, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xC1, 0xE1, 0xF0, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1E,
  0x07, 0x8E, 0x03, 0xC7, 0x07, 0xC3, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x80,
  0xE1, 0xE0, 0x70, 0xF0, 0x38, 0x38, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x03,
  0x87, 0x01, 0xE7, 0x80, 0x73, 0xC0, 0x3C, 0x03, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x1E, 0x06, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x80, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x71, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70,
  0x70, 0x0F, 0x07, 0x81, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0xC0, 0x1C, 0xF0, 0x0F,
  0x3C, 0x03, 0x87, 0x01, 0xE1, 0xC0, 0x70, 0x70, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x81, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0x9C, 0x01, 0xEF,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x1E,
  0xF0, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0x1C, 0xF0, 0x3F, 0x03, 0xCF, 0x03,
  0xF0, 0x38, 0x70, 0x77, 0x07, 0x87, 0x07, 0x70, 0x70, 0x70, 0xE7, 0x0F,
  0x07, 0x0E, 0x70, 0xE0, 0x71, 0xE7, 0x0E, 0x07, 0x1C, 0x71, 0xE0, 0x71,
  0xC7, 0x1C, 0x07, 0x38, 0x73, 0xC0, 0x73, 0x87, 0x38, 0x07, 0x70, 0x77,
  0x80, 0x77, 0x07, 0x70, 0x07, 0xE0, 0x77, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x70,
  0x3C, 0x01, 0xE1, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x38, 0x00, 0x3D, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8F,
  0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x70, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xE0, 0x0E, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0xF8, 0x07, 0x9C, 0x07,
  0x8E, 0x03, 0x87, 0x03, 0xC3, 0xC3, 0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x39,
  0xE0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0xE1, 0xC3, 0x80, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x1C, 0x30, 0x0E, 0x70,
  0x0E, 0x60, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0x9C, 0xE3,
  0x8C, 0x00, 0x80, 0x03, 0xF9, 0xC3, 0xFE, 0xE3, 0xE7, 0xE3, 0xE0, 0xF1,
  0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07,
  0x9E, 0x03, 0xCF, 0x03, 0xC3, 0x81, 0xE1, 0xC1, 0xF0, 0xFB, 0xB8, 0x3F,
  0x9C, 0x0F, 0x9C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x10, 0x1E, 0xFC, 0x1D, 0xFE, 0x1F, 0x9F,
  0x1F, 0x0F, 0x3E, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0xFE, 0xF8,
  0xEF, 0xF0, 0xE7, 0xE0, 0x00, 0x40, 0x1F, 0xF0, 0xFF, 0xC7, 0xC6, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x81, 0x1F, 0xBC, 0x3F, 0xF0, 0x7F, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x08, 0x38, 0x1F, 0xDE, 0x0F, 0xFF, 0x07, 0xC7, 0xC3, 0xE0,
  0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x7C, 0x1F,
  0x77, 0x03, 0xF9, 0xC0, 0x7C, 0x60, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xF0,
  0xF8, 0xE3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0x3C, 0x3E, 0x7F, 0xF8, 0xFF,
  0xC1, 0xF8, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x02, 0x3F, 0x78,
  0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xF1, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x03, 0xF9,
  0xC3, 0xFE, 0xE3, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0,
  0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC3,
  0x81, 0xE1, 0xC1, 0xF0, 0xFB, 0xB8, 0x3F, 0xBC, 0x0F, 0x9C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x83, 0x07, 0xC1, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x10, 0x1E, 0xFE, 0x1D, 0xFE, 0x1F, 0x8F,
  0x1F, 0x0F, 0x3E, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E,
  0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C,
  0xE0, 0x3C, 0xE0, 0x3C, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x7E, 0x03, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x02, 0x3C,
  0x1E, 0x1C, 0x1E, 0x0E, 0x1E, 0x07, 0x1E, 0x07, 0x9E, 0x03, 0xDE, 0x01,
  0xDE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7D, 0xC0, 0x3C, 0xF0, 0x1C, 0x38,
  0x0E, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0x81, 0xE1, 0xC0, 0x78, 0x07,
  0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x00,
  0x10, 0x04, 0x07, 0x3F, 0x0F, 0xC1, 0xDF, 0xE7, 0xF8, 0x7E, 0x7B, 0x9E,
  0x1F, 0x0F, 0xC3, 0xCF, 0x83, 0xE0, 0xF3, 0xC0, 0xF0, 0x38, 0xF0, 0x3C,
  0x0E, 0x38, 0x0E, 0x03, 0x8E, 0x07, 0x81, 0xE7, 0x81, 0xE0, 0x79, 0xE0,
  0x70, 0x1C, 0x70, 0x1C, 0x07, 0x1C, 0x07, 0x01, 0xC7, 0x03, 0xC0, 0xF3,
  0xC0, 0xF0, 0x3C, 0xE0, 0x38, 0x0E, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x1C, 0xFE, 0x1D, 0xFF, 0x1F, 0x8F, 0x1F, 0x0F, 0x3E, 0x07, 0x3C, 0x0F,
  0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E,
  0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xE0, 0x3C, 0x00, 0x40,
  0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0x3E, 0x3C, 0x0E, 0x3C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0xF0, 0x0E, 0x70, 0x1E,
  0x70, 0x1C, 0x78, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x04,
  0x01, 0xCF, 0xC0, 0x77, 0xF8, 0x1F, 0x9F, 0x07, 0xC3, 0xC3, 0xE0, 0x70,
  0xF0, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0xFE, 0xF8, 0x3B, 0xFC,
  0x0E, 0x7E, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x03,
  0xF9, 0xC3, 0xFE, 0xE3, 0xE3, 0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C,
  0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xC3, 0x81, 0xE1, 0xC1, 0xF0, 0xFB, 0xB8, 0x3F, 0xBC, 0x0F, 0x9C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x30, 0xE7, 0xC7, 0x7E, 0x3F, 0xE1,
  0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x3F, 0xF1, 0xFF, 0x87, 0x86, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC8,
  0x0F, 0x3C, 0xF8, 0xFF, 0xE1, 0xFE, 0x00, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x07, 0xFE, 0xFF, 0xE7, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFC, 0x3F, 0x83, 0xF0,
  0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E,
  0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x78,
  0xE0, 0x78, 0xE0, 0xF8, 0xFF, 0xB8, 0xFF, 0x38, 0x7E, 0x30, 0xE0, 0x1F,
  0xC0, 0x7B, 0x80, 0xF7, 0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x3C, 0x38, 0x78,
  0xF0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x3B,
  0x83, 0xE0, 0xF7, 0x06, 0xC1, 0xCE, 0x1D, 0x87, 0x9C, 0x3B, 0x0E, 0x38,
  0xE6, 0x1C, 0x71, 0xCC, 0x78, 0xE7, 0x1C, 0xE1, 0xCE, 0x3B, 0xC3, 0x98,
  0x77, 0x07, 0x70, 0xFE, 0x0E, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0xC3, 0xC1, 0xE0,
  0x70, 0xF0, 0x1E, 0x78, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3D, 0xC0, 0x1E, 0x78,
  0x07, 0x0E, 0x03, 0xC3, 0xC1, 0xE0, 0x70, 0xF0, 0x1E, 0x00, 0x07, 0x00,
  0xF0, 0x70, 0x1E, 0x07, 0x01, 0xE0, 0x70, 0x3C, 0x07, 0x03, 0x80, 0x78,
  0x78, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x39, 0xE0, 0x03,
  0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xB8, 0x00, 0x1B, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x38, 0x07,
  0xC0, 0x7E, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x78, 0x0F, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x0E,
  0x00, 0x18, 0x02, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xF8, 0x07, 0xC0,
};

const GFXglyph NotoSans_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 23, 9, 1, -23 },
  { 24, 11, 8, 13, 3, -23 },
  { 35, 20, 23, 21, 1, -23 },
  { 93, 16, 26, 18, 1, -24 },
  { 145, 23, 23, 26, 2, -23 },
  { 212, 20, 23, 22, 1, -23 },
  { 270, 5, 8, 7, 3, -23 },
  { 275, 11, 28, 10, 1, -23 },
  { 314, 10, 28, 10, -2, -23 },
  { 349, 15, 15, 18, 3, -24 },
  { 378, 15, 15, 18, 2, -19 },
  { 407, 6, 8, 8, -1, -4 },
  { 413, 8, 3, 10, 1, -10 },
  { 416, 4, 4, 8, 1, -4 },
  { 418, 16, 23, 12, -1, -23 },
  { 464, 15, 23, 18, 2, -23 },
  { 508, 11, 23, 18, 4, -23 },
  { 540, 17, 23, 18, 0, -23 },
  { 589, 16, 23, 18, 1, -23 },
  { 635, 17, 23, 18, 0, -23 },
  { 684, 16, 23, 18, 1, -23 },
  { 730, 16, 23, 18, 2, -23 },
  { 776, 16, 23, 18, 2, -23 },
  { 822, 16, 23, 18, 1, -23 },
  { 868, 16, 23, 18, 1, -23 },
  { 914, 7, 18, 8, 1, -18 },
  { 930, 10, 22, 8, -2, -18 },
  { 958, 15, 16, 18, 2, -20 },
  { 988, 15, 9, 18, 2, -16 },
  { 1005, 15, 16, 18, 2, -20 },
  { 1035, 13, 23, 14, 2, -23 },
  { 1073, 25, 26, 27, 2, -23 },
  { 1155, 19, 23, 19, -2, -23 },
  { 1210, 18, 23, 19, 1, -23 },
  { 1262, 18, 23, 19, 2, -23 },
  { 1314, 19, 23, 21, 1, -23 },
  { 1369, 17, 23, 17, 1, -23 },
  { 1418, 17, 23, 16, 1, -23 },
  { 1467, 19, 23, 22, 2, -23 },
  { 1522, 21, 23, 22, 1, -23 },
  { 1583, 14, 23, 11, -1, -23 },
  { 1624, 15, 29, 9, -5, -23 },
  { 1679, 20, 23, 18, 1, -23 },
  { 1737, 13, 23, 16, 1, -23 },
  { 1775, 26, 23, 27, 1, -23 },
  { 1850, 22, 23, 23, 1, -23 },
  { 1914, 20, 23, 23, 2, -23 },
  { 1972, 18, 23, 19, 1, -23 },
  { 2024, 20, 28, 23, 2, -23 },
  { 2094, 17, 23, 19, 1, -23 },
  { 2143, 16, 23, 16, 1, -23 },
  { 2189, 16, 23, 16, 3, -23 },
  { 2235, 20, 23, 22, 2, -23 },
  { 2293, 18, 23, 18, 3, -23 },
  { 2345, 28, 23, 28, 3, -23 },
  { 2426, 22, 23, 18, -2, -23 },
  { 2490, 17, 23, 17, 3, -23 },
  { 2539, 19, 23, 17, -1, -23 },
  { 2594, 12, 28, 10, 0, -23 },
  { 2636, 7, 23, 12, 3, -23 },
  { 2657, 12, 28, 10, -2, -23 },
  { 2699, 16, 15, 18, 1, -23 },
  { 2729, 13, 2, 13, -3, 3 },
  { 2733, 5, 6, 9, 5, -25 },
  { 2737, 17, 18, 18, 1, -18 },
  { 2776, 16, 24, 19, 1, -24 },
  { 2824, 14, 18, 15, 1, -18 },
  { 2856, 18, 24, 19, 1, -24 },
  { 2910, 15, 18, 17, 1, -18 },
  { 2944, 19, 32, 11, -4, -24 },
  { 3020, 17, 26, 19, 1, -18 },
  { 3076, 16, 24, 19, 1, -24 },
  { 3124, 8, 24, 9, 1, -24 },
  { 3148, 13, 32, 9, -4, -24 },
  { 3200, 17, 24, 17, 1, -24 },
  { 3251, 8, 24, 9, 1, -24 },
  { 3275, 26, 18, 28, 1, -18 },
  { 3334, 16, 18, 19, 1, -18 },
  { 3370, 16, 18, 18, 1, -18 },
  { 3406, 18, 26, 19, -1, -18 },
  { 3465, 17, 26, 19, 1, -18 },
  { 3521, 13, 18, 13, 1, -18 },
  { 3551, 14, 18, 14, 0, -18 },
  { 3583, 11, 21, 11, 1, -21 },
  { 3612, 16, 17, 19, 2, -17 },
  { 3646, 15, 17, 15, 2, -17 },
  { 3678, 23, 17, 24, 2, -17 },
  { 3727, 18, 17, 16, -1, -17 },
  { 3766, 20, 25, 15, -3, -17 },
  { 3829, 15, 17, 14, -1, -17 },
  { 3861, 13, 28, 11, 0, -23 },
  { 3907, 3, 32, 18, 8, -24 },
  { 3919, 12, 28, 11, -1, -23 },
  { 3961, 15, 5, 18, 2, -14 },
};

const GFXfont NotoSans_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_MEDIUMITALIC32PT7B_H_
