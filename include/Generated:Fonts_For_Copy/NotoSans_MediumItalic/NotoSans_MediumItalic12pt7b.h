#ifndef _NOTOSANS_MEDIUMITALIC12PT7B_H_
#define _NOTOSANS_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x82, 0xC0, 0x55, 0x9A, 0x0A, 0x12, 0x14, 0x7F, 0x24,
  0x24, 0xFE, 0x28, 0x48, 0x08, 0xF7, 0x1C, 0x38, 0x71, 0xFE, 0x20, 0x80,
  0x61, 0xD2, 0x94, 0xAC, 0xAF, 0x55, 0x25, 0x6D, 0xC6, 0x18, 0x34, 0x24,
  0x2C, 0x30, 0x5B, 0xCE, 0xC4, 0x7A, 0x5A, 0x19, 0x88, 0x84, 0x21, 0x18,
  0x42, 0x10, 0x21, 0x11, 0x11, 0x13, 0x24, 0xC0, 0x12, 0x47, 0xDC, 0x58,
  0x21, 0x3E, 0x42, 0x10, 0x6A, 0x00, 0xE0, 0x70, 0x06, 0x08, 0x20, 0x41,
  0x06, 0x08, 0x30, 0xC0, 0x33, 0x73, 0x18, 0xC6, 0x32, 0xF0, 0x2E, 0x96,
  0x92, 0xC0, 0x19, 0xB0, 0x41, 0x08, 0x62, 0x10, 0xFC, 0x19, 0x90, 0x41,
  0x38, 0x20, 0xE3, 0xF8, 0x04, 0x31, 0x4D, 0x29, 0x2F, 0xC2, 0x18, 0x3C,
  0xF2, 0x08, 0x78, 0x30, 0x63, 0xF8, 0x1D, 0x94, 0x20, 0xFA, 0x28, 0xA6,
  0xF0, 0xFF, 0xF0, 0x84, 0x30, 0x86, 0x10, 0xC0, 0x18, 0x48, 0x99, 0x23,
  0x89, 0xB1, 0x26, 0x78, 0x32, 0xE3, 0x19, 0xB4, 0x62, 0xE0, 0x2C, 0x00,
  0xB0, 0x13, 0x00, 0x00, 0x64, 0x80, 0x09, 0xB0, 0xC1, 0x84, 0xF8, 0x3E,
  0xC3, 0x82, 0x7C, 0x40, 0x76, 0x86, 0x22, 0x20, 0x10, 0xC0, 0x0C, 0x19,
  0x90, 0x33, 0xDA, 0x4D, 0x26, 0xB5, 0x6C, 0xC0, 0x3E, 0x00, 0x04, 0x18,
  0x38, 0xD1, 0x27, 0xCF, 0xA1, 0xC2, 0x38, 0x7C, 0x89, 0x37, 0x88, 0x91,
  0xA2, 0xF8, 0x1E, 0xE9, 0x06, 0x08, 0x10, 0x20, 0x60, 0x78, 0x38, 0x3E,
  0x23, 0x23, 0x63, 0x42, 0x42, 0x4C, 0xF8, 0x3E, 0x78, 0x81, 0x07, 0xC8,
  0x10, 0x20, 0xF8, 0x3E, 0x78, 0x81, 0x07, 0xC8, 0x10, 0x20, 0xC0, 0x1C,
  0xED, 0x06, 0x08, 0xF2, 0xA1, 0x62, 0x7C, 0x31, 0x21, 0x21, 0x23, 0x7E,
  0x42, 0x42, 0x42, 0xC6, 0x79, 0x88, 0x42, 0x31, 0x08, 0xE0, 0x0C, 0x20,
  0x82, 0x18, 0x61, 0x04, 0x10, 0xCE, 0x00, 0x33, 0x26, 0x24, 0x28, 0x70,
  0x68, 0x48, 0x4C, 0xC4, 0x31, 0x08, 0x46, 0x21, 0x08, 0xF8, 0x30, 0xCC,
  0x33, 0x14, 0xC7, 0x72, 0x96, 0xA4, 0xC9, 0x32, 0xC9, 0x80, 0x30, 0x98,
  0x8C, 0x45, 0x26, 0x92, 0x59, 0x18, 0x8C, 0xC6, 0x00, 0x18, 0xED, 0x0E,
  0x18, 0x30, 0x61, 0xE6, 0x78, 0x38, 0x7C, 0x89, 0x16, 0x4F, 0x10, 0x20,
  0xC0, 0x18, 0xED, 0x0E, 0x18, 0x30, 0x61, 0xE6, 0x78, 0x30, 0x30, 0x38,
  0x7C, 0x89, 0x37, 0xCF, 0x12, 0x26, 0xC4, 0x18, 0xD6, 0x18, 0x30, 0x60,
  0xA2, 0xF0, 0xFF, 0xF2, 0x08, 0x21, 0x86, 0x10, 0x40, 0x42, 0x85, 0x0A,
  0x3C, 0x50, 0xA1, 0x46, 0x78, 0x87, 0x0B, 0x36, 0x45, 0x8A, 0x1C, 0x30,
  0x60, 0x84, 0x63, 0x1C, 0xCF, 0x52, 0xD5, 0xBD, 0x4E, 0x51, 0x98, 0x46,
  0x00, 0x31, 0x89, 0x84, 0x83, 0x80, 0x80, 0xE0, 0xD0, 0x48, 0xC6, 0x00,
  0x87, 0x34, 0x94, 0x71, 0x86, 0x10, 0x40, 0x3E, 0xFC, 0x30, 0x41, 0x06,
  0x18, 0x60, 0xF8, 0x39, 0x08, 0xC4, 0x21, 0x08, 0xC5, 0x30, 0x99, 0x24,
  0x92, 0x20, 0x38, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x38, 0x10, 0x42, 0x8A,
  0x47, 0x10, 0xF8, 0x90, 0x21, 0xF8, 0xA2, 0x8A, 0x6F, 0x00, 0x20, 0x82,
  0x9D, 0x65, 0x14, 0x53, 0xB8, 0x3B, 0xA1, 0x08, 0x43, 0xC0, 0x04, 0x12,
  0xD6, 0x8A, 0x28, 0xA6, 0xF0, 0x32, 0xE3, 0xE8, 0x43, 0xC0, 0x0C, 0x41,
  0x4E, 0x30, 0xC2, 0x08, 0x21, 0x84, 0x30, 0x10, 0x7D, 0x12, 0x24, 0x49,
  0x9E, 0x04, 0x99, 0xE0, 0x20, 0x82, 0x9D, 0x65, 0x14, 0x53, 0xCC, 0x24,
  0x36, 0x92, 0xC0, 0x08, 0x40, 0x31, 0x88, 0x42, 0x31, 0x09, 0xC0, 0x20,
  0x40, 0x8B, 0x65, 0x8E, 0x14, 0x2C, 0xCC, 0x32, 0x26, 0x64, 0x44, 0xC0,
  0x08, 0x9D, 0xF6, 0x45, 0x13, 0x44, 0xD3, 0x2C, 0x88, 0x09, 0xF6, 0x51,
  0x45, 0x3C, 0xC0, 0x23, 0xE3, 0x18, 0xCF, 0xC0, 0x09, 0xD6, 0x51, 0x45,
  0x3F, 0xA0, 0x82, 0x00, 0x21, 0xF8, 0xA2, 0x9A, 0x6F, 0x04, 0x10, 0xC0,
  0x0B, 0xD8, 0x84, 0x23, 0x00, 0x33, 0x50, 0xE1, 0x0F, 0xC0, 0x45, 0xEC,
  0x88, 0x8C, 0xCE, 0x28, 0xA2, 0x9B, 0xC0, 0x8C, 0xAD, 0x4E, 0x60, 0x99,
  0xAA, 0xAA, 0xAE, 0xCC, 0xCC, 0x6C, 0xE3, 0x0C, 0x52, 0x20, 0x22, 0x48,
  0xB1, 0x42, 0x86, 0x0C, 0x10, 0xC0, 0x78, 0x8C, 0xC4, 0x78, 0x08, 0x88,
  0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF0, 0x42, 0x22, 0x23, 0x64, 0x44,
  0x80, 0xEC, 0xC0,
};

const GFXglyph NotoSans_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 5, 1, -9 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 6, 10, 7, 0, -9 },
  { 24, 8, 9, 10, 1, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 2, 4, 3, 1, -9 },
  { 43, 5, 11, 4, 0, -9 },
  { 50, 4, 11, 4, -1, -9 },
  { 56, 6, 5, 7, 1, -9 },
  { 60, 5, 6, 7, 1, -7 },
  { 64, 3, 3, 3, -1, -1 },
  { 66, 3, 1, 4, 0, -4 },
  { 67, 2, 2, 3, 0, -2 },
  { 68, 7, 9, 5, -1, -9 },
  { 76, 5, 9, 7, 1, -9 },
  { 82, 3, 9, 7, 2, -9 },
  { 86, 6, 9, 7, 0, -9 },
  { 93, 6, 9, 7, 0, -9 },
  { 100, 6, 9, 7, 0, -9 },
  { 107, 6, 9, 7, 0, -9 },
  { 114, 6, 9, 7, 1, -9 },
  { 121, 6, 9, 7, 1, -9 },
  { 128, 7, 9, 7, 0, -9 },
  { 136, 5, 9, 7, 1, -9 },
  { 142, 3, 7, 3, 0, -7 },
  { 145, 4, 9, 3, -1, -7 },
  { 150, 5, 6, 7, 1, -7 },
  { 154, 5, 3, 7, 1, -6 },
  { 156, 5, 6, 7, 1, -7 },
  { 160, 5, 9, 5, 1, -9 },
  { 166, 9, 10, 10, 1, -9 },
  { 178, 7, 9, 7, -1, -9 },
  { 186, 7, 9, 7, 0, -9 },
  { 194, 7, 9, 7, 1, -9 },
  { 202, 8, 9, 8, 0, -9 },
  { 211, 7, 9, 6, 0, -9 },
  { 219, 7, 9, 6, 0, -9 },
  { 227, 7, 9, 8, 1, -9 },
  { 235, 8, 9, 8, 0, -9 },
  { 244, 5, 9, 4, 0, -9 },
  { 250, 6, 11, 3, -2, -9 },
  { 259, 8, 9, 7, 0, -9 },
  { 268, 5, 9, 6, 0, -9 },
  { 274, 10, 9, 10, 0, -9 },
  { 286, 9, 9, 9, 0, -9 },
  { 297, 7, 9, 9, 1, -9 },
  { 305, 7, 9, 7, 0, -9 },
  { 313, 7, 11, 9, 1, -9 },
  { 323, 7, 9, 7, 0, -9 },
  { 331, 6, 9, 6, 0, -9 },
  { 338, 6, 9, 6, 1, -9 },
  { 345, 7, 9, 8, 1, -9 },
  { 353, 7, 9, 7, 1, -9 },
  { 361, 10, 9, 10, 1, -9 },
  { 373, 9, 9, 7, -1, -9 },
  { 384, 6, 9, 6, 1, -9 },
  { 391, 7, 9, 6, 0, -9 },
  { 399, 5, 11, 4, 0, -9 },
  { 406, 3, 9, 5, 1, -9 },
  { 410, 5, 11, 4, -1, -9 },
  { 417, 6, 6, 7, 0, -9 },
  { 422, 5, 1, 5, -1, 1 },
  { 423, 2, 2, 3, 2, -9 },
  { 424, 6, 7, 7, 1, -7 },
  { 430, 6, 9, 7, 0, -9 },
  { 437, 5, 7, 6, 1, -7 },
  { 442, 6, 9, 7, 1, -9 },
  { 449, 5, 7, 6, 1, -7 },
  { 454, 6, 12, 4, -1, -9 },
  { 463, 7, 10, 7, 0, -7 },
  { 472, 6, 9, 7, 0, -9 },
  { 479, 3, 9, 3, 0, -9 },
  { 483, 5, 12, 3, -2, -9 },
  { 491, 7, 9, 6, 0, -9 },
  { 499, 4, 9, 3, 0, -9 },
  { 504, 10, 7, 11, 0, -7 },
  { 513, 6, 7, 7, 0, -7 },
  { 519, 5, 7, 7, 1, -7 },
  { 524, 6, 10, 7, 0, -7 },
  { 532, 6, 10, 7, 1, -7 },
  { 540, 5, 7, 5, 0, -7 },
  { 545, 5, 7, 5, 0, -7 },
  { 550, 4, 8, 4, 1, -8 },
  { 554, 6, 6, 7, 1, -6 },
  { 559, 5, 6, 6, 1, -6 },
  { 563, 8, 6, 9, 1, -6 },
  { 569, 6, 6, 6, 0, -6 },
  { 574, 7, 9, 6, -1, -6 },
  { 582, 5, 6, 5, 0, -6 },
  { 586, 5, 11, 4, 0, -9 },
  { 593, 1, 12, 7, 3, -9 },
  { 595, 4, 11, 4, 0, -9 },
  { 601, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_MEDIUMITALIC12PT7B_H_
