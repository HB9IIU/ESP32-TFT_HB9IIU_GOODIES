#ifndef _NOTOSANS_MEDIUMITALIC29PT7B_H_
#define _NOTOSANS_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x00, 0x00, 0x30, 0x78, 0xF8, 0x70, 0x73, 0xB9,
  0xDC, 0xEC, 0x66, 0x37, 0x1B, 0x1D, 0x8C, 0x00, 0xC3, 0x00, 0x71, 0xC0,
  0x18, 0x60, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC3, 0x83, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC1, 0x86, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0C, 0x38,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x71, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x03,
  0x8E, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x01, 0xFF, 0x1F, 0xFC, 0x73, 0x33, 0x88, 0x0E, 0x60, 0x39, 0x80, 0x76,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0D, 0xE0, 0x33, 0x80, 0xCE, 0x06,
  0x3B, 0x19, 0xCF, 0xFF, 0x3F, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0x00, 0xE3, 0xF8, 0x0C, 0x3B, 0x81, 0xC7, 0x18, 0x38, 0x61,
  0x83, 0x0E, 0x18, 0x60, 0xE1, 0x8E, 0x0E, 0x39, 0xC0, 0xE3, 0x99, 0xCE,
  0x33, 0x3F, 0xE7, 0x77, 0xF7, 0xEE, 0xE3, 0x3C, 0xCE, 0x30, 0x18, 0xC3,
  0x03, 0x9C, 0x30, 0x71, 0xC3, 0x06, 0x1C, 0x70, 0xC1, 0xC6, 0x1C, 0x1C,
  0xE3, 0x80, 0xFC, 0x70, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x7B,
  0xC0, 0x38, 0x70, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x39, 0xE0,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF7, 0x07, 0x79, 0xE3, 0xBC,
  0x38, 0xEE, 0x07, 0x73, 0x81, 0xF8, 0xE0, 0x3E, 0x3C, 0x0F, 0x0F, 0x8F,
  0xE1, 0xFF, 0xBC, 0x3F, 0x87, 0x80, 0x77, 0x76, 0x6E, 0xCC, 0x01, 0xC0,
  0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x38, 0x0E,
  0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80,
  0xC0, 0x70, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x86, 0x0F, 0x30,
  0x7F, 0x8C, 0x3F, 0xE1, 0xFF, 0x1F, 0x01, 0xCC, 0x1C, 0x60, 0x63, 0x82,
  0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x3C, 0xE7, 0x9C, 0x63, 0x8C, 0x00, 0xFF, 0xFF, 0xF8,
  0x33, 0xFC, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE1,
  0xC1, 0xC7, 0x03, 0x8E, 0x07, 0xBC, 0x0F, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x1C, 0x70, 0x78,
  0xE1, 0xE1, 0xE7, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0x83, 0xC7, 0xEF,
  0xFF, 0xF7, 0x39, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x80, 0x01, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF8, 0x60, 0x70, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x80,
  0x03, 0xF0, 0x7F, 0xE1, 0xFF, 0xC2, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x3F, 0xC0, 0xF8, 0x03, 0xF8, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7A, 0x01, 0xCE, 0x1F, 0x3F, 0xF8, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0E, 0xC0, 0x1F,
  0x80, 0x77, 0x01, 0xCE, 0x07, 0x1C, 0x1C, 0x70, 0x70, 0xE1, 0xE1, 0xC3,
  0x83, 0x8E, 0x07, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x79, 0x00, 0xE3, 0x8F, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x0F,
  0xF0, 0xFF, 0xC7, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x77,
  0xC3, 0xBF, 0xCF, 0xCF, 0x3C, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0xB8,
  0x1C, 0xE0, 0x73, 0x83, 0xCF, 0x3E, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x3E, 0xF0, 0xF0, 0xF1, 0xC0, 0xE3,
  0x81, 0xC7, 0x07, 0x0F, 0x0E, 0x0F, 0x78, 0x0F, 0xE0, 0x3F, 0x81, 0xF7,
  0x87, 0x87, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xE0, 0x71,
  0xE3, 0xC3, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0x0F, 0x38, 0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xE0, 0xF3,
  0x87, 0xCF, 0xF7, 0x1F, 0xB8, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x8C, 0x7C, 0x3F, 0xE0, 0xFF, 0x00, 0x0E, 0x3C, 0x78, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0F, 0x3C, 0x38, 0x07, 0x0F, 0x0F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x38, 0x38,
  0x70, 0x70, 0xE0, 0xE0, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00,
  0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0x90, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x3C, 0x01, 0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x01, 0x8E,
  0x0F, 0xE3, 0x9C, 0x3F, 0xC7, 0x70, 0xE3, 0x86, 0xE3, 0x87, 0x0D, 0x86,
  0x0C, 0x1B, 0x1C, 0x18, 0x76, 0x38, 0x70, 0xFC, 0x60, 0xE1, 0xB8, 0xC3,
  0xC7, 0x31, 0xCF, 0x9C, 0x61, 0xFB, 0xF0, 0xE1, 0xE3, 0xC1, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x08, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0x60, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x01, 0xE3,
  0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x38,
  0x07, 0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x38,
  0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x0E, 0x0F, 0x0E, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x38, 0x7C,
  0x38, 0x1C, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x3C,
  0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0xC3, 0xE0, 0x41, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x9E, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x38, 0x3C,
  0x0E, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0xCF,
  0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE7, 0x80,
  0x71, 0xC0, 0x3C, 0x70, 0x1E, 0x1C, 0x0F, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0x83, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xFF, 0xE1, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0x21, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x1F, 0xDC, 0x0F,
  0xEE, 0x07, 0xF7, 0x00, 0x7B, 0x80, 0x39, 0xE0, 0x1C, 0xF0, 0x0E, 0x3C,
  0x07, 0x1F, 0x9F, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0x80, 0x70, 0x70, 0x0E, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F,
  0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0E, 0x00, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0xF8, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC3,
  0x81, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x01, 0xC7,
  0x80, 0x73, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3D, 0xE0, 0x0E, 0x38, 0x07, 0x8F, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C,
  0x1E, 0x07, 0x03, 0x83, 0x80, 0xF0, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0D, 0x80, 0x7E, 0x1D, 0x80, 0xEE, 0x1D, 0x80, 0xEE, 0x1D,
  0x81, 0xDC, 0x1D, 0xC1, 0xDC, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x39,
  0xC7, 0x38, 0x39, 0xC6, 0x38, 0x38, 0xCE, 0x38, 0x70, 0xCC, 0x38, 0x70,
  0xDC, 0x38, 0x70, 0xD8, 0x70, 0x70, 0xF8, 0x70, 0x60, 0xF0, 0x70, 0xE0,
  0xF0, 0x70, 0xE0, 0xE0, 0xF0, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x80,
  0x70, 0xF8, 0x0E, 0x0F, 0x80, 0xE1, 0xDC, 0x0E, 0x1D, 0xC0, 0xE1, 0xDC,
  0x0E, 0x1C, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x38,
  0x71, 0xC3, 0x83, 0xB8, 0x70, 0x3B, 0x87, 0x03, 0xB8, 0x70, 0x1F, 0x87,
  0x01, 0xF0, 0x60, 0x1F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x1E, 0x3C, 0x03, 0xCE, 0x00, 0xF7,
  0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F,
  0x1E, 0x07, 0x87, 0xEF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x0E, 0x0F, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E, 0x39, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78,
  0x1E, 0x3C, 0x03, 0xCE, 0x00, 0xF7, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xEE,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x1E, 0x07, 0x87, 0xEF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1E, 0x0E,
  0x0F, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x3E, 0x3F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x38, 0xE0, 0x78, 0x70, 0x70, 0x70, 0x70,
  0x78, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x3C, 0xE0, 0x1C, 0x03, 0xF0, 0x3F,
  0xF1, 0xFF, 0xC7, 0x02, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x72, 0x03, 0xCF, 0x3E, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x1C, 0x3C, 0x0F, 0x07, 0xCF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0,
  0x78, 0xE0, 0x70, 0xE0, 0xF0, 0x60, 0xE0, 0x71, 0xE0, 0x71, 0xC0, 0x73,
  0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x76, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x07, 0xF0, 0x1E, 0x03, 0xB8,
  0x0F, 0x01, 0xDC, 0x0F, 0x81, 0xCE, 0x07, 0xC0, 0xE7, 0x07, 0xE0, 0xE3,
  0x83, 0xF0, 0x71, 0xC3, 0x98, 0x70, 0xE1, 0xCC, 0x38, 0x70, 0xC6, 0x1C,
  0x38, 0xE3, 0x1C, 0x1C, 0x61, 0x8E, 0x0E, 0x70, 0xCE, 0x07, 0x38, 0x67,
  0x01, 0xB8, 0x37, 0x00, 0xDC, 0x1B, 0x80, 0x6C, 0x0D, 0x80, 0x3E, 0x07,
  0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x38, 0x3C, 0x01, 0xC3, 0x80,
  0x1C, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x07, 0x9C,
  0x00, 0x71, 0xC0, 0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x3C, 0x0F, 0x03, 0x80,
  0x70, 0xF0, 0x07, 0x00, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xE7, 0x83, 0xC7,
  0x07, 0x0E, 0x1C, 0x1C, 0x78, 0x18, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0xFC,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xE3, 0x8E, 0x18, 0x61, 0xC7, 0x1C, 0x70,
  0xC3, 0x0E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC7, 0x1C, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x87, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0x80, 0x0E,
  0x00, 0x3C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x81, 0xC6, 0x06, 0x1C, 0x38,
  0x30, 0xC0, 0xE7, 0x01, 0x98, 0x07, 0xE0, 0x1C, 0x7F, 0xFF, 0xFF, 0xF3,
  0x8E, 0x30, 0x03, 0xC6, 0x1F, 0xDC, 0x7F, 0xF9, 0xE1, 0xF3, 0x81, 0xCF,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x83,
  0xCF, 0x0F, 0x8F, 0x3E, 0x1F, 0xEC, 0x1F, 0x38, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x3C, 0x0E, 0xFC, 0x1B,
  0xFC, 0x7C, 0x38, 0xF0, 0x71, 0xC0, 0xF3, 0x81, 0xE7, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x73, 0xC1, 0xE7, 0xC7, 0x8E, 0xFE, 0x19,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3E,
  0x60, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x0F, 0x38, 0x1F, 0xDC, 0x1F, 0xFE, 0x1E,
  0x1F, 0x0E, 0x07, 0x0F, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE1,
  0xE0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x3C, 0x3E, 0x0F, 0x3E, 0x07, 0xFB,
  0x01, 0xF3, 0x80, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0xB8,
  0x1D, 0xC3, 0xCF, 0xFC, 0xFF, 0xC7, 0x80, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x30, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x71, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x03, 0xC6, 0x1F, 0xDC, 0x7F, 0xF9, 0xE1, 0xF3, 0x81,
  0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x39, 0xE0, 0x73, 0xC0, 0xE7,
  0x83, 0xCF, 0x0F, 0x8F, 0x36, 0x1F, 0xDC, 0x1F, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x84, 0x0F, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xCF, 0x07,
  0x7F, 0x1B, 0xFC, 0xF8, 0x73, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x77,
  0x01, 0xDC, 0x0F, 0x70, 0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x0E, 0xE0, 0x73,
  0x81, 0xC0, 0x04, 0x1C, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x1C, 0x70, 0xE1,
  0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x00, 0x00, 0x20,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x8E, 0x1E, 0x1C, 0x78, 0x71,
  0xE0, 0xE7, 0x81, 0xDE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3D, 0xC0,
  0x73, 0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x07, 0x0E, 0x0F, 0x1C, 0x0E, 0x00,
  0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8F,
  0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x00, 0x18, 0xF0, 0x78, 0x33,
  0xF1, 0xF8, 0x6F, 0xF7, 0xF9, 0xF0, 0xF8, 0x73, 0xC1, 0xE0, 0xE7, 0x83,
  0x81, 0xCE, 0x07, 0x03, 0x9C, 0x0E, 0x0F, 0x70, 0x38, 0x1C, 0xE0, 0x70,
  0x39, 0xC0, 0xE0, 0x73, 0x81, 0xC0, 0xEF, 0x07, 0x83, 0xDC, 0x0E, 0x07,
  0x38, 0x1C, 0x0E, 0x70, 0x38, 0x1C, 0x1C, 0xF8, 0x67, 0xF1, 0xBF, 0xCF,
  0x87, 0x3C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x70, 0x1D, 0xC0, 0xF7,
  0x03, 0x9C, 0x0E, 0xF0, 0x3B, 0x81, 0xEE, 0x07, 0xB8, 0x1C, 0x03, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xBC, 0x0E, 0x70, 0x79, 0xE7, 0xC3, 0xFE,
  0x07, 0xE0, 0x06, 0x3C, 0x03, 0x3F, 0x01, 0xBF, 0xC1, 0xF0, 0xE0, 0xF0,
  0x70, 0x70, 0x3C, 0x38, 0x1E, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87,
  0x03, 0xC3, 0x81, 0xC3, 0xC1, 0xE1, 0xF1, 0xE0, 0xEF, 0xE0, 0x73, 0xE0,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x03, 0xC6, 0x1F, 0xDC, 0x7F, 0xF9, 0xE1, 0xF3, 0x81,
  0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xE7,
  0x03, 0xCF, 0x0F, 0x8F, 0x36, 0x1F, 0xDC, 0x1F, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C,
  0xF1, 0x9E, 0x1B, 0xE3, 0xF0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0xC1, 0xFF, 0x3F, 0xF3, 0x81, 0x38, 0x03, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xEC, 0x3C, 0xFF, 0xC7, 0xF8, 0x06,
  0x03, 0x80, 0xC0, 0xFF, 0x7F, 0xFF, 0xF3, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x71, 0x1F, 0x83, 0xE0, 0x38,
  0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xB8,
  0x0E, 0xE0, 0x7B, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE1, 0xF3, 0xCD, 0x8F,
  0xF6, 0x1F, 0x18, 0xE0, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x1E, 0x70, 0x71,
  0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0x71, 0xC1, 0xCE, 0x03, 0x38, 0x0D, 0xC0,
  0x37, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0xE0, 0xF0, 0x7F, 0x07, 0x83,
  0xB8, 0x7C, 0x1D, 0xC3, 0x61, 0xCE, 0x1B, 0x0E, 0x71, 0xD8, 0xE3, 0x8C,
  0xC7, 0x1C, 0xE6, 0x70, 0xE6, 0x33, 0x87, 0x71, 0x98, 0x3B, 0x0D, 0xC1,
  0xF8, 0x6E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF0, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x0E, 0x0E, 0x0E, 0x1E, 0x07, 0x3C, 0x07, 0x38, 0x07,
  0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x1C, 0x70, 0x38, 0x70, 0x78, 0x38, 0xF0, 0x38, 0x0E, 0x01, 0xC1,
  0xC0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0x70,
  0xE0, 0x1C, 0x78, 0x03, 0x1C, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x13,
  0xFF, 0x1F, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xE0, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x01, 0xF0, 0x3E, 0x01, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x1E, 0x07,
  0xC1, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x07, 0xC0, 0xF0, 0x18, 0x00, 0x7E, 0x07, 0xFF, 0xFC, 0x7F, 0xA0, 0x3C,
};

const GFXglyph NotoSans_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 21, 8, 0, -21 },
  { 22, 9, 8, 12, 3, -21 },
  { 31, 18, 21, 19, 1, -21 },
  { 79, 14, 24, 16, 1, -22 },
  { 121, 20, 21, 24, 2, -21 },
  { 174, 18, 21, 20, 1, -21 },
  { 222, 4, 8, 7, 3, -21 },
  { 226, 10, 26, 9, 1, -21 },
  { 259, 10, 26, 9, -2, -21 },
  { 292, 13, 13, 16, 3, -22 },
  { 314, 14, 14, 17, 2, -17 },
  { 339, 6, 7, 8, -1, -3 },
  { 345, 7, 3, 9, 1, -9 },
  { 348, 5, 4, 8, 0, -4 },
  { 351, 14, 21, 11, -1, -21 },
  { 388, 15, 21, 16, 1, -21 },
  { 428, 9, 21, 16, 4, -21 },
  { 452, 15, 21, 16, 0, -21 },
  { 492, 14, 21, 16, 1, -21 },
  { 529, 15, 21, 16, 0, -21 },
  { 569, 15, 21, 16, 1, -21 },
  { 609, 14, 21, 16, 2, -21 },
  { 646, 15, 21, 16, 2, -21 },
  { 686, 15, 21, 16, 1, -21 },
  { 726, 14, 21, 16, 1, -21 },
  { 763, 7, 16, 8, 0, -16 },
  { 777, 8, 20, 8, -1, -16 },
  { 797, 14, 15, 17, 2, -18 },
  { 824, 14, 8, 17, 2, -14 },
  { 838, 14, 15, 17, 2, -18 },
  { 865, 11, 21, 13, 2, -21 },
  { 894, 23, 24, 25, 1, -21 },
  { 963, 17, 21, 17, -2, -21 },
  { 1008, 16, 21, 18, 1, -21 },
  { 1050, 17, 21, 17, 2, -21 },
  { 1095, 18, 21, 19, 1, -21 },
  { 1143, 15, 21, 15, 1, -21 },
  { 1183, 15, 21, 14, 1, -21 },
  { 1223, 17, 21, 20, 2, -21 },
  { 1268, 19, 21, 20, 1, -21 },
  { 1318, 13, 21, 10, -1, -21 },
  { 1353, 14, 27, 8, -5, -21 },
  { 1401, 18, 21, 17, 1, -21 },
  { 1449, 11, 21, 14, 1, -21 },
  { 1478, 24, 21, 25, 1, -21 },
  { 1541, 20, 21, 21, 1, -21 },
  { 1594, 18, 21, 21, 2, -21 },
  { 1642, 16, 21, 17, 1, -21 },
  { 1684, 18, 26, 21, 2, -21 },
  { 1743, 16, 21, 17, 1, -21 },
  { 1785, 14, 21, 15, 1, -21 },
  { 1822, 14, 21, 15, 3, -21 },
  { 1859, 18, 21, 20, 2, -21 },
  { 1907, 16, 21, 16, 3, -21 },
  { 1949, 25, 21, 25, 3, -21 },
  { 2015, 20, 21, 16, -2, -21 },
  { 2068, 15, 21, 15, 3, -21 },
  { 2108, 17, 21, 15, 0, -21 },
  { 2153, 11, 26, 9, 0, -21 },
  { 2189, 6, 21, 11, 3, -21 },
  { 2205, 11, 26, 9, -2, -21 },
  { 2241, 14, 13, 16, 1, -21 },
  { 2264, 12, 2, 11, -3, 3 },
  { 2267, 5, 4, 8, 4, -22 },
  { 2270, 15, 16, 17, 1, -16 },
  { 2300, 15, 22, 17, 1, -22 },
  { 2342, 13, 16, 13, 1, -16 },
  { 2368, 17, 22, 17, 1, -22 },
  { 2415, 13, 16, 15, 1, -16 },
  { 2441, 16, 29, 10, -3, -22 },
  { 2499, 15, 23, 17, 1, -16 },
  { 2543, 14, 22, 17, 1, -22 },
  { 2582, 7, 22, 8, 1, -22 },
  { 2602, 12, 29, 8, -4, -22 },
  { 2646, 15, 22, 15, 1, -22 },
  { 2688, 7, 22, 8, 1, -22 },
  { 2708, 23, 16, 26, 1, -16 },
  { 2754, 14, 16, 17, 1, -16 },
  { 2782, 14, 16, 17, 1, -16 },
  { 2810, 17, 23, 17, -1, -16 },
  { 2859, 15, 23, 17, 1, -16 },
  { 2903, 12, 16, 12, 1, -16 },
  { 2927, 12, 16, 13, 0, -16 },
  { 2951, 10, 19, 10, 1, -19 },
  { 2975, 14, 16, 17, 2, -16 },
  { 3003, 14, 16, 14, 1, -16 },
  { 3031, 21, 16, 22, 2, -16 },
  { 3073, 16, 16, 14, -1, -16 },
  { 3105, 18, 23, 14, -3, -16 },
  { 3157, 13, 16, 13, 0, -16 },
  { 3183, 12, 26, 10, 0, -21 },
  { 3222, 3, 29, 16, 7, -22 },
  { 3233, 11, 26, 10, -1, -21 },
  { 3269, 14, 4, 17, 2, -12 },
};

const GFXfont NotoSans_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_MEDIUMITALIC29PT7B_H_
