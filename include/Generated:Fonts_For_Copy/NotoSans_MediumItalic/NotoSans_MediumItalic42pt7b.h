#ifndef _NOTOSANS_MEDIUMITALIC42PT7B_H_
#define _NOTOSANS_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0F,
  0x03, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x08, 0x00, 0x3C, 0x7C, 0xF1, 0xF3,
  0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x87, 0x1C, 0x3C, 0x70, 0xF1,
  0xC3, 0x8E, 0x0E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x38, 0x07, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1E,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFD, 0xDE, 0x0F, 0x8C, 0x10, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1E,
  0x38, 0x00, 0xF1, 0xC0, 0x07, 0xCC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0xC0, 0x07,
  0x3E, 0x00, 0x38, 0xF0, 0x01, 0x87, 0x80, 0x1C, 0x3C, 0x80, 0xE3, 0xE7,
  0x07, 0x3E, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xF0, 0x3F, 0xC0, 0x07, 0x81, 0xFF, 0x80, 0x3C, 0x0F,
  0x1E, 0x01, 0xE0, 0x3C, 0x38, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x07, 0x83,
  0x81, 0xE0, 0x1C, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x38, 0x03, 0xC1, 0xE1,
  0xE0, 0x0F, 0x07, 0x8F, 0x00, 0x3C, 0x1C, 0x78, 0x00, 0xF0, 0xF1, 0xE7,
  0xE3, 0xC3, 0xCF, 0x3F, 0xCF, 0x1E, 0x79, 0xFF, 0x9F, 0xFB, 0xCF, 0x1E,
  0x7F, 0xCF, 0x3C, 0x38, 0xFC, 0x79, 0xE0, 0xF0, 0x03, 0xC7, 0x83, 0x80,
  0x0E, 0x1C, 0x0E, 0x00, 0x78, 0xF0, 0x38, 0x03, 0xC3, 0xC1, 0xE0, 0x1E,
  0x0F, 0x07, 0x80, 0x70, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0xF0, 0x1E, 0x03,
  0xC3, 0xC0, 0xF0, 0x0F, 0x1E, 0x03, 0x80, 0x1F, 0xF8, 0x1E, 0x00, 0x7F,
  0xC0, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0x1F,
  0xBE, 0x03, 0xC7, 0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0x1E, 0x3E, 0x07, 0xC7,
  0xC7, 0x80, 0x7D, 0xF1, 0xF0, 0x07, 0xFC, 0x3E, 0x00, 0xFF, 0x07, 0xC0,
  0x0F, 0xE0, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x7F, 0x81, 0xFC, 0x7F, 0xF0,
  0x1F, 0xFF, 0xDF, 0x01, 0xFF, 0xF1, 0xF0, 0x1F, 0xF8, 0x3F, 0x00, 0x3C,
  0xF3, 0xDE, 0x79, 0xE7, 0x9C, 0x71, 0xCE, 0x00, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x40, 0x78, 0x07, 0x07, 0x00, 0x7C, 0x70, 0x0F,
  0xF7, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x0E,
  0x07, 0xF8, 0x00, 0xF3, 0x80, 0x1E, 0x38, 0x07, 0xE3, 0xC0, 0x3C, 0x1C,
  0x01, 0x81, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0x87,
  0xC7, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE0, 0x11, 0xEF, 0xFF, 0xFB, 0xE6, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xC3,
  0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0xDF, 0x00, 0x3C, 0xF8, 0x01,
  0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xE0,
  0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x3C, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF8, 0xFD, 0xEF, 0xEF,
  0x9F, 0x3E, 0x30, 0xF0, 0x83, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xC0, 0x7C, 0x04, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xC7, 0xF0, 0x70, 0x0F, 0x81, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC6, 0x00, 0x7E,
  0x3E, 0x1F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0xF0,
  0x01, 0xF3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x0F,
  0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC4, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC3, 0x00, 0x3F, 0x0F, 0x87, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFC, 0x20, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x7C, 0x03, 0xCF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x79, 0xF0,
  0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x00, 0x78,
  0x78, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0xCF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xC3, 0xE0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78,
  0x07, 0x83, 0xE0, 0x7C, 0x0F, 0x8F, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0x9F, 0x81, 0xF0, 0x7C, 0x1F, 0x01,
  0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x9E,
  0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x1F, 0x87, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFC, 0x7E, 0x1F, 0x03, 0xE1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF3, 0xC0, 0x3F, 0x3E, 0x07, 0xF3, 0xFF, 0xFE, 0x1F, 0xFD,
  0xE0, 0xFF, 0x9E, 0x07, 0xE3, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0xE1,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x07, 0xC7,
  0xE3, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x1E, 0x1F, 0x8F, 0xC7, 0xC3, 0xE0, 0xC0,
  0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xC7, 0xE3, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0xFC, 0x07, 0x0F, 0x01, 0xFF, 0xC3, 0x8F, 0x03, 0xFF, 0xC1,
  0xE7, 0x03, 0xE1, 0xE0, 0xF7, 0x83, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0x78,
  0x3D, 0xC1, 0xE0, 0x38, 0x1E, 0xE0, 0xE0, 0x3C, 0x0F, 0xF0, 0xF0, 0x1E,
  0x07, 0x78, 0x78, 0x0F, 0x03, 0xBC, 0x3C, 0x07, 0x03, 0xDE, 0x1E, 0x07,
  0x81, 0xCF, 0x0F, 0x07, 0xC1, 0xE7, 0x87, 0x83, 0xE1, 0xE3, 0xC3, 0xE7,
  0xF9, 0xF1, 0xE0, 0xFF, 0x9F, 0xF0, 0x78, 0x3F, 0x8F, 0xF0, 0x3C, 0x07,
  0x00, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x18, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3E,
  0x01, 0xE0, 0x3E, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x78, 0x07, 0xE0, 0xF0, 0x07, 0xC1,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7C, 0x3C,
  0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x03,
  0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3C, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x04,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0x00, 0x40, 0x3F, 0xEF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x78, 0x0F, 0xE0, 0x3C, 0x01, 0xF8, 0x1E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x78,
  0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xE3, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1,
  0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xF0, 0x78, 0x03, 0xF8, 0x7C, 0x07, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0B, 0xE0, 0x1F, 0xF9, 0xF0, 0x0F,
  0xFC, 0xF8, 0x07, 0xFE, 0x7C, 0x03, 0xFF, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF8,
  0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3F, 0x80, 0x3C, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00,
  0x78, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xE0,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xC0,
  0x0F, 0xC0, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x07,
  0x80, 0xFC, 0x01, 0xE0, 0x7E, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xBC, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3D, 0xE0, 0xF7, 0x80, 0x0F, 0xF8, 0x3D, 0xE0, 0x07, 0xBC, 0x0F, 0x78,
  0x01, 0xEF, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0xF7, 0x80, 0x3D, 0xF0, 0x7C,
  0xE0, 0x1E, 0x7C, 0x1E, 0x38, 0x07, 0x9E, 0x07, 0x8E, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0xF8, 0x3E, 0x3C, 0x1C, 0x3E,
  0x0F, 0x0F, 0x0F, 0x0F, 0x03, 0xC3, 0xC7, 0x83, 0xC0, 0xF0, 0xF1, 0xE0,
  0xF0, 0x3C, 0x3C, 0xF0, 0x7C, 0x1E, 0x07, 0x3C, 0x1E, 0x07, 0x81, 0xDE,
  0x07, 0x81, 0xE0, 0x77, 0x81, 0xE0, 0x78, 0x1F, 0xC0, 0xF8, 0x3E, 0x07,
  0xF0, 0x3E, 0x0F, 0x01, 0xF8, 0x0F, 0x03, 0xC0, 0x7E, 0x03, 0xC0, 0xF0,
  0x1F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x3C, 0x0F, 0xE0, 0x01, 0xE0, 0x7F,
  0x00, 0x1F, 0x03, 0xFC, 0x00, 0xF0, 0x3D, 0xE0, 0x07, 0x81, 0xEF, 0x00,
  0x3C, 0x0F, 0x3C, 0x03, 0xE0, 0x79, 0xE0, 0x1F, 0x03, 0xCF, 0x80, 0xF0,
  0x3E, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F, 0x83, 0xE0, 0x78,
  0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x3E, 0x0F, 0x87, 0x81, 0xE0, 0x3C,
  0x3C, 0x0F, 0x01, 0xE3, 0xE0, 0x78, 0x0F, 0x9E, 0x03, 0xC0, 0x3C, 0xF0,
  0x3C, 0x01, 0xF7, 0x81, 0xE0, 0x07, 0xBC, 0x0F, 0x00, 0x3D, 0xE0, 0x78,
  0x01, 0xFE, 0x07, 0xC0, 0x07, 0xF0, 0x3C, 0x00, 0x3F, 0x81, 0xE0, 0x01,
  0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xE0,
  0x3F, 0x83, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF1,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0x80,
  0xFC, 0x1E, 0x01, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C,
  0x07, 0xE1, 0xE0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xE0, 0x3F, 0x83, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0x80,
  0xFC, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C,
  0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C,
  0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xC0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x03, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x86, 0x00, 0xFC, 0x3F, 0x7F, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0xFC,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x3F,
  0x00, 0x3E, 0xF8, 0x03, 0xF8, 0x03, 0xCF, 0x80, 0x7F, 0x80, 0x7C, 0x78,
  0x07, 0xF8, 0x07, 0x87, 0x80, 0x77, 0x80, 0xF8, 0x78, 0x0F, 0x78, 0x0F,
  0x07, 0x80, 0xF7, 0x81, 0xF0, 0x78, 0x1E, 0x78, 0x1E, 0x07, 0x81, 0xE7,
  0x81, 0xE0, 0x78, 0x3C, 0x78, 0x3E, 0x07, 0x83, 0xC7, 0x83, 0xC0, 0x78,
  0x78, 0x78, 0x7C, 0x07, 0x87, 0x87, 0x87, 0x80, 0x78, 0xF0, 0x78, 0xF8,
  0x07, 0x8F, 0x07, 0x8F, 0x00, 0x79, 0xF0, 0x78, 0xF0, 0x07, 0x9E, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x79, 0xE0, 0x07, 0xBC, 0x03, 0xBE, 0x00, 0x7B,
  0xC0, 0x3B, 0xC0, 0x07, 0xF8, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x1F, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78,
  0x03, 0xE1, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x1F,
  0x00, 0xF8, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xF7, 0x00, 0x07, 0x3C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x1C, 0x0F, 0x00,
  0xF0, 0x70, 0x03, 0x87, 0x80, 0x1E, 0x38, 0x00, 0x73, 0xC0, 0x03, 0xFC,
  0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x78, 0x7C,
  0x3C, 0x1E, 0x0E, 0x07, 0x00, 0xF8, 0x38, 0x1F, 0xF1, 0xC1, 0xFF, 0xDE,
  0x1F, 0xFE, 0xF1, 0xF8, 0x3F, 0x9F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x79, 0xF0, 0x03, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xF0, 0xF8, 0xF7, 0x07, 0xFF, 0x78, 0x1F,
  0xF3, 0xC0, 0x7F, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x79, 0xFE, 0x03,
  0xEF, 0xFC, 0x0F, 0x7F, 0xF8, 0x3F, 0x83, 0xE0, 0xFC, 0x07, 0x83, 0xE0,
  0x1E, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0x87, 0x80, 0x1E,
  0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7F, 0x8F,
  0xC1, 0xDF, 0xFE, 0x0F, 0x3F, 0xF0, 0x3C, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x80, 0x8F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x21, 0xF8, 0x78, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0xF0, 0x0F, 0xF9, 0xE0, 0x3F, 0xFB, 0xC0,
  0xFF, 0xF7, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80,
  0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF0, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0xFE, 0x07, 0xC7, 0xB8,
  0x0F, 0xFE, 0xF0, 0x0F, 0xF9, 0xE0, 0x0F, 0xE3, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xF7, 0xE1, 0xF8, 0x3C, 0x7C, 0x07, 0xCF,
  0x80, 0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x03, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x04, 0x3F, 0x07, 0x83, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xF6, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x1C, 0x07, 0xFC, 0x70, 0x3F, 0xFB, 0xC1, 0xFF, 0xEF, 0x0F, 0xC1, 0xFC,
  0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x87,
  0xC0, 0xFE, 0x0F, 0x8F, 0xF0, 0x3F, 0xFB, 0xC0, 0x7F, 0xCF, 0x00, 0xFE,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0xC0, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x3E, 0x01, 0xE7, 0xFC, 0x1F, 0x7F,
  0xF0, 0xF7, 0xFF, 0x87, 0xF0, 0x7C, 0x3F, 0x01, 0xE1, 0xF0, 0x0F, 0x1F,
  0x80, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F,
  0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0,
  0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xE0,
  0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0xC7, 0xC0,
  0x1F, 0x3E, 0x00, 0x79, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x81,
  0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x3E, 0x01, 0xC7, 0xF8, 0x3F,
  0xC0, 0xF3, 0xFF, 0x1F, 0xF8, 0x3D, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0xF7,
  0x07, 0xC3, 0xF0, 0x3F, 0x81, 0xF0, 0xF8, 0x0F, 0xC0, 0x7C, 0x7E, 0x03,
  0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x01, 0xE1, 0xE0,
  0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC0, 0x1E, 0x3E, 0x01, 0xF0, 0x0F, 0x8F,
  0x00, 0x78, 0x03, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x3C,
  0x7C, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC0, 0x1E, 0x3E, 0x01, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0x07, 0xE0, 0x38, 0xFF, 0x83,
  0xCF, 0xFE, 0x1E, 0xFF, 0xF0, 0xFF, 0x0F, 0x87, 0xE0, 0x3C, 0x7E, 0x01,
  0xE3, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3E,
  0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE3, 0xE0, 0x1E, 0x3E, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF8,
  0x03, 0xCF, 0x80, 0x7C, 0x7C, 0x0F, 0x87, 0xF3, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xC1, 0xF0, 0x01, 0xC7, 0xF8, 0x03,
  0xCF, 0xFC, 0x03, 0xDF, 0xFE, 0x03, 0xF8, 0x3E, 0x03, 0xF0, 0x1E, 0x03,
  0xE0, 0x1E, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0F,
  0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0xE3, 0xF0, 0x1E, 0xFF, 0xE0, 0x3E, 0xFF, 0xC0, 0x3E,
  0x7F, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x38, 0x1F,
  0xF1, 0xC1, 0xFF, 0xDE, 0x1F, 0xFE, 0xF1, 0xF8, 0x3F, 0x9F, 0x80, 0xF8,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00,
  0x79, 0xF0, 0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1E,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xF0, 0xF8, 0xFF,
  0x07, 0xFF, 0x78, 0x1F, 0xF3, 0xC0, 0x7F, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0x0F, 0x83, 0x8F, 0xC3, 0xCF, 0xE1, 0xEF, 0xF0, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0x01, 0x87,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC8, 0x01, 0xE3, 0xC1, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x41,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0,
  0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC3, 0xE0, 0x0F,
  0x0F, 0x80, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F,
  0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x81, 0xFC, 0x1F, 0x1E, 0xE0,
  0x7F, 0xF7, 0x81, 0xFF, 0x9E, 0x01, 0xFC, 0x78, 0x00, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x78, 0x07, 0xC7, 0x80, 0x7C,
  0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E,
  0x07, 0x83, 0xC0, 0x7C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF,
  0x00, 0x3D, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF0,
  0x0F, 0x80, 0x79, 0xE0, 0x3F, 0x01, 0xF3, 0xC0, 0x7E, 0x03, 0xC7, 0x81,
  0xFC, 0x0F, 0x8F, 0x03, 0xB8, 0x1F, 0x1E, 0x0F, 0x70, 0x3C, 0x3C, 0x1C,
  0xE0, 0xF8, 0x78, 0x79, 0xC1, 0xE0, 0xF0, 0xF3, 0x87, 0xC1, 0xE3, 0xC7,
  0x0F, 0x03, 0xC7, 0x8E, 0x3E, 0x07, 0x8E, 0x1C, 0x78, 0x0F, 0x3C, 0x38,
  0xF0, 0x1E, 0x70, 0x73, 0xC0, 0x3D, 0xE0, 0xE7, 0x80, 0x7B, 0x81, 0xDE,
  0x00, 0xFF, 0x03, 0xBC, 0x01, 0xFE, 0x07, 0x78, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x01, 0xE0,
  0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xFB,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF,
  0x80, 0x03, 0xC7, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x83, 0xC0, 0x1F, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0xFC, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3,
  0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x78, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x17, 0xFC, 0x03,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 31, 11, 1, -30 },
  { 44, 14, 11, 17, 4, -30 },
  { 64, 26, 30, 27, 1, -30 },
  { 162, 21, 34, 23, 1, -32 },
  { 252, 30, 30, 34, 3, -30 },
  { 365, 27, 30, 29, 1, -30 },
  { 467, 6, 11, 10, 4, -30 },
  { 476, 14, 37, 13, 2, -30 },
  { 541, 14, 37, 13, -3, -30 },
  { 606, 20, 20, 23, 4, -32 },
  { 656, 20, 20, 24, 3, -25 },
  { 706, 9, 10, 11, -2, -5 },
  { 718, 11, 4, 13, 1, -13 },
  { 724, 6, 7, 11, 1, -6 },
  { 730, 21, 30, 16, -2, -30 },
  { 809, 21, 30, 23, 2, -30 },
  { 888, 14, 30, 23, 5, -30 },
  { 941, 22, 30, 23, 0, -30 },
  { 1024, 21, 30, 23, 1, -30 },
  { 1103, 22, 30, 23, 0, -30 },
  { 1186, 22, 30, 23, 1, -30 },
  { 1269, 21, 30, 23, 2, -30 },
  { 1348, 21, 30, 23, 3, -30 },
  { 1427, 21, 30, 23, 2, -30 },
  { 1506, 20, 30, 23, 2, -30 },
  { 1581, 9, 24, 11, 1, -23 },
  { 1608, 12, 28, 11, -2, -23 },
  { 1650, 20, 21, 24, 3, -26 },
  { 1703, 19, 12, 24, 3, -21 },
  { 1732, 20, 21, 24, 3, -26 },
  { 1785, 17, 31, 18, 3, -30 },
  { 1851, 33, 34, 36, 2, -30 },
  { 1992, 24, 30, 24, -2, -30 },
  { 2082, 23, 30, 25, 2, -30 },
  { 2169, 24, 30, 25, 3, -30 },
  { 2259, 25, 30, 28, 2, -30 },
  { 2353, 22, 30, 22, 2, -30 },
  { 2436, 22, 30, 21, 2, -30 },
  { 2519, 25, 30, 29, 3, -30 },
  { 2613, 27, 30, 29, 2, -30 },
  { 2715, 18, 30, 14, -1, -30 },
  { 2783, 20, 38, 12, -7, -30 },
  { 2878, 26, 30, 24, 2, -30 },
  { 2976, 16, 30, 21, 2, -30 },
  { 3036, 34, 30, 36, 2, -30 },
  { 3164, 29, 30, 30, 2, -30 },
  { 3273, 26, 30, 30, 3, -30 },
  { 3371, 22, 30, 24, 2, -30 },
  { 3454, 26, 37, 30, 3, -30 },
  { 3575, 22, 30, 25, 2, -30 },
  { 3658, 21, 30, 22, 1, -30 },
  { 3737, 21, 30, 21, 4, -30 },
  { 3816, 26, 30, 29, 3, -30 },
  { 3914, 24, 30, 24, 4, -30 },
  { 4004, 36, 30, 36, 4, -30 },
  { 4139, 29, 30, 23, -2, -30 },
  { 4248, 22, 30, 22, 4, -30 },
  { 4331, 25, 30, 22, -1, -30 },
  { 4425, 17, 37, 13, -1, -30 },
  { 4504, 8, 30, 16, 5, -30 },
  { 4534, 16, 37, 13, -3, -30 },
  { 4608, 21, 19, 24, 1, -30 },
  { 4658, 17, 3, 17, -4, 4 },
  { 4665, 8, 7, 12, 6, -32 },
  { 4672, 21, 23, 24, 2, -23 },
  { 4733, 22, 32, 25, 1, -32 },
  { 4821, 18, 23, 19, 2, -23 },
  { 4873, 23, 32, 24, 2, -32 },
  { 4965, 19, 23, 22, 2, -23 },
  { 5020, 24, 42, 14, -5, -32 },
  { 5146, 22, 33, 25, 1, -23 },
  { 5237, 21, 32, 25, 1, -32 },
  { 5321, 11, 31, 11, 1, -31 },
  { 5364, 17, 41, 11, -5, -31 },
  { 5452, 22, 32, 22, 1, -32 },
  { 5540, 11, 32, 11, 1, -32 },
  { 5584, 34, 23, 37, 1, -23 },
  { 5682, 21, 23, 25, 1, -23 },
  { 5743, 20, 23, 24, 2, -23 },
  { 5801, 24, 33, 25, -1, -23 },
  { 5900, 21, 33, 24, 2, -23 },
  { 5987, 17, 23, 17, 1, -23 },
  { 6036, 18, 23, 19, 0, -23 },
  { 6088, 14, 28, 15, 2, -28 },
  { 6137, 22, 23, 25, 2, -23 },
  { 6201, 20, 23, 20, 2, -23 },
  { 6259, 31, 23, 31, 2, -23 },
  { 6349, 24, 23, 21, -2, -23 },
  { 6418, 26, 33, 20, -4, -23 },
  { 6526, 20, 23, 19, -1, -23 },
  { 6584, 17, 37, 15, 0, -30 },
  { 6663, 4, 42, 23, 10, -32 },
  { 6684, 17, 37, 15, -2, -30 },
  { 6763, 20, 6, 24, 3, -18 },
};

const GFXfont NotoSans_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_MEDIUMITALIC42PT7B_H_
