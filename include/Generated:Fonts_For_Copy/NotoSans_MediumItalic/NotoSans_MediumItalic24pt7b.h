#ifndef _NOTOSANS_MEDIUMITALIC24PT7B_H_
#define _NOTOSANS_MEDIUMITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0xC1, 0x80,
  0x00, 0x1C, 0x78, 0xE0, 0xE7, 0x9F, 0x3E, 0x6C, 0xD1, 0x80, 0x03, 0x18,
  0x06, 0x30, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x0F, 0xFF, 0xDF, 0xFF, 0x86,
  0x30, 0x0C, 0x60, 0x31, 0x83, 0xFF, 0xE7, 0xFF, 0xC3, 0x08, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x63, 0x00, 0x01, 0x80, 0x10, 0x0F, 0xF1, 0xFE,
  0x3B, 0x23, 0x30, 0x32, 0x03, 0xA0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x4C,
  0x04, 0xC0, 0xCC, 0xCD, 0xCF, 0xF8, 0x7E, 0x01, 0x80, 0x18, 0x00, 0x3E,
  0x07, 0x3F, 0x06, 0x19, 0x87, 0x18, 0xC3, 0x0C, 0x63, 0x06, 0x33, 0x03,
  0x1B, 0x91, 0x99, 0xBE, 0xFD, 0xBB, 0x3D, 0x99, 0xC0, 0xDC, 0xE0, 0xCC,
  0x60, 0xC6, 0x30, 0xC3, 0x18, 0x61, 0x9C, 0x60, 0xFC, 0x60, 0x3C, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x03,
  0xF0, 0x07, 0x80, 0x3F, 0x02, 0xF6, 0x1B, 0x8E, 0x77, 0x0E, 0xCC, 0x0F,
  0x98, 0x1E, 0x38, 0x7C, 0x7F, 0xDC, 0x7F, 0x3C, 0xFB, 0x6D, 0x00, 0x07,
  0x0E, 0x0C, 0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x06, 0x06, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x0E, 0x0C,
  0x1C, 0x18, 0x30, 0x70, 0xE0, 0x03, 0x00, 0x30, 0x46, 0x07, 0x60, 0xFF,
  0xF0, 0xFE, 0x1E, 0x03, 0xB0, 0x73, 0x02, 0x38, 0x01, 0x00, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x39, 0xDC, 0xC6, 0x60, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x00, 0x0F, 0xC1, 0xFE, 0x1C, 0x73, 0x87, 0x70, 0x77, 0x07, 0x60, 0x76,
  0x07, 0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0x63, 0xC7,
  0xF8, 0x3E, 0x00, 0x07, 0x1F, 0x3E, 0xF6, 0x6E, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x07, 0xE0, 0xFF, 0x82,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0,
  0x0F, 0xE0, 0xFF, 0x82, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x03, 0xC1,
  0xF8, 0x0F, 0x80, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x73, 0x07,
  0x9F, 0xF8, 0x7F, 0x80, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0x60, 0x3F,
  0x03, 0xB8, 0x39, 0x83, 0x8C, 0x18, 0xE1, 0x87, 0x18, 0x31, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xF1, 0xFF, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x36, 0x07, 0xF8, 0x37, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x83, 0xCF, 0xF8, 0xFE, 0x00, 0x03, 0xF0,
  0xFF, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x77, 0x86, 0xFC, 0x78, 0xE7,
  0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0xE6, 0x0C, 0x71, 0xC7, 0xF8, 0x3F, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x00, 0x0F, 0xE1, 0xFF, 0x18, 0x73, 0x83, 0x38, 0x71, 0x87, 0x1C,
  0xE0, 0xF8, 0x1F, 0x87, 0x9C, 0x60, 0xCE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1,
  0xC7, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0xE7, 0x06, 0x70, 0x76,
  0x07, 0x60, 0x77, 0x0E, 0x79, 0xE3, 0xF6, 0x1C, 0xE0, 0x0C, 0x01, 0xC0,
  0x18, 0x07, 0x8F, 0xF0, 0xFC, 0x00, 0x1C, 0xF3, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x3C, 0xE0, 0x0E, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE1, 0x87, 0x0C, 0x38, 0x60, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0x30, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x30, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x18, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x1F, 0x0F, 0x0F, 0x83, 0xC0,
  0x40, 0x00, 0x7F, 0x7F, 0xD0, 0xE0, 0x30, 0x18, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x38, 0x07, 0x0E, 0x00, 0x63, 0x80, 0x0E, 0x61, 0xF8,
  0xD8, 0xE3, 0x1B, 0x18, 0x63, 0xE6, 0x18, 0x78, 0xC3, 0x0F, 0x18, 0x63,
  0x63, 0x1C, 0x6C, 0x67, 0x99, 0xCF, 0xBE, 0x18, 0x41, 0x03, 0x80, 0x00,
  0x38, 0x04, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x01, 0x8E, 0x0E, 0x38,
  0x30, 0xE1, 0xFF, 0x87, 0xFE, 0x38, 0x19, 0xC0, 0x67, 0x01, 0xB8, 0x07,
  0xE0, 0x1C, 0x1F, 0xE0, 0xFF, 0xC7, 0x0E, 0x30, 0x31, 0x81, 0x9C, 0x1C,
  0xE1, 0xC7, 0xFC, 0x3F, 0xC3, 0x87, 0x9C, 0x1C, 0xE0, 0x66, 0x07, 0x30,
  0x3B, 0x83, 0x9F, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xCF, 0x02, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC1, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0x7F, 0xE1, 0xC3, 0x86, 0x07, 0x18, 0x1C, 0xE0, 0x33, 0x80, 0xCC, 0x03,
  0x30, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x60, 0x39, 0x81, 0xCE, 0x3E,
  0x3F, 0xF0, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0xFE, 0x3F, 0xC7, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x3F, 0xC7, 0xFC, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xF3,
  0xC0, 0x8E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE1, 0xFB,
  0x07, 0xEC, 0x03, 0xB0, 0x0C, 0xE0, 0x33, 0x81, 0xC7, 0x07, 0x1F, 0xFC,
  0x1F, 0xE0, 0x1C, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x18, 0x0E,
  0x38, 0x0C, 0x38, 0x0C, 0x3F, 0xFC, 0x3F, 0xFC, 0x70, 0x1C, 0x70, 0x18,
  0x70, 0x18, 0x60, 0x38, 0x60, 0x38, 0xE0, 0x30, 0xE0, 0x30, 0xE0, 0x70,
  0x0F, 0xE1, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x7F, 0x0F, 0xC1, 0xC0, 0x00, 0x1C, 0x1E, 0x38, 0x70, 0x71,
  0xE0, 0xC3, 0x81, 0x8E, 0x07, 0x38, 0x0E, 0xE0, 0x1B, 0x80, 0x3F, 0x00,
  0xF7, 0x01, 0xCE, 0x03, 0x8C, 0x06, 0x1C, 0x0C, 0x38, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xFF, 0xFF, 0x80, 0x1E,
  0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x07, 0xE3,
  0xF0, 0x6C, 0x33, 0x0C, 0xC3, 0x30, 0xDC, 0x33, 0x19, 0xC7, 0x31, 0x9C,
  0x73, 0x31, 0x86, 0x33, 0x18, 0x63, 0x63, 0x86, 0x36, 0x38, 0xE3, 0xC3,
  0x0E, 0x1C, 0x30, 0xC1, 0x87, 0x00, 0x1E, 0x03, 0x1E, 0x03, 0x1E, 0x07,
  0x1F, 0x07, 0x3B, 0x06, 0x3B, 0x06, 0x33, 0x86, 0x31, 0x8E, 0x31, 0x8E,
  0x71, 0xCC, 0x70, 0xCC, 0x60, 0xCC, 0x60, 0xFC, 0x60, 0x7C, 0xE0, 0x78,
  0xE0, 0x78, 0xC0, 0x38, 0x07, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7,
  0x00, 0xCC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0D, 0x80, 0x1B, 0x00,
  0x76, 0x00, 0xEE, 0x03, 0x9C, 0x0F, 0x1C, 0x3C, 0x3F, 0xF0, 0x1F, 0x80,
  0x1F, 0xE0, 0xFF, 0x87, 0x1E, 0x30, 0x71, 0x83, 0x9C, 0x1C, 0xE0, 0xE6,
  0x0E, 0x3F, 0xE3, 0xFE, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7,
  0x00, 0xCC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0D, 0x80, 0x1B, 0x00,
  0x76, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x1C, 0x3C, 0x3F, 0xF0, 0x1F, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0xFF, 0x87,
  0x1E, 0x30, 0x71, 0x83, 0x9C, 0x1C, 0xE0, 0xC6, 0x1E, 0x3F, 0xE3, 0xFC,
  0x1C, 0x60, 0xE3, 0x86, 0x1C, 0x30, 0x63, 0x83, 0x9C, 0x1C, 0xE0, 0x70,
  0x07, 0xF8, 0x7F, 0x87, 0x04, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0x07,
  0x1F, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x00, 0x38, 0x0E, 0x70, 0x18, 0xC0, 0x71,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x18, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0x80, 0xC6, 0x03, 0x8C, 0x07, 0x1C, 0x0C, 0x38, 0x38, 0x3F, 0xE0,
  0x3F, 0x80, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0x18, 0x1C, 0x60, 0x61, 0x83,
  0x86, 0x0C, 0x18, 0x70, 0x61, 0x81, 0xCE, 0x07, 0x30, 0x1D, 0xC0, 0x76,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x3B, 0x03,
  0x81, 0x98, 0x3C, 0x1C, 0xC1, 0xE0, 0xC6, 0x1B, 0x0E, 0x30, 0xD8, 0x61,
  0x8E, 0xC7, 0x0C, 0x66, 0x38, 0x67, 0x31, 0x83, 0x31, 0x9C, 0x19, 0x8C,
  0xC0, 0xD8, 0x6E, 0x06, 0xC3, 0x60, 0x3C, 0x1B, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x0E, 0x0E, 0x06, 0x1C, 0x07,
  0x18, 0x07, 0x38, 0x03, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0xE0, 0x0E, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x30, 0x70, 0x70,
  0x30, 0xE0, 0x38, 0xE0, 0x7B, 0x03, 0x98, 0x38, 0xE1, 0x87, 0x1C, 0x19,
  0xC0, 0xCC, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x0F, 0x87, 0xC3, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1F, 0x0F,
  0x80, 0xCC, 0xCC, 0xEE, 0x66, 0x66, 0x67, 0x33, 0x33, 0x30, 0x07, 0xC3,
  0xE0, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC1, 0xE0, 0xF8,
  0x00, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xD8, 0x19, 0x83, 0x98, 0x30, 0xC7,
  0x0C, 0x60, 0x6E, 0x06, 0xC0, 0x30, 0xFF, 0xFF, 0xE0, 0xE1, 0x8E, 0x0F,
  0x31, 0xFB, 0x38, 0xF7, 0x07, 0x70, 0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x1C, 0xE3, 0xC7, 0xEC, 0x7C, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0xBC, 0x37, 0xE3, 0xC7, 0x38, 0x77, 0x07, 0x70, 0x76,
  0x07, 0x60, 0x66, 0x0E, 0xE0, 0xEF, 0x1C, 0xDF, 0x8D, 0xF0, 0x0F, 0xC7,
  0xF3, 0x85, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x09,
  0xFC, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x3C, 0xC1, 0xFB, 0x0E, 0x3C, 0x70, 0x71, 0xC1, 0x86, 0x06, 0x38, 0x18,
  0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0xF0, 0x7E, 0xC1, 0xF3, 0x00, 0x0F,
  0x83, 0xF8, 0xE3, 0xB8, 0x76, 0x0D, 0xCF, 0xBF, 0xC7, 0xC0, 0xE0, 0x1C,
  0x03, 0x82, 0x3F, 0xC3, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x02, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0x0F,
  0x31, 0xFB, 0x38, 0xF7, 0x07, 0x70, 0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x1C, 0xE3, 0xC7, 0xEC, 0x7D, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0xC7,
  0x0F, 0xE0, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0xBE, 0x37, 0xE3, 0xC7, 0x38, 0x77, 0x07, 0x70, 0x67, 0x06, 0x60, 0xE6,
  0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x1C, 0x0C, 0x71, 0x80, 0x00, 0xE3,
  0x8C, 0x31, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x00, 0x00, 0xC0, 0x70,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x2E,
  0x0F, 0x83, 0x80, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x87,
  0x38, 0xE3, 0x1C, 0x33, 0x87, 0x70, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x70,
  0xE3, 0x0E, 0x38, 0xC1, 0x8C, 0x1C, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x8C,
  0x31, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x00, 0x33, 0xC7, 0xC6, 0xFD,
  0xFC, 0xF1, 0xE3, 0x9C, 0x38, 0x77, 0x07, 0x0E, 0xE0, 0xC1, 0xDC, 0x38,
  0x33, 0x07, 0x06, 0x60, 0xE1, 0xDC, 0x18, 0x3B, 0x83, 0x07, 0x60, 0xE0,
  0xCC, 0x1C, 0x38, 0x33, 0xE3, 0x7E, 0x3C, 0x73, 0x87, 0x70, 0x77, 0x07,
  0x70, 0x66, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x0C, 0xC1, 0xC0, 0x0F,
  0x81, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0,
  0xEE, 0x0E, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x0C, 0xF0, 0x37, 0xE0, 0xF1,
  0xC3, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x06, 0x18, 0x38, 0xE0,
  0xE3, 0xC7, 0x0D, 0xF8, 0x33, 0xC0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0xF7, 0x07, 0x70,
  0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0xC7, 0xEC, 0x7D,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x33, 0xCD,
  0xE3, 0xC0, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x00, 0x1F, 0xCF, 0xF3, 0x84, 0xC0, 0x38, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0x80, 0xE8, 0x3B, 0xFC, 0xFE, 0x00, 0x0C, 0x18, 0x18, 0x7F,
  0xFF, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0x7C, 0x7C,
  0x38, 0x33, 0x03, 0x30, 0x77, 0x07, 0x70, 0x77, 0x06, 0x60, 0x66, 0x0E,
  0xE0, 0xEE, 0x1C, 0xE3, 0xC7, 0xEC, 0x7C, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0,
  0xC6, 0x1C, 0x61, 0x86, 0x38, 0x63, 0x06, 0x70, 0x66, 0x06, 0xE0, 0x7C,
  0x03, 0xC0, 0x38, 0x00, 0xE1, 0xC1, 0xF8, 0x70, 0x6E, 0x34, 0x39, 0x8D,
  0x8C, 0x63, 0x67, 0x19, 0x99, 0x86, 0x66, 0xE1, 0xB1, 0xB0, 0x6C, 0x6C,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x70, 0x00, 0x1C, 0x3C,
  0x70, 0xE0, 0xC7, 0x03, 0xB8, 0x07, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0xE0,
  0x0D, 0x80, 0x77, 0x03, 0x8C, 0x1C, 0x38, 0xE0, 0xE0, 0x1C, 0x0E, 0x38,
  0x38, 0x30, 0x60, 0x61, 0xC0, 0xC3, 0x01, 0x8E, 0x03, 0x18, 0x07, 0x70,
  0x0E, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0xBC, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xE7, 0xFC,
  0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x7F, 0xCF, 0xF0, 0x03, 0xC1, 0xE0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x1E, 0x0E, 0x00, 0xE0, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0E, 0x07, 0x81, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xC0,
  0xE1, 0xF0, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x1E, 0x0E, 0x00,
  0xF8, 0x3F, 0xFE, 0x1F, 0x00,
};

const GFXglyph NotoSans_MediumItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 7, 6, 10, 3, -17 },
  { 22, 15, 17, 16, 1, -17 },
  { 54, 12, 19, 13, 1, -18 },
  { 83, 17, 17, 20, 2, -17 },
  { 120, 15, 17, 16, 1, -17 },
  { 152, 3, 6, 6, 3, -17 },
  { 155, 8, 21, 7, 1, -17 },
  { 176, 8, 21, 7, -2, -17 },
  { 197, 12, 11, 13, 2, -18 },
  { 214, 11, 11, 14, 2, -14 },
  { 230, 5, 6, 6, -1, -3 },
  { 234, 6, 3, 8, 1, -8 },
  { 237, 4, 3, 6, 0, -3 },
  { 239, 12, 17, 9, -1, -17 },
  { 265, 12, 17, 13, 1, -17 },
  { 291, 8, 17, 13, 3, -17 },
  { 308, 13, 17, 13, 0, -17 },
  { 336, 13, 17, 13, 0, -17 },
  { 364, 13, 17, 13, 0, -17 },
  { 392, 12, 17, 13, 1, -17 },
  { 418, 12, 17, 13, 1, -17 },
  { 444, 12, 17, 13, 2, -17 },
  { 470, 12, 17, 13, 1, -17 },
  { 496, 12, 17, 13, 1, -17 },
  { 522, 6, 13, 6, 0, -13 },
  { 532, 7, 16, 6, -1, -13 },
  { 546, 11, 12, 14, 2, -15 },
  { 563, 11, 7, 14, 2, -12 },
  { 573, 11, 12, 14, 2, -15 },
  { 590, 9, 17, 11, 2, -17 },
  { 610, 19, 19, 20, 1, -17 },
  { 656, 14, 17, 14, -1, -17 },
  { 686, 13, 17, 15, 1, -17 },
  { 714, 13, 17, 14, 2, -17 },
  { 742, 14, 17, 16, 1, -17 },
  { 772, 12, 17, 13, 1, -17 },
  { 798, 12, 17, 12, 1, -17 },
  { 824, 14, 17, 16, 2, -17 },
  { 854, 16, 17, 16, 1, -17 },
  { 888, 11, 17, 8, -1, -17 },
  { 912, 11, 22, 7, -4, -17 },
  { 943, 15, 17, 14, 1, -17 },
  { 975, 9, 17, 12, 1, -17 },
  { 995, 20, 17, 20, 1, -17 },
  { 1038, 16, 17, 17, 1, -17 },
  { 1072, 15, 17, 17, 2, -17 },
  { 1104, 13, 17, 14, 1, -17 },
  { 1132, 15, 21, 17, 2, -17 },
  { 1172, 13, 17, 14, 1, -17 },
  { 1200, 13, 17, 12, 0, -17 },
  { 1228, 12, 17, 12, 2, -17 },
  { 1254, 15, 17, 16, 2, -17 },
  { 1286, 14, 17, 14, 2, -17 },
  { 1316, 21, 17, 21, 2, -17 },
  { 1361, 16, 17, 13, -1, -17 },
  { 1395, 13, 17, 13, 2, -17 },
  { 1423, 14, 17, 13, 0, -17 },
  { 1453, 9, 21, 7, 0, -17 },
  { 1477, 4, 17, 9, 3, -17 },
  { 1486, 10, 21, 7, -2, -17 },
  { 1513, 12, 11, 14, 1, -17 },
  { 1530, 10, 2, 10, -2, 2 },
  { 1533, 5, 3, 7, 3, -18 },
  { 1535, 12, 13, 14, 1, -13 },
  { 1555, 12, 18, 14, 1, -18 },
  { 1582, 10, 13, 11, 1, -13 },
  { 1599, 14, 18, 14, 1, -18 },
  { 1631, 11, 13, 12, 1, -13 },
  { 1649, 14, 24, 8, -3, -18 },
  { 1691, 12, 19, 14, 1, -13 },
  { 1720, 12, 18, 14, 1, -18 },
  { 1747, 6, 18, 6, 1, -18 },
  { 1761, 10, 24, 6, -3, -18 },
  { 1791, 12, 18, 12, 1, -18 },
  { 1818, 6, 18, 6, 1, -18 },
  { 1832, 19, 13, 21, 1, -13 },
  { 1863, 12, 13, 14, 1, -13 },
  { 1883, 12, 13, 14, 1, -13 },
  { 1903, 14, 19, 14, -1, -13 },
  { 1937, 12, 19, 14, 1, -13 },
  { 1966, 10, 13, 10, 1, -13 },
  { 1983, 10, 13, 11, 0, -13 },
  { 2000, 8, 16, 9, 1, -16 },
  { 2016, 12, 13, 14, 1, -13 },
  { 2036, 12, 13, 12, 1, -13 },
  { 2056, 18, 13, 18, 1, -13 },
  { 2086, 14, 13, 12, -1, -13 },
  { 2109, 15, 19, 12, -2, -13 },
  { 2145, 11, 13, 11, 0, -13 },
  { 2163, 10, 21, 8, 0, -17 },
  { 2190, 2, 24, 13, 6, -18 },
  { 2196, 9, 21, 8, -1, -17 },
  { 2220, 11, 3, 14, 2, -10 },
};

const GFXfont NotoSans_MediumItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_MEDIUMITALIC24PT7B_H_
