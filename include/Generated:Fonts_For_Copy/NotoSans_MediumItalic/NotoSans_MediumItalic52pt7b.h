#ifndef _NOTOSANS_MEDIUMITALIC52PT7B_H_
#define _NOTOSANS_MEDIUMITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0xC0, 0x00, 0x7E, 0x1F, 0x7C, 0x3F,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C,
  0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x78, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFB, 0x9F,
  0x01, 0xF8, 0xE0, 0xC0, 0xFC, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xE1, 0xC0, 0x00, 0xF8, 0x70, 0x00, 0x3F, 0x3C, 0x00, 0x0F,
  0xEF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x77,
  0xF0, 0x00, 0x1C, 0xFE, 0x00, 0x0F, 0x1F, 0x80, 0x03, 0xC7, 0xE0, 0x00,
  0xE1, 0xF8, 0x00, 0x38, 0x7E, 0x00, 0x1E, 0x1F, 0x08, 0x07, 0x8F, 0xC3,
  0xE1, 0xCF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x0F, 0xFE, 0x00,
  0x0F, 0x81, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0x3F, 0x00, 0x1E, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0x80,
  0x7C, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x07, 0x80, 0x0F, 0x01,
  0xF0, 0xF8, 0x00, 0xF0, 0x1E, 0x1F, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xE0,
  0xF0, 0x3E, 0x3C, 0x7F, 0xCF, 0x03, 0xC7, 0xCF, 0xFE, 0xF8, 0x7C, 0xF9,
  0xFF, 0xEF, 0xCF, 0x8F, 0x1F, 0x1F, 0x7F, 0xF1, 0xF3, 0xE1, 0xF7, 0xFE,
  0x3E, 0x7C, 0x0F, 0x3F, 0xC7, 0xC7, 0xC0, 0xF0, 0x60, 0x78, 0x78, 0x0F,
  0x00, 0x0F, 0x8F, 0x80, 0xF0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x3E, 0x0F,
  0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x01, 0xE0, 0x0F,
  0x80, 0xF0, 0x1E, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x3E,
  0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x0F,
  0xFF, 0x80, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x07, 0xFE, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x1F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x87, 0xE0, 0x3E, 0x7F, 0x07, 0xF0, 0x7E, 0x7E, 0x03, 0xF0, 0xFC,
  0xFC, 0x01, 0xF8, 0xF8, 0xFC, 0x00, 0xFD, 0xF8, 0xF8, 0x00, 0xFF, 0xF0,
  0xF8, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8,
  0x0F, 0xFF, 0x01, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x7E, 0xF9, 0xF3, 0xE7,
  0xCF, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8E, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x70, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7F, 0x1E, 0x00, 0xFF,
  0xDC, 0x00, 0x7F, 0xFC, 0x3F, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0x03, 0xEE, 0x00, 0x07, 0xCF, 0x00, 0x0F,
  0xCF, 0x00, 0x1F, 0x8F, 0x80, 0x3F, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x0E,
  0x07, 0xC0, 0x04, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x00,
  0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC3, 0xF8,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0,
  0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7,
  0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x87, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF, 0x7C,
  0xFE, 0x3E, 0x3E, 0x3F, 0x1C, 0x1F, 0x04, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFE, 0x00,
  0xF0, 0x07, 0xE0, 0x0C, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0x70, 0x03, 0xF0, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x84,
  0x00, 0x03, 0xF0, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x01,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x08, 0x00, 0x1F, 0xC3, 0x00, 0x0F, 0xE0, 0xF8, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xC0,
  0x20, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x30, 0x00, 0xF8, 0xFF, 0x80, 0x7E, 0x7F, 0xF8,
  0x1F, 0xBF, 0xFE, 0x07, 0xDF, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x7F, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x07, 0xE3, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00,
  0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0xFE,
  0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF0, 0x00,
  0xF9, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x9F, 0x80, 0x1F, 0xC7, 0xE0, 0x1F, 0xE3, 0xF8, 0x3F, 0xF1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0xF8, 0x1F, 0xFE, 0xFC, 0x03, 0xFC, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x70, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xE0, 0x7F, 0x30, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0xE0, 0x1E, 0x1F, 0x00, 0xFF, 0xFC, 0x1F, 0x3E, 0x01, 0xFF, 0xFC, 0x1F,
  0x3E, 0x03, 0xFF, 0xFC, 0x0F, 0x7C, 0x07, 0xE0, 0x78, 0x0F, 0x7C, 0x0F,
  0x80, 0x78, 0x0F, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0xF8, 0x3E, 0x00, 0xF0, 0x0F, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0xF0,
  0x3C, 0x01, 0xF0, 0x1F, 0xF0, 0x3C, 0x01, 0xE0, 0x1E, 0xF0, 0x7C, 0x01,
  0xE0, 0x1E, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0xF0, 0x7C, 0x03, 0xE0, 0x3C,
  0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0xF0, 0x3C, 0x0F, 0xE0, 0xF8, 0xF0, 0x3E,
  0x1F, 0xF1, 0xF0, 0xF8, 0x3F, 0xFD, 0xFF, 0xF0, 0xF8, 0x1F, 0xF8, 0xFF,
  0xC0, 0x78, 0x0F, 0xF0, 0x7F, 0x80, 0x7C, 0x03, 0x80, 0x0C, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xFC, 0x0F,
  0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xC1, 0xF8, 0x0F, 0xF0, 0x01, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x04, 0x01, 0xFF, 0x87, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF0,
  0x00, 0x3F, 0x83, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x1F, 0x80,
  0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0x00,
  0xFF, 0x00, 0x06, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0x1F, 0x80, 0x1F,
  0xFE, 0x3E, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0,
  0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0xF0, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0,
  0x3F, 0x80, 0x01, 0xF0, 0x3F, 0x80, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x1F,
  0x3F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x7C, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x00,
  0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x03, 0xEF, 0x80, 0x7D, 0xE0, 0x00, 0xFB,
  0xF0, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x00, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF3,
  0xE0, 0x07, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x03, 0xE1,
  0xF8, 0x07, 0xC3, 0xC0, 0x7C, 0x3E, 0x01, 0xF8, 0x78, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0xF8, 0x3F, 0x00, 0xF8,
  0x3E, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0x07, 0xC0, 0xF8,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xE7, 0x80,
  0xFC, 0x03, 0xE0, 0x3D, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3E, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x03,
  0xE0, 0x1F, 0xF0, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0xF8,
  0x00, 0x7C, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0x3E, 0xF8, 0x00, 0x7C, 0x07,
  0xCF, 0xC0, 0x0F, 0xC0, 0x7C, 0x7C, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x0F,
  0x80, 0x7C, 0x7E, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0xFC, 0x3E,
  0x01, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F,
  0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x80, 0xF8, 0x3E,
  0x01, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x00, 0x7E, 0x7E, 0x03, 0xE0, 0x03, 0xE7, 0xC0, 0x3E,
  0x00, 0x3E, 0x7C, 0x03, 0xE0, 0x03, 0xF7, 0xC0, 0x3E, 0x00, 0x1F, 0x7C,
  0x07, 0xE0, 0x01, 0xF7, 0xC0, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x07,
  0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x87,
  0xE0, 0x7F, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC2, 0x00, 0x07,
  0xF0, 0xC0, 0x03, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0,
  0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E,
  0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF7,
  0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xBE, 0x00, 0xF8, 0x1F, 0x00, 0x7D, 0xF0,
  0x0F, 0xC0, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x7C, 0x07,
  0xE0, 0x3E, 0x03, 0xE3, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x03,
  0xE0, 0x7C, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80,
  0x78, 0xF8, 0x00, 0x7C, 0xF8, 0x03, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x1E,
  0x7C, 0x00, 0x1F, 0x3C, 0x00, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x07, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xF8,
  0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00,
  0x3E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1F, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xF8, 0x3C, 0x03, 0xFF,
  0x8F, 0x80, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x83,
  0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F,
  0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x7F, 0x03, 0xF0, 0x1F, 0xE0,
  0x7F, 0x0F, 0xFC, 0x07, 0xFF, 0xEF, 0x80, 0xFF, 0xF9, 0xF0, 0x0F, 0xFE,
  0x3C, 0x00, 0xFF, 0x07, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x08, 0x00, 0x3F, 0x1F, 0xE0, 0x07, 0xC7, 0xFE, 0x00, 0xF9, 0xFF, 0xE0,
  0x3F, 0x7F, 0xFE, 0x07, 0xDE, 0x1F, 0xC0, 0xFF, 0x81, 0xF8, 0x1F, 0xC0,
  0x1F, 0x83, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x07, 0xF0, 0x07, 0xE1, 0xFE, 0x01, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xDF,
  0xFF, 0xC0, 0xF3, 0xFF, 0xF0, 0x1E, 0x3F, 0xFC, 0x07, 0xC3, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x08, 0x3F, 0x81,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x07, 0xC0, 0x07,
  0xFC, 0x3E, 0x00, 0x7F, 0xF3, 0xF0, 0x07, 0xFF, 0xDF, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x7C,
  0x00, 0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x1F,
  0xF8, 0x03, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0x3E, 0x00, 0x7F, 0xF1, 0xE0,
  0x01, 0xFE, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE,
  0x0F, 0xC3, 0xF0, 0x0F, 0x8F, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00,
  0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0x0F, 0xE7, 0xE0, 0x7F, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x08, 0x3F, 0x80, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x21, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x7F, 0xF1,
  0xF0, 0x1F, 0xFF, 0x9F, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFE, 0x07,
  0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x3E, 0x00, 0xFE, 0x03, 0xF0,
  0x1F, 0xE0, 0x3F, 0x87, 0xFE, 0x01, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x7E,
  0x00, 0xFF, 0xE7, 0xC0, 0x07, 0xF8, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x0C, 0x00, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x08, 0x00, 0x3E, 0x1F, 0xF0, 0x07, 0xC7,
  0xFF, 0x00, 0xF9, 0xFF, 0xF0, 0x3F, 0x7F, 0xFE, 0x07, 0xDF, 0x0F, 0xC0,
  0xFF, 0x80, 0xFC, 0x1F, 0xE0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0x30, 0x03, 0xE0, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x08, 0x7F, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x3E, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0xF8,
  0x7F, 0x80, 0x7F, 0x80, 0x3C, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0x3F, 0xFE,
  0x3F, 0xFE, 0x03, 0xCF, 0xFF, 0x9F, 0xFF, 0xC1, 0xF7, 0x87, 0xE7, 0x87,
  0xF0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0x07,
  0xF0, 0x0F, 0xF0, 0x07, 0xC3, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x87, 0xC0,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07,
  0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x3F, 0xE0, 0x0F, 0x8F, 0xFE,
  0x01, 0xE7, 0xFF, 0xE0, 0x7D, 0xFF, 0xFC, 0x0F, 0xBE, 0x1F, 0xC1, 0xFF,
  0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xDF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x07,
  0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xC3, 0xFC, 0x00, 0x3C, 0x3F, 0xF0, 0x01, 0xE7, 0xFF, 0xC0, 0x0F,
  0x7F, 0xFF, 0x00, 0xFB, 0xC3, 0xF8, 0x07, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x03, 0xFC, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0x80, 0xFB, 0xFF, 0xF8, 0x07, 0xDF, 0xFF, 0x80, 0x3E, 0x7F,
  0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0x80, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF8, 0x3C, 0x03, 0xFF, 0x8F, 0x81,
  0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x0F,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E,
  0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE0,
  0xF8, 0x01, 0xFC, 0x1F, 0x00, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x0F,
  0xFC, 0x07, 0xFF, 0xEF, 0x80, 0xFF, 0xFB, 0xF0, 0x0F, 0xFE, 0x7C, 0x00,
  0xFF, 0x0F, 0x80, 0x03, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x0F,
  0x87, 0xF0, 0x3E, 0x3F, 0x80, 0xF3, 0xFE, 0x07, 0xCF, 0xF8, 0x1F, 0x7F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x80, 0xE0, 0xFC, 0x00, 0x83,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x20, 0x01, 0xF8, 0xF0, 0x0F,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x82, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x18, 0x00, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xE0, 0x07, 0xF0, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0xFF, 0x0F, 0xC0, 0x7F,
  0x83, 0xF8, 0x7F, 0xE0, 0xFF, 0xFE, 0xF8, 0x1F, 0xFF, 0x3E, 0x03, 0xFF,
  0x8F, 0x80, 0x7F, 0x83, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x0F,
  0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xEF, 0x80,
  0x1F, 0xC0, 0x1F, 0xBE, 0x00, 0xFF, 0x00, 0xFC, 0xF8, 0x03, 0xFC, 0x03,
  0xF3, 0xE0, 0x1E, 0xF0, 0x0F, 0x8F, 0x80, 0x7B, 0xC0, 0x7E, 0x3E, 0x03,
  0xEF, 0x01, 0xF0, 0xF8, 0x0F, 0x3C, 0x0F, 0xC3, 0xE0, 0x7C, 0xF0, 0x3E,
  0x0F, 0xC1, 0xE3, 0xC1, 0xF8, 0x1F, 0x0F, 0x8F, 0x07, 0xC0, 0x7C, 0x3E,
  0x3C, 0x3F, 0x01, 0xF1, 0xF0, 0xF0, 0xF8, 0x07, 0xC7, 0xC3, 0xC3, 0xE0,
  0x1F, 0x1E, 0x0F, 0x1F, 0x80, 0x7C, 0xF8, 0x3C, 0x7C, 0x01, 0xF3, 0xC0,
  0xF3, 0xF0, 0x07, 0xDF, 0x03, 0xCF, 0x80, 0x1F, 0x78, 0x0F, 0x3E, 0x00,
  0x7D, 0xE0, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x03,
  0xDE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xEF,
  0xC0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xFC, 0x00, 0xDF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0xFF, 0xFA, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_MediumItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 38, 14, 1, -37 },
  { 68, 16, 13, 21, 6, -37 },
  { 94, 33, 37, 34, 1, -37 },
  { 247, 26, 42, 29, 2, -39 },
  { 384, 36, 39, 42, 4, -38 },
  { 560, 32, 39, 36, 2, -38 },
  { 716, 7, 13, 12, 6, -37 },
  { 728, 18, 45, 16, 2, -37 },
  { 830, 18, 45, 16, -4, -37 },
  { 932, 24, 25, 29, 5, -40 },
  { 1007, 25, 25, 30, 3, -31 },
  { 1086, 11, 13, 14, -2, -6 },
  { 1104, 14, 5, 16, 1, -16 },
  { 1113, 7, 8, 14, 1, -7 },
  { 1120, 26, 37, 20, -2, -37 },
  { 1241, 25, 39, 29, 3, -38 },
  { 1363, 17, 37, 29, 7, -37 },
  { 1442, 28, 38, 29, 0, -38 },
  { 1575, 27, 39, 29, 1, -38 },
  { 1707, 28, 37, 29, 0, -37 },
  { 1837, 26, 38, 29, 2, -37 },
  { 1961, 26, 39, 29, 3, -38 },
  { 2088, 26, 37, 29, 4, -37 },
  { 2209, 26, 39, 29, 2, -38 },
  { 2336, 25, 39, 29, 2, -38 },
  { 2458, 11, 30, 14, 1, -29 },
  { 2500, 15, 36, 14, -3, -29 },
  { 2568, 25, 26, 30, 3, -32 },
  { 2650, 24, 15, 30, 4, -26 },
  { 2695, 25, 26, 30, 3, -32 },
  { 2777, 20, 39, 23, 4, -38 },
  { 2875, 40, 42, 44, 3, -37 },
  { 3085, 31, 37, 30, -3, -37 },
  { 3229, 29, 37, 32, 2, -37 },
  { 3364, 29, 39, 31, 4, -38 },
  { 3506, 31, 37, 35, 2, -37 },
  { 3650, 27, 37, 27, 2, -37 },
  { 3775, 27, 37, 26, 2, -37 },
  { 3900, 31, 39, 35, 4, -38 },
  { 4052, 34, 37, 36, 2, -37 },
  { 4210, 22, 37, 18, -1, -37 },
  { 4312, 24, 47, 15, -8, -37 },
  { 4453, 33, 37, 30, 2, -37 },
  { 4606, 20, 37, 25, 2, -37 },
  { 4699, 43, 37, 44, 2, -37 },
  { 4898, 36, 37, 38, 2, -37 },
  { 5065, 32, 39, 38, 4, -38 },
  { 5221, 28, 37, 30, 2, -37 },
  { 5351, 32, 47, 38, 4, -38 },
  { 5539, 28, 37, 31, 2, -37 },
  { 5669, 26, 39, 27, 1, -38 },
  { 5796, 26, 37, 27, 5, -37 },
  { 5917, 32, 38, 35, 4, -37 },
  { 6069, 29, 37, 29, 5, -37 },
  { 6204, 45, 37, 45, 5, -37 },
  { 6413, 36, 37, 29, -3, -37 },
  { 6580, 27, 37, 27, 5, -37 },
  { 6705, 31, 37, 28, -1, -37 },
  { 6849, 21, 45, 16, -1, -37 },
  { 6968, 10, 37, 20, 6, -37 },
  { 7015, 21, 45, 16, -4, -37 },
  { 7134, 26, 23, 29, 2, -37 },
  { 7209, 22, 3, 21, -5, 5 },
  { 7218, 9, 8, 15, 8, -40 },
  { 7227, 27, 30, 30, 2, -29 },
  { 7329, 27, 41, 30, 1, -40 },
  { 7468, 22, 30, 24, 2, -29 },
  { 7551, 29, 41, 30, 2, -40 },
  { 7700, 23, 30, 27, 2, -29 },
  { 7787, 30, 52, 17, -6, -40 },
  { 7982, 28, 41, 30, 1, -29 },
  { 8126, 27, 40, 30, 1, -40 },
  { 8261, 14, 39, 14, 1, -39 },
  { 8330, 22, 51, 14, -7, -39 },
  { 8471, 28, 40, 27, 1, -40 },
  { 8611, 14, 40, 14, 1, -40 },
  { 8681, 42, 29, 46, 1, -29 },
  { 8834, 27, 29, 30, 1, -29 },
  { 8932, 25, 28, 30, 2, -28 },
  { 9020, 29, 41, 30, -1, -29 },
  { 9169, 27, 41, 30, 2, -29 },
  { 9308, 22, 29, 21, 1, -29 },
  { 9388, 22, 30, 23, 0, -29 },
  { 9471, 18, 35, 18, 2, -34 },
  { 9550, 26, 29, 30, 3, -28 },
  { 9645, 25, 28, 25, 3, -28 },
  { 9733, 38, 28, 39, 3, -28 },
  { 9866, 30, 28, 26, -2, -28 },
  { 9971, 33, 40, 25, -5, -28 },
  { 10136, 24, 28, 24, -1, -28 },
  { 10220, 21, 45, 18, 0, -37 },
  { 10339, 4, 51, 29, 13, -39 },
  { 10365, 20, 45, 18, -2, -37 },
  { 10478, 25, 7, 30, 3, -22 },
};

const GFXfont NotoSans_MediumItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_MEDIUMITALIC52PT7B_H_
