#ifndef _NOTOSANS_MEDIUMITALIC27PT7B_H_
#define _NOTOSANS_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x73, 0xB3, 0xB9, 0xDC,
  0xCC, 0x66, 0x33, 0x18, 0x01, 0x86, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x31, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0x0C, 0x70, 0x0E, 0x30, 0x06,
  0x18, 0x03, 0x0C, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0xC3, 0x00, 0x63, 0x80,
  0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x1C, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x0F, 0xF1, 0xFF, 0x8E, 0xCC, 0xE6, 0x07, 0x30, 0x39, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x03, 0x38, 0x19, 0xC0, 0xCE, 0x86,
  0xE7, 0xFF, 0x3F, 0xF0, 0x3C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x47, 0xE0, 0x30, 0xFC, 0x0C, 0x39, 0xC3, 0x86, 0x38, 0x61, 0xC6,
  0x18, 0x38, 0xC6, 0x06, 0x19, 0xC0, 0xC7, 0x33, 0x98, 0xCD, 0xFB, 0xFB,
  0xBB, 0xBE, 0xEE, 0x31, 0x19, 0x86, 0x06, 0x31, 0xC1, 0xCE, 0x38, 0x71,
  0xC6, 0x0C, 0x38, 0xC3, 0x07, 0x38, 0xE0, 0x7E, 0x38, 0x0F, 0x80, 0x00,
  0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xC7, 0x00, 0xE1, 0x80, 0x60, 0xC0,
  0x30, 0xE0, 0x1D, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x27, 0x70,
  0x67, 0x1C, 0x77, 0x07, 0x73, 0x83, 0xF9, 0xC0, 0xF8, 0xE0, 0x78, 0x78,
  0x7E, 0x1F, 0xF7, 0x87, 0xF1, 0xE0, 0x76, 0xEE, 0xCC, 0xC0, 0x03, 0x83,
  0x83, 0x81, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0x03, 0x83, 0x83,
  0x83, 0x80, 0x02, 0x00, 0x30, 0x03, 0x08, 0x70, 0xE6, 0x0F, 0xE1, 0x1F,
  0xF0, 0xEF, 0x1B, 0x07, 0x30, 0xF3, 0x82, 0x38, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x3C, 0xE7, 0x1C, 0x63,
  0x80, 0xFF, 0xF8, 0x27, 0xF7, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x3F, 0x83, 0xFE, 0x3C, 0x73, 0xC3, 0x9C, 0x0C, 0xE0, 0x6E,
  0x03, 0x70, 0x3B, 0x81, 0xD8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81,
  0xDC, 0x0E, 0x70, 0xE3, 0x8F, 0x0F, 0xF0, 0x3E, 0x00, 0x03, 0x87, 0xCF,
  0xFF, 0x77, 0x72, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x40, 0x1F, 0xE1, 0xFF,
  0xC3, 0x07, 0x08, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0x00, 0x40, 0x1F, 0xE1, 0xFF, 0xC3,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x1F, 0x80,
  0x7C, 0x02, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x73,
  0x83, 0xCF, 0xFE, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3F,
  0x01, 0xD8, 0x0E, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x30, 0x71, 0xC3, 0x87,
  0x1C, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0F, 0xE0, 0x3F, 0xE0, 0xC7, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0xC1, 0xE3, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x60, 0x1F, 0xC3, 0xFC, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE7, 0xC7, 0xFF, 0x3E, 0x39, 0xC0, 0xEE, 0x07, 0x60, 0x3B,
  0x01, 0x98, 0x1C, 0xE0, 0xE7, 0x8E, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0x0F,
  0x1C, 0x1C, 0x70, 0x71, 0xC1, 0x87, 0x0E, 0x0E, 0xF0, 0x1F, 0x01, 0xFC,
  0x0F, 0x38, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0xC3,
  0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x80, 0x7F, 0x07, 0xFC, 0x78, 0xF3, 0x83,
  0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0xCE, 0x7E, 0x7F, 0x70,
  0xF7, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE4, 0x3E, 0x3F, 0xE1, 0xFC,
  0x00, 0x0C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x73, 0xC7,
  0x00, 0x06, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x87, 0x1C, 0x38, 0xE1, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x1C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x01, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x0E, 0x00,
  0x40, 0x00, 0x06, 0x0F, 0xF1, 0xFF, 0x30, 0xE0, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x03, 0x80, 0x60, 0x10, 0x00, 0x00,
  0x20, 0x1E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01,
  0xE0, 0x3C, 0x1C, 0x00, 0x61, 0xC0, 0x03, 0x9C, 0x1F, 0x8C, 0xC3, 0xFC,
  0x6E, 0x38, 0xE3, 0x63, 0x86, 0x1B, 0x18, 0x30, 0xF8, 0xC1, 0x87, 0xCE,
  0x1C, 0x7E, 0x70, 0xC3, 0x71, 0x8E, 0x39, 0x8F, 0xDF, 0x8C, 0x3C, 0xF8,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x40, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x6C, 0x00, 0xEE,
  0x00, 0xCE, 0x01, 0xCE, 0x01, 0x8E, 0x03, 0x8E, 0x03, 0x0E, 0x07, 0x06,
  0x0F, 0xFE, 0x0F, 0xFF, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x70, 0x07, 0xF0, 0x07, 0x0F, 0xF8, 0x1F, 0xF8, 0x70, 0x78, 0xE0, 0x71,
  0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x9C, 0x1E, 0x3F, 0xF0, 0x7F, 0xE0, 0xE1,
  0xE1, 0x81, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x61, 0xF9,
  0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x3F, 0xF8, 0xF8, 0x23,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF8, 0x60, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x1C, 0x3E,
  0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C,
  0x70, 0x7C, 0x67, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF1,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xF0,
  0xFF, 0xC3, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFE, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0x06,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0xFE, 0xE0, 0xFE, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xF0, 0x1C, 0x7C, 0x38, 0x3F, 0xF8, 0x1F, 0xF0, 0x0E, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x70,
  0xE0, 0x1C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x80, 0xE0, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x70, 0x60, 0x1C, 0x38, 0x07,
  0x0E, 0x01, 0xC0, 0x0F, 0xF0, 0xFE, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0x0E, 0x07, 0x87, 0x07,
  0x07, 0x07, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE7, 0x80, 0x67, 0x80, 0x77,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x3C, 0x38, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F,
  0xFF, 0xFB, 0xFF, 0x00, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x36, 0x1F, 0x81, 0xF8, 0x6E, 0x06, 0xE1, 0xB8, 0x3B, 0x8E,
  0xE0, 0xCE, 0x39, 0x87, 0x30, 0xE6, 0x19, 0xC3, 0x18, 0xE7, 0x0C, 0x63,
  0x1C, 0x71, 0x9C, 0x61, 0xC6, 0x63, 0x87, 0x1F, 0x0E, 0x18, 0x7C, 0x38,
  0xE1, 0xE0, 0xE3, 0x87, 0x83, 0x0E, 0x0C, 0x1C, 0x00, 0x0F, 0x00, 0xE1,
  0xE0, 0x18, 0x7C, 0x07, 0x0F, 0xC0, 0xE1, 0xF8, 0x1C, 0x33, 0x03, 0x06,
  0x70, 0xE1, 0xCE, 0x1C, 0x38, 0xC3, 0x87, 0x1C, 0x70, 0xC3, 0x8C, 0x18,
  0x33, 0x87, 0x07, 0x70, 0xE0, 0xEE, 0x1C, 0x0F, 0xC3, 0x01, 0xF0, 0xE0,
  0x3E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x0E, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x39, 0xC0, 0x3C, 0x70, 0x3C, 0x3E, 0x3C, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x70, 0xF0, 0xE0, 0xF1, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x9C, 0x0E, 0x38, 0x3C, 0x7F, 0xF0, 0xFF, 0xC1, 0xF8,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0,
  0x71, 0xC0, 0x39, 0xC0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x3C,
  0x70, 0x3C, 0x3E, 0x7C, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x1F, 0xF8,
  0x70, 0xF0, 0xE0, 0xE1, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x1C, 0x0E, 0x38,
  0x78, 0x7F, 0xE0, 0xFF, 0x01, 0x8E, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x60, 0x71, 0xC0, 0xF3, 0x80, 0xE0, 0x01, 0x80, 0x7F, 0xC7,
  0xFE, 0x78, 0x23, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE6,
  0x1E, 0x3F, 0xF1, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0,
  0x70, 0x78, 0xF0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0xE0, 0x0F, 0x60, 0x0E,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0x70, 0xE0, 0x31, 0xC0, 0x31, 0xC0, 0x33, 0x80, 0x33, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x78,
  0x1F, 0xC0, 0xF0, 0x3B, 0x81, 0xE0, 0x77, 0x07, 0xC1, 0xCE, 0x0F, 0x83,
  0x9C, 0x3F, 0x0E, 0x38, 0x66, 0x1C, 0x71, 0xCC, 0x70, 0xE3, 0x18, 0xE1,
  0xCE, 0x31, 0x83, 0x98, 0x67, 0x07, 0x70, 0xCE, 0x0E, 0xE1, 0xB8, 0x1D,
  0x83, 0x70, 0x3F, 0x06, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0xC1, 0xC1, 0xE0, 0x70, 0x70,
  0x1C, 0x38, 0x03, 0x9C, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x03, 0x8C,
  0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x1C, 0x1C, 0x07, 0x0E, 0x01, 0xC0,
  0xF0, 0x1E, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0x83, 0x0E, 0x07, 0x1C, 0x0E,
  0x70, 0x1D, 0xC0, 0x1B, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x07, 0xC3, 0xF0, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0xE0, 0x3F, 0x0F, 0x80, 0xE7, 0x39, 0xC6, 0x31, 0x8E,
  0x73, 0x8C, 0x63, 0x1C, 0xE7, 0x38, 0xC6, 0x07, 0xE0, 0xF8, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC1,
  0xF8, 0x3F, 0x00, 0x03, 0x00, 0x3C, 0x01, 0xE0, 0x1B, 0x80, 0xCC, 0x0C,
  0x60, 0x61, 0x87, 0x0C, 0x30, 0x73, 0x81, 0x98, 0x0F, 0xC0, 0x30, 0xFF,
  0xFF, 0xF8, 0xE7, 0x1C, 0x61, 0x80, 0x07, 0x8C, 0x3F, 0x71, 0xFF, 0xCF,
  0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x98, 0x0E, 0xE0, 0x73, 0x81, 0xCE,
  0x07, 0x38, 0x3C, 0x71, 0xF1, 0xFD, 0x83, 0xE6, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0x83, 0x7E, 0x3F, 0xF9,
  0xE1, 0xCE, 0x06, 0x70, 0x37, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x77, 0x83, 0xBE, 0x39, 0xBF, 0xCC, 0xF8, 0x00, 0x03, 0xC0, 0xFF, 0x1F,
  0xE3, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0xC7, 0xFC, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0xE7, 0x07, 0xEE, 0x1F, 0xFC,
  0x70, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xC1, 0xE1, 0xC7, 0xC3, 0xFB, 0x03, 0xE6, 0x00, 0x03,
  0xC0, 0xFE, 0x1E, 0xF3, 0x87, 0x78, 0x77, 0x07, 0x73, 0xEF, 0xFC, 0xFE,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x47, 0xFC, 0x1F, 0xC0, 0x00, 0x1C,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x7E, 0x03,
  0xFC, 0x0F, 0xF8, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0x8C, 0x3F, 0x71, 0xFF, 0xCF, 0x0E, 0x78, 0x39, 0xC0, 0xE7,
  0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0x71, 0xF1,
  0xFD, 0x83, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x08, 0x3C, 0x3F, 0xE0,
  0xFF, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x73, 0x83, 0x7F, 0x3F, 0xF9, 0xF1, 0xCF, 0x0E, 0x70, 0x77, 0x83, 0xB8,
  0x1D, 0xC0, 0xEE, 0x06, 0x60, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0E,
  0x00, 0x0C, 0x3C, 0x30, 0x00, 0x03, 0x86, 0x1C, 0x38, 0x70, 0xE3, 0x87,
  0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x00, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0xF8, 0x1E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC1, 0xCE, 0x0E, 0x38, 0x70, 0xE3,
  0x83, 0x9C, 0x0C, 0xE0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1C, 0xE0, 0x63,
  0x83, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xE0, 0x0E, 0x1C, 0x30, 0xE1,
  0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC3,
  0x87, 0x0E, 0x00, 0x18, 0xE0, 0xF0, 0xDF, 0x8F, 0xCF, 0xFE, 0xFE, 0x78,
  0x7C, 0x73, 0xC3, 0xC1, 0x9C, 0x1C, 0x1D, 0xE0, 0xE0, 0xEE, 0x06, 0x07,
  0x70, 0x70, 0x3B, 0x83, 0x81, 0x98, 0x1C, 0x1D, 0xC0, 0xE0, 0xEE, 0x06,
  0x07, 0x70, 0x70, 0x3B, 0x83, 0x83, 0x80, 0x18, 0xF1, 0xDF, 0xCF, 0xFE,
  0x7C, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C,
  0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x80, 0x03, 0xC0, 0x7F, 0x07,
  0xFC, 0x70, 0x77, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1D, 0xC0, 0xE7, 0x1E, 0x1F, 0xE0, 0x7E, 0x00, 0x06, 0x38, 0x0D,
  0xF8, 0x3F, 0xF8, 0x78, 0x70, 0xE0, 0x61, 0xC0, 0xC7, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x71, 0xE0, 0xE3, 0xE3, 0x87, 0xFF, 0x0E,
  0xF8, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x07, 0x8C, 0x3F, 0x71, 0xFF, 0xCF, 0x0E, 0x78, 0x39, 0xC0, 0xE7,
  0x03, 0x98, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0x71, 0xF1,
  0xFD, 0x83, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x18, 0xE3, 0x7C, 0xFF, 0x1F, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0xC3, 0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x70, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xEC, 0x3D, 0xFF, 0x3F, 0xC0, 0x0C, 0x06, 0x07, 0x07,
  0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x80, 0xE0, 0x7E, 0x3F, 0x00, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x38, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC6, 0x07,
  0x38, 0x3C, 0x71, 0xF1, 0xFD, 0x83, 0xE6, 0x00, 0xE0, 0x3F, 0x01, 0xD8,
  0x1C, 0xC0, 0xE7, 0x0E, 0x38, 0x71, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x98,
  0x0D, 0xC0, 0x6C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xC0, 0xE0, 0xF8,
  0x3C, 0x1F, 0x07, 0x87, 0x61, 0xF0, 0xEC, 0x36, 0x39, 0x8E, 0xC7, 0x31,
  0x98, 0xC6, 0x73, 0x38, 0xCC, 0x66, 0x19, 0x8D, 0xC3, 0x61, 0xB8, 0x6C,
  0x36, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x00, 0x1C, 0x0E, 0x18,
  0x38, 0x38, 0xF0, 0x71, 0xC0, 0x77, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0xE7, 0x03, 0x86, 0x0E, 0x0E, 0x3C,
  0x1E, 0x00, 0x1C, 0x07, 0x1C, 0x07, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x70, 0x06, 0x60, 0x06, 0xE0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xE0, 0x7C, 0x0E, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x81, 0xF0, 0x70, 0x0F,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x3C,
  0x07, 0x07, 0xC3, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x3E, 0x0F, 0x00, 0xFE, 0x1F, 0xFF, 0xE0, 0xFC,
};

const GFXglyph NotoSans_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 11, 3, -19 },
  { 28, 17, 19, 17, 1, -19 },
  { 69, 13, 23, 15, 1, -21 },
  { 107, 19, 20, 22, 2, -20 },
  { 155, 17, 20, 18, 1, -20 },
  { 198, 4, 7, 6, 3, -19 },
  { 202, 9, 23, 8, 1, -19 },
  { 228, 9, 23, 8, -2, -19 },
  { 254, 12, 13, 15, 3, -21 },
  { 274, 13, 13, 15, 2, -16 },
  { 296, 6, 6, 7, -1, -3 },
  { 301, 7, 2, 9, 1, -8 },
  { 303, 4, 4, 7, 0, -4 },
  { 305, 13, 19, 10, -1, -19 },
  { 336, 13, 20, 15, 1, -20 },
  { 369, 9, 19, 15, 3, -19 },
  { 391, 14, 20, 15, 0, -20 },
  { 426, 14, 20, 15, 0, -20 },
  { 461, 14, 19, 15, 0, -19 },
  { 495, 14, 19, 15, 1, -19 },
  { 529, 13, 20, 15, 2, -20 },
  { 562, 13, 19, 15, 2, -19 },
  { 593, 14, 20, 15, 1, -20 },
  { 628, 13, 20, 15, 1, -20 },
  { 661, 6, 15, 7, 0, -15 },
  { 673, 7, 18, 7, -1, -15 },
  { 689, 13, 14, 15, 2, -17 },
  { 712, 12, 7, 15, 2, -13 },
  { 723, 13, 14, 15, 2, -17 },
  { 746, 11, 20, 12, 2, -20 },
  { 774, 21, 21, 23, 1, -19 },
  { 830, 16, 19, 16, -2, -19 },
  { 868, 15, 19, 16, 1, -19 },
  { 904, 15, 20, 16, 2, -20 },
  { 942, 16, 19, 18, 1, -19 },
  { 980, 14, 19, 14, 1, -19 },
  { 1014, 14, 19, 13, 1, -19 },
  { 1048, 16, 20, 18, 2, -20 },
  { 1088, 18, 19, 19, 1, -19 },
  { 1131, 12, 19, 9, -1, -19 },
  { 1160, 12, 24, 8, -4, -19 },
  { 1196, 17, 19, 16, 1, -19 },
  { 1237, 11, 19, 13, 1, -19 },
  { 1264, 22, 19, 23, 1, -19 },
  { 1317, 19, 19, 20, 1, -19 },
  { 1363, 17, 20, 20, 2, -20 },
  { 1406, 15, 19, 16, 1, -19 },
  { 1442, 17, 25, 20, 2, -20 },
  { 1496, 15, 19, 16, 1, -19 },
  { 1532, 13, 20, 14, 1, -20 },
  { 1565, 14, 19, 14, 2, -19 },
  { 1599, 17, 19, 18, 2, -19 },
  { 1640, 16, 19, 15, 2, -19 },
  { 1678, 23, 19, 23, 3, -19 },
  { 1733, 18, 19, 15, -1, -19 },
  { 1776, 15, 19, 14, 2, -19 },
  { 1812, 16, 19, 14, 0, -19 },
  { 1850, 10, 23, 8, 0, -19 },
  { 1879, 5, 19, 10, 3, -19 },
  { 1891, 11, 23, 8, -2, -19 },
  { 1923, 13, 12, 15, 1, -19 },
  { 1943, 11, 2, 11, -2, 2 },
  { 1946, 5, 5, 8, 4, -21 },
  { 1950, 14, 15, 16, 1, -15 },
  { 1977, 13, 21, 16, 1, -21 },
  { 2012, 12, 15, 12, 1, -15 },
  { 2035, 15, 21, 16, 1, -21 },
  { 2075, 12, 15, 14, 1, -15 },
  { 2098, 15, 27, 9, -3, -21 },
  { 2149, 14, 21, 16, 1, -15 },
  { 2186, 13, 21, 16, 1, -21 },
  { 2221, 7, 20, 7, 1, -20 },
  { 2239, 11, 26, 7, -3, -20 },
  { 2275, 14, 21, 14, 1, -21 },
  { 2312, 7, 21, 7, 1, -21 },
  { 2331, 21, 15, 24, 1, -15 },
  { 2371, 13, 15, 16, 1, -15 },
  { 2396, 13, 15, 15, 1, -15 },
  { 2421, 15, 21, 16, -1, -15 },
  { 2461, 14, 21, 16, 1, -15 },
  { 2498, 11, 15, 11, 1, -15 },
  { 2519, 11, 15, 12, 0, -15 },
  { 2540, 9, 18, 10, 1, -18 },
  { 2561, 14, 15, 16, 1, -15 },
  { 2588, 13, 15, 13, 1, -15 },
  { 2613, 19, 15, 20, 2, -15 },
  { 2649, 15, 15, 13, -1, -15 },
  { 2678, 16, 21, 13, -2, -15 },
  { 2720, 12, 15, 12, 0, -15 },
  { 2743, 11, 23, 10, 0, -19 },
  { 2775, 2, 27, 15, 7, -21 },
  { 2782, 10, 23, 10, -1, -19 },
  { 2811, 13, 3, 15, 2, -11 },
};

const GFXfont NotoSans_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_MEDIUMITALIC27PT7B_H_
