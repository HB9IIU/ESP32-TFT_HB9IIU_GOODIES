#ifndef _NOTOSANS_MEDIUMITALIC67PT7B_H_
#define _NOTOSANS_MEDIUMITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F,
  0xC1, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xFC, 0x01, 0xFE, 0x3E, 0x0F, 0x00, 0xFF,
  0x0F, 0x80, 0x80, 0x3F, 0x83, 0xC0, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x0F, 0xE1, 0xE0, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x00, 0xFF, 0x3E, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0x03, 0xE3, 0xFC, 0x00,
  0x00, 0xF0, 0x7F, 0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0x1F, 0x07, 0xF0,
  0x00, 0x07, 0xC1, 0xFC, 0x00, 0x01, 0xE0, 0x7F, 0x00, 0x00, 0x78, 0x3F,
  0x82, 0x00, 0x1E, 0x0F, 0xE0, 0xF0, 0x0F, 0x87, 0xF8, 0x3F, 0x83, 0xE7,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0xC3, 0xFE,
  0x1F, 0x80, 0xFC, 0x3F, 0x1F, 0xFE, 0x3F, 0x01, 0xF8, 0xFC, 0x7F, 0xFE,
  0x7E, 0x07, 0xE3, 0xF9, 0xFF, 0xFE, 0xFE, 0x1F, 0x87, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0x8F, 0xE1, 0xF9, 0xFF, 0xFC, 0x7E, 0x3F, 0x81, 0xF9,
  0xFF, 0xF0, 0xFC, 0x7E, 0x03, 0xF3, 0xFF, 0xC3, 0xF1, 0xFC, 0x07, 0xE1,
  0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x20, 0x3F, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x01,
  0xFC, 0x1F, 0xF3, 0xFC, 0x00, 0xFE, 0x0F, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xF8, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0x03, 0xFC,
  0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0xBF, 0x83, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC,
  0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x30, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x03,
  0xFF, 0x0F, 0x00, 0x07, 0xFF, 0x9E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xF8, 0x03, 0xFF, 0x80, 0x70, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x60, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x0E, 0x0F, 0xE7, 0xF9, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFB, 0xFE, 0x7F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF,
  0xCF, 0xFC, 0xFE, 0x3F, 0xE3, 0xF8, 0x7E, 0x0F, 0xE0, 0xF0, 0x3F, 0x83,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3E, 0x00,
  0x1F, 0xE0, 0x01, 0xC0, 0x01, 0xFE, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x01, 0xF8, 0x01, 0xFF,
  0x00, 0x78, 0x00, 0x3F, 0xC0, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0x03, 0xFC, 0x30, 0x00, 0x01, 0xFE,
  0x0F, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x84, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x82, 0x00, 0x00, 0x1F,
  0xE0, 0xC0, 0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x7C, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0xE0, 0x03, 0xF8, 0xFF, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0x01, 0xFC,
  0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0x0F,
  0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xCF, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0xC0,
  0x01, 0xFF, 0x1F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x1F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0xFE, 0x03, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xF9, 0xFC, 0x00, 0xFF,
  0xE1, 0xFC, 0x00, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x80, 0x03,
  0xFF, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xBF, 0xF8, 0x7C, 0x01, 0xFF, 0x18, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x7E, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0x87, 0xE0, 0x0F, 0xF0, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xFE, 0x00, 0xF8,
  0x03, 0xF3, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xCF, 0xC0, 0x3F,
  0x00, 0x1F, 0x00, 0x3E, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF3, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x9F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE7, 0xC0, 0x7E, 0x00, 0x3F, 0x00,
  0x3E, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0x9F, 0x80, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x1F, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0x7B, 0xE0, 0xFE, 0x07,
  0xE0, 0x3F, 0xFF, 0xDF, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xFC, 0xFF, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x00, 0x60,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x20,
  0x03, 0xFF, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC,
  0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x10, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x9F,
  0xF0, 0x00, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFD, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x03, 0xFB, 0xE0, 0x00, 0x07,
  0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x7F,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF3, 0xF8,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x7E,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xF9, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xE7, 0xF0,
  0x00, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x01,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x00,
  0x03, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x80, 0x00, 0x0F, 0xF0, 0x30, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7E, 0x3E, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE,
  0x00, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x9F,
  0xC0, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x40, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xF0, 0x03, 0xFF,
  0xF0, 0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xDF, 0xC0, 0x7F,
  0xFF, 0xF7, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0x8F, 0xEF, 0xC0, 0x3F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xF9,
  0xFC, 0x01, 0xFF, 0xFC, 0x7E, 0x00, 0x3F, 0xFE, 0x1F, 0x80, 0x07, 0xFE,
  0x07, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x07,
  0xF0, 0x7F, 0xE0, 0x01, 0xFC, 0x7F, 0xFC, 0x00, 0x7F, 0x3F, 0xFF, 0x80,
  0x1F, 0x9F, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFC, 0x07, 0xEF,
  0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0xFF, 0x00, 0xFC, 0x7F, 0xFF, 0x80, 0x3F,
  0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0x0F, 0x80, 0xFF, 0x80, 0x04, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x81, 0xFF, 0x00, 0x18, 0x07, 0xFE, 0x07, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xC0, 0x7F, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0xFF, 0x1F,
  0xC0, 0x03, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xF0, 0x03, 0xFF,
  0xFF, 0xBF, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0xFD, 0xF8, 0x00, 0xFF, 0xFF, 0xCF, 0xC0, 0x07, 0xFF, 0xFC, 0x7C, 0x00,
  0x1F, 0xFF, 0xC7, 0xE0, 0x00, 0x7F, 0xFC, 0x3F, 0x00, 0x01, 0xFF, 0x81,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x00,
  0xFF, 0x0F, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3,
  0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x02, 0x07,
  0xFC, 0x00, 0x38, 0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x78, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x7C, 0x00, 0x7F, 0xFE, 0x1F, 0x80, 0x1F, 0xFF, 0xE3, 0xF0, 0x07, 0xFF,
  0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x9F,
  0xC0, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x60,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x08, 0x00, 0x03, 0xF8, 0x01, 0x80, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x3E, 0x00,
  0x07, 0xF0, 0x7F, 0xF0, 0x01, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0x3F, 0xFF,
  0xC0, 0x1F, 0x9F, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF1, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x7E, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFE, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x87, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7E,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x0F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xF3, 0xF0,
  0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0xDF, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFF, 0xC0, 0x03, 0xF0, 0xFF,
  0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xFC, 0x03, 0xFB,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x07, 0xFE, 0x00,
  0x01, 0xF8, 0x7F, 0xFC, 0x00, 0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x1F, 0x9F,
  0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0xFF, 0x80,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xEF,
  0xFF, 0xFE, 0x00, 0x3F, 0x9F, 0xFF, 0xF0, 0x00, 0xFE, 0x3F, 0xFF, 0x80,
  0x03, 0xF8, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xF0, 0x03,
  0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xCF, 0xC0,
  0x7F, 0xFF, 0xF7, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF,
  0xF9, 0xF8, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xFE, 0x3F, 0x80, 0x07,
  0xFE, 0x0F, 0xE0, 0x00, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xFC, 0x07, 0xE1, 0xFF, 0x80, 0xFC,
  0x7F, 0xF0, 0x1F, 0x9F, 0xFC, 0x07, 0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xE0, 0x7F, 0x80, 0x06, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x88, 0x00,
  0x07, 0xF8, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F,
  0xF8, 0x7F, 0x7E, 0x03, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xFF, 0xC7, 0xE0,
  0x1F, 0xFF, 0xE1, 0xF0, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xC0, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xBF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xE3,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7C, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x7E, 0x7C, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x3E, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x1F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x8F, 0x80, 0xFE,
  0x01, 0xF8, 0x1F, 0x87, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xC3, 0xE0, 0x7F,
  0x00, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0xF8, 0x3F,
  0x80, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF8, 0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0xFD,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0x3F, 0xFF, 0x80, 0x03, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_MediumItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 18, 49, 18, 1, -48 },
  { 112, 22, 17, 27, 7, -48 },
  { 159, 42, 48, 43, 2, -48 },
  { 411, 34, 55, 37, 2, -51 },
  { 645, 47, 50, 55, 5, -49 },
  { 939, 42, 50, 46, 2, -49 },
  { 1202, 10, 17, 15, 7, -48 },
  { 1224, 22, 59, 20, 3, -48 },
  { 1387, 23, 59, 20, -5, -48 },
  { 1557, 31, 31, 37, 7, -51 },
  { 1678, 32, 33, 38, 4, -40 },
  { 1810, 14, 17, 18, -3, -8 },
  { 1840, 17, 6, 21, 2, -21 },
  { 1853, 10, 10, 18, 1, -9 },
  { 1866, 34, 48, 25, -3, -48 },
  { 2070, 33, 50, 37, 3, -49 },
  { 2277, 22, 48, 37, 9, -48 },
  { 2409, 36, 49, 37, 0, -49 },
  { 2630, 34, 50, 37, 1, -49 },
  { 2843, 36, 48, 37, 0, -48 },
  { 3059, 34, 49, 37, 2, -48 },
  { 3268, 33, 50, 37, 4, -49 },
  { 3475, 33, 48, 37, 5, -48 },
  { 3673, 34, 50, 37, 3, -49 },
  { 3886, 32, 50, 37, 3, -49 },
  { 4086, 15, 38, 18, 1, -37 },
  { 4158, 19, 46, 18, -3, -37 },
  { 4268, 32, 34, 38, 4, -41 },
  { 4404, 31, 19, 38, 5, -33 },
  { 4478, 32, 34, 38, 4, -41 },
  { 4614, 26, 50, 29, 5, -49 },
  { 4777, 53, 54, 57, 3, -48 },
  { 5135, 39, 48, 39, -4, -48 },
  { 5369, 38, 48, 41, 2, -48 },
  { 5597, 38, 50, 40, 5, -49 },
  { 5835, 41, 48, 45, 2, -48 },
  { 6081, 36, 48, 35, 2, -48 },
  { 6297, 36, 48, 33, 2, -48 },
  { 6513, 40, 50, 46, 5, -49 },
  { 6763, 44, 48, 46, 2, -48 },
  { 7027, 29, 48, 23, -2, -48 },
  { 7201, 31, 61, 20, -11, -48 },
  { 7438, 43, 48, 39, 2, -48 },
  { 7696, 27, 48, 33, 2, -48 },
  { 7858, 55, 48, 57, 2, -48 },
  { 8188, 47, 48, 48, 2, -48 },
  { 8470, 41, 50, 49, 5, -49 },
  { 8727, 37, 48, 39, 2, -48 },
  { 8949, 41, 60, 49, 5, -49 },
  { 9257, 37, 48, 39, 2, -48 },
  { 9479, 34, 50, 34, 1, -49 },
  { 9692, 34, 48, 34, 6, -48 },
  { 9896, 41, 49, 46, 5, -48 },
  { 10148, 38, 48, 38, 6, -48 },
  { 10376, 57, 48, 58, 7, -48 },
  { 10718, 46, 48, 37, -4, -48 },
  { 10994, 35, 48, 35, 6, -48 },
  { 11204, 40, 48, 36, -1, -48 },
  { 11444, 26, 59, 20, -1, -48 },
  { 11636, 14, 48, 25, 7, -48 },
  { 11720, 26, 59, 20, -5, -48 },
  { 11912, 34, 30, 38, 2, -48 },
  { 12040, 28, 5, 27, -6, 6 },
  { 12058, 12, 10, 20, 10, -51 },
  { 12073, 34, 38, 39, 3, -37 },
  { 12235, 34, 52, 39, 2, -51 },
  { 12456, 29, 38, 31, 3, -37 },
  { 12594, 37, 52, 39, 3, -51 },
  { 12835, 30, 38, 35, 3, -37 },
  { 12978, 37, 67, 22, -7, -51 },
  { 13288, 35, 53, 39, 2, -37 },
  { 13520, 34, 51, 39, 2, -51 },
  { 13737, 17, 50, 18, 2, -50 },
  { 13844, 28, 66, 18, -9, -50 },
  { 14075, 35, 51, 35, 2, -51 },
  { 14299, 18, 51, 18, 2, -51 },
  { 14414, 54, 37, 59, 2, -37 },
  { 14664, 35, 37, 39, 1, -37 },
  { 14826, 32, 38, 38, 3, -37 },
  { 14978, 38, 53, 39, -2, -37 },
  { 15230, 34, 53, 39, 3, -37 },
  { 15456, 27, 37, 27, 2, -37 },
  { 15581, 28, 38, 30, 0, -37 },
  { 15714, 23, 45, 24, 3, -44 },
  { 15844, 34, 37, 39, 4, -36 },
  { 16002, 33, 36, 32, 3, -36 },
  { 16151, 49, 36, 50, 4, -36 },
  { 16372, 39, 36, 33, -3, -36 },
  { 16548, 42, 52, 32, -6, -36 },
  { 16821, 31, 36, 30, -1, -36 },
  { 16961, 26, 59, 24, 1, -48 },
  { 17153, 5, 67, 37, 17, -51 },
  { 17195, 26, 59, 24, -3, -48 },
  { 17387, 32, 9, 38, 4, -28 },
};

const GFXfont NotoSans_MediumItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_MEDIUMITALIC67PT7B_H_
