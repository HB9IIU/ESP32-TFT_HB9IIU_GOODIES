#ifndef _NOTOSANS_MEDIUMITALIC34PT7B_H_
#define _NOTOSANS_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x71, 0xEE, 0x3B, 0xCF, 0x71, 0xCE, 0x39, 0xC7,
  0x38, 0xE6, 0x18, 0xC3, 0x00, 0x00, 0x70, 0xE0, 0x03, 0x06, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x07,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0E,
  0x00, 0x70, 0x60, 0x03, 0x87, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0x70, 0xE0, 0x03, 0x07, 0x00, 0x38, 0x30, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0x60, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7D, 0xCC, 0x3C,
  0xC0, 0x1C, 0x60, 0x0E, 0x30, 0x07, 0xB8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0x9E, 0x00, 0xC7, 0x00, 0x63,
  0x80, 0x33, 0xC8, 0x39, 0xE7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x02, 0x0F,
  0xC0, 0x1C, 0x1F, 0xE0, 0x1C, 0x3C, 0xE0, 0x38, 0x38, 0xE0, 0x70, 0x70,
  0xE0, 0xE0, 0x70, 0xE0, 0xE0, 0x70, 0xE1, 0xC0, 0x70, 0xE3, 0x80, 0x60,
  0xE7, 0x00, 0xE1, 0xC7, 0x3C, 0x61, 0xCE, 0xFE, 0x73, 0x9C, 0xFF, 0x7F,
  0xB9, 0xC7, 0x3F, 0x39, 0xC7, 0x18, 0x73, 0x87, 0x00, 0xE3, 0x87, 0x01,
  0xC3, 0x87, 0x01, 0xC3, 0x87, 0x03, 0x87, 0x07, 0x07, 0x07, 0x0E, 0x0F,
  0x03, 0x8E, 0x0E, 0x03, 0x9C, 0x1C, 0x03, 0xFC, 0x38, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x78,
  0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x3D,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x1C,
  0xFB, 0xC1, 0xEF, 0x0F, 0x0E, 0x70, 0x3C, 0xF7, 0x81, 0xFF, 0x3C, 0x07,
  0xF1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0x3C, 0x1F, 0xE1, 0xF0, 0x77, 0xFE, 0xEE, 0xEC, 0xC0, 0x00, 0xF0,
  0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x40, 0xC0, 0x70, 0xC0,
  0x7D, 0xC0, 0xFF, 0xC1, 0x0F, 0xFF, 0x03, 0xFF, 0x07, 0xC3, 0x0E, 0xC0,
  0x1C, 0xE0, 0x7C, 0xE0, 0x38, 0x70, 0x10, 0x78, 0x00, 0x60, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38,
  0x70, 0xF0, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xBE, 0x1E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0x78, 0x07, 0x78, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xC0, 0x01, 0xF0, 0x3E, 0x0F, 0xE3, 0xFE, 0xFD, 0xE7,
  0x9C, 0x61, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x07, 0x03, 0xC1, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x00, 0x70, 0x03, 0xFF, 0x07, 0xFF, 0xC1, 0xF3, 0xF0, 0xC0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE4, 0x01, 0xE3,
  0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x0F, 0x78, 0x07,
  0x9C, 0x01, 0xC7, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x0E,
  0x0F, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xCC, 0x07, 0xC7, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFE,
  0x20, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0xFE, 0x0E, 0xFF, 0x87, 0xF7, 0xE7, 0xE0, 0xF3, 0xE0, 0x79,
  0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0x3E, 0x0F, 0x07,
  0x83, 0x80, 0xF0, 0xE0, 0x38, 0x38, 0x0E, 0x0F, 0x07, 0x83, 0xC3, 0xC0,
  0x7B, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xE3, 0xC1, 0xF0,
  0x78, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E,
  0x1E, 0x07, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xC0,
  0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0x3E, 0x3C, 0x1E, 0x38, 0x0F, 0x78, 0x0F,
  0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x78, 0x3E,
  0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0x9E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00,
  0x0C, 0x3C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF1, 0xE3, 0xC0, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x07, 0x01, 0xFF, 0x3F, 0xFC, 0xFB, 0xE4, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0x83, 0xE0, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xE3, 0xC0, 0x30, 0x1C, 0xE0, 0xFF, 0xC7, 0x70, 0x7F, 0xE1,
  0xDC, 0x3C, 0x38, 0x7E, 0x1E, 0x0E, 0x1F, 0x87, 0x03, 0x87, 0xE1, 0xC1,
  0xC1, 0xF8, 0xE0, 0x70, 0x7E, 0x38, 0x1C, 0x1B, 0x8E, 0x0F, 0x0E, 0xE3,
  0x83, 0x83, 0xB8, 0xF1, 0xF1, 0xCE, 0x1F, 0xDF, 0xE3, 0x83, 0xE3, 0xF0,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x80, 0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xDC, 0x00, 0x3D, 0xC0,
  0x03, 0x9C, 0x00, 0x79, 0xC0, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x1C,
  0x01, 0xE1, 0xC0, 0x1C, 0x1E, 0x03, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE3, 0xC0,
  0x0E, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0x81, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x0E, 0x03, 0xC3, 0xC0, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x81,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0x41, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x20, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0E, 0x07, 0xC0, 0xF0, 0x1F,
  0x07, 0x80, 0x78, 0x3C, 0x01, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x01, 0xE1, 0xC0, 0x1F, 0x1E, 0x01,
  0xF0, 0xF0, 0x1F, 0x07, 0x83, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFC, 0x03, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xFE,
  0x78, 0x0F, 0xF3, 0xC0, 0x7F, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80,
  0x0E, 0x3E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x1F, 0x01, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0x80, 0x1C, 0x1E,
  0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x00,
  0xE0, 0xF0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1C,
  0x1E, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x3C,
  0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x7C, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x01, 0xC0, 0xF0, 0x0F, 0x07, 0x80,
  0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x7B,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF9, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x07,
  0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0x07, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E,
  0x0E, 0xE0, 0x0E, 0xE0, 0xEE, 0x00, 0xEE, 0x0E, 0xE0, 0x1D, 0xE0, 0xEE,
  0x01, 0xDE, 0x1E, 0xE0, 0x39, 0xC1, 0xEE, 0x03, 0x9C, 0x1C, 0xE0, 0x73,
  0xC1, 0xC7, 0x0F, 0x3C, 0x1C, 0x70, 0xE3, 0x83, 0xC7, 0x1E, 0x38, 0x3C,
  0x71, 0xC3, 0x83, 0x87, 0x3C, 0x78, 0x38, 0x73, 0x87, 0x83, 0x87, 0x70,
  0x70, 0x78, 0x77, 0x07, 0x07, 0x87, 0xE0, 0xF0, 0x70, 0x3E, 0x0F, 0x07,
  0x03, 0xC0, 0xF0, 0x70, 0x3C, 0x0E, 0x0F, 0x03, 0x81, 0xE0, 0x07, 0xC0,
  0x0F, 0x07, 0xC0, 0x0E, 0x07, 0xC0, 0x0E, 0x07, 0xE0, 0x1E, 0x0E, 0xE0,
  0x1E, 0x0E, 0xE0, 0x1E, 0x0E, 0xF0, 0x1C, 0x0E, 0x70, 0x1C, 0x1E, 0x78,
  0x3C, 0x1E, 0x78, 0x3C, 0x1C, 0x38, 0x38, 0x1C, 0x3C, 0x38, 0x1C, 0x3C,
  0x38, 0x3C, 0x1C, 0x78, 0x3C, 0x1E, 0x78, 0x38, 0x0E, 0x70, 0x38, 0x0E,
  0x70, 0x38, 0x0F, 0x70, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x70, 0x07,
  0xE0, 0x70, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0xF0,
  0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x39, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xC7,
  0x00, 0x1F, 0x1E, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0xF8, 0x3F, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0x81, 0xE0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x70, 0x0F, 0x0E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x0F, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0x80, 0xF0, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x39, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0x70, 0x00, 0x3B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x7C,
  0x03, 0xE0, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0x81, 0xE0, 0xF0, 0x1C, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x70,
  0x0E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x3E, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x07, 0x03,
  0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xE0, 0x1E, 0x1C, 0x03,
  0xC7, 0x80, 0x3C, 0x00, 0x38, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1,
  0xF0, 0x10, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC4,
  0x03, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x78, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x38,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03,
  0xC7, 0x00, 0x78, 0xE0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0xF0, 0x70, 0x1E,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x71, 0xE0,
  0x0E, 0x3C, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x70, 0x07, 0x80, 0x7D, 0xC0, 0x3E, 0x01, 0xE7, 0x00, 0xF8, 0x07, 0x1C,
  0x07, 0xE0, 0x3C, 0x70, 0x1F, 0x80, 0xE1, 0xC0, 0x7E, 0x07, 0x87, 0x03,
  0xB8, 0x1C, 0x1C, 0x0E, 0xE0, 0xF0, 0x70, 0x73, 0x83, 0xC1, 0xC1, 0xCE,
  0x0E, 0x07, 0x0E, 0x38, 0x78, 0x1C, 0x38, 0xE1, 0xC0, 0x71, 0xE3, 0x8F,
  0x01, 0xC7, 0x0E, 0x38, 0x07, 0x3C, 0x39, 0xE0, 0x1C, 0xE0, 0xE7, 0x00,
  0x73, 0x83, 0x9C, 0x01, 0xDC, 0x0E, 0xF0, 0x07, 0x70, 0x3B, 0x80, 0x1F,
  0x80, 0x6E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78,
  0x07, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B,
  0x80, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x00, 0x0F, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1C, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0,
  0x7C, 0x00, 0xF0, 0xF0, 0x07, 0xDC, 0x01, 0xE7, 0x00, 0xF1, 0xE0, 0x78,
  0x78, 0x1E, 0x0E, 0x0F, 0x03, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x07,
  0x38, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x08, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x03, 0xF8, 0x1F, 0xC1, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xE1, 0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x03, 0xF8, 0x3F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x37, 0x00, 0x39, 0xC0, 0x18, 0xE0,
  0x1C, 0x38, 0x0C, 0x1C, 0x0E, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x3B, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xC7, 0x8E,
  0x1C, 0x01, 0x80, 0x03, 0xF9, 0xC7, 0xFD, 0xE3, 0xE7, 0xE3, 0xC1, 0xF3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x07, 0x38, 0x07,
  0x9C, 0x03, 0xCE, 0x03, 0xC7, 0x01, 0xE3, 0x81, 0xF1, 0xE1, 0xF8, 0xFF,
  0xDC, 0x3F, 0xDC, 0x0F, 0xCE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x10, 0x0E,
  0x7E, 0x0F, 0x7F, 0x87, 0xF3, 0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x1C,
  0xF0, 0x0E, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xF0, 0xF9, 0xFF, 0xF8, 0xEF, 0xF8, 0x71,
  0xF8, 0x00, 0x01, 0xE0, 0x1F, 0xF1, 0xFF, 0xC7, 0xC6, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x08, 0x7F, 0xE1, 0xFF, 0x81, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x3C, 0x07, 0xF7, 0x83, 0xFE, 0xF0,
  0xFC, 0xFC, 0x1E, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x1E, 0x0E,
  0x03, 0xC1, 0xC0, 0xF8, 0x3C, 0x3F, 0x07, 0xFE, 0xE0, 0x7F, 0xB8, 0x07,
  0xE7, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xE3, 0xC1, 0xEF,
  0x03, 0xDC, 0x07, 0x78, 0x3E, 0xF7, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x08, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xFE, 0x70, 0xFF, 0xBC, 0x7E, 0x7E, 0x1E, 0x0F, 0x8F, 0x01,
  0xE3, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0xF1,
  0xC0, 0x3C, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x03, 0xE1, 0xE1, 0xF8, 0x7F,
  0xFE, 0x0F, 0xF7, 0x01, 0xF1, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x82, 0x03, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x38, 0x0E, 0x7F, 0x0F, 0x7F, 0xC7, 0x73, 0xE3,
  0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x1C, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x71, 0xC0,
  0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x07, 0x03, 0xC1, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x01, 0x0E, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0,
  0x70, 0xF0, 0x1C, 0x78, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xEF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x07, 0xDE, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x1E,
  0x07, 0x07, 0x83, 0xC0, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x80, 0x07, 0x83,
  0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1,
  0xE0, 0xF0, 0x78, 0x00, 0x00, 0x18, 0x07, 0x01, 0xCF, 0xC3, 0xF8, 0x73,
  0xFC, 0xFF, 0x8E, 0xE7, 0xB9, 0xF1, 0xF0, 0x7E, 0x1E, 0x3C, 0x0F, 0x81,
  0xC7, 0x81, 0xE0, 0x39, 0xE0, 0x3C, 0x0F, 0x3C, 0x07, 0x01, 0xE7, 0x81,
  0xE0, 0x3C, 0xE0, 0x3C, 0x07, 0x3C, 0x07, 0x81, 0xE7, 0x80, 0xE0, 0x3C,
  0xF0, 0x1C, 0x07, 0x9C, 0x07, 0x80, 0xE3, 0x80, 0xF0, 0x1C, 0xF0, 0x1C,
  0x07, 0x9E, 0x03, 0x80, 0xF3, 0xC0, 0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x0F,
  0x3F, 0x87, 0x3F, 0xE3, 0xB9, 0xF1, 0xF8, 0x78, 0xF8, 0x3C, 0xF8, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8E, 0x01, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xC0, 0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x80, 0x00, 0xC0, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0x3E, 0x3C, 0x1E,
  0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x73, 0xF0, 0x1C, 0xFF, 0x03,
  0xB9, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x38, 0x78, 0x07, 0x0F,
  0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x81, 0xE0, 0xF8, 0x7C, 0x3F, 0xFF, 0x07, 0xBF, 0xC0, 0xF3,
  0xF0, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xF9, 0xC7, 0xFE, 0xE7, 0xE7, 0xE3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x07, 0x38, 0x07, 0x9C, 0x03, 0xCE, 0x03,
  0xC7, 0x01, 0xE3, 0x81, 0xF1, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xDC, 0x0F,
  0xCE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x39, 0xF1, 0xCF,
  0x87, 0x7E, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xF1, 0xFF, 0xC7, 0x87,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xA0, 0x3C, 0xFF, 0xF3, 0xFF,
  0x87, 0xFC, 0x00, 0x06, 0x01, 0xC0, 0x78, 0x0E, 0x0F, 0xFF, 0xFF, 0xCF,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0x8F, 0xF0, 0xFE, 0x00, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1C, 0x70, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF,
  0x03, 0xC7, 0x03, 0xE3, 0xC3, 0xF1, 0xFF, 0xB8, 0x7F, 0xB8, 0x1F, 0x9C,
  0x00, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x38, 0xF0,
  0x78, 0xF0, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x71, 0xE0, 0x71, 0xC0, 0x73,
  0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0xE0, 0x3C, 0x07, 0xF0, 0x3E, 0x07, 0xB8, 0x1F, 0x03, 0x9C, 0x1D,
  0x83, 0xCF, 0x0E, 0xC1, 0xC7, 0x87, 0x61, 0xE3, 0xC7, 0x30, 0xE1, 0xE3,
  0x98, 0xF0, 0xF3, 0x8C, 0x78, 0x79, 0xC6, 0x38, 0x3D, 0xC3, 0xBC, 0x1E,
  0xE1, 0xDC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xB0, 0x37, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xE1, 0xE0, 0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x39, 0xE0, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0xF3, 0x80, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE0, 0xE0,
  0x78, 0x1E, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x38, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x01, 0xC1, 0xE0, 0x0E, 0x0E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0xBC,
  0x00, 0x1D, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x1F,
  0x01, 0xF8, 0x07, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x03,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0xE7, 0xE7, 0xFF,
  0x80, 0xFE,
};

const GFXglyph NotoSans_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 24, 9, 1, -24 },
  { 28, 11, 9, 14, 4, -24 },
  { 41, 21, 24, 22, 1, -24 },
  { 104, 17, 28, 19, 1, -26 },
  { 164, 24, 25, 28, 2, -25 },
  { 239, 21, 25, 23, 1, -25 },
  { 305, 4, 9, 8, 4, -24 },
  { 310, 12, 29, 10, 1, -24 },
  { 354, 12, 29, 10, -3, -24 },
  { 398, 16, 16, 19, 3, -26 },
  { 430, 16, 16, 19, 2, -20 },
  { 462, 8, 8, 9, -2, -4 },
  { 470, 9, 3, 11, 1, -11 },
  { 474, 4, 4, 9, 1, -4 },
  { 476, 18, 24, 13, -2, -24 },
  { 530, 16, 25, 19, 2, -25 },
  { 580, 12, 24, 19, 4, -24 },
  { 616, 18, 25, 19, 0, -25 },
  { 673, 17, 25, 19, 1, -25 },
  { 727, 18, 24, 19, 0, -24 },
  { 781, 17, 24, 19, 1, -24 },
  { 832, 17, 25, 19, 2, -25 },
  { 886, 17, 24, 19, 2, -24 },
  { 937, 18, 25, 19, 1, -25 },
  { 994, 16, 25, 19, 2, -25 },
  { 1044, 7, 19, 9, 1, -19 },
  { 1061, 10, 23, 9, -2, -19 },
  { 1090, 16, 17, 19, 2, -21 },
  { 1124, 16, 10, 19, 2, -17 },
  { 1144, 16, 17, 19, 2, -21 },
  { 1178, 13, 25, 15, 3, -25 },
  { 1219, 26, 27, 29, 2, -24 },
  { 1307, 20, 24, 20, -2, -24 },
  { 1367, 19, 24, 21, 1, -24 },
  { 1424, 20, 25, 20, 2, -25 },
  { 1487, 21, 24, 23, 1, -24 },
  { 1550, 18, 24, 18, 1, -24 },
  { 1604, 18, 24, 17, 1, -24 },
  { 1658, 21, 25, 23, 2, -25 },
  { 1724, 22, 24, 23, 1, -24 },
  { 1790, 15, 24, 12, -1, -24 },
  { 1835, 15, 31, 10, -5, -24 },
  { 1894, 22, 24, 20, 1, -24 },
  { 1960, 14, 24, 17, 1, -24 },
  { 2002, 28, 24, 29, 1, -24 },
  { 2086, 24, 24, 25, 1, -24 },
  { 2158, 22, 25, 25, 2, -25 },
  { 2227, 19, 24, 20, 1, -24 },
  { 2284, 22, 31, 25, 2, -25 },
  { 2370, 19, 24, 20, 1, -24 },
  { 2427, 17, 25, 17, 1, -25 },
  { 2481, 17, 24, 17, 3, -24 },
  { 2532, 21, 24, 23, 3, -24 },
  { 2595, 19, 24, 19, 3, -24 },
  { 2652, 30, 24, 29, 3, -24 },
  { 2742, 23, 24, 19, -2, -24 },
  { 2811, 18, 24, 18, 3, -24 },
  { 2865, 21, 24, 18, -1, -24 },
  { 2928, 13, 29, 10, 0, -24 },
  { 2976, 7, 24, 13, 4, -24 },
  { 2997, 13, 29, 10, -2, -24 },
  { 3045, 17, 15, 19, 1, -24 },
  { 3077, 14, 2, 13, -3, 3 },
  { 3081, 6, 5, 10, 5, -26 },
  { 3085, 17, 19, 20, 2, -19 },
  { 3126, 17, 26, 20, 1, -26 },
  { 3182, 14, 19, 16, 2, -19 },
  { 3216, 19, 26, 20, 2, -26 },
  { 3278, 15, 19, 18, 2, -19 },
  { 3314, 19, 34, 11, -4, -26 },
  { 3395, 18, 27, 20, 1, -19 },
  { 3456, 17, 26, 20, 1, -26 },
  { 3512, 9, 25, 9, 1, -25 },
  { 3541, 14, 33, 9, -4, -25 },
  { 3599, 18, 26, 18, 1, -26 },
  { 3658, 9, 26, 9, 1, -26 },
  { 3688, 27, 19, 30, 1, -19 },
  { 3753, 17, 19, 20, 1, -19 },
  { 3794, 16, 19, 19, 2, -19 },
  { 3832, 19, 27, 20, -1, -19 },
  { 3897, 17, 27, 20, 2, -19 },
  { 3955, 14, 19, 14, 1, -19 },
  { 3989, 14, 19, 15, 0, -19 },
  { 4023, 11, 22, 12, 2, -22 },
  { 4054, 17, 18, 20, 2, -18 },
  { 4093, 16, 18, 16, 2, -18 },
  { 4129, 25, 18, 25, 2, -18 },
  { 4186, 19, 18, 17, -1, -18 },
  { 4229, 21, 26, 16, -3, -18 },
  { 4298, 16, 18, 15, -1, -18 },
  { 4334, 14, 29, 12, 0, -24 },
  { 4385, 3, 34, 19, 8, -26 },
  { 4398, 13, 29, 12, -1, -24 },
  { 4446, 16, 4, 19, 2, -14 },
};

const GFXfont NotoSans_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_MEDIUMITALIC34PT7B_H_
