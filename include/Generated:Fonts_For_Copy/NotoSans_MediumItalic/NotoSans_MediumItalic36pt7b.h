#ifndef _NOTOSANS_MEDIUMITALIC36PT7B_H_
#define _NOTOSANS_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x83, 0xE1, 0xF0, 0xF8, 0x78, 0x10, 0x00, 0x79, 0xEF, 0x3D, 0xC7,
  0xB8, 0xEF, 0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x98, 0x70, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE1, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x07, 0xFE, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0xF3, 0x18, 0x78, 0xC0, 0x1E, 0x70, 0x07, 0x9C, 0x01,
  0xE6, 0x00, 0x7D, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xDF, 0x00, 0x33, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0x8F,
  0x30, 0x67, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x0E, 0x0F, 0xE0,
  0x0E, 0x0F, 0xF8, 0x0F, 0x0F, 0x1C, 0x07, 0x07, 0x0E, 0x07, 0x07, 0x87,
  0x07, 0x83, 0x83, 0x83, 0x81, 0xC1, 0xC3, 0x80, 0xE0, 0xE3, 0x80, 0x70,
  0xE3, 0xC0, 0x38, 0x71, 0xC7, 0x1C, 0x39, 0xCF, 0xEE, 0x39, 0xCF, 0xF7,
  0xFD, 0xEF, 0x3D, 0xFC, 0xE7, 0x0E, 0x78, 0xE7, 0x87, 0x00, 0xE3, 0x83,
  0x80, 0xF1, 0xC1, 0xC0, 0x70, 0xE1, 0xE0, 0x70, 0xF0, 0xE0, 0x70, 0x78,
  0x70, 0x78, 0x3C, 0x78, 0x38, 0x1E, 0x38, 0x38, 0x07, 0xBC, 0x38, 0x03,
  0xFC, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x38, 0x01, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x3E, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x03, 0xC7, 0xDE, 0x0F,
  0x1E, 0x3E, 0x1E, 0x78, 0x3C, 0x78, 0xE0, 0x3C, 0xF3, 0xC0, 0x7F, 0xC7,
  0x80, 0x7F, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1E, 0x07, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFC, 0xF0, 0x3F, 0xE1, 0xF0, 0x7B, 0xDC, 0xEF, 0x73,
  0x9C, 0xE6, 0x00, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x01,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x81, 0xC0, 0xE1, 0xC0, 0xF9,
  0xC0, 0xFF, 0x87, 0x1F, 0xFF, 0x07, 0xFF, 0x0F, 0xC3, 0x1E, 0xC0, 0x3C,
  0xE0, 0x78, 0xE0, 0x78, 0xF0, 0x30, 0x70, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x77,
  0xFF, 0xFF, 0x20, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xF1, 0xF0,
  0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E,
  0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81,
  0xE1, 0xE1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xE0,
  0x7C, 0x1F, 0x8F, 0xF7, 0xFF, 0xFB, 0xBC, 0xF3, 0x1E, 0x43, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x03, 0xE3, 0xF0, 0x70, 0x1E, 0x04, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0,
  0x01, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x3C, 0x1F, 0x04, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x01,
  0xF0, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x20,
  0x07, 0xCC, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7B, 0x80, 0x0E, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0x80, 0x3C, 0xF0, 0x0F,
  0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0,
  0x78, 0x78, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x02, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x20, 0x07, 0xCC, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x9F,
  0xC1, 0xEF, 0xF8, 0x77, 0xFE, 0x3F, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C,
  0x07, 0x87, 0x83, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xC1, 0xE0, 0xF0,
  0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC0, 0xF0,
  0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xCF,
  0x81, 0xE0, 0xF8, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1F, 0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE3,
  0xC0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x81, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xDE, 0x03, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC2, 0x07, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x0E,
  0x1F, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x40, 0x01, 0xC0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xE3, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x40, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE1,
  0xC0, 0x38, 0x0E, 0x38, 0x1F, 0xF8, 0x73, 0x83, 0xFF, 0x87, 0x70, 0x78,
  0x70, 0x77, 0x0F, 0x07, 0x07, 0xE0, 0xE0, 0x70, 0x7E, 0x1C, 0x0F, 0x07,
  0xE1, 0xC0, 0xE0, 0xFE, 0x1C, 0x0E, 0x0E, 0xE1, 0xC1, 0xE0, 0xEE, 0x1C,
  0x1E, 0x1C, 0xE1, 0xC3, 0xE1, 0xCE, 0x1E, 0x7F, 0x78, 0xE1, 0xFE, 0xFF,
  0x0F, 0x0F, 0xC7, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x38, 0x01, 0xE1,
  0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3C, 0x00, 0xE1, 0xE0, 0x07,
  0x1E, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80,
  0x03, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x1F, 0x0E, 0x03, 0xE1, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1E, 0x07, 0xC1, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x1F, 0x87,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xE1, 0xE0, 0xFC, 0x01, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x0C, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0x81, 0xF8, 0x1E, 0x03, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x78,
  0x03, 0xE1, 0xE0, 0x3F, 0x07, 0x87, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFE, 0x3E, 0x07, 0xC0, 0x08, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0xF9, 0xE0, 0x3F, 0xC7, 0x80,
  0xFF, 0x3E, 0x04, 0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xC7, 0x80, 0x0E,
  0x1E, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x83, 0xF0, 0x3E, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0xC0, 0xFF,
  0xC1, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x04, 0x7E, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x3C,
  0x0F, 0x80, 0x78, 0x3E, 0x00, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x87,
  0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xF7, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07,
  0x81, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x70,
  0x07, 0x81, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x77, 0x83, 0xDC, 0x03, 0xDC, 0x0E, 0x70, 0x0E,
  0xF0, 0x39, 0xC0, 0x7B, 0xC0, 0xE7, 0x01, 0xCF, 0x07, 0x9C, 0x0F, 0x38,
  0x1E, 0x70, 0x38, 0xE0, 0x79, 0xC1, 0xC7, 0x81, 0xC7, 0x07, 0x1E, 0x07,
  0x1E, 0x38, 0x78, 0x3C, 0x38, 0xE1, 0xC0, 0xF0, 0xE7, 0x07, 0x03, 0x83,
  0xBC, 0x3C, 0x0E, 0x0E, 0xE0, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xE0, 0xFC,
  0x0E, 0x07, 0x83, 0xF0, 0x78, 0x1C, 0x0F, 0x81, 0xE0, 0x70, 0x3E, 0x07,
  0x83, 0xC0, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0x83, 0xE0, 0x03, 0xC1,
  0xF8, 0x01, 0xE0, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0x70, 0x3F, 0x80, 0x78,
  0x3F, 0xC0, 0x3C, 0x1E, 0xF0, 0x1E, 0x0E, 0x78, 0x0E, 0x07, 0x1C, 0x07,
  0x03, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE1, 0xC1, 0xE0, 0xF0, 0xF0,
  0xE0, 0x70, 0x78, 0x70, 0x38, 0x1C, 0x78, 0x3C, 0x0F, 0x3C, 0x1E, 0x07,
  0x9E, 0x0E, 0x01, 0xEE, 0x07, 0x00, 0xF7, 0x07, 0x80, 0x7F, 0x83, 0xC0,
  0x1F, 0xC1, 0xE0, 0x0F, 0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xF0, 0x78,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0x8F, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x9F,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xFC, 0x00,
  0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x3E,
  0x1E, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x8F, 0xC0, 0xF8,
  0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x3D,
  0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F,
  0x80, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0E, 0x01, 0xE1, 0xE0,
  0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3C,
  0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0x78, 0x0F, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x3C,
  0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x1E, 0x1F, 0x00, 0x87,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x20,
  0x0F, 0x8C, 0x07, 0xC3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0xC1,
  0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE1,
  0xE0, 0x07, 0x0F, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00,
  0x7B, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x80,
  0x1E, 0x00, 0xFE, 0x00, 0xF8, 0x07, 0xB8, 0x03, 0xE0, 0x1E, 0xE0, 0x1F,
  0x80, 0x7B, 0xC0, 0x7E, 0x03, 0xCF, 0x03, 0xF8, 0x0F, 0x3C, 0x0E, 0xE0,
  0x78, 0xF0, 0x7B, 0x81, 0xE3, 0xC1, 0xCE, 0x0F, 0x0F, 0x0F, 0x38, 0x3C,
  0x3C, 0x38, 0xE0, 0xE0, 0xF0, 0xE3, 0x87, 0x83, 0xC7, 0x8E, 0x1C, 0x0F,
  0x1C, 0x38, 0xF0, 0x3C, 0xF0, 0xE3, 0xC0, 0xF3, 0x83, 0xDE, 0x03, 0xDE,
  0x0F, 0x78, 0x0F, 0x70, 0x3D, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F,
  0x81, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x0E, 0x07,
  0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x7C, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x79,
  0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x70, 0x1E, 0x0F, 0x07, 0x81,
  0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0x8F, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF1, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3,
  0x87, 0x8F, 0x0E, 0x1C, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x8F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xB8, 0x00,
  0xEE, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1E, 0x03, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x07,
  0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xF0, 0xF1, 0xE1,
  0xC1, 0xC1, 0xC0, 0x01, 0xC0, 0x01, 0xFC, 0x70, 0xFF, 0xBC, 0x7E, 0xFE,
  0x3E, 0x0F, 0x8F, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF0, 0x07, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x03,
  0xE3, 0xC0, 0xF8, 0xF0, 0xFE, 0x3F, 0xFF, 0x87, 0xFD, 0xC0, 0xFC, 0x70,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x78, 0x0F, 0x7F, 0x03, 0xBF, 0xE1, 0xFE,
  0xFC, 0x7E, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0xC0, 0xF1, 0xF0, 0x7C, 0xFF, 0xFE, 0x39, 0xFF, 0x0E, 0x3F,
  0x00, 0x00, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0xFC, 0xE3, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x10, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x3C, 0x07,
  0xF3, 0xC0, 0xFF, 0xBC, 0x1F, 0xBF, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E,
  0x0F, 0x07, 0xE0, 0xFF, 0xFC, 0x07, 0xF9, 0xC0, 0x3F, 0x1C, 0x00, 0x00,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x3E, 0x0F, 0x3C, 0x0F, 0x78,
  0x0E, 0x78, 0x1E, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x18, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x40, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x7F, 0x1C, 0x1F, 0xF7, 0x87, 0xEF, 0xF1, 0xF0, 0x7C,
  0x3C, 0x0F, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3,
  0xC0, 0xF8, 0x78, 0x7F, 0x0F, 0xFD, 0xE0, 0xFF, 0x38, 0x0F, 0xCF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x80, 0x7C, 0x1F,
  0x7F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x38, 0x0F, 0x7F, 0x83, 0xBF, 0xF1, 0xFE, 0x7C, 0x7E, 0x0F,
  0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE0, 0x03, 0x03,
  0xC1, 0xE0, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0xDF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x01, 0x0F, 0x03, 0xC1, 0xC0,
  0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x38, 0xF0, 0x0F, 0x3C,
  0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFB, 0xC0, 0x3E, 0x78,
  0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x03, 0xC3, 0xC0, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x73, 0xF8, 0x7F, 0x83,
  0xBF, 0xE7, 0xFC, 0x3F, 0xDF, 0x79, 0xF1, 0xF8, 0x3F, 0x07, 0x8F, 0x81,
  0xF0, 0x3C, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0xC0,
  0x71, 0xE0, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x3C, 0x70, 0x0F, 0x01, 0xE7,
  0x80, 0x70, 0x0F, 0x3C, 0x07, 0x80, 0x71, 0xE0, 0x3C, 0x07, 0x8F, 0x01,
  0xE0, 0x3C, 0x70, 0x0F, 0x01, 0xE7, 0x80, 0x70, 0x0F, 0x3C, 0x07, 0x80,
  0xF1, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x9F, 0xE0, 0xEF, 0xFC,
  0x7F, 0xFF, 0x1F, 0x83, 0xC7, 0xC0, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x78, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xF7, 0xE3, 0xE0,
  0xF3, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x79, 0xE0, 0x3C,
  0xF8, 0x3C, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x39, 0xFC, 0x03, 0xBF, 0xE0, 0x7F, 0xBF, 0x07, 0xE0, 0xF0, 0x7C, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xE0, 0x0F, 0x0E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xF0,
  0x3C, 0x1F, 0x07, 0xC3, 0xFF, 0xF8, 0x3D, 0xFF, 0x03, 0xCF, 0xC0, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0xFE, 0x70, 0xFF, 0xBC, 0x7E, 0xFE, 0x3E, 0x0F, 0x8F, 0x03, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x7E,
  0x3F, 0xF7, 0x87, 0xF9, 0xC0, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x1C, 0xFC, 0x3B, 0xF0, 0xFF, 0xE1,
  0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8,
  0xF8, 0xF1, 0xE0, 0x27, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C,
  0xC0, 0x79, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1E, 0x0F, 0xFF, 0xFF, 0xE3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x1E, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC3, 0xF8, 0xFF, 0xDE, 0x1F, 0xE7,
  0x03, 0xF1, 0xC0, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF,
  0x03, 0xC7, 0x81, 0xE1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0xF0, 0x38, 0x78,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x03, 0xFC,
  0x0F, 0x81, 0xEF, 0x03, 0xE0, 0x7B, 0xC1, 0xF8, 0x1C, 0xF0, 0x7E, 0x0F,
  0x3C, 0x3B, 0x83, 0x8F, 0x0E, 0xE1, 0xE3, 0xC7, 0x38, 0x78, 0xF1, 0xCE,
  0x3C, 0x1C, 0xF3, 0x8F, 0x07, 0x38, 0xE7, 0x81, 0xDE, 0x39, 0xE0, 0x77,
  0x07, 0x70, 0x1D, 0xC1, 0xFC, 0x07, 0xE0, 0x6E, 0x01, 0xF8, 0x1B, 0x80,
  0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01,
  0xF0, 0x78, 0x3E, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x03, 0xCF, 0x00, 0x3D,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x1E, 0x1C, 0x03,
  0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x0E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0xC0, 0x01, 0xDE, 0x00, 0x07, 0x78,
  0x00, 0x1D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC2, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0xC0,
  0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F,
  0x40, 0x3E, 0x00, 0xF8, 0x0F, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x20, 0x00, 0x3F, 0x00, 0xBF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x03, 0xE0,
};

const GFXglyph NotoSans_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 27, 10, 1, -26 },
  { 32, 11, 10, 15, 4, -26 },
  { 46, 23, 26, 23, 1, -26 },
  { 121, 18, 29, 20, 1, -27 },
  { 187, 25, 26, 29, 3, -26 },
  { 269, 23, 26, 25, 1, -26 },
  { 344, 5, 10, 8, 4, -26 },
  { 351, 13, 32, 11, 1, -26 },
  { 403, 13, 32, 11, -3, -26 },
  { 455, 16, 17, 20, 4, -28 },
  { 489, 17, 17, 21, 2, -21 },
  { 526, 8, 9, 10, -2, -4 },
  { 535, 9, 3, 11, 1, -11 },
  { 539, 5, 6, 10, 1, -5 },
  { 543, 18, 26, 14, -2, -26 },
  { 602, 17, 26, 20, 2, -26 },
  { 658, 11, 26, 20, 5, -26 },
  { 694, 19, 26, 20, 0, -26 },
  { 756, 18, 26, 20, 1, -26 },
  { 815, 19, 26, 20, 0, -26 },
  { 877, 18, 26, 20, 1, -26 },
  { 936, 18, 26, 20, 2, -26 },
  { 995, 19, 26, 20, 2, -26 },
  { 1057, 19, 26, 20, 1, -26 },
  { 1119, 17, 26, 20, 2, -26 },
  { 1175, 8, 21, 10, 1, -20 },
  { 1196, 11, 25, 10, -2, -20 },
  { 1231, 17, 18, 21, 2, -22 },
  { 1270, 17, 10, 21, 2, -18 },
  { 1292, 17, 18, 21, 2, -22 },
  { 1331, 14, 27, 16, 3, -26 },
  { 1379, 28, 29, 31, 2, -26 },
  { 1481, 21, 26, 21, -2, -26 },
  { 1550, 20, 26, 22, 1, -26 },
  { 1615, 21, 26, 21, 2, -26 },
  { 1684, 22, 26, 24, 1, -26 },
  { 1756, 19, 26, 19, 1, -26 },
  { 1818, 19, 26, 18, 1, -26 },
  { 1880, 22, 26, 25, 2, -26 },
  { 1952, 24, 26, 25, 1, -26 },
  { 2030, 15, 26, 12, -1, -26 },
  { 2079, 17, 33, 10, -6, -26 },
  { 2150, 23, 26, 21, 1, -26 },
  { 2225, 14, 26, 18, 1, -26 },
  { 2271, 30, 26, 31, 1, -26 },
  { 2369, 25, 26, 26, 1, -26 },
  { 2451, 23, 26, 26, 2, -26 },
  { 2526, 20, 26, 21, 1, -26 },
  { 2591, 23, 32, 26, 2, -26 },
  { 2683, 20, 26, 21, 1, -26 },
  { 2748, 18, 26, 18, 1, -26 },
  { 2807, 18, 26, 18, 3, -26 },
  { 2866, 22, 26, 25, 3, -26 },
  { 2938, 21, 26, 20, 3, -26 },
  { 3007, 30, 26, 31, 4, -26 },
  { 3105, 25, 26, 20, -2, -26 },
  { 3187, 19, 26, 19, 3, -26 },
  { 3249, 22, 26, 19, -1, -26 },
  { 3321, 14, 32, 11, 0, -26 },
  { 3377, 7, 26, 14, 4, -26 },
  { 3400, 14, 32, 11, -3, -26 },
  { 3456, 18, 17, 20, 1, -26 },
  { 3495, 15, 3, 14, -3, 3 },
  { 3501, 7, 6, 10, 5, -28 },
  { 3507, 18, 20, 21, 2, -20 },
  { 3552, 18, 27, 21, 1, -27 },
  { 3613, 15, 20, 17, 2, -20 },
  { 3651, 20, 27, 21, 2, -27 },
  { 3719, 16, 20, 19, 2, -20 },
  { 3759, 20, 37, 12, -4, -28 },
  { 3852, 19, 29, 21, 1, -20 },
  { 3921, 18, 27, 21, 1, -27 },
  { 3982, 9, 27, 10, 1, -27 },
  { 4013, 15, 36, 10, -5, -27 },
  { 4081, 19, 27, 19, 1, -27 },
  { 4146, 10, 27, 10, 1, -27 },
  { 4180, 29, 20, 32, 1, -20 },
  { 4253, 18, 20, 21, 1, -20 },
  { 4298, 17, 20, 20, 2, -20 },
  { 4341, 20, 29, 21, -1, -20 },
  { 4414, 18, 29, 21, 2, -20 },
  { 4480, 15, 20, 15, 1, -20 },
  { 4518, 15, 20, 16, 0, -20 },
  { 4556, 12, 24, 13, 2, -24 },
  { 4592, 18, 19, 21, 2, -19 },
  { 4635, 17, 19, 17, 2, -19 },
  { 4676, 26, 19, 27, 2, -19 },
  { 4738, 20, 19, 18, -1, -19 },
  { 4786, 22, 28, 17, -3, -19 },
  { 4863, 17, 19, 16, -1, -19 },
  { 4904, 15, 32, 13, 0, -26 },
  { 4964, 3, 36, 20, 9, -27 },
  { 4978, 14, 32, 13, -1, -26 },
  { 5034, 17, 5, 21, 2, -15 },
};

const GFXfont NotoSans_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_MEDIUMITALIC36PT7B_H_
