#ifndef _NOTOSANS_MEDIUMITALIC10PT7B_H_
#define _NOTOSANS_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x30, 0xB4, 0x14, 0x49, 0xF9, 0x4F, 0xCA, 0x14, 0x00,
  0x11, 0xD4, 0xA3, 0x16, 0xEC, 0x20, 0xE5, 0x52, 0xC6, 0xF2, 0xAA, 0x63,
  0x00, 0x38, 0x50, 0xE3, 0x9D, 0x51, 0x1D, 0x00, 0xC0, 0x32, 0x44, 0x88,
  0x84, 0x40, 0x21, 0x11, 0x22, 0x24, 0x80, 0x25, 0x1E, 0xCB, 0x00, 0x22,
  0xF2, 0x20, 0xE0, 0xE0, 0xC0, 0x18, 0x88, 0x44, 0x42, 0x00, 0x3A, 0x52,
  0x9C, 0xAD, 0xC0, 0x3E, 0x22, 0x24, 0x40, 0x78, 0x42, 0x22, 0x23, 0xE0,
  0x78, 0x42, 0x60, 0x87, 0xC0, 0x08, 0xCA, 0x9F, 0x88, 0x40, 0x39, 0x10,
  0xF0, 0x87, 0xC0, 0x7E, 0x29, 0xA9, 0x4B, 0x80, 0xF8, 0x88, 0x44, 0x22,
  0x00, 0x3A, 0x4A, 0x64, 0xC5, 0xC0, 0x3A, 0x52, 0xF0, 0x8B, 0xC0, 0x50,
  0x30, 0x24, 0x00, 0xF0, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80,
  0xE1, 0x24, 0x80, 0x80, 0x3C, 0x86, 0xEE, 0x5C, 0xB7, 0xA0, 0x3C, 0x0C,
  0x51, 0x49, 0x3D, 0x1C, 0x40, 0x3C, 0x94, 0xDE, 0x49, 0x2F, 0x80, 0x7E,
  0x21, 0x08, 0x41, 0xC0, 0x3C, 0x94, 0x51, 0x45, 0x3F, 0x00, 0x3C, 0x84,
  0x1E, 0x41, 0x0F, 0x00, 0x3C, 0x84, 0x1E, 0x41, 0x0C, 0x00, 0x7F, 0x08,
  0x26, 0x8A, 0x27, 0x80, 0x22, 0x4D, 0x13, 0xE4, 0x48, 0xB2, 0x00, 0x72,
  0x24, 0x44, 0xE0, 0x08, 0x44, 0x21, 0x08, 0x44, 0xE0, 0x26, 0x51, 0x43,
  0x85, 0x0B, 0x32, 0x00, 0x22, 0x44, 0x44, 0xF0, 0x21, 0xA9, 0x94, 0xCA,
  0xA5, 0x92, 0xD2, 0x48, 0x22, 0xA5, 0x4A, 0xB4, 0xC9, 0xA3, 0x00, 0x7B,
  0x18, 0x61, 0x8E, 0x27, 0x00, 0x38, 0x94, 0x5E, 0x41, 0x0C, 0x00, 0x7B,
  0x18, 0x61, 0x8E, 0x27, 0x04, 0x18, 0x38, 0x94, 0xDE, 0x51, 0x2C, 0x80,
  0x3A, 0x10, 0x61, 0x8B, 0xC0, 0xF9, 0x10, 0x84, 0x23, 0x00, 0x47, 0x38,
  0xA2, 0x8A, 0x6F, 0x00, 0x8E, 0x29, 0x24, 0xA2, 0x84, 0x00, 0x99, 0xCC,
  0xA6, 0x95, 0x4A, 0xC6, 0x63, 0x30, 0x22, 0x28, 0x60, 0xC3, 0x85, 0x31,
  0x00, 0x8C, 0x98, 0xC4, 0x23, 0x00, 0x7C, 0x21, 0x08, 0x61, 0x0F, 0x80,
  0x34, 0x44, 0x44, 0x88, 0xC0, 0xA9, 0x54, 0x31, 0x12, 0x22, 0x22, 0xC0,
  0x31, 0x93, 0x90, 0xF0, 0xD0, 0x7D, 0x24, 0xB6, 0x68, 0x21, 0x14, 0xD4,
  0xA5, 0x36, 0x7A, 0x31, 0x87, 0x00, 0x04, 0x10, 0x5E, 0x49, 0x2D, 0x9A,
  0x7A, 0x7C, 0x87, 0x00, 0x0C, 0x41, 0x1A, 0x20, 0x82, 0x08, 0x43, 0x00,
  0x7D, 0x24, 0xB6, 0x68, 0x4F, 0x00, 0x21, 0x14, 0xD4, 0xA5, 0x33, 0x21,
  0x24, 0xA0, 0x10, 0x22, 0x22, 0x44, 0xC0, 0x20, 0x84, 0x56, 0x71, 0x85,
  0x26, 0x25, 0x24, 0x94, 0x7F, 0x49, 0x49, 0x49, 0x9B, 0x13, 0x52, 0x94,
  0xCC, 0x7A, 0x72, 0x97, 0x00, 0x7A, 0x52, 0x9B, 0x42, 0x00, 0x7D, 0x24,
  0xB6, 0x68, 0x41, 0x00, 0x74, 0x44, 0x80, 0x74, 0x21, 0xE0, 0x24, 0xF4,
  0x44, 0x60, 0x9C, 0xA5, 0x6D, 0x00, 0xCA, 0x94, 0xC6, 0x00, 0xB7, 0x6B,
  0x66, 0xC9, 0x80, 0x59, 0x88, 0xA9, 0x00, 0x64, 0xA2, 0x8C, 0x30, 0x8E,
  0x00, 0x79, 0x18, 0x8F, 0x00, 0x32, 0x24, 0xC4, 0x44, 0x40, 0xFF, 0xC0,
  0x64, 0x92, 0x96, 0x80, 0xF0,
};

const GFXglyph NotoSans_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 7, 7, 6, 0, -7 },
  { 12, 5, 9, 6, 0, -8 },
  { 18, 7, 7, 8, 1, -7 },
  { 25, 7, 7, 7, 0, -7 },
  { 32, 1, 2, 2, 1, -7 },
  { 33, 4, 9, 3, 0, -7 },
  { 38, 4, 9, 3, -1, -7 },
  { 43, 5, 5, 5, 1, -8 },
  { 47, 4, 5, 6, 1, -6 },
  { 50, 2, 2, 3, 0, -1 },
  { 51, 3, 1, 3, 0, -3 },
  { 52, 2, 1, 3, 0, -1 },
  { 53, 5, 7, 4, 0, -7 },
  { 58, 5, 7, 6, 0, -7 },
  { 63, 4, 7, 6, 1, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 0, -7 },
  { 82, 5, 7, 6, 0, -7 },
  { 87, 5, 7, 6, 1, -7 },
  { 92, 5, 7, 6, 1, -7 },
  { 97, 5, 7, 6, 0, -7 },
  { 102, 5, 7, 6, 0, -7 },
  { 107, 2, 6, 3, 0, -6 },
  { 109, 3, 7, 3, -1, -6 },
  { 112, 4, 5, 6, 1, -6 },
  { 115, 4, 3, 6, 1, -5 },
  { 117, 4, 5, 6, 1, -6 },
  { 120, 4, 7, 4, 1, -7 },
  { 124, 7, 8, 9, 1, -7 },
  { 131, 6, 7, 6, -1, -7 },
  { 137, 6, 7, 6, 0, -7 },
  { 143, 5, 7, 6, 1, -7 },
  { 148, 6, 7, 7, 0, -7 },
  { 154, 6, 7, 5, 0, -7 },
  { 160, 6, 7, 5, 0, -7 },
  { 166, 6, 7, 7, 1, -7 },
  { 172, 7, 7, 7, 0, -7 },
  { 179, 4, 7, 3, 0, -7 },
  { 183, 5, 9, 3, -2, -7 },
  { 189, 7, 7, 6, 0, -7 },
  { 196, 4, 7, 5, 0, -7 },
  { 200, 9, 7, 9, 0, -7 },
  { 208, 7, 7, 7, 0, -7 },
  { 215, 6, 7, 7, 1, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 6, 9, 7, 1, -7 },
  { 234, 6, 7, 6, 0, -7 },
  { 240, 5, 7, 5, 0, -7 },
  { 245, 5, 7, 5, 1, -7 },
  { 250, 6, 7, 7, 1, -7 },
  { 256, 6, 7, 6, 1, -7 },
  { 262, 9, 7, 9, 1, -7 },
  { 270, 7, 7, 6, -1, -7 },
  { 277, 5, 7, 5, 1, -7 },
  { 282, 6, 7, 5, 0, -7 },
  { 288, 4, 9, 3, 0, -7 },
  { 293, 2, 7, 4, 1, -7 },
  { 295, 4, 9, 3, -1, -7 },
  { 300, 5, 4, 6, 0, -7 },
  { 303, 4, 1, 4, -1, 1 },
  { 304, 2, 2, 3, 1, -8 },
  { 305, 6, 5, 6, 0, -5 },
  { 309, 5, 8, 6, 0, -8 },
  { 314, 5, 5, 5, 0, -5 },
  { 318, 6, 8, 6, 0, -8 },
  { 324, 5, 5, 5, 0, -5 },
  { 328, 6, 10, 3, -1, -8 },
  { 336, 6, 7, 6, 0, -5 },
  { 342, 5, 8, 6, 0, -8 },
  { 347, 3, 7, 3, 0, -7 },
  { 350, 4, 9, 3, -1, -7 },
  { 355, 6, 8, 5, 0, -8 },
  { 361, 3, 8, 3, 0, -8 },
  { 364, 8, 5, 9, 0, -5 },
  { 369, 5, 6, 6, 0, -6 },
  { 373, 5, 5, 6, 0, -5 },
  { 377, 5, 7, 6, 0, -5 },
  { 382, 6, 7, 6, 0, -5 },
  { 388, 4, 5, 4, 0, -5 },
  { 391, 4, 5, 4, 0, -5 },
  { 394, 4, 7, 4, 0, -7 },
  { 398, 5, 5, 6, 1, -5 },
  { 402, 5, 5, 5, 0, -5 },
  { 406, 7, 5, 7, 1, -5 },
  { 411, 5, 5, 5, 0, -5 },
  { 415, 6, 7, 5, -1, -5 },
  { 421, 5, 5, 5, 0, -5 },
  { 425, 4, 9, 4, 0, -7 },
  { 430, 1, 10, 6, 2, -8 },
  { 432, 3, 9, 4, 0, -7 },
  { 436, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_MEDIUMITALIC10PT7B_H_
