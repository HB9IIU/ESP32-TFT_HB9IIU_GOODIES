#ifndef _NOTOSANS_MEDIUMITALIC66PT7B_H_
#define _NOTOSANS_MEDIUMITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF0,
  0x00, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x7F, 0x1F, 0x83, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x00, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xCF,
  0xC0, 0x1F, 0xC3, 0xC0, 0xE0, 0x1F, 0xC1, 0xE0, 0x00, 0x0F, 0xE0, 0xF0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x01, 0xF8, 0x3C,
  0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x3F, 0x8F,
  0x80, 0x00, 0x1F, 0xF7, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xBF, 0xE0, 0x00, 0x07, 0x8F, 0xF0, 0x00,
  0x03, 0xC3, 0xF8, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0xF0, 0x3F, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x00, 0x3C, 0x1F, 0xC2,
  0x00, 0x3E, 0x1F, 0xE1, 0xC0, 0x1F, 0x1F, 0xE0, 0xFC, 0x0F, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x9F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x00, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x7F, 0xE3, 0xF0, 0x1F, 0x0F, 0xC7, 0xFF,
  0xCF, 0xC0, 0xFC, 0x7E, 0x3F, 0xFF, 0xBF, 0x07, 0xE1, 0xF9, 0xFF, 0xFE,
  0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFD, 0xFF, 0xFC, 0x7E, 0x3F, 0x83, 0xF7,
  0xFF, 0xE3, 0xF0, 0xFC, 0x0F, 0xCF, 0xFF, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0xF8, 0x7E, 0x1F, 0x80, 0xFC, 0x0F, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x00, 0x01,
  0xFD, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x03, 0xF8, 0x3F, 0xE3,
  0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0,
  0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFF, 0xC1,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x08, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0xFF, 0x07, 0xC0, 0x01, 0xFF, 0x8F, 0x80, 0x03, 0xFF,
  0xDE, 0x00, 0x0B, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xC1, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x9F,
  0x00, 0x00, 0xFE, 0x1F, 0x00, 0x03, 0xFC, 0x3E, 0x00, 0x0F, 0xF0, 0x7E,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1E, 0x01, 0xF8,
  0x00, 0x18, 0x03, 0xF8, 0x00, 0x10, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x06, 0x1F, 0xDF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE1,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0xFB, 0xF3, 0xFF, 0xDF, 0xC7, 0xFC, 0x7F, 0x1F, 0xE1, 0xFC, 0x3E,
  0x07, 0xE0, 0x70, 0x3F, 0x81, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x3C, 0x00, 0x1F, 0xE0, 0x03, 0x00, 0x03, 0xFC, 0x00, 0x40, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x01, 0xF0, 0x01, 0xFE, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x08, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x0F, 0xF8,
  0x3E, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xF3, 0xFF, 0xE0, 0x01, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x00,
  0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x87, 0xFF, 0x00, 0x3F, 0x9F, 0xFF,
  0xC0, 0x7F, 0x3F, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0xFF, 0xC0, 0x03,
  0xF8, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE,
  0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xF9, 0xFC, 0x00, 0xFF, 0xE1, 0xFC,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x03, 0xFF, 0x00,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xF8, 0x78, 0x01, 0xFE, 0x10,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xFF,
  0xFE, 0x07, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x3E, 0x0F, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x3F, 0x1F, 0x00,
  0x7F, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0x3E, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x7E, 0x00, 0x3F,
  0x00, 0x3E, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0x00,
  0x3F, 0x00, 0x7E, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xCF, 0xC0, 0x7C,
  0x00, 0x7E, 0x00, 0xFC, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xCF, 0xC0,
  0x7E, 0x00, 0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x01, 0xFE, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7F, 0xE0, 0x7E,
  0x07, 0xC0, 0x3F, 0xFF, 0xBF, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xF9, 0xFF,
  0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x04, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xFD,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0x00, 0x0C, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x7F,
  0x00, 0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x07,
  0xFF, 0xF8, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7,
  0xF0, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x9F,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F,
  0xC0, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3E, 0x1F,
  0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7C, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0x01,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF7, 0xF0, 0x00,
  0x1F, 0xC0, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x3F,
  0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE3,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x9F,
  0xF0, 0x07, 0xFE, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x00, 0x1F,
  0xF0, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xBF,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xBF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFE,
  0x00, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x07,
  0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07,
  0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x07, 0xFF,
  0x83, 0xF0, 0x07, 0xFF, 0xF0, 0xF8, 0x03, 0xFF, 0xFE, 0x7E, 0x01, 0xFF,
  0xFF, 0x9F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFC,
  0x07, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x3F, 0xFF, 0xE7,
  0xE0, 0x07, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x1F, 0xF8,
  0x1F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0xF0, 0x01, 0xFC, 0xFF, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0xFE, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFC, 0x1F, 0xF8, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x07, 0xFC,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE,
  0x1F, 0xF8, 0x01, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0x03, 0xF7, 0xFF, 0xFF, 0x03, 0xF3, 0xFF, 0xFF, 0x01, 0xF8, 0xFF, 0xFF,
  0x00, 0xFC, 0x3F, 0xFF, 0x00, 0x7C, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFE, 0x00, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x3F,
  0xF0, 0x3E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFF,
  0xC3, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0xFC, 0x00,
  0x7F, 0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFB, 0xF0, 0x00, 0xFF, 0xFF, 0x9F,
  0x80, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xE0, 0x00, 0x3F,
  0xF0, 0x3E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE,
  0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0xFF, 0x8F, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x08, 0x3F, 0xE0, 0x01, 0xC0, 0xFF, 0x80, 0x7E,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x10, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFF,
  0xE0, 0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x3F, 0xFF, 0xE7, 0xE0, 0x0F,
  0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x81, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x7E, 0xFC, 0x01, 0xFF, 0xFF, 0x9F,
  0x80, 0x1F, 0xFF, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xFE,
  0x1F, 0xC0, 0x01, 0xFF, 0x83, 0xF0, 0x00, 0x03, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x40, 0x00, 0x3F, 0xC0, 0x0C, 0x00, 0x0F, 0xF8, 0x01, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0xF8, 0x01,
  0xF8, 0x7F, 0xFE, 0x00, 0xFC, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xF8, 0x1F, 0xFC, 0x01, 0xFC,
  0x1F, 0xFC, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x02, 0x0F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xBF,
  0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xC1, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7E, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x0F, 0xDF, 0x03,
  0xFD, 0xF0, 0x1F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x07, 0xFF,
  0x80, 0x0F, 0xC7, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xFE, 0x01, 0xF9, 0xFF,
  0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xF0, 0x1F, 0xBF, 0x03, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x3F,
  0xE0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0xFC, 0x00, 0x07, 0xE3, 0xFF, 0xF0, 0x00, 0x3E, 0x3F, 0xFF, 0xC0,
  0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x1F, 0xBF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFD, 0xFF, 0xFF, 0xC0, 0x0F, 0xE7, 0xFF,
  0xFC, 0x00, 0x7F, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0xFC, 0x00, 0x1F,
  0xC1, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x07,
  0xFF, 0x83, 0xF0, 0x07, 0xFF, 0xF0, 0xF8, 0x03, 0xFF, 0xFE, 0x7E, 0x01,
  0xFF, 0xFF, 0xDF, 0x80, 0xFF, 0xFF, 0xF7, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFC, 0x07, 0xFC, 0x1F, 0x7E, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x3F, 0xFF,
  0xEF, 0xE0, 0x07, 0xFF, 0xF3, 0xF8, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0x00, 0x00, 0x60, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0xE0, 0x3F, 0x07, 0xFC, 0x07, 0xE3, 0xFF, 0x00, 0xFC, 0xFF,
  0xE0, 0x3F, 0x3F, 0xFC, 0x07, 0xE7, 0xFF, 0x80, 0xFD, 0xFC, 0x20, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xF1, 0xFE, 0x07, 0xF8,
  0x01, 0xC0, 0x7F, 0x00, 0x04, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x80, 0x00, 0x7F, 0x0E, 0x00, 0x0F, 0xF0, 0xFC, 0x03,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x10, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFC, 0x0F, 0xE0,
  0x0F, 0xFE, 0x07, 0xF0, 0x0F, 0xBF, 0x03, 0xFE, 0x1F, 0xBF, 0x81, 0xFF,
  0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0xC7, 0xE0, 0x0F,
  0xFF, 0x83, 0xF0, 0x01, 0xFF, 0x81, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFB, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFB, 0xF0, 0x0F, 0xF0,
  0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF3, 0xF0, 0x0F, 0xE0,
  0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0x80,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x00,
  0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x01, 0xF1, 0xFC, 0x00,
  0x7E, 0x3E, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x01, 0xF3, 0xF8, 0x00,
  0x7E, 0x7E, 0x01, 0xF3, 0xF8, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x00,
  0x7E, 0xFC, 0x01, 0xF7, 0xF0, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x1F, 0xFE, 0x00, 0x03,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xFC,
  0x80, 0x00, 0x3F, 0xF0,
};

const GFXglyph NotoSans_MediumItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 18, 48, 18, 1, -47 },
  { 109, 21, 17, 27, 7, -47 },
  { 154, 41, 47, 43, 2, -47 },
  { 395, 33, 54, 36, 2, -50 },
  { 618, 46, 49, 54, 5, -48 },
  { 900, 42, 49, 45, 2, -48 },
  { 1158, 9, 17, 15, 7, -47 },
  { 1178, 22, 57, 20, 3, -47 },
  { 1335, 22, 57, 20, -5, -47 },
  { 1492, 31, 31, 36, 6, -50 },
  { 1613, 32, 32, 38, 4, -39 },
  { 1741, 14, 17, 17, -3, -8 },
  { 1771, 17, 6, 21, 2, -21 },
  { 1784, 9, 10, 17, 1, -9 },
  { 1796, 33, 47, 25, -3, -47 },
  { 1990, 32, 49, 36, 3, -48 },
  { 2186, 22, 47, 36, 8, -47 },
  { 2316, 35, 48, 36, 0, -48 },
  { 2526, 34, 49, 36, 1, -48 },
  { 2735, 35, 47, 36, 0, -47 },
  { 2941, 34, 48, 36, 2, -47 },
  { 3145, 32, 49, 36, 4, -48 },
  { 3341, 34, 47, 36, 4, -47 },
  { 3541, 33, 49, 36, 3, -48 },
  { 3744, 32, 49, 36, 3, -48 },
  { 3940, 15, 37, 17, 1, -36 },
  { 4010, 19, 45, 17, -3, -36 },
  { 4117, 32, 33, 38, 4, -40 },
  { 4249, 30, 18, 38, 5, -32 },
  { 4317, 32, 33, 38, 4, -40 },
  { 4449, 26, 49, 29, 5, -48 },
  { 4609, 52, 53, 56, 3, -47 },
  { 4954, 39, 47, 38, -4, -47 },
  { 5184, 37, 47, 40, 2, -47 },
  { 5402, 38, 49, 39, 4, -48 },
  { 5635, 40, 47, 44, 2, -47 },
  { 5870, 35, 47, 35, 2, -47 },
  { 6076, 35, 47, 33, 2, -47 },
  { 6282, 40, 49, 45, 4, -48 },
  { 6527, 44, 47, 45, 2, -47 },
  { 6786, 28, 47, 23, -2, -47 },
  { 6951, 30, 60, 19, -10, -47 },
  { 7176, 42, 47, 38, 2, -47 },
  { 7423, 26, 47, 32, 2, -47 },
  { 7576, 55, 47, 56, 2, -47 },
  { 7900, 46, 47, 48, 2, -47 },
  { 8171, 42, 49, 48, 4, -48 },
  { 8429, 36, 47, 38, 2, -47 },
  { 8641, 42, 59, 48, 4, -48 },
  { 8951, 36, 47, 39, 2, -47 },
  { 9163, 34, 49, 34, 1, -48 },
  { 9372, 33, 47, 34, 6, -47 },
  { 9566, 41, 48, 45, 5, -47 },
  { 9812, 37, 47, 37, 6, -47 },
  { 10030, 56, 47, 57, 7, -47 },
  { 10359, 46, 47, 36, -4, -47 },
  { 10630, 35, 47, 35, 6, -47 },
  { 10836, 39, 47, 35, -1, -47 },
  { 11066, 26, 57, 20, -1, -47 },
  { 11252, 13, 47, 25, 7, -47 },
  { 11329, 26, 57, 20, -5, -47 },
  { 11515, 33, 30, 37, 2, -47 },
  { 11639, 27, 4, 26, -6, 6 },
  { 11653, 11, 11, 19, 10, -51 },
  { 11669, 34, 37, 38, 3, -36 },
  { 11827, 33, 51, 39, 2, -50 },
  { 12038, 28, 37, 30, 3, -36 },
  { 12168, 37, 51, 38, 3, -50 },
  { 12404, 29, 37, 34, 3, -36 },
  { 12539, 37, 66, 22, -7, -50 },
  { 12845, 35, 52, 39, 2, -36 },
  { 13073, 33, 50, 39, 2, -50 },
  { 13280, 17, 49, 18, 2, -49 },
  { 13385, 27, 65, 18, -8, -49 },
  { 13605, 34, 50, 34, 2, -50 },
  { 13818, 17, 50, 18, 2, -50 },
  { 13925, 53, 36, 58, 2, -36 },
  { 14164, 34, 36, 39, 1, -36 },
  { 14317, 32, 37, 38, 3, -36 },
  { 14465, 37, 52, 39, -2, -36 },
  { 14706, 34, 52, 38, 3, -36 },
  { 14927, 27, 36, 27, 2, -36 },
  { 15049, 28, 37, 29, 0, -36 },
  { 15179, 22, 45, 23, 3, -44 },
  { 15303, 33, 37, 39, 4, -36 },
  { 15456, 32, 36, 32, 3, -36 },
  { 15600, 48, 36, 49, 4, -36 },
  { 15816, 38, 36, 33, -3, -36 },
  { 15987, 41, 52, 32, -6, -36 },
  { 16254, 31, 36, 30, -1, -36 },
  { 16394, 26, 57, 23, 1, -47 },
  { 16580, 6, 66, 36, 16, -50 },
  { 16630, 26, 57, 23, -3, -47 },
  { 16816, 32, 9, 38, 4, -28 },
};

const GFXfont NotoSans_MediumItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_MEDIUMITALIC66PT7B_H_
