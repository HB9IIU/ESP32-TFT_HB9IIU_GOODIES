#ifndef _NOTOSANS_MEDIUMITALIC25PT7B_H_
#define _NOTOSANS_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83,
  0x00, 0x00, 0x38, 0xF0, 0xE0, 0xE7, 0xE6, 0xE6, 0xC6, 0xCC, 0xCC, 0x8C,
  0x03, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x38, 0xC0, 0x63, 0x0F, 0xFF, 0xDF,
  0xFF, 0x86, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0x87, 0xFF, 0xEF, 0xFF,
  0xC3, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x31, 0x80, 0xC7, 0x00, 0x01, 0x80,
  0x18, 0x07, 0xE1, 0xFF, 0x3D, 0x33, 0xB0, 0x33, 0x03, 0xB0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x7E, 0x06, 0xE0, 0x4E, 0x8C, 0xEE, 0xFC, 0xFF, 0x87,
  0xE0, 0x08, 0x01, 0x80, 0x1E, 0x03, 0x3F, 0x03, 0x19, 0xC3, 0x9C, 0x61,
  0x8C, 0x31, 0x86, 0x39, 0x83, 0x19, 0xC1, 0x8C, 0xDE, 0xCE, 0xDF, 0xFE,
  0xCC, 0xDE, 0xEC, 0x60, 0x66, 0x30, 0x63, 0x18, 0x63, 0x8C, 0x71, 0xCE,
  0x30, 0xE6, 0x30, 0x3F, 0x30, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x0E,
  0x70, 0x1C, 0x30, 0x1C, 0x30, 0x1C, 0x70, 0x0C, 0xE0, 0x0F, 0xC0, 0x0F,
  0x00, 0x3F, 0x07, 0x73, 0x8E, 0xE1, 0xCC, 0xE1, 0xDC, 0xC0, 0xF8, 0xE0,
  0x70, 0xE1, 0xF8, 0x7F, 0xF8, 0x3F, 0x1C, 0xFF, 0xED, 0xA0, 0x03, 0x83,
  0x03, 0x83, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x01, 0x80, 0x06,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x00,
  0x03, 0x80, 0x30, 0x43, 0x06, 0x30, 0xFA, 0x01, 0xFF, 0x0E, 0xF1, 0xB0,
  0x3B, 0x07, 0x18, 0x21, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x39,
  0xDC, 0xE6, 0x60, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x30, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xC0,
  0xFE, 0x1C, 0x73, 0x87, 0x38, 0x37, 0x03, 0x70, 0x37, 0x03, 0x60, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xC7, 0x1C, 0x7F, 0x83,
  0xF0, 0x03, 0x0F, 0x3F, 0x7F, 0xF7, 0x46, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x07, 0xE0, 0x7F, 0x87, 0x1E,
  0x10, 0x70, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x02, 0xFF, 0xE7, 0xFF,
  0x00, 0x07, 0xE0, 0xFF, 0x83, 0x0E, 0x10, 0x70, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x1E, 0x0F, 0xC0, 0x7E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xD8, 0x1C, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E,
  0x03, 0xF0, 0x1B, 0x01, 0x98, 0x1D, 0xC1, 0xCE, 0x1C, 0x61, 0xC3, 0x0C,
  0x38, 0xC1, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xF0, 0x3F, 0xC1, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x90, 0x78, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x83, 0xC0,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0xF8, 0x7F, 0xE3, 0xC7, 0x1C,
  0x1D, 0xC0, 0xEE, 0x06, 0x70, 0x31, 0x83, 0x8E, 0x38, 0x7F, 0xC1, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x1C, 0x30, 0x73, 0x83,
  0x8C, 0x18, 0x71, 0xC1, 0xFC, 0x0F, 0x81, 0xFE, 0x1E, 0x79, 0xC1, 0xCE,
  0x06, 0x70, 0x33, 0x83, 0x9E, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0x07, 0xC1,
  0xFE, 0x3C, 0xF3, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0xF3,
  0xFF, 0x3F, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC8, 0x78, 0xFF, 0x0F,
  0xE0, 0x1C, 0x73, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xF3, 0xC0,
  0x0E, 0x1C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x0E,
  0x18, 0x70, 0xC0, 0x00, 0x30, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x3C, 0x1F, 0x07, 0xC0, 0xF0, 0x08,
  0x00, 0x3F, 0x3F, 0xE6, 0x38, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x1E,
  0x0F, 0x03, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0x83, 0xC0, 0xC0, 0x0E, 0x18, 0x00,
  0x63, 0x07, 0xC6, 0x71, 0xFE, 0x36, 0x38, 0xC3, 0x63, 0x0C, 0x3E, 0x70,
  0xC7, 0xC6, 0x1C, 0x6C, 0x61, 0x86, 0xC6, 0x38, 0xEE, 0x76, 0xDC, 0x63,
  0xCF, 0x86, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x40, 0x1F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xB8, 0x0E,
  0xE0, 0x33, 0x81, 0xC6, 0x06, 0x18, 0x38, 0x60, 0xFF, 0x87, 0xFE, 0x3F,
  0xFC, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0xE0, 0x1F, 0x80, 0x30, 0x0F, 0xE0,
  0x7F, 0xE1, 0xC7, 0xC7, 0x07, 0x18, 0x1C, 0x60, 0x73, 0x83, 0x8E, 0x3C,
  0x3F, 0xE0, 0xFF, 0x87, 0x07, 0x1C, 0x0E, 0x70, 0x39, 0xC0, 0xE6, 0x07,
  0x38, 0x7C, 0xFF, 0xE3, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xF1, 0x8F,
  0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x18, 0x7F, 0xE0,
  0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x73, 0xF0, 0xE0, 0xE1, 0x80, 0xE3,
  0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x3B, 0x80,
  0xE7, 0x01, 0xCE, 0x07, 0x18, 0x1E, 0x71, 0xF8, 0xFF, 0xC1, 0xFE, 0x00,
  0x0F, 0xF8, 0xFF, 0xC7, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0xE1, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0xFC, 0x7C, 0x31, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0xFD, 0xC1, 0xFB, 0x87, 0xE7, 0x01, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x0C, 0x3C, 0x18, 0x3F, 0xF0, 0x3F, 0xC0, 0x0C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x3F, 0xFC, 0x3F, 0xFC, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0x0F, 0xE1,
  0xFC, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x7E, 0x1F, 0xC0, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x0B, 0xE1, 0xF8, 0x3E, 0x00, 0x0C, 0x0F, 0x1C, 0x1C, 0x1C,
  0x38, 0x1C, 0x78, 0x18, 0xF0, 0x19, 0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x7B, 0x80, 0x71, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x60,
  0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0, 0x70, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1B, 0x03, 0xF1, 0xB0, 0x36, 0x3B, 0x06, 0x63,
  0xB0, 0x6E, 0x33, 0x0C, 0xE3, 0x31, 0xCC, 0x73, 0x18, 0xC7, 0x33, 0x9C,
  0x73, 0xB1, 0xC6, 0x1F, 0x1C, 0x61, 0xE1, 0x8E, 0x1E, 0x18, 0xE1, 0xC3,
  0x8C, 0x1C, 0x38, 0x0E, 0x01, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0xE0, 0x61,
  0xB0, 0x30, 0xDC, 0x18, 0xEE, 0x1C, 0x73, 0x0E, 0x31, 0xC6, 0x18, 0xE3,
  0x1C, 0x33, 0x8E, 0x1D, 0xC7, 0x0E, 0xE3, 0x03, 0x61, 0x81, 0xF1, 0xC0,
  0x78, 0xE0, 0x3C, 0x60, 0x1E, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0xF1,
  0xC0, 0x77, 0x00, 0xEE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x3C, 0x7C,
  0x7F, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0xC1, 0xCF, 0x87, 0x0E, 0x18,
  0x1C, 0x60, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x78, 0xFF, 0xC7, 0xFC, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0xF0, 0x78, 0xF1, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xDC, 0x03, 0xB8, 0x0E, 0x3C, 0x78, 0x7F, 0xE0, 0x3F, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0x3E, 0x38,
  0x71, 0x81, 0x8C, 0x0C, 0xE0, 0xE7, 0x07, 0x39, 0xF1, 0xFF, 0x1F, 0xE0,
  0xE3, 0x87, 0x1C, 0x38, 0x61, 0x83, 0x9C, 0x1C, 0xE0, 0x77, 0x03, 0x80,
  0x03, 0xF0, 0x7F, 0xC7, 0x8C, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x98, 0x3C, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC1, 0xC0, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x38, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0x80, 0x73, 0x00, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0x9C, 0x06, 0x38, 0x1C, 0x78, 0x70, 0x7F, 0xE0, 0x7F, 0x00, 0xE0, 0x1F,
  0x80, 0x76, 0x03, 0x98, 0x0E, 0x60, 0x71, 0x81, 0xC6, 0x0E, 0x1C, 0x38,
  0x71, 0xC1, 0xC6, 0x07, 0x38, 0x1C, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x3E, 0x07, 0x81, 0xB0,
  0x3C, 0x1D, 0x83, 0xE0, 0xCC, 0x1F, 0x0E, 0x61, 0xF8, 0x73, 0x0C, 0xC7,
  0x18, 0x66, 0x38, 0xC6, 0x31, 0x86, 0x31, 0x9C, 0x33, 0x8C, 0xC1, 0x98,
  0x6E, 0x0D, 0xC3, 0x60, 0x6C, 0x1B, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x87, 0x03, 0x81, 0x83,
  0x80, 0xE3, 0x80, 0x73, 0x80, 0x19, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0xE6, 0x00, 0xE3, 0x80,
  0xE1, 0xC0, 0x70, 0x70, 0x70, 0x38, 0x70, 0x1C, 0x00, 0xE0, 0x3B, 0x01,
  0xDC, 0x1C, 0xE1, 0xC7, 0x0C, 0x18, 0xE0, 0xCE, 0x07, 0x60, 0x3F, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x0F,
  0x87, 0xC3, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0F, 0x87, 0xC0,
  0xC6, 0x31, 0xCE, 0x31, 0x8C, 0x63, 0x1C, 0xE3, 0x18, 0xC6, 0x31, 0xC0,
  0x07, 0xC3, 0xF0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x7C, 0x3E, 0x00, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xD8, 0x1D, 0x81,
  0x9C, 0x38, 0xC3, 0x0E, 0x70, 0x66, 0x06, 0xE0, 0x30, 0xFF, 0xFF, 0xF0,
  0xEE, 0x73, 0x07, 0x00, 0xFC, 0xCF, 0xFE, 0x70, 0xE7, 0x07, 0x38, 0x39,
  0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC7, 0xC7, 0xEC, 0x1E,
  0x60, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x9C, 0x3B, 0xE3,
  0xFF, 0x3C, 0x73, 0x83, 0x70, 0x37, 0x03, 0x70, 0x76, 0x07, 0x60, 0x7E,
  0x0E, 0xF1, 0xED, 0xFC, 0xCF, 0x80, 0x03, 0x83, 0xFC, 0xFB, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x47, 0xF8,
  0x7F, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x1C,
  0xE1, 0xFB, 0x8F, 0xFE, 0x38, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x1C, 0xE0,
  0x63, 0x81, 0x8E, 0x0E, 0x38, 0x78, 0xE3, 0xE1, 0xFB, 0x03, 0xCC, 0x00,
  0x03, 0x81, 0xF8, 0xFB, 0x9C, 0x37, 0x0E, 0xC1, 0xFF, 0xF7, 0xF8, 0xE0,
  0x1C, 0x03, 0x80, 0x38, 0x47, 0xF8, 0x7F, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x3E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xFC, 0xCF, 0xFE, 0x70, 0xE7, 0x07,
  0x38, 0x39, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC7, 0xC7,
  0xEC, 0x1E, 0x60, 0x07, 0x00, 0x38, 0x01, 0x84, 0x3C, 0x3F, 0xC1, 0xFC,
  0x00, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x8C, 0x3B, 0xF3,
  0xFF, 0x3C, 0x33, 0x83, 0x70, 0x77, 0x07, 0x70, 0x76, 0x06, 0x60, 0x6E,
  0x0E, 0xE0, 0xEE, 0x0E, 0xC0, 0xC0, 0x08, 0x71, 0xC0, 0x00, 0x03, 0x8E,
  0x38, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x8C, 0x00, 0x00, 0x80, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07,
  0x03, 0x83, 0xE0, 0xF0, 0x00, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x04, 0xE1, 0xC7, 0x1C, 0x31, 0xC1, 0x9C, 0x1D, 0xC0, 0xFC,
  0x07, 0xE0, 0x3B, 0x81, 0x8C, 0x1C, 0x70, 0xE3, 0x87, 0x0E, 0x30, 0x78,
  0x0C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x71, 0x86, 0x38,
  0xE3, 0x8C, 0x00, 0x08, 0xC1, 0xC3, 0x3E, 0x7E, 0x37, 0xFE, 0xF3, 0xC7,
  0x87, 0x38, 0x78, 0x77, 0x07, 0x07, 0x70, 0x70, 0x67, 0x06, 0x0E, 0x60,
  0x60, 0xE6, 0x0E, 0x0E, 0xE0, 0xE0, 0xEE, 0x0E, 0x0C, 0xE0, 0xC1, 0xCC,
  0x1C, 0x1C, 0x38, 0xC3, 0xBF, 0x37, 0xF3, 0xC3, 0x38, 0x37, 0x07, 0x70,
  0x77, 0x07, 0x60, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEC, 0x0C, 0x03,
  0x81, 0xFC, 0x3F, 0xE3, 0x87, 0x70, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0xE0, 0xE7, 0x1C, 0x7F, 0xC3, 0xF0, 0x02, 0x70, 0x33, 0xE0,
  0xDF, 0xC3, 0xC7, 0x0E, 0x0C, 0x70, 0x31, 0xC0, 0xC7, 0x07, 0x18, 0x1C,
  0x60, 0x73, 0x83, 0x8F, 0x1E, 0x37, 0xF0, 0xCF, 0x83, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFC, 0xCF, 0xFE,
  0x70, 0xE7, 0x07, 0x38, 0x39, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x38,
  0x79, 0xC7, 0xC7, 0xEC, 0x1E, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x00, 0xCE, 0xF3, 0x78, 0xF0, 0x38, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x07, 0x03,
  0xFC, 0xF7, 0x18, 0x03, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x30,
  0x06, 0x41, 0xCF, 0xF9, 0xFC, 0x00, 0x0C, 0x0C, 0x0E, 0x3F, 0xEF, 0xF1,
  0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x01, 0xF0, 0xF8,
  0x38, 0x39, 0xC1, 0xCC, 0x0C, 0xE0, 0x67, 0x07, 0x38, 0x39, 0xC1, 0xCC,
  0x0C, 0xE0, 0xE7, 0x0F, 0x38, 0xF8, 0xFD, 0x87, 0xCC, 0x00, 0xE0, 0x7E,
  0x0E, 0x60, 0xE6, 0x1C, 0x61, 0xC6, 0x38, 0x63, 0x87, 0x70, 0x76, 0x07,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x00, 0x60, 0xE1, 0xEC, 0x3C, 0x39, 0x87,
  0x86, 0x31, 0xB1, 0xC6, 0x36, 0x30, 0xCC, 0xCE, 0x19, 0x99, 0x83, 0x73,
  0x70, 0x6C, 0x6C, 0x0D, 0x8D, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x07,
  0x80, 0x1C, 0x3C, 0x30, 0xE0, 0xE7, 0x01, 0xB8, 0x07, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x73, 0x03, 0x8E, 0x1C, 0x38, 0xE0, 0x70,
  0x1C, 0x0E, 0x18, 0x38, 0x30, 0x70, 0x61, 0xC0, 0xC3, 0x81, 0xCE, 0x03,
  0x9C, 0x07, 0x70, 0x06, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x1F, 0xE7, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x7F, 0xCF, 0xF8, 0x01, 0xC0, 0xF0, 0x78, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x0F, 0x0F, 0x83, 0xC0, 0x38, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0xC0, 0x3C, 0x0E, 0x0F, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0xF0, 0x38, 0x00, 0x20, 0x1F, 0xE3,
  0xDF, 0xF8, 0x3C,
};

const GFXglyph NotoSans_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 18, 7, 0, -18 },
  { 17, 8, 7, 10, 3, -18 },
  { 24, 15, 18, 16, 1, -18 },
  { 58, 12, 20, 14, 1, -19 },
  { 88, 17, 18, 20, 2, -18 },
  { 127, 16, 18, 17, 1, -18 },
  { 163, 3, 7, 6, 3, -18 },
  { 166, 9, 22, 8, 1, -18 },
  { 191, 9, 22, 8, -2, -18 },
  { 216, 12, 12, 14, 2, -19 },
  { 234, 11, 12, 14, 2, -15 },
  { 251, 5, 6, 7, -1, -3 },
  { 255, 6, 2, 8, 1, -8 },
  { 257, 4, 3, 7, 0, -3 },
  { 259, 12, 18, 9, -1, -18 },
  { 286, 12, 18, 14, 1, -18 },
  { 313, 8, 18, 14, 3, -18 },
  { 331, 13, 18, 14, 0, -18 },
  { 361, 13, 18, 14, 0, -18 },
  { 391, 13, 18, 14, 0, -18 },
  { 421, 13, 18, 14, 1, -18 },
  { 451, 13, 18, 14, 1, -18 },
  { 481, 12, 18, 14, 2, -18 },
  { 508, 13, 18, 14, 1, -18 },
  { 538, 12, 18, 14, 1, -18 },
  { 565, 6, 14, 7, 0, -14 },
  { 576, 7, 17, 7, -1, -14 },
  { 591, 12, 12, 14, 2, -15 },
  { 609, 11, 7, 14, 2, -12 },
  { 619, 12, 12, 14, 2, -15 },
  { 637, 10, 18, 11, 2, -18 },
  { 660, 20, 20, 21, 1, -18 },
  { 710, 14, 18, 15, -1, -18 },
  { 742, 14, 18, 15, 1, -18 },
  { 774, 14, 18, 15, 2, -18 },
  { 806, 15, 18, 17, 1, -18 },
  { 840, 13, 18, 13, 1, -18 },
  { 870, 13, 18, 12, 1, -18 },
  { 900, 15, 18, 17, 2, -18 },
  { 934, 16, 18, 17, 1, -18 },
  { 970, 11, 18, 9, -1, -18 },
  { 995, 11, 23, 7, -4, -18 },
  { 1027, 16, 18, 14, 1, -18 },
  { 1063, 10, 18, 12, 1, -18 },
  { 1086, 20, 18, 21, 1, -18 },
  { 1131, 17, 18, 18, 1, -18 },
  { 1170, 15, 18, 18, 2, -18 },
  { 1204, 14, 18, 15, 1, -18 },
  { 1236, 15, 22, 18, 2, -18 },
  { 1278, 13, 18, 15, 1, -18 },
  { 1308, 13, 18, 13, 0, -18 },
  { 1338, 13, 18, 13, 2, -18 },
  { 1368, 15, 18, 17, 2, -18 },
  { 1402, 14, 18, 14, 2, -18 },
  { 1434, 21, 18, 22, 3, -18 },
  { 1482, 17, 18, 14, -1, -18 },
  { 1521, 13, 18, 13, 2, -18 },
  { 1551, 14, 18, 13, 0, -18 },
  { 1583, 9, 22, 8, 0, -18 },
  { 1608, 5, 18, 9, 3, -18 },
  { 1620, 10, 22, 8, -2, -18 },
  { 1648, 12, 11, 14, 1, -18 },
  { 1665, 10, 2, 10, -2, 2 },
  { 1668, 4, 4, 7, 4, -19 },
  { 1670, 13, 14, 14, 1, -14 },
  { 1693, 12, 19, 15, 1, -19 },
  { 1722, 11, 14, 12, 1, -14 },
  { 1742, 14, 19, 15, 1, -19 },
  { 1776, 11, 14, 13, 1, -14 },
  { 1796, 14, 25, 8, -3, -19 },
  { 1840, 13, 20, 15, 1, -14 },
  { 1873, 12, 19, 15, 1, -19 },
  { 1902, 6, 19, 7, 1, -19 },
  { 1917, 10, 25, 7, -3, -19 },
  { 1949, 13, 19, 13, 1, -19 },
  { 1980, 6, 19, 7, 1, -19 },
  { 1995, 20, 14, 22, 1, -14 },
  { 2030, 12, 14, 15, 1, -14 },
  { 2051, 12, 14, 14, 1, -14 },
  { 2072, 14, 20, 15, -1, -14 },
  { 2107, 13, 20, 15, 1, -14 },
  { 2140, 10, 14, 10, 1, -14 },
  { 2158, 11, 14, 11, 0, -14 },
  { 2178, 9, 16, 9, 1, -16 },
  { 2196, 13, 13, 15, 1, -13 },
  { 2218, 12, 13, 12, 1, -13 },
  { 2238, 19, 13, 19, 1, -13 },
  { 2269, 14, 13, 12, -1, -13 },
  { 2292, 15, 19, 12, -2, -13 },
  { 2328, 11, 13, 11, 0, -13 },
  { 2346, 10, 22, 9, 0, -18 },
  { 2374, 2, 25, 14, 6, -19 },
  { 2381, 10, 22, 9, -1, -18 },
  { 2409, 12, 4, 14, 2, -11 },
};

const GFXfont NotoSans_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_MEDIUMITALIC25PT7B_H_
