#ifndef _LIBERATIONMONO_ITALIC66PT7B_H_
#define _LIBERATIONMONO_ITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x1E, 0x3F, 0xE0, 0x0F, 0xE0,
  0x78, 0x3F, 0x80, 0x7F, 0x01, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0x3C, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x0E, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x3F, 0x81, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x00, 0x01, 0xFF, 0x9E,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x3F, 0xF0, 0x00,
  0x00, 0x78, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0x80,
  0x7E, 0x00, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x0F, 0x81, 0xC0, 0x0F, 0x00, 0x3E, 0x3F, 0x00, 0x3C, 0x01,
  0xF8, 0xFC, 0x00, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xC0, 0x3F, 0x0F, 0xE0,
  0x1E, 0x00, 0xFC, 0x1F, 0xC0, 0x78, 0x07, 0xE0, 0x7F, 0x81, 0xE0, 0x7F,
  0x80, 0xFF, 0x87, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x0F,
  0x80, 0x00, 0x78, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x78, 0x00,
  0x01, 0xF8, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x87, 0xC0, 0x00, 0x03,
  0xFF, 0xE1, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x00, 0x01, 0xFC,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x7F, 0x80, 0x00, 0x00, 0x3C, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xC0, 0x00,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x01, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0x9F, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0x01, 0xFF,
  0xE0, 0x03, 0xE0, 0x7F, 0x7E, 0x00, 0x3E, 0x0F, 0xE3, 0xF0, 0x07, 0xC0,
  0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x80,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x7C, 0x00,
  0x7E, 0x3E, 0x07, 0xC0, 0x07, 0xE3, 0xE0, 0xFC, 0x00, 0x3F, 0x7C, 0x0F,
  0xC0, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x08, 0x0F,
  0x01, 0xBE, 0x1E, 0x1F, 0x7F, 0xBD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xEF, 0x80, 0x0F, 0x8F, 0x00, 0x3F, 0x1F, 0x00, 0xFC, 0x3E, 0x03,
  0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x00, 0xE0, 0x02, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF7, 0xFB, 0xFD, 0xFE, 0xFE, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0xFE, 0x07,
  0xEF, 0xC0, 0xFF, 0x03, 0xF7, 0xE0, 0x7F, 0x81, 0xFB, 0xF0, 0x3F, 0xC0,
  0xFD, 0xF8, 0x1F, 0xC0, 0xFC, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xF0,
  0x3F, 0x7E, 0x07, 0xF8, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xC7, 0xC0,
  0x03, 0xFF, 0x0F, 0xC0, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xC0, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x07,
  0xCF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x18, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0x0F,
  0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0xE0, 0x7E, 0x7F, 0xFF, 0xF0, 0x7E, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x0F, 0xFE, 0x0F, 0xF8, 0x1F, 0xBE, 0x07, 0xFF, 0xFF, 0xBF,
  0x01, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0x07,
  0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x00,
  0xF0, 0x1F, 0xF1, 0xEF, 0x01, 0xE0, 0x3F, 0xF9, 0xCF, 0x03, 0xE0, 0x7C,
  0x7B, 0xCF, 0x03, 0xC0, 0xF0, 0x3B, 0xCF, 0x07, 0xC1, 0xE0, 0x1F, 0x8F,
  0x07, 0x83, 0xC0, 0x1F, 0x8F, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x0F, 0x07,
  0x80, 0x1F, 0x0F, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x1F, 0x0F, 0x00, 0x3E,
  0x0F, 0x1E, 0x1F, 0x00, 0x3E, 0x0F, 0x1E, 0x1E, 0x00, 0x3E, 0x0E, 0x1E,
  0x3E, 0x00, 0x3C, 0x1E, 0x3C, 0x3C, 0x00, 0x7C, 0x1E, 0x3C, 0x3C, 0x00,
  0x78, 0x1E, 0x3C, 0x7C, 0x00, 0x78, 0x1C, 0x3C, 0x78, 0x00, 0xF8, 0x3C,
  0x78, 0x78, 0x00, 0xF0, 0x3C, 0x78, 0x78, 0x00, 0xF0, 0x38, 0x78, 0xF8,
  0x01, 0xE0, 0x78, 0x78, 0xF8, 0x01, 0xE0, 0x78, 0x78, 0xF8, 0x03, 0xE0,
  0x70, 0x78, 0xF0, 0x07, 0xC0, 0xF0, 0xF8, 0xF0, 0x07, 0xC0, 0xE0, 0xF8,
  0xF0, 0x0F, 0xC1, 0xE0, 0xF8, 0xF8, 0x1F, 0xC3, 0xC0, 0xF8, 0xF8, 0x3B,
  0x83, 0x80, 0xF8, 0x78, 0x73, 0xCF, 0x00, 0xF8, 0x7F, 0xE3, 0xFE, 0x00,
  0x78, 0x3F, 0xC3, 0xFC, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x01, 0xFF, 0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xC1, 0xFC,
  0x00, 0x00, 0x60, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x80, 0xFC, 0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x03, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x1F,
  0xFF, 0xC7, 0xF0, 0x03, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0x1F, 0x80,
  0x1F, 0xFF, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x07,
  0xE1, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xF8,
  0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xBE, 0x01, 0xFF,
  0x80, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0x3D, 0xF8, 0x0F, 0x9F, 0x00, 0xFB,
  0xE0, 0x1F, 0x3E, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x1F, 0x1F, 0x01, 0xF9, 0xF8, 0x3E, 0x7E, 0x03, 0xE3, 0xF0, 0xF8,
  0xF8, 0x07, 0xC3, 0xE1, 0xF1, 0xF0, 0x0F, 0x87, 0xC7, 0xC3, 0xE0, 0x1F,
  0x0F, 0x8F, 0x87, 0xC0, 0x7E, 0x1F, 0x3E, 0x1F, 0x80, 0xF8, 0x3E, 0x78,
  0x3E, 0x01, 0xF0, 0x3D, 0xF0, 0x7C, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x07,
  0xC0, 0xFF, 0x81, 0xF0, 0x1F, 0x81, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x3F,
  0xC0, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0xC0, 0x00, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x3F, 0xF0,
  0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0xBE, 0x00, 0x1F, 0x80,
  0xFD, 0xF0, 0x00, 0xF8, 0x07, 0xCF, 0xC0, 0x07, 0xC0, 0x3E, 0x7E, 0x00,
  0x7E, 0x01, 0xF1, 0xF0, 0x03, 0xF0, 0x1F, 0x8F, 0x80, 0x1F, 0x80, 0xFC,
  0x7E, 0x00, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x7E, 0x01,
  0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF0,
  0x03, 0xE3, 0xF0, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0xFC, 0x00, 0xFC, 0xF8,
  0x07, 0xE0, 0x07, 0xE7, 0xC0, 0x3E, 0x00, 0x1F, 0x3E, 0x01, 0xF0, 0x00,
  0xFD, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xE0, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x3F,
  0xF0, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07,
  0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xBE, 0x07, 0xC0, 0x1F, 0x83, 0xEF, 0x81, 0xF0, 0x07, 0xE0,
  0xFB, 0xE0, 0xFC, 0x01, 0xF8, 0x3C, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x3E,
  0x0F, 0x80, 0x1F, 0x87, 0x8F, 0x87, 0xE0, 0x07, 0xC3, 0xE1, 0xE1, 0xF0,
  0x01, 0xF0, 0xF0, 0x78, 0x7C, 0x00, 0x7C, 0x7C, 0x1E, 0x3F, 0x00, 0x1F,
  0x1E, 0x07, 0x8F, 0x80, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x01, 0xF3, 0xE0,
  0x79, 0xF8, 0x00, 0x7D, 0xF0, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x07, 0xDF,
  0x00, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x7B, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0x81, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF,
  0xC0, 0xFC, 0x00, 0xF7, 0xE0, 0x7F, 0x81, 0xF3, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x7E, 0x1F,
  0xFF, 0x00, 0x1F, 0x8F, 0xFF, 0xE0, 0x07, 0xE7, 0xFF, 0xFC, 0x01, 0xF3,
  0xC0, 0xFF, 0x80, 0xFD, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x01, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x7E,
  0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFB, 0x80, 0x1F, 0xC0, 0x7E, 0xF8, 0x1F,
  0xE0, 0x1F, 0x9F, 0xFF, 0xF0, 0x07, 0xC7, 0xFF, 0xF8, 0x01, 0xF0, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xFF,
  0xE1, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0xF9, 0xF8, 0x03,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x01, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3B, 0xE0,
  0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x81, 0xF7, 0xE0, 0x07, 0xFF, 0xFE,
  0x7E, 0x00, 0x3F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xF0, 0x7C, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x80, 0xFE, 0x00, 0x01, 0xF0,
  0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC1, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xFF,
  0x3F, 0x01, 0xFE, 0x07, 0xCF, 0xC0, 0x7E, 0x00, 0x7B, 0xE0, 0x3F, 0x00,
  0x0F, 0xF8, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x83, 0xF0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xDF, 0x80, 0xFF, 0x03, 0xE7, 0xC0,
  0x3F, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xF8, 0x3F,
  0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0xFF,
  0xF8, 0x03, 0xF1, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFE, 0x03, 0xE7, 0xC1,
  0xFF, 0x07, 0xEE, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x87, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x8F, 0xF8, 0x3F, 0xE0, 0x3E,
  0x7F, 0xE1, 0xFF, 0x80, 0xFB, 0xFF, 0x8F, 0xFF, 0x03, 0xEE, 0x3F, 0x71,
  0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC1, 0xFC,
  0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x1F,
  0x83, 0xE0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0x1F, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0xF8,
  0x03, 0xE1, 0xFF, 0xFE, 0x03, 0xE3, 0xFF, 0xFE, 0x03, 0xE7, 0xC1, 0xFF,
  0x07, 0xEE, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xE1, 0xFF, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0x80, 0x07, 0xE7,
  0xFF, 0xFC, 0x00, 0x7C, 0xF0, 0x1F, 0xE0, 0x0F, 0xDC, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x0F,
  0xF0, 0x00, 0xFE, 0x01, 0xFB, 0x80, 0x1F, 0xC0, 0x1F, 0xBE, 0x07, 0xF8,
  0x01, 0xF9, 0xFF, 0xFF, 0x00, 0x1F, 0x9F, 0xFF, 0xE0, 0x01, 0xF8, 0x7F,
  0xF8, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x0F, 0xC0, 0x3F, 0xFF, 0xC7, 0xE0, 0x3F, 0xFF, 0xF3, 0xF0, 0x3F, 0xC0,
  0x7B, 0xF0, 0x3F, 0x80, 0x1F, 0xF8, 0x1F, 0x80, 0x07, 0xFC, 0x1F, 0x80,
  0x01, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0xEF,
  0x81, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x81, 0xF7, 0xE0, 0x3F, 0xFF, 0xF3,
  0xF0, 0x0F, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xE0, 0xF8, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x0F, 0xC0, 0x7F, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF, 0xE0,
  0x7E, 0x3F, 0xFF, 0xC0, 0xFC, 0xFE, 0x00, 0x81, 0xF9, 0xF0, 0x00, 0x03,
  0xF7, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE1, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x81, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x38, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x81, 0xF8,
  0x00, 0xEF, 0x80, 0xFF, 0x03, 0xE7, 0xC0, 0x7F, 0xFF, 0xE7, 0xE0, 0x1F,
  0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0xC1, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xF0,
  0x07, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0xC0,
  0x7E, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x1F, 0x01, 0xEF, 0x03, 0xF0, 0x3E,
  0x07, 0xDE, 0x07, 0xE0, 0x7C, 0x0F, 0x3C, 0x0F, 0x80, 0xF8, 0x3E, 0x78,
  0x3F, 0x01, 0xF0, 0x78, 0xF0, 0x7E, 0x03, 0xE1, 0xF1, 0xF0, 0xF8, 0x07,
  0xC3, 0xC3, 0xE3, 0xF0, 0x0F, 0x8F, 0x87, 0xC7, 0xC0, 0x3F, 0x1E, 0x0F,
  0x8F, 0x80, 0x7E, 0x7C, 0x0F, 0x3F, 0x00, 0xFC, 0xF0, 0x1E, 0x7C, 0x01,
  0xFB, 0xE0, 0x3C, 0xF8, 0x03, 0xE7, 0x80, 0x7B, 0xF0, 0x07, 0xDF, 0x00,
  0xF7, 0xC0, 0x0F, 0xBC, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x03, 0xDE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x27, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x03, 0xFF, 0xFF, 0xE8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xC0,
};

const GFXglyph LiberationMono_Italic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 15, 43, 40, 13, -43 },
  { 82, 25, 21, 40, 12, -48 },
  { 148, 39, 43, 40, 1, -43 },
  { 358, 38, 52, 40, 1, -47 },
  { 605, 43, 45, 40, -1, -44 },
  { 847, 36, 45, 40, 0, -44 },
  { 1050, 10, 21, 40, 19, -48 },
  { 1077, 25, 62, 40, 10, -48 },
  { 1271, 24, 62, 40, 5, -48 },
  { 1457, 23, 23, 40, 12, -48 },
  { 1524, 32, 33, 40, 4, -38 },
  { 1656, 18, 21, 40, 3, -10 },
  { 1704, 19, 5, 40, 10, -20 },
  { 1716, 9, 10, 40, 13, -10 },
  { 1728, 42, 49, 40, 0, -48 },
  { 1986, 33, 45, 40, 4, -44 },
  { 2172, 32, 43, 40, 2, -43 },
  { 2344, 36, 44, 40, 1, -44 },
  { 2542, 34, 45, 40, 3, -44 },
  { 2734, 34, 43, 40, 2, -43 },
  { 2917, 35, 44, 40, 3, -43 },
  { 3110, 32, 45, 40, 5, -44 },
  { 3290, 31, 43, 40, 9, -43 },
  { 3457, 34, 45, 40, 3, -44 },
  { 3649, 33, 45, 40, 4, -44 },
  { 3835, 14, 35, 40, 13, -35 },
  { 3897, 21, 46, 40, 6, -35 },
  { 4018, 32, 33, 40, 4, -38 },
  { 4150, 32, 21, 40, 4, -32 },
  { 4234, 32, 33, 40, 4, -38 },
  { 4366, 32, 44, 40, 6, -44 },
  { 4542, 40, 56, 40, 0, -48 },
  { 4822, 39, 43, 40, -3, -43 },
  { 5032, 36, 43, 40, 2, -43 },
  { 5226, 35, 45, 40, 4, -44 },
  { 5423, 36, 43, 40, 2, -43 },
  { 5617, 38, 43, 40, 2, -43 },
  { 5822, 37, 43, 40, 3, -43 },
  { 6021, 35, 45, 40, 4, -44 },
  { 6218, 37, 43, 40, 2, -43 },
  { 6417, 35, 43, 40, 3, -43 },
  { 6606, 33, 44, 40, 4, -43 },
  { 6788, 40, 43, 40, 2, -43 },
  { 7003, 29, 43, 40, 4, -43 },
  { 7159, 39, 43, 40, 1, -43 },
  { 7369, 37, 43, 40, 2, -43 },
  { 7568, 35, 45, 40, 3, -44 },
  { 7765, 37, 43, 40, 2, -43 },
  { 7964, 35, 57, 40, 3, -44 },
  { 8214, 37, 43, 40, 2, -43 },
  { 8413, 37, 45, 40, 1, -44 },
  { 8622, 35, 43, 40, 7, -43 },
  { 8811, 36, 44, 40, 4, -43 },
  { 9009, 39, 43, 40, 5, -43 },
  { 9219, 42, 43, 40, 3, -43 },
  { 9445, 44, 43, 40, -2, -43 },
  { 9682, 37, 43, 40, 6, -43 },
  { 9881, 42, 43, 40, -1, -43 },
  { 10107, 30, 62, 40, 7, -48 },
  { 10340, 22, 49, 40, 10, -48 },
  { 10475, 29, 62, 40, 3, -48 },
  { 10700, 31, 29, 40, 4, -43 },
  { 10813, 41, 3, 40, -5, 4 },
  { 10829, 12, 8, 40, 19, -47 },
  { 10841, 33, 37, 40, 2, -36 },
  { 10994, 34, 49, 40, 2, -48 },
  { 11203, 32, 37, 40, 4, -36 },
  { 11351, 36, 49, 40, 4, -48 },
  { 11572, 32, 37, 40, 4, -36 },
  { 11720, 34, 48, 40, 7, -48 },
  { 11924, 34, 50, 40, 3, -36 },
  { 12137, 32, 48, 40, 3, -48 },
  { 12329, 33, 48, 40, 1, -48 },
  { 12527, 35, 62, 40, -2, -48 },
  { 12799, 35, 48, 40, 4, -48 },
  { 13009, 32, 48, 40, 1, -48 },
  { 13201, 38, 36, 40, 0, -36 },
  { 13372, 32, 36, 40, 3, -36 },
  { 13516, 32, 37, 40, 4, -36 },
  { 13664, 36, 50, 40, 0, -36 },
  { 13889, 33, 50, 40, 4, -36 },
  { 14096, 31, 36, 40, 6, -36 },
  { 14236, 31, 37, 40, 4, -36 },
  { 14380, 26, 45, 40, 9, -44 },
  { 14527, 33, 36, 40, 4, -35 },
  { 14676, 35, 35, 40, 6, -35 },
  { 14830, 39, 35, 40, 3, -35 },
  { 15001, 39, 35, 40, 0, -35 },
  { 15172, 42, 49, 40, -1, -35 },
  { 15430, 36, 35, 40, 1, -35 },
  { 15588, 33, 62, 40, 7, -48 },
  { 15844, 5, 62, 40, 17, -48 },
  { 15883, 34, 62, 40, -1, -48 },
  { 16147, 34, 8, 40, 4, -26 },
};

const GFXfont LiberationMono_Italic66pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic66pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic66pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _LIBERATIONMONO_ITALIC66PT7B_H_
