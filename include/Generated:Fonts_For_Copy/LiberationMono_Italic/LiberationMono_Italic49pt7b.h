#ifndef _LIBERATIONMONO_ITALIC49PT7B_H_
#define _LIBERATIONMONO_ITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x38, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x1C, 0x7E, 0x07, 0xC1, 0xC1, 0xF0, 0x78,
  0x1C, 0x1F, 0x0F, 0x81, 0xC0, 0xE0, 0xF0, 0x1C, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0xF8, 0x38, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x7F, 0x38, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x71, 0xF8, 0x00, 0x0E, 0x07, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x30, 0x0E,
  0x03, 0xCF, 0x01, 0xC0, 0x78, 0xF8, 0x1C, 0x0F, 0x8F, 0xC1, 0xC1, 0xF8,
  0x7E, 0x1C, 0x7F, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0x01, 0xFF, 0x00, 0x0E, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0x87, 0x80, 0x38,
  0x0F, 0x03, 0x80, 0x70, 0x0F, 0x03, 0x80, 0xF0, 0x0E, 0x03, 0x81, 0xE0,
  0x1E, 0x03, 0x83, 0xC0, 0x1E, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x8F, 0x00,
  0x1C, 0x07, 0x0E, 0x00, 0x1E, 0x0F, 0x1C, 0x00, 0x1E, 0x1E, 0x38, 0x00,
  0x0F, 0xFE, 0x70, 0x00, 0x0F, 0xF8, 0xE0, 0x00, 0x03, 0xF1, 0xE0, 0x00,
  0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x0F, 0x3F, 0xF8,
  0x00, 0x1E, 0x7C, 0x7C, 0x00, 0x1C, 0x78, 0x3C, 0x00, 0x38, 0xF0, 0x3C,
  0x00, 0x70, 0xF0, 0x3C, 0x00, 0xE0, 0xE0, 0x3C, 0x01, 0xE0, 0xE0, 0x38,
  0x03, 0xC1, 0xE0, 0x38, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x70,
  0x1E, 0x00, 0xF1, 0xF0, 0x1C, 0x00, 0xFF, 0xE0, 0x38, 0x00, 0x7F, 0xC0,
  0x70, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x38, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x60, 0x1F, 0xE0, 0x0E, 0x0F, 0xBC,
  0x03, 0xC3, 0xE7, 0xC0, 0x70, 0xF8, 0x78, 0x1E, 0x1E, 0x0F, 0x83, 0x87,
  0x80, 0xF0, 0xF0, 0xF0, 0x1F, 0x1C, 0x3C, 0x01, 0xE7, 0x87, 0x80, 0x3F,
  0xE0, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0x3F, 0x03, 0xC0, 0x07, 0xE0, 0x7C,
  0x01, 0xFE, 0x07, 0xE0, 0xFF, 0xF4, 0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0x87,
  0xF0, 0x7F, 0x80, 0x3C, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0x06, 0x0D, 0xF7, 0x3F, 0xFF, 0xFF, 0x1F, 0xFC,
  0x01, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xEF, 0x00, 0xF3, 0x80, 0xF1,
  0xE0, 0xF0, 0xF0, 0x70, 0x38, 0x10, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0xBF, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0x03, 0xF0,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xE1, 0xF8, 0x79, 0xE0, 0xF8, 0x3C, 0xF0, 0x7C, 0x1E, 0xF8, 0x7E,
  0x0F, 0x7C, 0x3F, 0x0F, 0xBE, 0x1F, 0x87, 0x9E, 0x00, 0x03, 0xCF, 0x00,
  0x03, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0xF0, 0x07, 0xFC, 0xF0, 0x07, 0xF0, 0xF0,
  0x07, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x78, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x8F, 0xC0, 0x07, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x7C, 0x00, 0x07,
  0x1F, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF0, 0x01,
  0xE0, 0x38, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x7F, 0x00, 0x0F, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x3F, 0x80,
  0x78, 0xFF, 0xE0, 0x7B, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0x81, 0xF8,
  0xFE, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x7E, 0x0F, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03,
  0xF0, 0x3F, 0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x7F,
  0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xDE, 0x0F, 0xFF, 0x9E, 0x07, 0xFF, 0x3E,
  0x01, 0xF8, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x70, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xFC, 0x0F, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x78, 0x3F, 0x9D, 0xC1, 0xC1, 0xC6,
  0xE7, 0x0F, 0x0E, 0x0F, 0x9C, 0x38, 0x70, 0x3E, 0x71, 0xE3, 0x80, 0xF1,
  0xC7, 0x1E, 0x03, 0xC7, 0x1C, 0x70, 0x0E, 0x1C, 0xE3, 0xC0, 0x78, 0x63,
  0x8E, 0x01, 0xE3, 0x8E, 0x38, 0x07, 0x0E, 0x79, 0xC0, 0x1C, 0x39, 0xC7,
  0x00, 0xF0, 0xC7, 0x1C, 0x03, 0x87, 0x1C, 0xF0, 0x0E, 0x1C, 0x73, 0xC0,
  0x70, 0x61, 0xCE, 0x01, 0xC3, 0x8E, 0x38, 0x0F, 0x0E, 0x38, 0xE0, 0x38,
  0x70, 0xE3, 0x81, 0xE1, 0x83, 0x8E, 0x0F, 0x8E, 0x0E, 0x3C, 0x6E, 0x70,
  0x3C, 0x7F, 0x3F, 0x80, 0xF0, 0xF0, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0xFE, 0x07,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0x81, 0xF8,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x83, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xFC, 0x0F,
  0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0x1F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3C,
  0x00, 0x3E, 0x07, 0x80, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x1F, 0xFC, 0xF8, 0x0F, 0xFF, 0x3E, 0x03, 0xFF,
  0xCF, 0x80, 0xFF, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3F,
  0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x80,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x38, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x1E, 0x0F, 0xC0, 0x00,
  0x78, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3C,
  0xFC, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xBF, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x01, 0xE0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF8,
  0x1D, 0xE0, 0x3B, 0xC1, 0xEF, 0x03, 0xDE, 0x0F, 0x78, 0x1C, 0xE0, 0x7B,
  0xC1, 0xEF, 0x03, 0xCE, 0x0E, 0x78, 0x1C, 0x78, 0xF3, 0xC1, 0xE3, 0xC7,
  0x1E, 0x0F, 0x1E, 0x78, 0xE0, 0x78, 0xF3, 0x8F, 0x03, 0xC7, 0xBC, 0x78,
  0x1C, 0x1D, 0xC3, 0xC1, 0xE0, 0xFC, 0x1E, 0x0F, 0x07, 0xE0, 0xE0, 0x78,
  0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1C, 0x07, 0x03, 0xC1, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0xF0, 0x3F, 0x80, 0x1F,
  0x03, 0xF8, 0x01, 0xE0, 0x3F, 0x80, 0x1E, 0x07, 0xBC, 0x01, 0xE0, 0x7B,
  0xC0, 0x1E, 0x07, 0xBC, 0x03, 0xE0, 0x7B, 0xE0, 0x3C, 0x07, 0x9E, 0x03,
  0xC0, 0xF1, 0xE0, 0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xF0, 0xF0, 0x7C, 0x0F,
  0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0x78,
  0x78, 0x1E, 0x07, 0x8F, 0x81, 0xE0, 0x78, 0xF0, 0x1E, 0x07, 0xCF, 0x03,
  0xE0, 0x3C, 0xF0, 0x3C, 0x03, 0xCF, 0x03, 0xC0, 0x3C, 0xF0, 0x3C, 0x03,
  0xEE, 0x03, 0xC0, 0x1F, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0x80, 0x1F, 0xE0,
  0x78, 0x00, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0xFC, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xC0, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0xC0, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xC0, 0x07,
  0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x03,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0x8F, 0x81, 0xF0, 0x3C,
  0x3E, 0x07, 0xC0, 0xF0, 0xF0, 0x3F, 0x03, 0xC3, 0xC0, 0xFC, 0x1E, 0x0F,
  0x07, 0xF0, 0x78, 0x3C, 0x1D, 0xC1, 0xE0, 0xF0, 0xF7, 0x0F, 0x03, 0xC3,
  0x9C, 0x3C, 0x0F, 0x1E, 0x70, 0xF0, 0x3C, 0x71, 0xC7, 0x80, 0xF3, 0xC7,
  0x1E, 0x03, 0xCF, 0x1E, 0x78, 0x0F, 0x38, 0x7B, 0xC0, 0x3D, 0xE1, 0xEF,
  0x00, 0xF7, 0x07, 0xBC, 0x03, 0xBC, 0x1E, 0xE0, 0x0E, 0xE0, 0x7F, 0x80,
  0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x1C, 0x00,
  0x1E, 0x38, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x01, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0,
  0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0x80, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x01,
  0xF8, 0xF0, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFC, 0x1E, 0xF8, 0xFF, 0xFC,
  0xFF, 0x7F, 0xF0, 0xFF, 0x1F, 0xC0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0xF1, 0xFF, 0x80, 0xFB, 0xFF, 0xE0,
  0x7F, 0xC1, 0xF8, 0x3D, 0x80, 0x7C, 0x1F, 0x80, 0x1E, 0x0F, 0x80, 0x0F,
  0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3C, 0x00,
  0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xE0, 0xFC, 0x01, 0xF0, 0x7F,
  0x83, 0xF0, 0x7D, 0xFF, 0xF0, 0x3C, 0x7F, 0xF0, 0x1E, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x07, 0xF0, 0xF0, 0x07, 0xFF, 0x3C, 0x07, 0xFF, 0xEF,
  0x03, 0xF0, 0x3B, 0xC0, 0xF8, 0x07, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x83, 0xE0,
  0x1F, 0xC0, 0xFC, 0x0E, 0xF0, 0x1F, 0xFF, 0x3C, 0x03, 0xFF, 0x8F, 0x00,
  0x3F, 0x87, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x07, 0xE0, 0xFC, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E,
  0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x60, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xC0, 0x3F, 0xF1,
  0xE0, 0x3F, 0xFE, 0x78, 0x1F, 0x83, 0xDE, 0x07, 0xC0, 0x37, 0x83, 0xE0,
  0x0F, 0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xF0, 0x7C,
  0x01, 0xFC, 0x1F, 0x00, 0xFF, 0x03, 0xF0, 0x77, 0x80, 0xFF, 0xF9, 0xE0,
  0x1F, 0xFC, 0x78, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x83, 0xF8,
  0x07, 0x8F, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F, 0xF8, 0x3F, 0x0F, 0xE0, 0x1F,
  0x0F, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x7C,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x30, 0x1F, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x03, 0xC1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0x9F, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xEF, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x78,
  0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x0F, 0x03, 0xE0, 0x73, 0xF8, 0xFF, 0x07, 0x7F, 0x9F, 0xF0, 0xFE,
  0x7F, 0x8F, 0x0F, 0xC3, 0xF0, 0xF0, 0xF8, 0x3E, 0x0F, 0x0F, 0x03, 0xC0,
  0xF0, 0xF0, 0x3C, 0x0F, 0x1F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x0F, 0x1E,
  0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE3, 0xC0, 0x78,
  0x1E, 0x3C, 0x0F, 0x01, 0xE3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0x3C, 0x7C, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x3C, 0x78, 0x1E,
  0x07, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x8F, 0x81, 0xE0, 0x78,
  0xF0, 0x3E, 0x07, 0x8F, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xF8, 0x07, 0x8F,
  0xFE, 0x0F, 0xBF, 0xFE, 0x0F, 0x78, 0x3F, 0x0F, 0x60, 0x1F, 0x0F, 0xC0,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0,
  0x7C, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x3C,
  0x7F, 0xE0, 0x0F, 0xBF, 0xFE, 0x01, 0xFF, 0x07, 0xE0, 0x3D, 0x80, 0x7C,
  0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0,
  0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x81, 0xF8, 0x01, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xF8, 0x3F,
  0x01, 0xF7, 0xFF, 0xC0, 0x3C, 0x7F, 0xF0, 0x07, 0x83, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F,
  0x80, 0xFF, 0xE7, 0x81, 0xFF, 0xF3, 0xC1, 0xF8, 0x1D, 0xE0, 0xF8, 0x07,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x3F, 0x0F,
  0x80, 0x3F, 0x87, 0xC0, 0x3F, 0x83, 0xF0, 0x3B, 0xC0, 0xFF, 0xF9, 0xE0,
  0x3F, 0xF9, 0xF0, 0x07, 0xF0, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x1E, 0x03, 0xFE, 0x3E, 0x1F, 0xF8, 0x7C, 0xFF, 0xF0, 0xFB,
  0xFF, 0xE1, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE3,
  0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1E, 0x3F, 0x00, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x18, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E,
  0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78,
  0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F,
  0x87, 0xC0, 0x1F, 0x81, 0xF0, 0x3B, 0xC0, 0xFF, 0xF9, 0xE0, 0x3F, 0xF8,
  0xF0, 0x07, 0xF0, 0x78, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07,
  0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x03, 0xE0, 0x7C, 0x78,
  0x1F, 0x03, 0xC3, 0xC1, 0xF8, 0x1E, 0x1E, 0x0F, 0xE1, 0xF0, 0xF0, 0xFF,
  0x0F, 0x07, 0x87, 0x38, 0x78, 0x3C, 0x79, 0xC7, 0x81, 0xE3, 0x8E, 0x3C,
  0x0F, 0x3C, 0x71, 0xE0, 0x79, 0xC3, 0x9E, 0x03, 0x9E, 0x1C, 0xF0, 0x1C,
  0xE0, 0xE7, 0x80, 0xEF, 0x07, 0x78, 0x0F, 0x70, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEC, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0,
};

const GFXglyph LiberationMono_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 32, 29, 10, -32 },
  { 45, 18, 15, 29, 9, -36 },
  { 79, 29, 32, 29, 1, -32 },
  { 195, 28, 39, 29, 1, -35 },
  { 332, 32, 32, 29, -1, -32 },
  { 460, 27, 32, 29, 0, -32 },
  { 568, 8, 15, 29, 14, -36 },
  { 583, 19, 46, 29, 7, -36 },
  { 693, 18, 46, 29, 4, -36 },
  { 797, 17, 18, 29, 9, -36 },
  { 836, 24, 24, 29, 3, -28 },
  { 908, 13, 16, 29, 2, -7 },
  { 934, 14, 4, 29, 8, -14 },
  { 941, 7, 7, 29, 9, -7 },
  { 948, 31, 36, 29, 0, -36 },
  { 1088, 25, 32, 29, 3, -32 },
  { 1188, 24, 32, 29, 1, -32 },
  { 1284, 27, 32, 29, 1, -32 },
  { 1392, 26, 32, 29, 2, -32 },
  { 1496, 26, 32, 29, 1, -32 },
  { 1600, 26, 32, 29, 2, -32 },
  { 1704, 24, 32, 29, 4, -32 },
  { 1800, 22, 32, 29, 7, -32 },
  { 1888, 26, 32, 29, 2, -32 },
  { 1992, 24, 32, 29, 3, -32 },
  { 2088, 11, 26, 29, 9, -26 },
  { 2124, 16, 35, 29, 4, -26 },
  { 2194, 24, 25, 29, 3, -29 },
  { 2269, 24, 16, 29, 3, -24 },
  { 2317, 24, 25, 29, 3, -29 },
  { 2392, 24, 32, 29, 4, -32 },
  { 2488, 30, 42, 29, 0, -36 },
  { 2646, 30, 32, 29, -3, -32 },
  { 2766, 27, 32, 29, 1, -32 },
  { 2874, 26, 32, 29, 3, -32 },
  { 2978, 27, 32, 29, 1, -32 },
  { 3086, 29, 32, 29, 1, -32 },
  { 3202, 28, 32, 29, 2, -32 },
  { 3314, 26, 32, 29, 3, -32 },
  { 3418, 28, 32, 29, 1, -32 },
  { 3530, 26, 32, 29, 2, -32 },
  { 3634, 24, 32, 29, 3, -32 },
  { 3730, 30, 32, 29, 1, -32 },
  { 3850, 22, 32, 29, 3, -32 },
  { 3938, 29, 32, 29, 1, -32 },
  { 4054, 28, 32, 29, 1, -32 },
  { 4166, 26, 32, 29, 2, -32 },
  { 4270, 28, 32, 29, 1, -32 },
  { 4382, 26, 42, 29, 2, -32 },
  { 4519, 28, 32, 29, 1, -32 },
  { 4631, 28, 32, 29, 1, -32 },
  { 4743, 26, 32, 29, 5, -32 },
  { 4847, 27, 32, 29, 3, -32 },
  { 4955, 29, 32, 29, 4, -32 },
  { 5071, 30, 32, 29, 3, -32 },
  { 5191, 33, 32, 29, -2, -32 },
  { 5323, 27, 32, 29, 5, -32 },
  { 5431, 31, 32, 29, -1, -32 },
  { 5555, 22, 46, 29, 5, -36 },
  { 5682, 17, 36, 29, 7, -36 },
  { 5759, 22, 46, 29, 2, -36 },
  { 5886, 23, 22, 29, 3, -32 },
  { 5950, 30, 2, 29, -4, 3 },
  { 5958, 9, 6, 29, 14, -35 },
  { 5965, 24, 26, 29, 2, -26 },
  { 6043, 25, 36, 29, 2, -36 },
  { 6156, 24, 26, 29, 3, -26 },
  { 6234, 26, 36, 29, 3, -36 },
  { 6351, 24, 26, 29, 3, -26 },
  { 6429, 26, 36, 29, 5, -36 },
  { 6546, 26, 36, 29, 2, -26 },
  { 6663, 24, 36, 29, 2, -36 },
  { 6771, 24, 36, 29, 1, -36 },
  { 6879, 25, 46, 29, -1, -36 },
  { 7023, 26, 36, 29, 3, -36 },
  { 7140, 24, 36, 29, 1, -36 },
  { 7248, 28, 26, 29, 0, -26 },
  { 7339, 24, 26, 29, 2, -26 },
  { 7417, 24, 26, 29, 3, -26 },
  { 7495, 27, 36, 29, 0, -26 },
  { 7617, 25, 36, 29, 3, -26 },
  { 7730, 23, 26, 29, 5, -26 },
  { 7805, 23, 26, 29, 3, -26 },
  { 7880, 20, 33, 29, 6, -33 },
  { 7963, 25, 26, 29, 3, -26 },
  { 8045, 26, 26, 29, 4, -26 },
  { 8130, 29, 26, 29, 2, -26 },
  { 8225, 29, 26, 29, 0, -26 },
  { 8320, 30, 36, 29, 0, -26 },
  { 8455, 26, 26, 29, 1, -26 },
  { 8540, 25, 46, 29, 5, -36 },
  { 8684, 4, 46, 29, 13, -36 },
  { 8707, 25, 46, 29, -1, -36 },
  { 8851, 25, 6, 29, 3, -19 },
};

const GFXfont LiberationMono_Italic49pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic49pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic49pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _LIBERATIONMONO_ITALIC49PT7B_H_
