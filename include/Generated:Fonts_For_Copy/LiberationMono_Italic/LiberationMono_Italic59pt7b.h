#ifndef _LIBERATIONMONO_ITALIC59PT7B_H_
#define _LIBERATIONMONO_ITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x1C, 0x7F,
  0x80, 0x7E, 0x07, 0x07, 0xE0, 0x3F, 0x03, 0xC0, 0xFC, 0x0F, 0x80, 0xF0,
  0x3F, 0x03, 0xE0, 0x3C, 0x07, 0xC1, 0xF0, 0x0F, 0x01, 0xC0, 0x7C, 0x03,
  0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xF8,
  0x1E, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x0F, 0xF9, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0xFF,
  0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0xF8, 0x18, 0x03, 0xC0, 0x3E, 0x3E, 0x00, 0xF0, 0x0F, 0x8F, 0x80,
  0x38, 0x07, 0xE3, 0xF0, 0x0E, 0x01, 0xF0, 0x7E, 0x07, 0x80, 0xFC, 0x1F,
  0xC1, 0xE0, 0xFE, 0x07, 0xFC, 0x78, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x07, 0xFF, 0xC0, 0x01,
  0xF0, 0x1F, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x1F, 0x00, 0xF0,
  0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x1F, 0x0F,
  0x80, 0x03, 0xE0, 0x3C, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x78, 0x00, 0x07,
  0x81, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0xC7, 0x80, 0x00, 0x1F, 0xFF, 0x1E,
  0x00, 0x00, 0x1F, 0xF8, 0x78, 0x00, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x00, 0x3C,
  0x7F, 0xF0, 0x00, 0x00, 0xF1, 0xFF, 0xF0, 0x00, 0x03, 0xC7, 0xC3, 0xE0,
  0x00, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x07, 0xC0, 0x00, 0xF0,
  0x78, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x3E, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x0F,
  0x00, 0x78, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x07, 0xC0,
  0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x01, 0xFF,
  0x00, 0x1F, 0x03, 0xFF, 0x80, 0x1E, 0x07, 0xEF, 0x80, 0x1E, 0x0F, 0x87,
  0xC0, 0x3C, 0x1F, 0x07, 0xC0, 0x3C, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x03,
  0xE0, 0x78, 0x7C, 0x03, 0xF0, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0xF8, 0x01,
  0xF9, 0xF0, 0xF8, 0x00, 0xFB, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0xF8, 0x00,
  0x7F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0x3F, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF, 0x81, 0xFE, 0x03, 0xFC,
  0x00, 0x3C, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0x81, 0xE0, 0x4F, 0x0E, 0x1E,
  0xFF, 0x77, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xFC, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x1E, 0x01,
  0xE0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x9F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C,
  0xF8, 0x1F, 0x81, 0xF3, 0xE0, 0xFE, 0x07, 0xDF, 0x83, 0xF8, 0x3F, 0x7E,
  0x0F, 0xE0, 0xFD, 0xF0, 0x3F, 0x83, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x07,
  0xF0, 0x3E, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0xC1, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF3, 0xE0, 0x03,
  0xFF, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01,
  0xE0, 0x3E, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0,
  0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x07, 0xDF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xFE,
  0x00, 0x3E, 0x1F, 0xFE, 0x00, 0xF9, 0xFF, 0xFE, 0x03, 0xEF, 0xFF, 0xFC,
  0x1F, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE,
  0x1F, 0x80, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0xE0, 0xFF, 0x03, 0xEF, 0x81,
  0xFF, 0xFF, 0x7C, 0x03, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0x87, 0xC0, 0x07,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x0F, 0x03, 0xC0, 0x7F, 0x8E, 0xF0, 0x3C,
  0x0F, 0xFD, 0xE7, 0x07, 0x81, 0xE1, 0xDC, 0x70, 0x78, 0x3C, 0x0F, 0xC7,
  0x0F, 0x07, 0x80, 0xF8, 0xF0, 0xF0, 0xF0, 0x0F, 0x8F, 0x0E, 0x1E, 0x00,
  0xF8, 0xF1, 0xE1, 0xE0, 0x0F, 0x0F, 0x1E, 0x3C, 0x00, 0xF0, 0xF1, 0xC3,
  0xC0, 0x1E, 0x0E, 0x3C, 0x78, 0x01, 0xE0, 0xE3, 0xC7, 0x80, 0x1E, 0x1E,
  0x38, 0x78, 0x03, 0xC1, 0xE3, 0x8F, 0x00, 0x3C, 0x1C, 0x78, 0xF0, 0x03,
  0x83, 0xC7, 0x8F, 0x00, 0x78, 0x3C, 0x78, 0xF0, 0x07, 0x83, 0x87, 0x1E,
  0x00, 0xF0, 0x78, 0x71, 0xE0, 0x0F, 0x07, 0x0F, 0x1E, 0x01, 0xF0, 0xF0,
  0xF1, 0xE0, 0x3E, 0x0E, 0x0F, 0x1E, 0x03, 0xE1, 0xE0, 0xF1, 0xE0, 0x6E,
  0x1C, 0x0F, 0x0F, 0x1C, 0xE7, 0x80, 0xF0, 0xFF, 0xCF, 0xF0, 0x0F, 0x07,
  0xF0, 0xFE, 0x00, 0x70, 0x3E, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8,
  0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0x80, 0x0F, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8,
  0x7C, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x10,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7F, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x7E, 0x01, 0xFF, 0xF8, 0x7E,
  0x01, 0xFF, 0xF8, 0x7C, 0x01, 0xFF, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x01, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x0F,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C,
  0x0F, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0x9F, 0xC0,
  0x00, 0x00, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xC0,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1E, 0xF0, 0x07, 0xBE, 0x03,
  0xDF, 0x00, 0xF7, 0xC0, 0xFB, 0xE0, 0x3C, 0xF0, 0x1F, 0x7C, 0x07, 0x9E,
  0x03, 0xE7, 0x81, 0xE7, 0xC0, 0x78, 0xF0, 0x7C, 0xF8, 0x0F, 0x1F, 0x0F,
  0x1F, 0x03, 0xE3, 0xE3, 0xE3, 0xC0, 0x7C, 0x7C, 0x78, 0x78, 0x0F, 0x8F,
  0x9F, 0x1F, 0x01, 0xE0, 0xF3, 0xC3, 0xE0, 0x3C, 0x1E, 0xF0, 0x7C, 0x0F,
  0x83, 0xDE, 0x0F, 0x01, 0xF0, 0x7F, 0x81, 0xE0, 0x3E, 0x0F, 0xF0, 0x7C,
  0x07, 0x80, 0xFC, 0x0F, 0x80, 0xF0, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x07, 0xC0,
  0x7F, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x01, 0xF0, 0x3F, 0xE0, 0x01, 0xF0,
  0x1F, 0xF0, 0x00, 0xF8, 0x0F, 0xF8, 0x00, 0x7C, 0x07, 0xBE, 0x00, 0x3E,
  0x03, 0xDF, 0x00, 0x1F, 0x03, 0xEF, 0x80, 0x1F, 0x01, 0xF3, 0xC0, 0x0F,
  0x80, 0xF9, 0xF0, 0x07, 0xC0, 0x7C, 0xF8, 0x03, 0xE0, 0x3C, 0x7C, 0x01,
  0xF0, 0x3E, 0x1E, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x1F, 0x00,
  0x78, 0xF8, 0x0F, 0x80, 0x3E, 0x7C, 0x07, 0xC0, 0x1F, 0x3E, 0x03, 0xE0,
  0x0F, 0x9F, 0x03, 0xE0, 0x03, 0xEF, 0x81, 0xF0, 0x01, 0xF7, 0x80, 0xF8,
  0x00, 0xFB, 0xC0, 0x7C, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0xF0, 0x3E,
  0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x03, 0xFC, 0x07,
  0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x03, 0xF8,
  0x0F, 0x80, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x01,
  0xFC, 0x03, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F,
  0x80, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xFC,
  0x07, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xC0,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x70,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0xC0, 0x7C, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7C,
  0x0F, 0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0x81, 0xF0, 0x1F, 0x07, 0xBC, 0x0F,
  0x00, 0xF8, 0x3D, 0xE0, 0xF8, 0x07, 0xC3, 0xEF, 0x07, 0xC0, 0x3E, 0x1E,
  0x78, 0x3C, 0x01, 0xF0, 0xF3, 0xC3, 0xE0, 0x0F, 0x8F, 0x1E, 0x1F, 0x00,
  0x78, 0x78, 0xF0, 0xF0, 0x03, 0xC7, 0x87, 0x8F, 0x80, 0x3E, 0x3C, 0x3E,
  0x7C, 0x01, 0xF3, 0xC1, 0xF3, 0xC0, 0x0F, 0x9E, 0x07, 0xBE, 0x00, 0x7D,
  0xE0, 0x3D, 0xF0, 0x03, 0xEF, 0x01, 0xEF, 0x00, 0x1F, 0x78, 0x0F, 0x78,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0x0F, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xE1, 0xF8, 0x03, 0xDF, 0x0F, 0xE0, 0x7C,
  0xFC, 0x3F, 0xFF, 0xC7, 0xFD, 0xFF, 0xFC, 0x3F, 0xE7, 0xFF, 0x81, 0xFF,
  0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x03, 0xE1, 0xFF, 0xE0, 0x0F, 0x8F, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF,
  0x80, 0xFB, 0xC0, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xFE,
  0x00, 0x3F, 0x07, 0xFC, 0x01, 0xF8, 0x1F, 0x78, 0x1F, 0xC0, 0x7D, 0xFF,
  0xFE, 0x03, 0xF3, 0xFF, 0xF0, 0x0F, 0x87, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0xFC, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x7C, 0x00, 0x7F, 0xF8, 0x7C, 0x00, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xFE,
  0xFC, 0x03, 0xF8, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x03,
  0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0xFF,
  0x80, 0x7F, 0x03, 0xEF, 0x80, 0x3F, 0xFF, 0xDF, 0x80, 0x3F, 0xFF, 0x9F,
  0x00, 0x1F, 0xFE, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE0, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x7C, 0x01, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xF9, 0xF0,
  0x1F, 0xC0, 0xF7, 0xE0, 0x7E, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x00, 0x03, 0xF8, 0x3E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x3F,
  0x80, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x0F, 0xBE, 0x01, 0xFF, 0xFE, 0x7C,
  0x03, 0xFF, 0xF8, 0xF8, 0x03, 0xFF, 0xC3, 0xF0, 0x00, 0xFE, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xE1, 0xFF, 0xE0,
  0x0F, 0x8F, 0xFF, 0xC0, 0x3E, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFE, 0x07,
  0xDC, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x01, 0x80, 0x3F, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xF3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0xF1, 0xFC, 0x1F, 0xE0, 0x3D,
  0xFF, 0x8F, 0xFC, 0x1F, 0x7F, 0xE7, 0xFF, 0x07, 0xF8, 0xFB, 0x8F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF8, 0x1F,
  0x0F, 0xC0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80,
  0x78, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xC0, 0x3E,
  0x03, 0xE1, 0xF0, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x3E, 0x1F, 0x01,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x01, 0xF0, 0xF8,
  0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x07, 0x83,
  0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x78,
  0x07, 0xC3, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x87,
  0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0x00, 0xFB, 0xFF, 0xFE, 0x03, 0xFF, 0x03,
  0xF8, 0x1F, 0x70, 0x07, 0xE0, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF8,
  0x7F, 0xF8, 0x00, 0xF8, 0xFF, 0xFC, 0x00, 0xF9, 0xFF, 0xFE, 0x00, 0xFB,
  0xC0, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x01, 0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x1F, 0x78,
  0x1F, 0xE0, 0x1F, 0x7F, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0x00, 0x3F, 0x1F,
  0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF,
  0xC7, 0xC0, 0x7F, 0xFF, 0xBF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0x1F,
  0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8,
  0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x3B, 0xE0, 0x7F,
  0x83, 0xEF, 0x80, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xF9, 0xF0, 0x07, 0xFF,
  0x87, 0xC0, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x7C, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xF0, 0x7C, 0x7F,
  0xFF, 0x07, 0xC7, 0xFF, 0xE0, 0x7C, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x38, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3F,
  0x87, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0xC1, 0xFC, 0x07, 0xBE, 0x07,
  0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0x8F, 0x80, 0xFF, 0xF0, 0x78, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0xF8, 0xF8, 0x07, 0xE0, 0x1F, 0x1F, 0x00, 0xFC, 0x07, 0xC3, 0xE0,
  0x3F, 0x80, 0xF8, 0x7C, 0x07, 0xF0, 0x1F, 0x0F, 0x81, 0xEE, 0x07, 0xC1,
  0xF0, 0x39, 0xC0, 0xF8, 0x3E, 0x0F, 0x3C, 0x3E, 0x07, 0xC1, 0xC7, 0x87,
  0xC0, 0xF8, 0x78, 0xF0, 0xF8, 0x1F, 0x0F, 0x1E, 0x3E, 0x03, 0xE3, 0xC3,
  0xC7, 0xC0, 0x7C, 0x78, 0x78, 0xF8, 0x0F, 0x9E, 0x0F, 0x3E, 0x01, 0xF7,
  0xC1, 0xE7, 0xC0, 0x3E, 0xF0, 0x1C, 0xF0, 0x07, 0xDC, 0x03, 0xBE, 0x00,
  0xF7, 0x80, 0x7F, 0xC0, 0x1E, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x09, 0xFF, 0xFF, 0xC0, 0x73, 0xFF, 0xFF,
  0xFF, 0xE7, 0x00, 0xFF, 0xFF, 0xD8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00,
};

const GFXglyph LiberationMono_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 13, 39, 35, 12, -39 },
  { 65, 22, 18, 35, 11, -43 },
  { 115, 35, 39, 35, 1, -39 },
  { 286, 34, 48, 35, 1, -43 },
  { 490, 39, 41, 35, -1, -40 },
  { 690, 32, 41, 35, 0, -40 },
  { 854, 9, 18, 35, 17, -43 },
  { 875, 22, 55, 35, 9, -43 },
  { 1027, 22, 55, 35, 4, -43 },
  { 1179, 21, 21, 35, 11, -43 },
  { 1235, 29, 28, 35, 3, -34 },
  { 1337, 17, 19, 35, 2, -9 },
  { 1378, 17, 5, 35, 9, -17 },
  { 1389, 9, 9, 35, 11, -9 },
  { 1400, 37, 44, 35, 0, -43 },
  { 1604, 30, 41, 35, 3, -40 },
  { 1758, 29, 39, 35, 1, -39 },
  { 1900, 32, 40, 35, 1, -40 },
  { 2060, 30, 41, 35, 3, -40 },
  { 2214, 30, 39, 35, 2, -39 },
  { 2361, 32, 40, 35, 2, -39 },
  { 2521, 30, 41, 35, 4, -40 },
  { 2675, 27, 39, 35, 8, -39 },
  { 2807, 30, 41, 35, 3, -40 },
  { 2961, 30, 41, 35, 3, -40 },
  { 3115, 13, 31, 35, 11, -31 },
  { 3166, 19, 41, 35, 5, -31 },
  { 3264, 29, 30, 35, 3, -34 },
  { 3373, 29, 19, 35, 3, -29 },
  { 3442, 29, 30, 35, 3, -34 },
  { 3551, 29, 40, 35, 5, -40 },
  { 3696, 36, 50, 35, 0, -43 },
  { 3921, 35, 39, 35, -3, -39 },
  { 4092, 32, 39, 35, 2, -39 },
  { 4248, 32, 41, 35, 3, -40 },
  { 4412, 32, 39, 35, 2, -39 },
  { 4568, 34, 39, 35, 2, -39 },
  { 4734, 33, 39, 35, 3, -39 },
  { 4895, 32, 41, 35, 3, -40 },
  { 5059, 33, 39, 35, 2, -39 },
  { 5220, 31, 39, 35, 3, -39 },
  { 5372, 29, 40, 35, 4, -39 },
  { 5517, 36, 39, 35, 2, -39 },
  { 5693, 26, 39, 35, 4, -39 },
  { 5820, 35, 39, 35, 1, -39 },
  { 5991, 33, 39, 35, 2, -39 },
  { 6152, 31, 41, 35, 3, -40 },
  { 6311, 33, 39, 35, 2, -39 },
  { 6472, 31, 52, 35, 3, -40 },
  { 6674, 33, 39, 35, 2, -39 },
  { 6835, 33, 41, 35, 1, -40 },
  { 7005, 32, 39, 35, 6, -39 },
  { 7161, 33, 40, 35, 3, -39 },
  { 7326, 35, 39, 35, 5, -39 },
  { 7497, 37, 39, 35, 3, -39 },
  { 7678, 40, 39, 35, -2, -39 },
  { 7873, 33, 39, 35, 6, -39 },
  { 8034, 37, 39, 35, -1, -39 },
  { 8215, 27, 55, 35, 6, -43 },
  { 8401, 20, 44, 35, 9, -43 },
  { 8511, 27, 55, 35, 2, -43 },
  { 8697, 28, 26, 35, 3, -39 },
  { 8788, 36, 3, 35, -4, 4 },
  { 8802, 11, 7, 35, 17, -42 },
  { 8812, 29, 33, 35, 2, -32 },
  { 8932, 30, 44, 35, 2, -43 },
  { 9097, 29, 33, 35, 3, -32 },
  { 9217, 32, 44, 35, 3, -43 },
  { 9393, 29, 33, 35, 3, -32 },
  { 9513, 31, 43, 35, 6, -43 },
  { 9680, 31, 44, 35, 2, -32 },
  { 9851, 30, 43, 35, 2, -43 },
  { 10013, 29, 43, 35, 1, -43 },
  { 10169, 31, 55, 35, -2, -43 },
  { 10383, 31, 43, 35, 4, -43 },
  { 10550, 29, 43, 35, 1, -43 },
  { 10706, 34, 32, 35, 0, -32 },
  { 10842, 30, 32, 35, 2, -32 },
  { 10962, 29, 33, 35, 3, -32 },
  { 11082, 32, 44, 35, 0, -32 },
  { 11258, 30, 44, 35, 3, -32 },
  { 11423, 28, 32, 35, 5, -32 },
  { 11535, 28, 33, 35, 3, -32 },
  { 11651, 23, 40, 35, 8, -39 },
  { 11766, 29, 32, 35, 4, -31 },
  { 11882, 31, 31, 35, 5, -31 },
  { 12003, 35, 31, 35, 3, -31 },
  { 12139, 35, 31, 35, 0, -31 },
  { 12275, 36, 43, 35, 0, -31 },
  { 12469, 32, 31, 35, 1, -31 },
  { 12593, 30, 55, 35, 6, -43 },
  { 12800, 5, 55, 35, 15, -43 },
  { 12835, 30, 55, 35, -1, -43 },
  { 13042, 31, 7, 35, 3, -23 },
};

const GFXfont LiberationMono_Italic59pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic59pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic59pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _LIBERATIONMONO_ITALIC59PT7B_H_
