#ifndef _LIBERATIONMONO_ITALIC64PT7B_H_
#define _LIBERATIONMONO_ITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9,
  0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x78, 0xFF, 0x80, 0x7F, 0x03, 0xC1, 0xFC,
  0x03, 0xF0, 0x1E, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x07,
  0x80, 0xFC, 0x0F, 0x80, 0x78, 0x07, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0x80,
  0x00, 0x07, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0xF3, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0x00, 0x07, 0x83, 0xFC, 0x00,
  0x00, 0x78, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x07, 0x00,
  0x78, 0x03, 0xF1, 0xF8, 0x03, 0xC0, 0x1F, 0x8F, 0xC0, 0x1E, 0x00, 0xF8,
  0x7E, 0x00, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0x80, 0xFE, 0x0F, 0xE0, 0x78,
  0x1F, 0xE0, 0x7F, 0xE3, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0xC3, 0xF0,
  0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x1F,
  0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x1F,
  0x00, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x87, 0xC0, 0x00,
  0x3C, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0xF0, 0x00, 0x03, 0xF0,
  0xF8, 0x78, 0x00, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x78, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x3F, 0xFE, 0x00, 0x00, 0x1E,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC3, 0xC0,
  0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x00, 0x1E,
  0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0xC3, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0xFE, 0x00, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x07, 0x80, 0xFF, 0xF0, 0x01,
  0xF0, 0x3F, 0x3F, 0x00, 0x3E, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x7E,
  0x01, 0xF0, 0xFC, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xFC, 0x0F, 0x87, 0xE0,
  0x1F, 0x83, 0xE0, 0xF8, 0x01, 0xF8, 0x7C, 0x1F, 0x00, 0x3F, 0x1F, 0x07,
  0xE0, 0x03, 0xF3, 0xC0, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0x00, 0x07, 0xFE,
  0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0xFE, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xF8,
  0x3F, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0C, 0x07, 0x81, 0x9F, 0x0E,
  0x1F, 0x7F, 0x9D, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE7, 0x80,
  0x07, 0x8F, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x38, 0x01, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x9F, 0xCF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFD,
  0xFE, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F,
  0x7E, 0x07, 0xF0, 0x3F, 0x7C, 0x0F, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x7E,
  0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x7E,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0x8F, 0xC0, 0x07,
  0xFE, 0x1F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0x0F, 0xCF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x81, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0x00, 0x7C, 0x7F, 0xFF,
  0x81, 0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0x80, 0x03, 0xFE, 0x1F, 0xC0, 0x07,
  0xFE, 0x1F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0x7C, 0x07, 0xFF, 0xFE,
  0xFC, 0x03, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x81,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x3E, 0x03, 0xFC, 0x7B, 0xC0, 0x78, 0x1F, 0xFC, 0xE7, 0x81, 0xE0, 0x7C,
  0x3B, 0xCF, 0x03, 0xC1, 0xF0, 0x77, 0x9E, 0x0F, 0x07, 0xC0, 0x7E, 0x3C,
  0x1E, 0x0F, 0x00, 0xFC, 0x78, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0xF0, 0xF0,
  0x03, 0xE1, 0xE1, 0xE1, 0xE0, 0x07, 0xC3, 0xC7, 0x87, 0x80, 0x1F, 0x07,
  0x8F, 0x0F, 0x00, 0x3E, 0x0E, 0x1E, 0x3E, 0x00, 0x78, 0x3C, 0x78, 0x78,
  0x00, 0xF0, 0x78, 0xF0, 0xF0, 0x03, 0xE0, 0xF1, 0xE3, 0xC0, 0x07, 0x81,
  0xC3, 0xC7, 0x80, 0x0F, 0x07, 0x8F, 0x0F, 0x00, 0x3C, 0x0F, 0x1E, 0x3E,
  0x00, 0x78, 0x1C, 0x3C, 0x7C, 0x01, 0xF0, 0x78, 0x78, 0xF0, 0x03, 0xC0,
  0xF0, 0xF1, 0xE0, 0x0F, 0x81, 0xC1, 0xE3, 0xC0, 0x1F, 0x07, 0x87, 0x87,
  0x80, 0x7C, 0x0E, 0x0F, 0x0F, 0x00, 0xF8, 0x3C, 0x1E, 0x1E, 0x03, 0x70,
  0xF0, 0x3C, 0x3C, 0x0F, 0xE1, 0xC0, 0x78, 0x7C, 0x7B, 0xC7, 0x00, 0xF8,
  0x7F, 0xE7, 0xFC, 0x01, 0xF0, 0xFF, 0x87, 0xF0, 0x01, 0xE0, 0x7C, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0x07, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x02,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x8F, 0xE0, 0x0F,
  0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x00,
  0x3F, 0xFF, 0x8F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01,
  0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xC0,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF1, 0xFE, 0x00,
  0x00, 0x07, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0x00, 0x3F,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x00, 0x0F,
  0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x07,
  0xBE, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x1E, 0x7C, 0x07, 0xE7, 0xC0, 0xF9,
  0xF0, 0x1F, 0x1F, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x1F, 0x3E, 0x01, 0xF1,
  0xF0, 0xF8, 0xF8, 0x07, 0xC7, 0xC3, 0xC3, 0xE0, 0x1F, 0x0F, 0x1F, 0x0F,
  0x80, 0xF8, 0x3E, 0x78, 0x3E, 0x03, 0xE0, 0xFB, 0xE1, 0xF0, 0x0F, 0x83,
  0xEF, 0x07, 0xC0, 0x3E, 0x0F, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0xE0, 0x7C,
  0x07, 0xC0, 0x7F, 0x01, 0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x0F, 0xE0, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x3E, 0x01, 0xFF,
  0x80, 0x03, 0xE0, 0x3E, 0xF8, 0x00, 0x7E, 0x03, 0xEF, 0x80, 0x07, 0xE0,
  0x3E, 0xF8, 0x00, 0x7C, 0x03, 0xEF, 0xC0, 0x07, 0xC0, 0x3E, 0x7C, 0x00,
  0x7C, 0x03, 0xE7, 0xC0, 0x0F, 0xC0, 0x7E, 0x7E, 0x00, 0xFC, 0x07, 0xC3,
  0xE0, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x80,
  0x7C, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x01,
  0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x80,
  0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x3E, 0x01,
  0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x07, 0xC7,
  0xE0, 0x3F, 0x00, 0x7E, 0x7E, 0x03, 0xF0, 0x03, 0xE7, 0xC0, 0x3E, 0x00,
  0x3E, 0x7C, 0x03, 0xE0, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x3F, 0x7C, 0x07,
  0xE0, 0x01, 0xF7, 0xC0, 0x7E, 0x00, 0x1F, 0x7C, 0x07, 0xC0, 0x01, 0xFF,
  0x80, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x07, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x03, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x03, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x03, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xBC, 0x0F, 0x80, 0x7E, 0x0F, 0xBC, 0x0F, 0x80, 0x7C, 0x0F, 0x3C, 0x1F,
  0x80, 0x7C, 0x1F, 0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x3C, 0x1F, 0x00, 0x7C,
  0x3E, 0x3C, 0x1F, 0x00, 0x7C, 0x3E, 0x3C, 0x3E, 0x00, 0x7C, 0x3C, 0x3C,
  0x3E, 0x00, 0x7C, 0x7C, 0x3C, 0x3E, 0x00, 0x7C, 0x78, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x3E, 0x7C, 0x00, 0x7C, 0xF0, 0x3E, 0x7C, 0x00, 0x7D, 0xF0,
  0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x3E, 0xF8,
  0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3B, 0xE0, 0xFE,
  0x00, 0xF3, 0xF0, 0x7F, 0x03, 0xF3, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0x3F,
  0xFF, 0x83, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xFC,
  0x00, 0x1F, 0x87, 0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0xE0, 0x07, 0xCF, 0xFF,
  0xF8, 0x07, 0xEF, 0x81, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xC0,
  0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x03, 0xF0,
  0x3F, 0xF0, 0x07, 0xF0, 0x1F, 0xBC, 0x07, 0xF0, 0x0F, 0x9F, 0xFF, 0xF0,
  0x07, 0xC7, 0xFF, 0xF0, 0x07, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0xFF,
  0xFE, 0x3F, 0x00, 0x3F, 0xFF, 0xE7, 0xC0, 0x0F, 0xF0, 0x3E, 0xF8, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0x7C, 0x00, 0xFF, 0x03, 0xCF, 0x80, 0x1F, 0xFF, 0xF3,
  0xF0, 0x01, 0xFF, 0xFC, 0x7E, 0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x1F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x04, 0x07,
  0xE0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC1, 0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x01, 0xFF,
  0xFF, 0x3F, 0x00, 0xFF, 0x03, 0xEF, 0x80, 0x7F, 0x00, 0x7B, 0xE0, 0x3F,
  0x80, 0x0F, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x81,
  0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x0F, 0xF8,
  0x0F, 0xE0, 0x07, 0x7E, 0x01, 0xFE, 0x07, 0x9F, 0x00, 0x7F, 0xFF, 0xC7,
  0xC0, 0x0F, 0xFF, 0xE3, 0xF0, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x7F,
  0xF8, 0x01, 0xF1, 0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0xFE, 0x03, 0xF7, 0xC0,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x3F,
  0x80, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3E,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xC0, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x1F, 0xE0, 0xFF, 0x80, 0xF9, 0xFF, 0x0F, 0xFC, 0x07, 0xDF, 0xFC,
  0xFF, 0xF0, 0x3D, 0xC7, 0xEE, 0x1F, 0x81, 0xEC, 0x1F, 0x60, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7E, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x3E,
  0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0xFC, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x3E, 0x01,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0xFC, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0xFC,
  0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x7F, 0xF8, 0x01, 0xF1, 0xFF,
  0xFE, 0x03, 0xF3, 0xFF, 0xFE, 0x03, 0xF7, 0xC0, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x83, 0xFF, 0xC0, 0x01, 0xF1, 0xFF, 0xFC, 0x00, 0x3E,
  0x7F, 0xFF, 0xC0, 0x0F, 0xDF, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0xFD, 0xE0, 0x3F, 0x80, 0x1F, 0xBF, 0xFF, 0xF0, 0x03, 0xF3, 0xFF,
  0xF8, 0x00, 0x7C, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xC0,
  0x1F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0xE0, 0x7D, 0xF0,
  0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xC0, 0x01, 0xFE,
  0x0F, 0xC0, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xEF, 0x80, 0x7F,
  0x83, 0xEF, 0xC0, 0x3F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xE3, 0xF0, 0x03,
  0xFF, 0xE1, 0xF0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x1F, 0x01, 0xFF, 0xF0, 0x7C, 0x0F, 0xFF, 0xC1, 0xF0, 0xFF, 0xFE,
  0x07, 0xC7, 0xFF, 0xF8, 0x1F, 0x1F, 0x80, 0x20, 0x7C, 0xF8, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x07, 0xDC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0,
  0xFE, 0x00, 0x77, 0xC0, 0x7F, 0x81, 0xF7, 0xC0, 0x7F, 0xFF, 0xE7, 0xC0,
  0x3F, 0xFF, 0x87, 0xC0, 0x1F, 0xFF, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x07, 0xE1,
  0xF0, 0x0F, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x80, 0x7C, 0x1F, 0x01, 0xFE,
  0x03, 0xF0, 0x7C, 0x07, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0xE0, 0x3E, 0x07,
  0xC0, 0xF7, 0x81, 0xF8, 0x1F, 0x07, 0xDE, 0x07, 0xC0, 0x7C, 0x1E, 0x7C,
  0x1F, 0x03, 0xF0, 0xF9, 0xF0, 0xFC, 0x0F, 0xC3, 0xC3, 0xC3, 0xE0, 0x3F,
  0x1F, 0x0F, 0x0F, 0x80, 0xFC, 0x78, 0x3C, 0x7E, 0x03, 0xF3, 0xE0, 0xF1,
  0xF0, 0x0F, 0xCF, 0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x0F, 0x3E, 0x00, 0xF9,
  0xE0, 0x3C, 0xF8, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x0F, 0xBC, 0x03, 0xDF,
  0x00, 0x3E, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
};

const GFXglyph LiberationMono_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 14, 42, 38, 13, -42 },
  { 75, 23, 20, 38, 12, -46 },
  { 133, 38, 42, 38, 1, -42 },
  { 333, 37, 51, 38, 1, -46 },
  { 569, 42, 44, 38, -1, -43 },
  { 800, 35, 44, 38, 0, -43 },
  { 993, 9, 20, 38, 19, -46 },
  { 1016, 24, 59, 38, 10, -46 },
  { 1193, 24, 59, 38, 5, -46 },
  { 1370, 23, 22, 38, 11, -46 },
  { 1434, 31, 31, 38, 4, -37 },
  { 1555, 17, 21, 38, 3, -9 },
  { 1600, 18, 5, 38, 10, -20 },
  { 1612, 9, 9, 38, 12, -9 },
  { 1623, 41, 47, 38, 0, -46 },
  { 1864, 32, 44, 38, 4, -43 },
  { 2040, 31, 42, 38, 2, -42 },
  { 2203, 35, 43, 38, 1, -43 },
  { 2392, 33, 44, 38, 3, -43 },
  { 2574, 33, 42, 38, 2, -42 },
  { 2748, 34, 43, 38, 3, -42 },
  { 2931, 31, 44, 38, 5, -43 },
  { 3102, 29, 42, 38, 9, -42 },
  { 3255, 33, 44, 38, 3, -43 },
  { 3437, 32, 44, 38, 4, -43 },
  { 3613, 14, 34, 38, 12, -34 },
  { 3673, 21, 46, 38, 5, -34 },
  { 3794, 31, 32, 38, 4, -37 },
  { 3918, 31, 20, 38, 4, -31 },
  { 3996, 31, 32, 38, 4, -37 },
  { 4120, 32, 43, 38, 5, -43 },
  { 4292, 39, 55, 38, 0, -46 },
  { 4561, 38, 42, 38, -3, -42 },
  { 4761, 35, 42, 38, 2, -42 },
  { 4945, 34, 44, 38, 4, -43 },
  { 5132, 35, 42, 38, 2, -42 },
  { 5316, 37, 42, 38, 2, -42 },
  { 5511, 36, 42, 38, 3, -42 },
  { 5700, 34, 44, 38, 4, -43 },
  { 5887, 36, 42, 38, 2, -42 },
  { 6076, 34, 42, 38, 3, -42 },
  { 6255, 32, 43, 38, 4, -42 },
  { 6427, 39, 42, 38, 2, -42 },
  { 6632, 28, 42, 38, 4, -42 },
  { 6779, 38, 42, 38, 1, -42 },
  { 6979, 36, 42, 38, 2, -42 },
  { 7168, 34, 44, 38, 3, -43 },
  { 7355, 36, 42, 38, 2, -42 },
  { 7544, 34, 56, 38, 3, -43 },
  { 7782, 36, 42, 38, 2, -42 },
  { 7971, 36, 44, 38, 1, -43 },
  { 8169, 35, 42, 38, 6, -42 },
  { 8353, 36, 43, 38, 3, -42 },
  { 8547, 38, 42, 38, 5, -42 },
  { 8747, 40, 42, 38, 3, -42 },
  { 8957, 43, 42, 38, -2, -42 },
  { 9183, 36, 42, 38, 6, -42 },
  { 9372, 41, 42, 38, -1, -42 },
  { 9588, 29, 59, 38, 7, -46 },
  { 9802, 22, 47, 38, 9, -46 },
  { 9932, 28, 59, 38, 3, -46 },
  { 10139, 30, 28, 38, 4, -42 },
  { 10244, 40, 3, 38, -5, 4 },
  { 10259, 12, 8, 38, 18, -46 },
  { 10271, 32, 36, 38, 2, -35 },
  { 10415, 33, 47, 38, 2, -46 },
  { 10609, 32, 36, 38, 3, -35 },
  { 10753, 35, 47, 38, 3, -46 },
  { 10959, 31, 36, 38, 4, -35 },
  { 11099, 33, 46, 38, 7, -46 },
  { 11289, 34, 48, 38, 2, -35 },
  { 11493, 32, 46, 38, 2, -46 },
  { 11677, 32, 46, 38, 1, -46 },
  { 11861, 34, 59, 38, -2, -46 },
  { 12112, 34, 46, 38, 4, -46 },
  { 12308, 31, 46, 38, 1, -46 },
  { 12487, 37, 35, 38, 0, -35 },
  { 12649, 32, 35, 38, 2, -35 },
  { 12789, 32, 36, 38, 3, -35 },
  { 12933, 35, 48, 38, 0, -35 },
  { 13143, 33, 48, 38, 3, -35 },
  { 13341, 30, 35, 38, 6, -35 },
  { 13473, 31, 36, 38, 3, -35 },
  { 13613, 26, 44, 38, 8, -43 },
  { 13756, 32, 35, 38, 4, -34 },
  { 13896, 35, 34, 38, 5, -34 },
  { 14045, 38, 34, 38, 3, -34 },
  { 14207, 38, 34, 38, 0, -34 },
  { 14369, 41, 47, 38, -1, -34 },
  { 14610, 35, 34, 38, 1, -34 },
  { 14759, 32, 59, 38, 7, -46 },
  { 14995, 5, 59, 38, 17, -46 },
  { 15032, 33, 59, 38, -1, -46 },
  { 15276, 32, 8, 38, 4, -25 },
};

const GFXfont LiberationMono_Italic64pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic64pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic64pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _LIBERATIONMONO_ITALIC64PT7B_H_
