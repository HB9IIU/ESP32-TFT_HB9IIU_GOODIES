#ifndef _LIBERATIONMONO_ITALIC32PT7B_H_
#define _LIBERATIONMONO_ITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0x38, 0x30, 0x00, 0x00, 0x00, 0x70, 0x70, 0x70, 0x78, 0xF7,
  0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC,
  0x18, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x08,
  0x18, 0x03, 0x02, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0x06, 0x00, 0x40,
  0xC0, 0x18, 0x10, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE0, 0xC0, 0xC0, 0x18, 0x30, 0x02, 0x06, 0x00, 0xC1, 0x80, 0x10, 0x30,
  0x06, 0x04, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0x8D, 0xE1, 0xC7, 0x1C, 0x61, 0x87, 0x38, 0x61, 0xCE,
  0x18, 0x01, 0xC6, 0x00, 0x79, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0D,
  0xF0, 0x03, 0x1C, 0x00, 0xC3, 0x80, 0x60, 0xEC, 0x18, 0x33, 0x86, 0x1C,
  0xE1, 0x87, 0x3C, 0x67, 0x87, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x07, 0x80, 0x30, 0xFE, 0x03, 0x0E, 0x38, 0x30,
  0x61, 0xC3, 0x03, 0x0E, 0x38, 0x38, 0x63, 0x81, 0xC3, 0x38, 0x0E, 0x39,
  0x80, 0x71, 0x98, 0x01, 0xFD, 0x80, 0x07, 0x99, 0xE0, 0x01, 0xBF, 0x80,
  0x19, 0x8E, 0x01, 0x9C, 0x70, 0x1C, 0xC3, 0x81, 0xC6, 0x1C, 0x0C, 0x70,
  0xC0, 0xC3, 0x86, 0x0C, 0x0C, 0x70, 0xC0, 0x7F, 0x0C, 0x01, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0xF1, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x38,
  0x38, 0x0C, 0x38, 0x06, 0x78, 0x03, 0xF0, 0x03, 0xC0, 0xC7, 0xE0, 0xE7,
  0x38, 0x67, 0x1C, 0x33, 0x07, 0x33, 0x83, 0xB9, 0xC0, 0xF8, 0xE0, 0x7C,
  0x70, 0x1E, 0x3C, 0x3F, 0x8F, 0xF9, 0xF3, 0xF0, 0x78, 0x3B, 0xDE, 0xE7,
  0x39, 0xCC, 0x67, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x06, 0x00,
  0xC0, 0x18, 0x23, 0x1F, 0x6E, 0xFF, 0x87, 0xC0, 0xF0, 0x33, 0x0C, 0x61,
  0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x87, 0x83, 0x83,
  0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x60, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7B, 0x9D, 0xEF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x63, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC6, 0xE3, 0xCE, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x18,
  0xE0, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xE0, 0x1F, 0xC1, 0xF3, 0x83, 0x87, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFC, 0x01, 0xFF, 0x81, 0xC1, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0xFC, 0x01,
  0xFF, 0x81, 0xC1, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x0E, 0xF0, 0x0E, 0x38, 0x0F, 0x1E,
  0x0F, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x36, 0x00, 0x6E, 0x00, 0xCE, 0x01, 0xCE, 0x03, 0x8E, 0x07, 0x0C,
  0x0E, 0x1C, 0x0C, 0x1C, 0x18, 0x1C, 0x30, 0x1C, 0x60, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x33, 0xF0, 0x1F, 0xFC, 0x1F, 0x0F, 0x0E, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x0E,
  0x78, 0x0E, 0x1E, 0x1E, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xFE, 0x07, 0x0F, 0x0E, 0x07, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x31,
  0xF0, 0x77, 0xFC, 0x7C, 0x3C, 0x78, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x38, 0x78, 0x70, 0x3F,
  0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81,
  0xC1, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E,
  0x0E, 0x0E, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0x83, 0xC3, 0x80, 0xE3, 0x80,
  0x39, 0xC0, 0x1D, 0xC0, 0x0C, 0xE0, 0x0E, 0x38, 0x0F, 0x1E, 0x0F, 0x07,
  0xFF, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x1E, 0x1C, 0x0F,
  0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F,
  0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xEE, 0x0F, 0x8E, 0x00, 0x1C, 0x00, 0x1C,
  0xE0, 0x38, 0xE0, 0x70, 0xF0, 0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x1E, 0x3C,
  0x78, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8E, 0x1C, 0x78,
  0xF0, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x0E, 0x07,
  0x01, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x06, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00,
  0x80, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0xF0, 0x7B, 0xC0, 0x77, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01,
  0xE1, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x39, 0xB1,
  0x8F, 0xD3, 0x19, 0xC7, 0x33, 0x18, 0x73, 0x33, 0x06, 0x66, 0x70, 0x66,
  0x66, 0x0C, 0x66, 0x60, 0xC6, 0x6C, 0x0C, 0xCC, 0xC1, 0x8C, 0xCC, 0x38,
  0xCC, 0xC3, 0x18, 0xCC, 0x53, 0x0C, 0xF9, 0xF0, 0xC7, 0x1C, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x40, 0x38, 0x3C, 0x03, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xB0,
  0x00, 0x3B, 0x80, 0x07, 0x38, 0x00, 0x63, 0x80, 0x0E, 0x38, 0x00, 0xC1,
  0x80, 0x1C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x87,
  0x01, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0x01, 0xE3, 0x80, 0x73, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0xB8, 0x07, 0x9F,
  0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80,
  0xE3, 0xC0, 0x39, 0xC0, 0x19, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x11,
  0xC0, 0x1C, 0xE0, 0x1C, 0x78, 0x1E, 0x1E, 0x1E, 0x07, 0xFC, 0x00, 0xF8,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0x07, 0xC3, 0x80, 0xF1, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x70,
  0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF1, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xC3, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x19, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x7F, 0xB8, 0x3F, 0x9C, 0x01, 0xCE,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x78, 0x0E,
  0x1E, 0x1F, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0x71,
  0xE0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x38, 0x07, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x1C, 0x30, 0x07,
  0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8E,
  0x01, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xF0,
  0x70, 0x70, 0xE0, 0x7F, 0xC0, 0x1F, 0x00, 0x0E, 0x01, 0xE1, 0xC0, 0x78,
  0x70, 0x1E, 0x0E, 0x07, 0x81, 0xC1, 0xE0, 0x38, 0x70, 0x07, 0x1C, 0x00,
  0xC7, 0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x70, 0x03,
  0xCF, 0x00, 0xF0, 0xE0, 0x1C, 0x1E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E,
  0x03, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x8E, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0x00,
  0xF0, 0xF0, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0D, 0x87, 0xE1, 0xD8,
  0x6E, 0x1D, 0x8E, 0xC1, 0xDC, 0xCC, 0x19, 0xDD, 0xC1, 0x9D, 0x9C, 0x38,
  0xF1, 0xC3, 0x8F, 0x18, 0x38, 0xE1, 0x83, 0x0E, 0x38, 0x30, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0x0F, 0x01, 0xC3, 0xC0, 0x71, 0xF0, 0x1C, 0x7C, 0x06,
  0x1F, 0x81, 0x87, 0xE0, 0xE1, 0x98, 0x38, 0x66, 0x0E, 0x39, 0xC3, 0x0E,
  0x70, 0xC3, 0x8C, 0x70, 0xC3, 0x9C, 0x30, 0xE7, 0x1C, 0x39, 0x87, 0x06,
  0x61, 0xC1, 0xF8, 0x60, 0x7E, 0x18, 0x1F, 0x8E, 0x03, 0xE3, 0x80, 0xF0,
  0xE0, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0xE1, 0xC0, 0x78, 0x70, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x1C, 0x60, 0x0E, 0x38, 0x07, 0x8E, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x70, 0x7F,
  0xE0, 0x1F, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xE1, 0xC0, 0x7C,
  0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x38,
  0x03, 0x8E, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x38, 0x70, 0x1C, 0x1C,
  0x07, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x1C, 0x07, 0x0E, 0x01, 0xE3,
  0x80, 0x38, 0xE0, 0x0F, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x78,
  0x70, 0x0E, 0x1C, 0x03, 0xC7, 0x00, 0x61, 0xC0, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8F, 0x83, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x1C, 0x3C, 0x1C, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x03, 0x80,
  0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x1B,
  0x80, 0x06, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE,
  0x00, 0x1C, 0xE1, 0xC1, 0x8E, 0x1C, 0x38, 0xE3, 0xC3, 0x8E, 0x3C, 0x30,
  0xE7, 0xE7, 0x0E, 0x6E, 0x70, 0xEE, 0xE6, 0x0E, 0xCE, 0xE0, 0xCC, 0x6E,
  0x0D, 0x86, 0xC0, 0xD8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xE0, 0x70, 0x00, 0x07, 0x00, 0x38, 0x3C, 0x03, 0x80, 0xE0, 0x38,
  0x07, 0x03, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x03, 0x9C, 0x00, 0x1D,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x38, 0x38, 0x1C, 0x0E,
  0x0F, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0xC3, 0x03, 0x86, 0x06,
  0x0C, 0x1C, 0x1C, 0x30, 0x38, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xD8, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3, 0x87, 0x01, 0xF8, 0x07,
  0xFE, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07,
  0xFE, 0x1F, 0xFE, 0x3C, 0x0C, 0x70, 0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x7C, 0xF0, 0xDC, 0x7F, 0x9F, 0x3E, 0x0F, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x7C, 0x1D, 0xFE, 0x1F,
  0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x6C,
  0x38, 0x6F, 0xF8, 0xE3, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x1E, 0x1E, 0x38,
  0x0E, 0x70, 0x0F, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x70, 0x7F,
  0xE0, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x1F, 0x9C, 0x1F, 0xEE, 0x1C, 0x3F, 0x1C, 0x0F,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x0F, 0x0F, 0x0F, 0x83,
  0xFD, 0xC0, 0xF8, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x79, 0xC0, 0x77,
  0x00, 0xEE, 0x01, 0xDC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x01, 0x9C, 0x07, 0x1C, 0x1C, 0x3F, 0xF0, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x01, 0xFF, 0xF9, 0xFF, 0xFC, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x03, 0xF3, 0x83, 0xFD, 0xC3, 0x86, 0xE3, 0x81, 0xE3, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x81, 0xE1, 0xE1, 0xF0, 0x7F, 0xB8, 0x1F,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x1C, 0x07, 0x0F, 0x07, 0x03, 0x87, 0x81,
  0xFF, 0x80, 0x3F, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x7C, 0x1D, 0xFE, 0x1F, 0x0F, 0x1E, 0x07,
  0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E,
  0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0x1C,
  0xE0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x10, 0x38, 0x0F, 0xF8, 0x07,
  0xF0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x1C, 0x0C, 0x1C, 0x0E,
  0x3C, 0x07, 0x3C, 0x03, 0xBC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFB, 0x80,
  0x79, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x0E, 0x06, 0x07, 0x87, 0x01,
  0xC3, 0x80, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x7F, 0xFF, 0x7F,
  0xFF, 0x19, 0xE3, 0xC6, 0xF9, 0xF1, 0xE6, 0x9C, 0x71, 0xC3, 0x38, 0x70,
  0xCE, 0x1C, 0x33, 0x86, 0x1C, 0xE3, 0x87, 0x30, 0xE1, 0xDC, 0x38, 0x67,
  0x0E, 0x19, 0xC3, 0x0E, 0x70, 0xC3, 0x98, 0x70, 0xEE, 0x1C, 0x33, 0x87,
  0x0C, 0xE1, 0x87, 0x00, 0x1C, 0x7C, 0x1D, 0xFF, 0x1F, 0x0F, 0x1E, 0x07,
  0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38, 0x0E,
  0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0x1C,
  0xE0, 0x1C, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x79, 0xC0, 0x77, 0x00, 0xEE,
  0x01, 0xDC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xEE, 0x01, 0xDC, 0x07, 0x1C, 0x1C, 0x3F, 0xF0, 0x1F, 0x80, 0x0E, 0x3E,
  0x07, 0x7F, 0x83, 0xE1, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0xE3,
  0x80, 0x71, 0xE0, 0x70, 0xD8, 0x78, 0x6F, 0xF8, 0x71, 0xF0, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x07, 0xE7, 0x0F, 0xF7, 0x1C, 0x36, 0x38, 0x1E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x78, 0xF0, 0xF8, 0x7F, 0xB8, 0x3E, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x38, 0x7E, 0x73, 0xFC, 0xEF, 0xF9, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x1F,
  0xF8, 0x70, 0x39, 0xC0, 0x73, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xEC, 0x01, 0xDC, 0x03, 0x3C,
  0x1E, 0x3F, 0xF8, 0x3F, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x0F,
  0xFF, 0xFF, 0xF8, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xFF, 0xC3, 0xFC, 0x00, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E,
  0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x78, 0xF0, 0xF8, 0x7F, 0xB8,
  0x3E, 0x38, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9E, 0x01, 0xC7, 0x01,
  0xC3, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x70, 0x0E,
  0x30, 0x07, 0x38, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01,
  0xCE, 0x00, 0x39, 0xC3, 0x87, 0x38, 0xF1, 0xC6, 0x1E, 0x38, 0xC6, 0xC6,
  0x19, 0xD9, 0xC3, 0x33, 0x38, 0x6E, 0x76, 0x0D, 0x87, 0xC1, 0xF0, 0xF8,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x00, 0x0E, 0x01, 0xE1, 0xC0,
  0x78, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0x9C,
  0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0xC0, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x06, 0x0E, 0x00,
  0x71, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x03, 0x30, 0x00, 0x37, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xF8, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0xFF, 0xC3, 0xC3, 0xFF, 0x00, 0x7C,
};

const GFXglyph LiberationMono_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 21, 19, 6, -21 },
  { 22, 12, 10, 19, 6, -23 },
  { 37, 19, 21, 19, 0, -21 },
  { 87, 18, 27, 19, 1, -24 },
  { 148, 21, 21, 19, 0, -21 },
  { 204, 17, 21, 19, 0, -21 },
  { 249, 5, 10, 19, 9, -23 },
  { 256, 12, 30, 19, 5, -23 },
  { 301, 12, 30, 19, 2, -23 },
  { 346, 11, 11, 19, 6, -23 },
  { 362, 15, 16, 19, 2, -19 },
  { 392, 9, 10, 19, 1, -5 },
  { 404, 9, 3, 19, 5, -9 },
  { 408, 5, 5, 19, 6, -5 },
  { 412, 20, 23, 19, 0, -23 },
  { 470, 16, 21, 19, 2, -21 },
  { 512, 15, 21, 19, 1, -21 },
  { 552, 17, 21, 19, 1, -21 },
  { 597, 17, 21, 19, 1, -21 },
  { 642, 16, 21, 19, 1, -21 },
  { 684, 17, 21, 19, 1, -21 },
  { 729, 16, 21, 19, 2, -21 },
  { 771, 15, 21, 19, 4, -21 },
  { 811, 17, 21, 19, 1, -21 },
  { 856, 16, 21, 19, 2, -21 },
  { 898, 7, 17, 19, 6, -17 },
  { 913, 10, 22, 19, 3, -17 },
  { 941, 15, 17, 19, 2, -19 },
  { 973, 15, 9, 19, 2, -15 },
  { 990, 15, 17, 19, 2, -19 },
  { 1022, 15, 21, 19, 3, -21 },
  { 1062, 20, 27, 19, 0, -23 },
  { 1130, 20, 21, 19, -2, -21 },
  { 1183, 17, 21, 19, 1, -21 },
  { 1228, 17, 21, 19, 2, -21 },
  { 1273, 17, 21, 19, 1, -21 },
  { 1318, 18, 21, 19, 1, -21 },
  { 1366, 18, 21, 19, 1, -21 },
  { 1414, 17, 21, 19, 2, -21 },
  { 1459, 18, 21, 19, 1, -21 },
  { 1507, 16, 21, 19, 2, -21 },
  { 1549, 16, 21, 19, 2, -21 },
  { 1591, 19, 21, 19, 1, -21 },
  { 1641, 14, 21, 19, 2, -21 },
  { 1678, 20, 21, 19, 0, -21 },
  { 1731, 18, 21, 19, 1, -21 },
  { 1779, 16, 21, 19, 2, -21 },
  { 1821, 18, 21, 19, 1, -21 },
  { 1869, 16, 28, 19, 2, -21 },
  { 1925, 18, 21, 19, 1, -21 },
  { 1973, 18, 21, 19, 1, -21 },
  { 2021, 17, 21, 19, 3, -21 },
  { 2066, 17, 21, 19, 2, -21 },
  { 2111, 18, 21, 19, 3, -21 },
  { 2159, 20, 21, 19, 2, -21 },
  { 2212, 21, 21, 19, -1, -21 },
  { 2268, 18, 21, 19, 3, -21 },
  { 2316, 21, 21, 19, -1, -21 },
  { 2372, 15, 30, 19, 3, -23 },
  { 2429, 11, 23, 19, 5, -23 },
  { 2461, 15, 30, 19, 1, -23 },
  { 2518, 15, 14, 19, 2, -21 },
  { 2545, 19, 2, 19, -2, 2 },
  { 2550, 6, 4, 19, 9, -23 },
  { 2553, 16, 17, 19, 1, -17 },
  { 2587, 16, 23, 19, 1, -23 },
  { 2633, 16, 17, 19, 2, -17 },
  { 2667, 17, 23, 19, 2, -23 },
  { 2716, 15, 17, 19, 2, -17 },
  { 2748, 17, 23, 19, 3, -23 },
  { 2797, 17, 24, 19, 1, -17 },
  { 2848, 16, 23, 19, 1, -23 },
  { 2894, 15, 23, 19, 1, -23 },
  { 2938, 17, 30, 19, -1, -23 },
  { 3002, 17, 23, 19, 2, -23 },
  { 3051, 16, 23, 19, 0, -23 },
  { 3097, 18, 17, 19, 0, -17 },
  { 3136, 16, 17, 19, 1, -17 },
  { 3170, 15, 17, 19, 2, -17 },
  { 3202, 17, 24, 19, 0, -17 },
  { 3253, 16, 24, 19, 2, -17 },
  { 3301, 15, 17, 19, 3, -17 },
  { 3333, 15, 17, 19, 2, -17 },
  { 3365, 13, 21, 19, 4, -21 },
  { 3400, 16, 17, 19, 2, -17 },
  { 3434, 17, 17, 19, 3, -17 },
  { 3471, 19, 17, 19, 2, -17 },
  { 3512, 19, 17, 19, 0, -17 },
  { 3553, 20, 24, 19, 0, -17 },
  { 3613, 17, 17, 19, 1, -17 },
  { 3650, 16, 30, 19, 3, -23 },
  { 3710, 3, 30, 19, 8, -23 },
  { 3722, 16, 30, 19, 0, -23 },
  { 3782, 16, 4, 19, 2, -13 },
};

const GFXfont LiberationMono_Italic32pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic32pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic32pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _LIBERATIONMONO_ITALIC32PT7B_H_
