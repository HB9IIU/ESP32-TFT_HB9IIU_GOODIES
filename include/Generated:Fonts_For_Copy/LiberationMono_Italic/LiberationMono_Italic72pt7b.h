#ifndef _LIBERATIONMONO_ITALIC72PT7B_H_
#define _LIBERATIONMONO_ITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0x3F, 0xF0, 0x01, 0xFE, 0x07, 0x81, 0xFE,
  0x00, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xF8, 0x03,
  0xC0, 0x1C, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xBE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xF3, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x3F, 0x80, 0xC0, 0x03, 0xC0, 0x0F, 0xC3, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x81, 0xFC, 0x01, 0xE0, 0x0F, 0xE0,
  0x7F, 0x80, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x3E, 0x07, 0xF8, 0x03, 0xFF,
  0x8F, 0x8F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x87, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x87, 0xE1, 0xFC, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFF,
  0x00, 0x00, 0x0F, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x01,
  0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xFB, 0xF0, 0x00, 0xF8, 0x1F, 0xC7, 0xE0,
  0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x07, 0xC1, 0xFC, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x1F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3F,
  0x81, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0x81,
  0xF8, 0x00, 0x7E, 0x3E, 0x07, 0xE0, 0x00, 0xFE, 0xFC, 0x0F, 0xC0, 0x00,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xFC,
  0x07, 0xFC, 0x07, 0xFB, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0xF0, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC,
  0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x3C, 0x06, 0x3E, 0x1E, 0x0F, 0x9F,
  0xF7, 0x9F, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x3F,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x70, 0x07, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0x3F, 0xCF, 0xF7, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7,
  0xFB, 0xFE, 0xFF, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x1F, 0xE0, 0x3F,
  0x1F, 0x80, 0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F,
  0xC0, 0xFE, 0x7F, 0x03, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x3F, 0x1F,
  0x80, 0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0xC0,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xC0, 0x01, 0xFF, 0xF9,
  0xF8, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x07, 0xFE, 0x0F, 0xE0, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xE0, 0x00,
  0x00, 0x3E, 0x7F, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x00, 0x7E, 0x3F, 0xFF,
  0x80, 0x01, 0xFB, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3E, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0x83, 0xFF, 0xF0, 0x01, 0xF8, 0xFF, 0xFF,
  0x80, 0x3F, 0x1F, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0x00, 0x1F, 0x7E, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0xFC, 0x03, 0xFF, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0xF0, 0xFC, 0x00, 0x7F,
  0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0xFC, 0x3D, 0xF0, 0x0F, 0x80,
  0xFF, 0xE7, 0xCF, 0x01, 0xF0, 0x1F, 0xFE, 0x78, 0xF0, 0x1F, 0x03, 0xF0,
  0xF7, 0x8F, 0x03, 0xE0, 0x7C, 0x07, 0xF0, 0xF0, 0x3C, 0x0F, 0x80, 0x7F,
  0x0F, 0x07, 0xC1, 0xF0, 0x07, 0xF0, 0xF0, 0x7C, 0x1F, 0x00, 0x7E, 0x0F,
  0x07, 0x83, 0xE0, 0x07, 0xE1, 0xF0, 0xF8, 0x3C, 0x00, 0x7E, 0x1F, 0x0F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x1F, 0x0F,
  0x80, 0x0F, 0x81, 0xE1, 0xE0, 0xF0, 0x00, 0xF8, 0x1E, 0x1E, 0x1F, 0x00,
  0x0F, 0x83, 0xE3, 0xE1, 0xF0, 0x01, 0xF0, 0x3C, 0x3E, 0x1E, 0x00, 0x1F,
  0x03, 0xC3, 0xC3, 0xE0, 0x01, 0xE0, 0x3C, 0x3C, 0x3E, 0x00, 0x3E, 0x07,
  0xC7, 0xC3, 0xC0, 0x03, 0xE0, 0x78, 0x7C, 0x7C, 0x00, 0x3C, 0x07, 0x87,
  0xC7, 0xC0, 0x07, 0xC0, 0xF8, 0x78, 0x7C, 0x00, 0x7C, 0x0F, 0x07, 0x87,
  0xC0, 0x0F, 0x80, 0xF0, 0x78, 0x7C, 0x00, 0xF8, 0x1E, 0x07, 0x87, 0xC0,
  0x1F, 0x81, 0xE0, 0xF8, 0x7C, 0x03, 0xF0, 0x3C, 0x0F, 0x87, 0xC0, 0x3F,
  0x03, 0xC0, 0xF8, 0x7C, 0x07, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0xEF, 0x0F,
  0x80, 0xF8, 0x7E, 0x3E, 0xF1, 0xF0, 0x0F, 0x83, 0xFF, 0xCF, 0xFE, 0x00,
  0x78, 0x3F, 0xF8, 0xFF, 0xC0, 0x07, 0x81, 0xFE, 0x07, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0xC0,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0x01, 0xFC,
  0x00, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x07, 0xF0, 0x00,
  0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x02, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFC, 0x7F, 0x00,
  0x1F, 0xFF, 0xF1, 0xFC, 0x00, 0xFF, 0xFF, 0x87, 0xF0, 0x03, 0xFF, 0xFE,
  0x3F, 0x80, 0x0F, 0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00,
  0x01, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF1, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF7, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01,
  0xFB, 0xE0, 0x03, 0xEF, 0xC0, 0x3F, 0x7C, 0x00, 0x7D, 0xF0, 0x07, 0xEF,
  0x80, 0x1F, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x3F, 0x00,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xC7,
  0xC0, 0x1F, 0x8F, 0x81, 0xF9, 0xF8, 0x03, 0xE1, 0xF0, 0x3E, 0x3F, 0x00,
  0x7C, 0x3F, 0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x8F, 0x87, 0xE0, 0x0F, 0x81, 0xF3,
  0xE0, 0xFC, 0x01, 0xF0, 0x3E, 0x7C, 0x1F, 0x80, 0x7E, 0x07, 0xDF, 0x03,
  0xF0, 0x0F, 0xC0, 0xFB, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0x80,
  0x3F, 0x01, 0xFF, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x0F, 0xE0,
  0x0F, 0x8F, 0xC0, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0x0F,
  0xC0, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0x00, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xF8,
  0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF8,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFB, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x03, 0xF0, 0x7C, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xE7, 0xC0, 0xF8, 0x01, 0xF8, 0x3E, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF1, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8,
  0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC1, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x0F,
  0x8F, 0x80, 0x07, 0xE7, 0xE0, 0x7C, 0xFC, 0x00, 0x3F, 0x3E, 0x03, 0xE7,
  0xE0, 0x01, 0xF9, 0xF0, 0x1F, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0xFB, 0xF0,
  0x00, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xE0, 0x03, 0xF0, 0x3F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x00,
  0x1F, 0xE1, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x01, 0xFF, 0x07, 0xE0,
  0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x1E, 0xFC, 0x1F, 0xC0, 0x0F, 0x9F, 0x83,
  0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x17, 0xFF, 0xFE, 0x0F,
  0xFE, 0x7F, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xF8, 0x3F, 0xFF, 0x00, 0x1F, 0x87,
  0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0x78, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0xFE,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xF0, 0x03, 0xFC, 0x07, 0xEF, 0x80,
  0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xFE, 0x00, 0xFC,
  0x3F, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x03, 0xFF,
  0xE0, 0xFC, 0x00, 0x1F, 0xFF, 0xF1, 0xF8, 0x00, 0x7F, 0xFF, 0xE7, 0xF0,
  0x01, 0xFF, 0xFF, 0xEF, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xBF, 0x00, 0x3F, 0xE0, 0x3F, 0x7E, 0x00, 0x7F, 0xFF, 0xFD, 0xFC, 0x00,
  0x7F, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0xFF, 0x87, 0xE0, 0x00, 0x7F, 0xFE,
  0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x60, 0x3F, 0xC0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x1F, 0x80, 0x0F, 0xFF, 0xFC, 0x7E, 0x00,
  0x7F, 0xFF, 0xF9, 0xF8, 0x03, 0xFE, 0x07, 0xEF, 0xE0, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0xFD, 0xF8, 0x01, 0xFF, 0xFF,
  0xE7, 0xE0, 0x07, 0xFF, 0xFF, 0x1F, 0x80, 0x0F, 0xFF, 0xF0, 0xFE, 0x00,
  0x1F, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xC0,
  0x01, 0xF8, 0x3F, 0xFF, 0x00, 0x1F, 0x87, 0xFF, 0xF8, 0x01, 0xF9, 0xFF,
  0xFF, 0xC0, 0x1F, 0xBF, 0xFF, 0xFE, 0x03, 0xF7, 0xF0, 0x3F, 0xE0, 0x3F,
  0x78, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x00,
  0x3F, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0x1F,
  0xF8, 0x7F, 0xF8, 0x07, 0xCF, 0xFF, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xCF,
  0xFF, 0x80, 0xFF, 0xC7, 0xF7, 0x8F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0xF0, 0x01, 0xF8, 0x7F,
  0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFF, 0xE0, 0x3F,
  0x7F, 0x03, 0xFE, 0x03, 0xF7, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x0F, 0xFF,
  0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC0, 0x01, 0xF9, 0xFF, 0xFF, 0xC0, 0x07,
  0xF7, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF, 0x80, 0xFF, 0x80, 0x1F, 0xBC, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x7C, 0x07, 0xFC, 0x00, 0xFE, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x1F,
  0x80, 0x0F, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF,
  0xFF, 0x7F, 0x00, 0xFF, 0x80, 0xFB, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xF7, 0xE0, 0x1F, 0xF0, 0x1F, 0xBF, 0x00, 0xFF, 0xFF, 0xFB,
  0xF8, 0x03, 0xFF, 0xFF, 0x9F, 0x80, 0x0F, 0xFF, 0xF0, 0xFC, 0x00, 0x3F,
  0xFF, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0xC1, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x7E, 0x1F, 0xFF, 0xF8, 0x3F, 0x1F,
  0xFF, 0xFC, 0x1F, 0x8F, 0xE0, 0x04, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xE0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x07, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x1E, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xDF, 0x80, 0xFF, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xFF, 0x1F, 0x80,
  0x3F, 0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x01, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7B, 0xC0, 0x3F, 0x03,
  0xF0, 0x1F, 0x78, 0x0F, 0xC0, 0x7E, 0x03, 0xCF, 0x01, 0xF8, 0x0F, 0xC0,
  0xF9, 0xE0, 0x3F, 0x01, 0xF8, 0x1E, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC7,
  0xC1, 0xF8, 0x07, 0xE0, 0xF0, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x1F, 0x0F,
  0xC0, 0x1F, 0x87, 0x83, 0xE1, 0xF8, 0x03, 0xF1, 0xF0, 0x7C, 0x3E, 0x00,
  0x7E, 0x3C, 0x0F, 0x8F, 0xC0, 0x0F, 0xCF, 0x80, 0xF1, 0xF8, 0x01, 0xF1,
  0xE0, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x07, 0xCF, 0x00,
  0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00, 0x1F, 0x78, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x4F, 0xFF, 0xFE, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0x03, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x03, 0xFF, 0xFF, 0xFB, 0x80, 0x03, 0xFF, 0xFF, 0x90,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 17, 47, 43, 14, -47 },
  { 101, 27, 22, 43, 13, -52 },
  { 176, 43, 47, 43, 1, -47 },
  { 429, 42, 58, 43, 1, -52 },
  { 734, 47, 49, 43, -1, -48 },
  { 1022, 39, 49, 43, 0, -48 },
  { 1261, 11, 22, 43, 21, -52 },
  { 1292, 27, 67, 43, 11, -52 },
  { 1519, 27, 67, 43, 5, -52 },
  { 1746, 26, 25, 43, 13, -52 },
  { 1828, 35, 35, 43, 4, -42 },
  { 1982, 20, 23, 43, 3, -11 },
  { 2040, 21, 6, 43, 11, -22 },
  { 2056, 10, 11, 43, 14, -11 },
  { 2070, 46, 53, 43, 0, -52 },
  { 2375, 37, 49, 43, 4, -48 },
  { 2602, 35, 47, 43, 2, -47 },
  { 2808, 40, 48, 43, 1, -48 },
  { 3048, 38, 49, 43, 3, -48 },
  { 3281, 37, 47, 43, 2, -47 },
  { 3499, 38, 48, 43, 3, -47 },
  { 3727, 36, 49, 43, 5, -48 },
  { 3948, 33, 47, 43, 10, -47 },
  { 4142, 38, 49, 43, 3, -48 },
  { 4375, 36, 49, 43, 4, -48 },
  { 4596, 15, 38, 43, 14, -38 },
  { 4668, 23, 50, 43, 6, -38 },
  { 4812, 35, 37, 43, 4, -42 },
  { 4974, 35, 23, 43, 4, -35 },
  { 5075, 35, 37, 43, 4, -42 },
  { 5237, 35, 48, 43, 6, -48 },
  { 5447, 44, 62, 43, 0, -52 },
  { 5788, 43, 47, 43, -4, -47 },
  { 6041, 39, 47, 43, 2, -47 },
  { 6271, 39, 49, 43, 4, -48 },
  { 6510, 39, 47, 43, 2, -47 },
  { 6740, 42, 47, 43, 2, -47 },
  { 6987, 41, 47, 43, 3, -47 },
  { 7228, 38, 49, 43, 4, -48 },
  { 7461, 41, 47, 43, 2, -47 },
  { 7702, 39, 47, 43, 3, -47 },
  { 7932, 35, 48, 43, 5, -47 },
  { 8142, 44, 47, 43, 2, -47 },
  { 8401, 31, 47, 43, 5, -47 },
  { 8584, 43, 47, 43, 1, -47 },
  { 8837, 41, 47, 43, 2, -47 },
  { 9078, 37, 49, 43, 4, -48 },
  { 9305, 40, 47, 43, 2, -47 },
  { 9540, 37, 62, 43, 4, -48 },
  { 9827, 41, 47, 43, 2, -47 },
  { 10068, 41, 49, 43, 1, -48 },
  { 10320, 39, 47, 43, 7, -47 },
  { 10550, 40, 48, 43, 4, -47 },
  { 10790, 42, 47, 43, 6, -47 },
  { 11037, 45, 47, 43, 4, -47 },
  { 11302, 48, 47, 43, -2, -47 },
  { 11584, 40, 47, 43, 7, -47 },
  { 11819, 45, 47, 43, -1, -47 },
  { 12084, 32, 67, 43, 8, -52 },
  { 12352, 25, 53, 43, 10, -52 },
  { 12518, 32, 67, 43, 3, -52 },
  { 12786, 34, 32, 43, 4, -47 },
  { 12922, 44, 3, 43, -5, 4 },
  { 12939, 14, 9, 43, 20, -51 },
  { 12955, 35, 40, 43, 3, -39 },
  { 13130, 36, 53, 43, 3, -52 },
  { 13369, 36, 40, 43, 4, -39 },
  { 13549, 39, 53, 43, 4, -52 },
  { 13808, 35, 40, 43, 4, -39 },
  { 13983, 37, 52, 43, 8, -52 },
  { 14224, 38, 54, 43, 3, -39 },
  { 14481, 36, 52, 43, 3, -52 },
  { 14715, 36, 52, 43, 1, -52 },
  { 14949, 38, 67, 43, -2, -52 },
  { 15268, 37, 52, 43, 5, -52 },
  { 15509, 36, 52, 43, 1, -52 },
  { 15743, 42, 39, 43, 0, -39 },
  { 15948, 36, 39, 43, 3, -39 },
  { 16124, 35, 40, 43, 4, -39 },
  { 16299, 39, 54, 43, 0, -39 },
  { 16563, 37, 54, 43, 4, -39 },
  { 16813, 33, 39, 43, 7, -39 },
  { 16974, 34, 40, 43, 4, -39 },
  { 17144, 29, 49, 43, 9, -48 },
  { 17322, 36, 39, 43, 5, -38 },
  { 17498, 38, 38, 43, 6, -38 },
  { 17679, 43, 38, 43, 3, -38 },
  { 17884, 43, 38, 43, 0, -38 },
  { 18089, 46, 53, 43, -1, -38 },
  { 18394, 39, 38, 43, 1, -38 },
  { 18580, 37, 67, 43, 7, -52 },
  { 18890, 6, 67, 43, 19, -52 },
  { 18941, 37, 67, 43, -1, -52 },
  { 19251, 37, 9, 43, 4, -28 },
};

const GFXfont LiberationMono_Italic72pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic72pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic72pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _LIBERATIONMONO_ITALIC72PT7B_H_
