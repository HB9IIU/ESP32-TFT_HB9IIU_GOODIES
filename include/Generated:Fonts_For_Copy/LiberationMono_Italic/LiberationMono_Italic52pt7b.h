#ifndef _LIBERATIONMONO_ITALIC52PT7B_H_
#define _LIBERATIONMONO_ITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E,
  0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x78,
  0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFE, 0x3C, 0xFE,
  0x03, 0xE0, 0xE0, 0xF8, 0x1F, 0x03, 0x81, 0xF0, 0x78, 0x0E, 0x07, 0xC1,
  0xE0, 0x38, 0x1C, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x07, 0xF9, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0xFE, 0x00, 0x01, 0xC0, 0xF8,
  0x00, 0x07, 0x01, 0xF0, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x70, 0x1F, 0x0C,
  0x03, 0xC0, 0x78, 0xF8, 0x0E, 0x01, 0xE3, 0xE0, 0x38, 0x0F, 0x8F, 0x80,
  0xE0, 0x7C, 0x3F, 0x03, 0x83, 0xF0, 0x7F, 0x1E, 0x3F, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xF0, 0x3F, 0xFC, 0x00, 0x78, 0x1F, 0x0F, 0x00, 0x3C, 0x07, 0x83, 0xC0,
  0x1E, 0x03, 0xC0, 0x70, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x38, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x78, 0x01, 0xE0,
  0x38, 0x3C, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0x8F, 0x00, 0x07,
  0xC3, 0xC7, 0x80, 0x00, 0xFF, 0xE1, 0xC0, 0x00, 0x1F, 0xF0, 0xE0, 0x00,
  0x03, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x03, 0xC7,
  0xFF, 0x80, 0x01, 0xE3, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x38, 0x00, 0x38,
  0x78, 0x0E, 0x00, 0x1C, 0x1E, 0x03, 0x80, 0x0F, 0x07, 0x80, 0xE0, 0x07,
  0x81, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x78, 0x78,
  0x0E, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x7C,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x7E, 0x00, 0x07,
  0xBF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0xC0, 0x3F, 0xC0, 0x0F, 0x07, 0xFE, 0x00, 0xE0, 0xF9, 0xE0, 0x1E, 0x1F,
  0x1F, 0x01, 0xE3, 0xE0, 0xF0, 0x3C, 0x7C, 0x0F, 0x83, 0xC7, 0x80, 0x78,
  0x78, 0x78, 0x07, 0xC7, 0x8F, 0x80, 0x3E, 0xF0, 0xF0, 0x03, 0xFE, 0x0F,
  0x00, 0x1F, 0xE0, 0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x7E, 0x0F, 0xDF, 0xB3, 0xFF, 0xF9, 0xFF,
  0x1F, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x1E, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x40, 0xE0, 0xDE, 0x1C, 0x7B, 0xF7, 0x7F,
  0x7F, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0E, 0xF0, 0x03, 0x8E, 0x00, 0xF1, 0xE0, 0x3C, 0x1E, 0x07, 0x03, 0x80,
  0x40, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7E, 0xFD, 0xFB, 0xF7, 0xFF, 0xBF, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x7E, 0x1F, 0x7C, 0x1F, 0x87, 0xDF, 0x0F,
  0xC1, 0xF7, 0x83, 0xF0, 0x7D, 0xE0, 0xFC, 0x1E, 0xF8, 0x3F, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF7, 0x80, 0x1F,
  0xF1, 0xE0, 0x07, 0xF0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0xF3, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0xF0, 0x07,
  0xC7, 0xFF, 0x01, 0xF7, 0xFF, 0xF0, 0x7B, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F,
  0x8F, 0xF0, 0x07, 0xE3, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x81,
  0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE1, 0xF0, 0x07, 0xF8, 0x7F, 0x07, 0xFE,
  0x0F, 0xFF, 0xEF, 0x83, 0xFF, 0xF3, 0xC0, 0x7F, 0xF8, 0xF0, 0x07, 0xF0,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x01,
  0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03,
  0xC0, 0x78, 0x07, 0x07, 0x81, 0xFC, 0xE7, 0x07, 0x07, 0xFE, 0xE7, 0x0F,
  0x0F, 0x8E, 0xE7, 0x0E, 0x1E, 0x07, 0xC7, 0x0E, 0x1C, 0x07, 0xC7, 0x1C,
  0x3C, 0x07, 0x8F, 0x1C, 0x78, 0x07, 0x8E, 0x3C, 0x70, 0x07, 0x0E, 0x38,
  0xF0, 0x07, 0x0E, 0x38, 0xF0, 0x0E, 0x0E, 0x38, 0xE0, 0x0E, 0x1C, 0x79,
  0xE0, 0x0E, 0x1C, 0x71, 0xC0, 0x1C, 0x1C, 0x71, 0xC0, 0x1C, 0x38, 0x71,
  0xC0, 0x38, 0x38, 0x73, 0xC0, 0x38, 0x78, 0xF3, 0xC0, 0x78, 0x70, 0xF3,
  0xC0, 0xF0, 0xF0, 0xF3, 0xC1, 0xF0, 0xE0, 0xF1, 0xC3, 0x71, 0xC0, 0xF1,
  0xFF, 0x7F, 0x80, 0xF1, 0xFC, 0x3F, 0x00, 0xF0, 0xF8, 0x3E, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x04, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0x00,
  0x7F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x78, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x07, 0xC0, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x18, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x60, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x03, 0xFE, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xC0,
  0x0F, 0xE0, 0x3E, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x20, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0x7C, 0x03, 0xFF, 0xCF, 0x80, 0x7F, 0xF9,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xF0,
  0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x38, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x3E, 0x03, 0xF8, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x07, 0x8F, 0xE0, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x0F, 0xBF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF7, 0xE0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0,
  0x78, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80,
  0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xEE, 0x01, 0xEF, 0x03, 0xDE, 0x03,
  0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0x79,
  0xE0, 0x79, 0xE0, 0xE3, 0xC0, 0xF3, 0xE3, 0xCF, 0x01, 0xE3, 0xCF, 0x1E,
  0x07, 0x87, 0x9E, 0x3C, 0x0F, 0x0F, 0x78, 0x78, 0x1E, 0x1E, 0xF0, 0xF0,
  0x3C, 0x3F, 0xC3, 0xC0, 0x78, 0x3F, 0x07, 0x81, 0xF0, 0x7E, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x3C, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0xFF, 0x00, 0x1E, 0x03, 0xFC, 0x00,
  0x78, 0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0x80, 0x3E,
  0x07, 0xDE, 0x00, 0xF0, 0x1E, 0x78, 0x03, 0xC0, 0x79, 0xF0, 0x0F, 0x01,
  0xE3, 0xC0, 0x7C, 0x07, 0x8F, 0x01, 0xF0, 0x3E, 0x3C, 0x07, 0x80, 0xF8,
  0xF8, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x07, 0x83, 0xE0, 0x3C, 0x1F,
  0x0F, 0x81, 0xF0, 0x7C, 0x3C, 0x07, 0xC0, 0xF0, 0xF0, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0x0F, 0x9F, 0x01, 0xE0, 0x3E, 0x7C, 0x0F, 0x80, 0x79, 0xE0,
  0x3E, 0x01, 0xE7, 0x80, 0xF0, 0x07, 0xDE, 0x03, 0xC0, 0x0F, 0x78, 0x0F,
  0x00, 0x3D, 0xE0, 0x3C, 0x00, 0xF7, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0x80,
  0x07, 0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x7F, 0x01, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xF8, 0x0F,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC0, 0x7F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x01,
  0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x0F, 0x80,
  0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x81, 0xE0, 0xF8, 0x1F, 0x81,
  0xE0, 0xF8, 0x3F, 0x83, 0xE0, 0xF8, 0x3B, 0x83, 0xC0, 0xF8, 0x7B, 0x83,
  0xC0, 0xF8, 0x73, 0x87, 0xC0, 0xF8, 0xF3, 0x87, 0x80, 0xF0, 0xE3, 0xC7,
  0x80, 0xF1, 0xE3, 0xCF, 0x80, 0xF1, 0xE3, 0xCF, 0x00, 0xF3, 0xC3, 0xCF,
  0x00, 0xF3, 0xC3, 0xCF, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x83, 0xDE,
  0x00, 0xF7, 0x03, 0xDC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1C, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x3C, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x0E, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x80, 0x3C,
  0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x03,
  0xF8, 0xF8, 0x07, 0x7C, 0x7E, 0x0F, 0x3E, 0x1F, 0xFF, 0x1F, 0xE7, 0xFF,
  0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x1F, 0x1F, 0xFC, 0x07, 0xDF, 0xFF, 0x81,
  0xEF, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x0F, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x07, 0xF0, 0x07, 0xC3, 0xEF,
  0x07, 0xE0, 0xFB, 0xFF, 0xF0, 0x3C, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0x83, 0xC0, 0x0F, 0xFE, 0x7C, 0x03, 0xFF, 0xF7, 0xC0, 0x7E, 0x07, 0x7C,
  0x0F, 0xC0, 0x3F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0xF7, 0x80, 0x7F, 0xFE, 0x78, 0x03, 0xFF, 0x87, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x83, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFC, 0x3C, 0x07, 0xFF, 0xC7, 0x81, 0xF8, 0x3D, 0xF0, 0x7E, 0x01,
  0xFE, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x3F, 0x81, 0xF0, 0x0F, 0xF0, 0x3F, 0x07, 0xBE, 0x07, 0xFF, 0xE7, 0x80,
  0x7F, 0xF0, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1F,
  0x00, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x1F, 0x1F, 0xFC, 0x07,
  0xDF, 0xFF, 0x81, 0xEF, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x06, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0x80, 0x3F,
  0x00, 0x78, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0x8F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x81, 0xF0,
  0x1E, 0x7F, 0x1F, 0xE0, 0x7B, 0xFC, 0xFF, 0xC1, 0xF8, 0xFB, 0x1F, 0x07,
  0x41, 0xF8, 0x7C, 0x3F, 0x07, 0xC0, 0xF0, 0xF8, 0x1F, 0x07, 0xC3, 0xE0,
  0x78, 0x1F, 0x0F, 0x03, 0xE0, 0x7C, 0x3C, 0x0F, 0x81, 0xE1, 0xF0, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x03,
  0xE1, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0xF0,
  0xF0, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x1F, 0x0F, 0x03, 0xE0, 0x7C, 0x7C,
  0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1E, 0x03,
  0xC0, 0xF8, 0x78, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F, 0x0F, 0x81, 0xE0,
  0x3C, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xE1, 0xFF, 0xC0,
  0x79, 0xFF, 0xF8, 0x1E, 0xF0, 0x7E, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x1E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7E, 0x07,
  0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3C, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80,
  0x01, 0xF7, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0x1F, 0xFC, 0x01, 0xF7, 0xFF, 0xE0, 0x1E, 0xF0, 0x7E, 0x01, 0xEC, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C,
  0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x1E, 0xC0, 0x1F, 0x03, 0xEF,
  0x07, 0xE0, 0x3E, 0x7F, 0xFC, 0x03, 0xE3, 0xFF, 0x80, 0x3E, 0x1F, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0xF0, 0x3F, 0xFF, 0x7C, 0x1F, 0x81,
  0xDF, 0x0F, 0xC0, 0x3F, 0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x78,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x1F, 0x83, 0xDE,
  0x07, 0xFF, 0xE7, 0x80, 0xFF, 0xE3, 0xE0, 0x0F, 0xE0, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0x07,
  0xFF, 0x0F, 0x0F, 0xFF, 0x0F, 0x1F, 0xFF, 0x0F, 0x3E, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x07, 0xE0, 0x78, 0x00, 0xF0, 0x7C,
  0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE3, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x18, 0x7F, 0xFF,
  0x83, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x07, 0xF0,
  0x7E, 0x07, 0x7C, 0x1F, 0xFF, 0x9E, 0x03, 0xFF, 0xC7, 0x80, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1F, 0x3C, 0x07, 0xC0, 0x7C, 0xF0, 0x1F, 0x01, 0xE3, 0xC0, 0xFE,
  0x0F, 0x8F, 0x03, 0xF8, 0x3C, 0x3C, 0x1F, 0xE0, 0xF0, 0xF0, 0x77, 0x87,
  0xC3, 0xC3, 0xCE, 0x1E, 0x0F, 0x0E, 0x38, 0x78, 0x3C, 0x78, 0xE3, 0xE0,
  0xF3, 0xC3, 0x8F, 0x03, 0xCF, 0x0E, 0x3C, 0x0F, 0x78, 0x3D, 0xE0, 0x3D,
  0xE0, 0xF7, 0x80, 0xF7, 0x03, 0xDE, 0x03, 0xF8, 0x0F, 0xF0, 0x0E, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x19, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEE, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph LiberationMono_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 12, 34, 31, 10, -34 },
  { 52, 19, 16, 31, 10, -38 },
  { 90, 31, 34, 31, 1, -34 },
  { 222, 30, 41, 31, 1, -37 },
  { 376, 34, 36, 31, -1, -35 },
  { 529, 28, 36, 31, 0, -35 },
  { 655, 8, 16, 31, 15, -38 },
  { 671, 19, 49, 31, 8, -38 },
  { 788, 19, 49, 31, 4, -38 },
  { 905, 19, 19, 31, 9, -38 },
  { 951, 25, 26, 31, 3, -30 },
  { 1033, 14, 17, 31, 2, -8 },
  { 1063, 15, 4, 31, 8, -15 },
  { 1071, 7, 8, 31, 10, -8 },
  { 1078, 33, 39, 31, 0, -38 },
  { 1239, 26, 36, 31, 3, -35 },
  { 1356, 26, 34, 31, 1, -34 },
  { 1467, 28, 35, 31, 1, -35 },
  { 1590, 27, 36, 31, 2, -35 },
  { 1712, 26, 34, 31, 2, -34 },
  { 1823, 28, 35, 31, 2, -34 },
  { 1946, 26, 36, 31, 4, -35 },
  { 2063, 24, 34, 31, 7, -34 },
  { 2165, 27, 36, 31, 2, -35 },
  { 2287, 26, 36, 31, 3, -35 },
  { 2404, 11, 27, 31, 10, -27 },
  { 2442, 17, 36, 31, 4, -27 },
  { 2519, 25, 26, 31, 3, -30 },
  { 2601, 25, 17, 31, 3, -26 },
  { 2655, 25, 26, 31, 3, -30 },
  { 2737, 26, 35, 31, 4, -35 },
  { 2851, 32, 44, 31, 0, -38 },
  { 3027, 32, 34, 31, -3, -34 },
  { 3163, 29, 34, 31, 1, -34 },
  { 3287, 28, 36, 31, 3, -35 },
  { 3413, 29, 34, 31, 1, -34 },
  { 3537, 30, 34, 31, 1, -34 },
  { 3665, 30, 34, 31, 2, -34 },
  { 3793, 27, 36, 31, 3, -35 },
  { 3915, 30, 34, 31, 1, -34 },
  { 4043, 28, 34, 31, 2, -34 },
  { 4162, 25, 35, 31, 4, -34 },
  { 4272, 32, 34, 31, 1, -34 },
  { 4408, 23, 34, 31, 3, -34 },
  { 4506, 31, 34, 31, 1, -34 },
  { 4638, 30, 34, 31, 1, -34 },
  { 4766, 27, 36, 31, 3, -35 },
  { 4888, 30, 34, 31, 1, -34 },
  { 5016, 27, 46, 31, 3, -35 },
  { 5172, 30, 34, 31, 1, -34 },
  { 5300, 29, 36, 31, 1, -35 },
  { 5431, 28, 34, 31, 5, -34 },
  { 5550, 29, 35, 31, 3, -34 },
  { 5677, 31, 34, 31, 4, -34 },
  { 5809, 32, 34, 31, 3, -34 },
  { 5945, 35, 34, 31, -2, -34 },
  { 6094, 29, 34, 31, 5, -34 },
  { 6218, 33, 34, 31, -1, -34 },
  { 6359, 23, 49, 31, 6, -38 },
  { 6500, 18, 39, 31, 8, -38 },
  { 6588, 23, 49, 31, 2, -38 },
  { 6729, 24, 23, 31, 3, -34 },
  { 6798, 32, 2, 31, -4, 3 },
  { 6806, 9, 7, 31, 15, -38 },
  { 6814, 25, 29, 31, 2, -28 },
  { 6905, 26, 39, 31, 2, -38 },
  { 7032, 26, 29, 31, 3, -28 },
  { 7127, 28, 39, 31, 3, -38 },
  { 7264, 25, 29, 31, 3, -28 },
  { 7355, 27, 38, 31, 5, -38 },
  { 7484, 27, 39, 31, 2, -28 },
  { 7616, 26, 38, 31, 2, -38 },
  { 7740, 26, 38, 31, 1, -38 },
  { 7864, 28, 49, 31, -2, -38 },
  { 8036, 28, 38, 31, 3, -38 },
  { 8169, 25, 38, 31, 1, -38 },
  { 8288, 30, 28, 31, 0, -28 },
  { 8393, 26, 28, 31, 2, -28 },
  { 8484, 25, 29, 31, 3, -28 },
  { 8575, 28, 39, 31, 0, -28 },
  { 8712, 26, 39, 31, 3, -28 },
  { 8839, 24, 28, 31, 5, -28 },
  { 8923, 25, 29, 31, 3, -28 },
  { 9014, 20, 35, 31, 7, -34 },
  { 9102, 26, 28, 31, 3, -27 },
  { 9193, 28, 27, 31, 4, -27 },
  { 9288, 30, 27, 31, 3, -27 },
  { 9390, 31, 27, 31, 0, -27 },
  { 9495, 32, 38, 31, 0, -27 },
  { 9647, 28, 27, 31, 1, -27 },
  { 9742, 27, 49, 31, 5, -38 },
  { 9908, 5, 49, 31, 13, -38 },
  { 9939, 27, 49, 31, -1, -38 },
  { 10105, 27, 6, 31, 3, -20 },
};

const GFXfont LiberationMono_Italic52pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic52pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic52pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _LIBERATIONMONO_ITALIC52PT7B_H_
