#ifndef _LIBERATIONMONO_ITALIC50PT7B_H_
#define _LIBERATIONMONO_ITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x3F,
  0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x18,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0,
  0x18, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x80, 0x30, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0x1C, 0xFE, 0x07, 0xC1, 0xE1, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x3E, 0x1F, 0x03, 0x81, 0xC0, 0xF8, 0x1C, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0xFE, 0x70, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x8F, 0xE0, 0x00, 0x1C, 0x1F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x70, 0x1F, 0x0C,
  0x03, 0x80, 0xF1, 0xE0, 0x1C, 0x07, 0x8F, 0x81, 0xE0, 0x7C, 0x7C, 0x0E,
  0x03, 0xC3, 0xF0, 0x70, 0x7E, 0x0F, 0xE3, 0x8F, 0xE0, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x80, 0xFF, 0x80, 0x07, 0x80, 0xFF,
  0xE0, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x80, 0x70, 0x3C, 0x07, 0x80, 0x78,
  0x1E, 0x03, 0x80, 0x38, 0x0F, 0x03, 0x80, 0x3C, 0x07, 0x03, 0x80, 0x1E,
  0x03, 0x83, 0xC0, 0x0F, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE3, 0xC0, 0x03,
  0xC0, 0xE3, 0xC0, 0x01, 0xE0, 0xF3, 0xC0, 0x00, 0xF8, 0xF1, 0xC0, 0x00,
  0x3F, 0xF9, 0xC0, 0x00, 0x1F, 0xF9, 0xC0, 0x00, 0x03, 0xF1, 0xC3, 0xF0,
  0x00, 0x01, 0xE7, 0xFC, 0x00, 0x01, 0xE7, 0xFF, 0x00, 0x01, 0xE7, 0x87,
  0x80, 0x01, 0xE7, 0x81, 0xC0, 0x01, 0xE3, 0xC0, 0xE0, 0x00, 0xE3, 0xC0,
  0x70, 0x00, 0xE1, 0xE0, 0x38, 0x00, 0xE0, 0xF0, 0x3C, 0x00, 0xE0, 0x70,
  0x1E, 0x00, 0xF0, 0x38, 0x0F, 0x00, 0xF0, 0x1C, 0x0F, 0x00, 0xF0, 0x0F,
  0x07, 0x80, 0xF0, 0x07, 0x87, 0x80, 0xF0, 0x03, 0xFF, 0x80, 0x70, 0x00,
  0xFF, 0x80, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x70,
  0x07, 0x80, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x7C, 0x00, 0x38, 0x3F, 0x00,
  0x07, 0x9F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x01, 0x80, 0xFF, 0x80, 0x3C, 0x3E, 0xF8, 0x07, 0x0F,
  0x8F, 0x01, 0xE3, 0xE1, 0xE0, 0x3C, 0x78, 0x1E, 0x0F, 0x1E, 0x03, 0xC1,
  0xE3, 0xC0, 0x7C, 0x78, 0xF8, 0x07, 0xCE, 0x1E, 0x00, 0x7B, 0xC3, 0xC0,
  0x0F, 0xF0, 0x78, 0x00, 0xFE, 0x0F, 0x00, 0x1F, 0x81, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0xFF, 0x03, 0xF0, 0x7F, 0xFB, 0x3F, 0xFF, 0x3F, 0xE3, 0xFF,
  0xC1, 0xFC, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x7D, 0xFB, 0xE7, 0xCF, 0x9F,
  0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x70, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x60, 0xE0, 0x9E,
  0x38, 0xFF, 0xEE, 0xFC, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3D, 0xC0, 0x1E, 0x78, 0x0F, 0x1E, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x10, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE1, 0xF8, 0x3D, 0xF0, 0xFC, 0x3E,
  0xF0, 0x7E, 0x1F, 0x78, 0x3E, 0x0F, 0xFC, 0x3F, 0x07, 0xBE, 0x1F, 0x83,
  0xDF, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0xF9, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFB, 0xE0, 0x0F, 0xF9, 0xE0, 0x07, 0xF0,
  0xF0, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xF8,
  0x1F, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x70, 0x7C,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0E, 0x00, 0x1F, 0x07, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x87,
  0xF0, 0x00, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00,
  0x0E, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x1F,
  0x80, 0x7C, 0xFF, 0xE0, 0x79, 0xFF, 0xF8, 0x7B, 0xFF, 0xF8, 0x7F, 0x81,
  0xFC, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0x7F, 0x01,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xCF, 0x80,
  0x03, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x1F, 0x81, 0xEF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xF7, 0xC0, 0xFF, 0xE3, 0xC0, 0x1F, 0xC3, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0xE0, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x81, 0xE0, 0x38, 0x1E, 0x0F, 0xE7, 0x78, 0x38, 0x3F, 0xEE,
  0x70, 0xF0, 0xF1, 0xD8, 0xE1, 0xC3, 0xC1, 0xF1, 0xC3, 0x8F, 0x03, 0xE7,
  0x8E, 0x1C, 0x07, 0x8E, 0x1C, 0x78, 0x0F, 0x1C, 0x78, 0xE0, 0x1C, 0x38,
  0xE3, 0xC0, 0x38, 0x71, 0xC7, 0x00, 0xF0, 0xE3, 0x9E, 0x01, 0xC3, 0x8E,
  0x38, 0x03, 0x87, 0x1C, 0x70, 0x0E, 0x0E, 0x38, 0xE0, 0x1C, 0x38, 0x73,
  0xC0, 0x78, 0x70, 0xE7, 0x80, 0xE0, 0xE3, 0xCE, 0x03, 0xC3, 0x87, 0x1C,
  0x0F, 0x8F, 0x0E, 0x3C, 0x36, 0x1C, 0x1C, 0x78, 0xEC, 0x70, 0x38, 0x7F,
  0x9F, 0xC0, 0x78, 0xFE, 0x3F, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x03, 0xC0, 0x01,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x3C, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0x03, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x60, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x1F, 0xC0, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xE0,
  0x3F, 0xC0, 0x3C, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03,
  0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x03,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xFF, 0xBE, 0x01, 0xFF, 0xCF, 0x80,
  0xFF, 0xF3, 0xE0, 0x3F, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F, 0x80,
  0x0F, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x38, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x78, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x03, 0xF0, 0x00,
  0x1E, 0x0F, 0xC0, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x03, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1D, 0xE0, 0x7F,
  0x80, 0xF7, 0x01, 0xDE, 0x03, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3C, 0xF0,
  0x73, 0xC0, 0xF3, 0xC3, 0xCF, 0x03, 0xCF, 0x0E, 0x78, 0x0E, 0x3C, 0x79,
  0xE0, 0x78, 0xF3, 0xC7, 0x81, 0xE3, 0xCF, 0x1E, 0x07, 0x87, 0x78, 0x78,
  0x1E, 0x1D, 0xC3, 0xC0, 0x78, 0x7F, 0x0F, 0x03, 0xC1, 0xF8, 0x3C, 0x0F,
  0x07, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x1F, 0xC0, 0x07, 0xC0,
  0xFE, 0x00, 0x3C, 0x07, 0xF0, 0x01, 0xE0, 0x3F, 0x80, 0x0F, 0x01, 0xFE,
  0x00, 0x78, 0x0E, 0xF0, 0x07, 0xC0, 0xF7, 0x80, 0x3C, 0x07, 0xBC, 0x01,
  0xE0, 0x3C, 0xF0, 0x0F, 0x01, 0xE7, 0x80, 0x78, 0x0F, 0x3C, 0x07, 0xC0,
  0xF9, 0xF0, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0x3C, 0x3C, 0x0F, 0x01, 0xE1,
  0xE0, 0x78, 0x0F, 0x0F, 0x87, 0xC0, 0xF8, 0x3C, 0x3C, 0x07, 0x81, 0xE1,
  0xE0, 0x3C, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x01, 0xE7, 0xC0,
  0xF8, 0x0F, 0x3E, 0x07, 0x80, 0x7D, 0xE0, 0x3C, 0x01, 0xEF, 0x01, 0xE0,
  0x0F, 0x78, 0x0F, 0x00, 0x7B, 0xC0, 0xF8, 0x03, 0xFE, 0x07, 0x80, 0x0F,
  0xE0, 0x3C, 0x00, 0x7F, 0x01, 0xE0, 0x03, 0xF8, 0x0F, 0x00, 0x1F, 0xC0,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x78, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xF0, 0x3C, 0x00, 0x3F,
  0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC0, 0xF0, 0x03, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07,
  0xC0, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x7F, 0x01, 0xE0,
  0x00, 0xFC, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x7F, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x3C, 0x07, 0x87, 0xC0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0x3C,
  0x1F, 0x07, 0xE0, 0x78, 0x3E, 0x0F, 0xC0, 0xF0, 0x78, 0x3F, 0x83, 0xC0,
  0xF0, 0x77, 0x87, 0x81, 0xE1, 0xEF, 0x0F, 0x03, 0xC3, 0x9E, 0x3C, 0x07,
  0x8F, 0x3C, 0x78, 0x0F, 0x1C, 0x78, 0xF0, 0x1E, 0x78, 0xF3, 0xC0, 0x3C,
  0xF1, 0xE7, 0x80, 0x79, 0xC1, 0xCF, 0x00, 0xF7, 0x83, 0xBC, 0x01, 0xEE,
  0x07, 0x78, 0x03, 0xFC, 0x0E, 0xF0, 0x07, 0x70, 0x1D, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0,
  0x1E, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3C, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0xE0,
  0x07, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x07, 0x03,
  0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x38, 0xF0,
  0x00, 0x73, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x0F,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x3C, 0x3E,
  0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF0, 0x01, 0xF8, 0xF8, 0x03, 0xF8, 0xF8,
  0x07, 0xF8, 0xFC, 0x1E, 0xF8, 0x7F, 0xFC, 0xFF, 0x7F, 0xF0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xFC, 0x01, 0xE3, 0xFF,
  0x80, 0xF3, 0xFF, 0xE0, 0x7B, 0x83, 0xF0, 0x7F, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC7, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F,
  0x00, 0x07, 0xC7, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0xF0, 0xFC, 0x00, 0xF8, 0x7F, 0x00, 0xF8, 0x7F, 0xC1, 0xF8,
  0x3E, 0xFF, 0xF8, 0x1E, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0xF0, 0x07, 0xFF, 0x3E, 0x01,
  0xFF, 0xF7, 0xC0, 0x7E, 0x0E, 0xF0, 0x1F, 0x00, 0xFE, 0x07, 0xC0, 0x0F,
  0xC0, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF8, 0x0F, 0xC1, 0xDE, 0x01, 0xFF, 0xF3, 0xC0, 0x1F, 0xFC, 0x78, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0x7C, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x30, 0xF8, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0xF0, 0x1F, 0xFF, 0x3C, 0x0F, 0xC1,
  0xDF, 0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x07, 0xE0, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0x7E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x1B, 0xC0, 0xFC, 0x1D, 0xF0, 0x3F, 0xFE, 0x7C, 0x07, 0xFF, 0x1E,
  0x00, 0x7F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x1F,
  0x83, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xFC, 0x01, 0xE3, 0xFF, 0x80,
  0xF3, 0xFF, 0xE0, 0x7B, 0x83, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03,
  0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0x80, 0x7E, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x1E,
  0x00, 0x3E, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xE7, 0xC0, 0x03,
  0xF1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1E, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x03, 0xE0,
  0x3D, 0xFC, 0x3F, 0x81, 0xDF, 0xF3, 0xFE, 0x0E, 0xC7, 0xB1, 0xF0, 0xFC,
  0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0x3C, 0x3E, 0x0F, 0x81, 0xE1, 0xE0, 0x78,
  0x1F, 0x0F, 0x03, 0xC0, 0xF0, 0xF8, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C,
  0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0xF8, 0xF8,
  0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x0F, 0x81, 0xE1, 0xE0, 0x78,
  0x0F, 0x0F, 0x03, 0xC0, 0xF8, 0xF8, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C,
  0x3C, 0x0F, 0x81, 0xE1, 0xE0, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0xF8, 0xF8,
  0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x0F, 0x81, 0xE0, 0x00, 0x03,
  0xF8, 0x03, 0xC7, 0xFF, 0x01, 0xE7, 0xFF, 0xC1, 0xF7, 0x07, 0xE0, 0xFE,
  0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7E,
  0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3C, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x00, 0xF7, 0x07,
  0xE0, 0x3F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF8,
  0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3F, 0x00,
  0x1E, 0x07, 0xE0, 0x07, 0xC0, 0xFE, 0x01, 0xF0, 0x3E, 0xE0, 0xFC, 0x07,
  0xDF, 0xFF, 0x00, 0xF9, 0xFF, 0xC0, 0x1E, 0x0F, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE3, 0xC0, 0xFF,
  0xFB, 0xE0, 0xFC, 0x1D, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x01, 0xF8, 0x78,
  0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3E,
  0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xF0, 0x7E, 0x0E, 0xF0, 0x3F, 0xFE,
  0x78, 0x0F, 0xFE, 0x3C, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xFE, 0x3E, 0x1F, 0xFC, 0x3C, 0x7F, 0xF8, 0x79, 0xFF, 0xE1,
  0xF7, 0xC0, 0x03, 0xEE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x70, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xFC, 0x03, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3,
  0xE0, 0x0D, 0xE0, 0xFC, 0x1D, 0xF0, 0x7F, 0xFC, 0xF0, 0x1F, 0xFC, 0x78,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x0F,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1F, 0x1E, 0x03,
  0xE0, 0x78, 0x78, 0x1F, 0x81, 0xE1, 0xE0, 0xFE, 0x0F, 0x87, 0x83, 0xB8,
  0x3C, 0x1E, 0x1E, 0xE0, 0xF0, 0x78, 0x73, 0x87, 0x81, 0xE3, 0xCE, 0x1E,
  0x07, 0x8E, 0x38, 0xF8, 0x1E, 0x78, 0xE3, 0xC0, 0x79, 0xC3, 0xCF, 0x01,
  0xEF, 0x0F, 0x7C, 0x07, 0xB8, 0x3D, 0xE0, 0x1D, 0xE0, 0x77, 0x80, 0x77,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x1E,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
};

const GFXglyph LiberationMono_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 11, 33, 30, 10, -33 },
  { 47, 19, 16, 30, 9, -36 },
  { 85, 29, 33, 30, 1, -33 },
  { 205, 29, 40, 30, 1, -36 },
  { 350, 33, 33, 30, -1, -33 },
  { 487, 27, 35, 30, 0, -34 },
  { 606, 7, 16, 30, 15, -36 },
  { 620, 18, 46, 30, 8, -36 },
  { 724, 18, 46, 30, 4, -36 },
  { 828, 18, 17, 30, 9, -36 },
  { 867, 24, 24, 30, 3, -28 },
  { 939, 14, 16, 30, 2, -7 },
  { 967, 14, 4, 30, 8, -14 },
  { 974, 7, 7, 30, 10, -7 },
  { 981, 32, 37, 30, 0, -36 },
  { 1129, 25, 33, 30, 3, -33 },
  { 1233, 25, 33, 30, 1, -33 },
  { 1337, 27, 33, 30, 1, -33 },
  { 1449, 26, 33, 30, 2, -33 },
  { 1557, 26, 33, 30, 1, -33 },
  { 1665, 27, 33, 30, 2, -33 },
  { 1777, 24, 33, 30, 4, -33 },
  { 1876, 23, 33, 30, 7, -33 },
  { 1971, 26, 33, 30, 2, -33 },
  { 2079, 25, 33, 30, 3, -33 },
  { 2183, 10, 26, 30, 10, -26 },
  { 2216, 16, 35, 30, 4, -26 },
  { 2286, 24, 25, 30, 3, -29 },
  { 2361, 24, 17, 30, 3, -25 },
  { 2412, 24, 25, 30, 3, -29 },
  { 2487, 25, 34, 30, 4, -34 },
  { 2594, 31, 42, 30, 0, -36 },
  { 2757, 30, 33, 30, -3, -33 },
  { 2881, 28, 33, 30, 1, -33 },
  { 2997, 27, 35, 30, 3, -34 },
  { 3116, 28, 33, 30, 1, -33 },
  { 3232, 29, 33, 30, 1, -33 },
  { 3352, 28, 33, 30, 2, -33 },
  { 3468, 26, 35, 30, 3, -34 },
  { 3582, 29, 33, 30, 1, -33 },
  { 3702, 27, 33, 30, 2, -33 },
  { 3814, 25, 34, 30, 3, -33 },
  { 3921, 31, 33, 30, 1, -33 },
  { 4049, 22, 33, 30, 3, -33 },
  { 4140, 30, 33, 30, 1, -33 },
  { 4264, 29, 33, 30, 1, -33 },
  { 4384, 27, 35, 30, 2, -34 },
  { 4503, 28, 33, 30, 1, -33 },
  { 4619, 27, 44, 30, 2, -34 },
  { 4768, 29, 33, 30, 1, -33 },
  { 4888, 28, 35, 30, 1, -34 },
  { 5011, 27, 33, 30, 5, -33 },
  { 5123, 27, 34, 30, 3, -33 },
  { 5238, 30, 33, 30, 4, -33 },
  { 5362, 31, 33, 30, 3, -33 },
  { 5490, 34, 33, 30, -2, -33 },
  { 5631, 28, 33, 30, 5, -33 },
  { 5747, 32, 33, 30, -1, -33 },
  { 5879, 23, 46, 30, 5, -36 },
  { 6012, 18, 37, 30, 7, -36 },
  { 6096, 22, 46, 30, 2, -36 },
  { 6223, 23, 22, 30, 3, -33 },
  { 6287, 31, 2, 30, -4, 3 },
  { 6295, 9, 6, 30, 14, -35 },
  { 6302, 24, 28, 30, 2, -27 },
  { 6386, 25, 37, 30, 2, -36 },
  { 6502, 24, 28, 30, 3, -27 },
  { 6586, 27, 37, 30, 3, -36 },
  { 6711, 24, 28, 30, 3, -27 },
  { 6795, 26, 36, 30, 5, -36 },
  { 6912, 26, 37, 30, 2, -27 },
  { 7033, 25, 36, 30, 2, -36 },
  { 7146, 25, 36, 30, 1, -36 },
  { 7259, 27, 46, 30, -2, -36 },
  { 7415, 26, 36, 30, 3, -36 },
  { 7532, 24, 36, 30, 1, -36 },
  { 7640, 29, 27, 30, 0, -27 },
  { 7738, 25, 27, 30, 2, -27 },
  { 7823, 24, 28, 30, 3, -27 },
  { 7907, 27, 37, 30, 0, -27 },
  { 8032, 25, 37, 30, 3, -27 },
  { 8148, 23, 27, 30, 5, -27 },
  { 8226, 24, 28, 30, 3, -27 },
  { 8310, 19, 34, 30, 7, -33 },
  { 8391, 25, 27, 30, 3, -26 },
  { 8476, 27, 26, 30, 4, -26 },
  { 8564, 30, 26, 30, 2, -26 },
  { 8662, 30, 26, 30, 0, -26 },
  { 8760, 31, 36, 30, 0, -26 },
  { 8900, 27, 26, 30, 1, -26 },
  { 8988, 25, 46, 30, 5, -36 },
  { 9132, 4, 46, 30, 13, -36 },
  { 9155, 26, 46, 30, -1, -36 },
  { 9305, 25, 6, 30, 3, -20 },
};

const GFXfont LiberationMono_Italic50pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic50pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic50pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _LIBERATIONMONO_ITALIC50PT7B_H_
