#ifndef _LIBERATIONMONO_ITALIC26PT7B_H_
#define _LIBERATIONMONO_ITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x00, 0x06,
  0x38, 0xE0, 0x73, 0xB1, 0xF8, 0xFC, 0x6E, 0x36, 0x1B, 0x0D, 0x84, 0x00,
  0x82, 0x01, 0x86, 0x01, 0x04, 0x03, 0x0C, 0x02, 0x08, 0x3F, 0xFF, 0x04,
  0x10, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x20, 0xFF, 0xFC, 0x10, 0x40, 0x30,
  0xC0, 0x20, 0x80, 0x20, 0x80, 0x61, 0x80, 0x41, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x0F, 0xE0, 0x7F, 0xF1, 0xE4, 0xE3, 0x18, 0xC6, 0x30, 0x0C, 0x60,
  0x1C, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x0D, 0xE0, 0x18, 0xC0, 0x21, 0xB8,
  0x43, 0x31, 0x8E, 0x73, 0x38, 0x7F, 0xE0, 0x7F, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x1F, 0x03, 0x18, 0x83, 0x08, 0x61, 0x0C, 0x31, 0x86, 0x31, 0x83,
  0x19, 0x81, 0x89, 0x80, 0x79, 0x80, 0x01, 0x80, 0x01, 0x9E, 0x01, 0x99,
  0x80, 0x98, 0xC0, 0xCC, 0x60, 0xC6, 0x30, 0xC3, 0x18, 0xC1, 0x98, 0xC0,
  0x78, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x71, 0x81, 0x86, 0x0C, 0x18, 0x31,
  0xC0, 0x7C, 0x03, 0xC3, 0x3E, 0x0D, 0xCC, 0x66, 0x31, 0xB0, 0x6C, 0xC1,
  0xF3, 0x03, 0x8E, 0x1F, 0x1F, 0xFF, 0x3E, 0x1C, 0x6E, 0xEE, 0xCC, 0xCC,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x80,
  0x0C, 0x06, 0x22, 0x3D, 0x77, 0xE0, 0xC0, 0xB0, 0xCC, 0x44, 0x00, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x38, 0x61, 0xC3, 0x0C,
  0x18, 0x60, 0xFE, 0xFE, 0x7E, 0xEE, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0x8E,
  0x1C, 0x60, 0x77, 0x03, 0xB0, 0x1F, 0x80, 0xF8, 0xE7, 0xC7, 0x36, 0x71,
  0xB0, 0x1D, 0x80, 0xCC, 0x06, 0x60, 0x63, 0x87, 0x0F, 0xF0, 0x3E, 0x00,
  0x00, 0xE0, 0x1E, 0x07, 0xC3, 0xEC, 0x38, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xF8, 0x38, 0x78, 0x60, 0x71, 0xC0, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x03, 0xF0,
  0x3F, 0xE1, 0xC1, 0xC6, 0x07, 0x38, 0x1C, 0x00, 0x60, 0x07, 0x01, 0xF8,
  0x07, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0xE0, 0x33, 0x81, 0xCF, 0x0E,
  0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x33,
  0x03, 0x38, 0x31, 0xC3, 0x0C, 0x30, 0x61, 0x83, 0x18, 0x19, 0xFF, 0xFF,
  0xFF, 0x80, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0xFC, 0x7F, 0xF1,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x7C, 0x0F, 0xFC, 0x78, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0xC0, 0x33, 0x81, 0xCF, 0x0E, 0x1F, 0xF0,
  0x3F, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x73, 0x00, 0x30, 0x01,
  0x9F, 0x1F, 0xFC, 0xF0, 0xF7, 0x03, 0xB0, 0x1D, 0x80, 0xEC, 0x06, 0x60,
  0x73, 0x87, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xE1,
  0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x61, 0x83, 0x07, 0xF8, 0x1F, 0xE0,
  0xE1, 0xC6, 0x03, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xCF, 0x0E, 0x1F, 0xF0,
  0x3F, 0x80, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x06, 0x30, 0x1C, 0xC0,
  0x73, 0x01, 0x8C, 0x0E, 0x38, 0x78, 0xFF, 0x60, 0xF3, 0x80, 0x0C, 0x00,
  0x71, 0x81, 0x87, 0x1C, 0x1F, 0xE0, 0x3F, 0x00, 0x1C, 0xE3, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x38, 0xE3, 0x80, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xC0,
  0xE0, 0x60, 0x60, 0x00, 0x00, 0x08, 0x03, 0xC0, 0x7C, 0x1F, 0x83, 0xE0,
  0x7C, 0x03, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3C, 0x00, 0x60, 0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x0C, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0x8E, 0x0E, 0xC0, 0x7E, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x03, 0x0C, 0x06, 0x06, 0x0C,
  0x03, 0x18, 0x03, 0x10, 0xEF, 0x31, 0x2B, 0x22, 0x1B, 0x66, 0x3B, 0x6C,
  0x33, 0x4C, 0x32, 0x48, 0x22, 0xD8, 0x66, 0xD8, 0x66, 0xD8, 0xC4, 0xD8,
  0xCC, 0xD9, 0x58, 0xCE, 0x70, 0x40, 0x00, 0x60, 0x20, 0x30, 0xE0, 0x1F,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x60, 0x0E, 0xC0, 0x19, 0x80, 0x63,
  0x00, 0xC6, 0x03, 0x0E, 0x06, 0x1C, 0x18, 0x18, 0x7F, 0xF0, 0xFF, 0xE3,
  0x80, 0xC6, 0x01, 0xDC, 0x03, 0xB0, 0x03, 0xC0, 0x06, 0x1F, 0xF0, 0x7F,
  0xE1, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x63, 0x03, 0x0F, 0xF8, 0x7F,
  0xF1, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x80, 0xEE, 0x07, 0x3F,
  0xF8, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0xE1, 0xE1, 0xC6, 0x03, 0x38, 0x0C,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x04,
  0x60, 0x39, 0x81, 0xC7, 0x0E, 0x0F, 0xF0, 0x1F, 0x00, 0x1F, 0xC0, 0x7F,
  0xC1, 0x87, 0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x73, 0x01, 0xCC, 0x07, 0x70,
  0x1D, 0xC0, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x33, 0x81, 0xCE, 0x1E, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xF8, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xE1,
  0xC6, 0x07, 0x38, 0x0C, 0xC0, 0x07, 0x00, 0x1C, 0x7E, 0x61, 0xF9, 0x80,
  0x6E, 0x03, 0xB8, 0x0E, 0x60, 0x31, 0x80, 0xC7, 0x07, 0x0F, 0xF8, 0x1F,
  0x80, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x31, 0xC0, 0xE3, 0x81, 0xC6, 0x03,
  0x0C, 0x06, 0x1F, 0xFC, 0x7F, 0xF8, 0xE0, 0x71, 0x80, 0xC3, 0x01, 0x86,
  0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x38, 0xC0, 0x60, 0x1F, 0xFC, 0x7F,
  0xF0, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x1F,
  0xF8, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x8C, 0x1C,
  0x60, 0xE3, 0x8E, 0x1F, 0xE0, 0x3E, 0x00, 0x18, 0x0E, 0x18, 0x1C, 0x18,
  0x38, 0x38, 0x70, 0x38, 0xE0, 0x31, 0xC0, 0x37, 0x80, 0x3F, 0x00, 0x7F,
  0x80, 0x7B, 0x80, 0x71, 0xC0, 0x61, 0xC0, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0xC0, 0x30, 0xC0, 0x38, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0xFF, 0xFF, 0xE0, 0x0E, 0x07, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E,
  0x1E, 0x1F, 0x36, 0x1B, 0x36, 0x33, 0x66, 0x33, 0x6E, 0x33, 0xCC, 0x33,
  0x8C, 0x31, 0x8C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x18, 0xC0, 0x18, 0x1C, 0x0C, 0x38, 0x18, 0x78, 0x31, 0xB0, 0x63, 0x61,
  0xC6, 0xC3, 0x0D, 0xC6, 0x19, 0x8C, 0x73, 0x18, 0xC6, 0x71, 0x86, 0xC3,
  0x0D, 0x86, 0x1B, 0x1C, 0x3E, 0x30, 0x3C, 0x60, 0x78, 0xC0, 0xE0, 0x03,
  0xE0, 0x3F, 0xE1, 0xE3, 0x8E, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xD8,
  0x07, 0x60, 0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x0E, 0xE0, 0x31, 0x81, 0xC7,
  0x0E, 0x1F, 0xF0, 0x1F, 0x00, 0x1F, 0xF0, 0x7F, 0xF1, 0x81, 0xCE, 0x03,
  0x38, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x0E, 0x7F, 0xF1, 0xFF, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0xE3, 0x8E, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xD8,
  0x07, 0x60, 0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xC7,
  0x0E, 0x1F, 0xF0, 0x1F, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0xF0, 0x7F, 0xF1, 0x81, 0xCE, 0x03, 0x38, 0x0C, 0xC0,
  0x73, 0x03, 0x8F, 0xFC, 0x7F, 0xC1, 0x86, 0x06, 0x1C, 0x18, 0x30, 0x60,
  0xE3, 0x83, 0x8E, 0x07, 0x30, 0x1C, 0xC0, 0x30, 0x03, 0xF0, 0x3F, 0xE1,
  0xC1, 0xCE, 0x07, 0x30, 0x0C, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xE0, 0x03, 0x80, 0x06, 0xC0, 0x3B, 0x00, 0xCE, 0x0F, 0x1F, 0xF8,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x18, 0x0E, 0x70, 0x18,
  0xE0, 0x31, 0xC0, 0x63, 0x01, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x70,
  0x18, 0xC0, 0x71, 0x80, 0xE7, 0x01, 0x8E, 0x03, 0x1C, 0x0E, 0x1C, 0x38,
  0x3F, 0xE0, 0x3F, 0x00, 0xE0, 0x07, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0xC6,
  0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x38, 0x30, 0x30, 0xE0, 0x61, 0x80, 0xC6,
  0x01, 0xCC, 0x03, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0x63, 0x1C,
  0x71, 0x8E, 0x30, 0xCF, 0x18, 0x67, 0x9C, 0x32, 0xCC, 0x1B, 0x66, 0x0D,
  0x97, 0x0F, 0x8B, 0x06, 0xC5, 0x83, 0xC3, 0x81, 0xE1, 0xC0, 0xE0, 0xE0,
  0x00, 0x0E, 0x01, 0x81, 0x80, 0xC0, 0x70, 0x60, 0x0C, 0x38, 0x03, 0x9C,
  0x00, 0x6E, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x37, 0x00, 0x18, 0xC0, 0x0E, 0x38, 0x07, 0x06, 0x03, 0x81, 0xC1, 0xC0,
  0x30, 0x60, 0x0E, 0x00, 0x60, 0x0E, 0xE0, 0x38, 0xC0, 0x61, 0x81, 0x83,
  0x87, 0x03, 0x1C, 0x07, 0x70, 0x06, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xE1,
  0xFC, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x3F, 0x87, 0xF0, 0xC0, 0x70, 0x18, 0x0C, 0x07,
  0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0E, 0x03, 0x01, 0x80, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0xFE, 0x0F, 0xE0, 0x01, 0xC0, 0x0A, 0x00, 0xD8, 0x0C, 0xC0,
  0x66, 0x06, 0x30, 0x30, 0x83, 0x06, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0,
  0x30, 0xFF, 0xFF, 0xE1, 0x86, 0x07, 0xE0, 0xFF, 0x8E, 0x1C, 0x60, 0x60,
  0x03, 0x07, 0xF8, 0xFF, 0xCE, 0x0E, 0xE0, 0x67, 0x03, 0x30, 0x39, 0xC6,
  0xCF, 0xE7, 0xBE, 0x38, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0xF0, 0xFF, 0xC7, 0x87, 0x38, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x37,
  0x03, 0xB0, 0x19, 0x80, 0xCE, 0x0E, 0xF0, 0xE7, 0xFE, 0x33, 0xE0, 0x07,
  0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x37, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x1C, 0xE1, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0xFB, 0x87, 0xFE, 0x1E,
  0x3C, 0x30, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x01, 0x86, 0x03, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x78, 0x71, 0xE0, 0xFE, 0xC0, 0xF9, 0x80, 0x07, 0xE0,
  0x7F, 0x87, 0x0E, 0x70, 0x37, 0x01, 0xB8, 0x0D, 0xFF, 0xEF, 0xFF, 0xE0,
  0x07, 0x00, 0x18, 0x08, 0xE1, 0xC7, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x3F,
  0xC3, 0x80, 0x18, 0x01, 0xC0, 0x7F, 0xFB, 0xFF, 0xC3, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0x07, 0x9C, 0x7F, 0x63, 0xC7, 0x8E, 0x0E, 0x30,
  0x39, 0xC0, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x81, 0xC6, 0x0F, 0x1C,
  0x78, 0x7F, 0x60, 0xF9, 0x80, 0x06, 0x30, 0x30, 0xE1, 0xC1, 0xFE, 0x03,
  0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xF8,
  0xFF, 0xE6, 0x87, 0x38, 0x19, 0x81, 0xCC, 0x0E, 0xE0, 0x67, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x0E, 0xE0, 0x67, 0x03, 0x30, 0x18, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x83, 0xFF, 0xDF, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x0F, 0xF0, 0x3F, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x1C, 0xC1, 0xC6, 0x1C, 0x31,
  0xC3, 0x9C, 0x1D, 0xC0, 0xDC, 0x07, 0xE0, 0x3B, 0x81, 0x8C, 0x1C, 0x70,
  0xE1, 0xC6, 0x0E, 0x30, 0x38, 0x03, 0xF0, 0x3F, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x03, 0xFF, 0xFF, 0xFE,
  0x13, 0x9C, 0x6F, 0x7C, 0xE7, 0x99, 0xCE, 0x33, 0x1C, 0x66, 0x31, 0xDC,
  0x63, 0x30, 0xC6, 0x63, 0x8C, 0xC6, 0x19, 0x8C, 0x77, 0x18, 0xCC, 0x31,
  0x98, 0xE3, 0x00, 0x19, 0xF1, 0xFF, 0xCD, 0x0E, 0x70, 0x33, 0x03, 0x98,
  0x1D, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x01, 0x98, 0x1D, 0xC0, 0xCE, 0x06,
  0x60, 0x30, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x37, 0x01, 0xB0, 0x0D,
  0x80, 0x6C, 0x07, 0xE0, 0x3F, 0x01, 0x98, 0x1C, 0xE1, 0xC7, 0xFC, 0x0F,
  0x80, 0x0C, 0xF0, 0x7F, 0xF1, 0xE1, 0xC7, 0x03, 0x1C, 0x0C, 0x60, 0x33,
  0x80, 0xCE, 0x07, 0x30, 0x18, 0xC0, 0x63, 0x83, 0x9E, 0x1C, 0x7F, 0xE1,
  0x9F, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x07,
  0xDC, 0x7F, 0x63, 0xC7, 0x8C, 0x0E, 0x70, 0x39, 0x80, 0xE6, 0x03, 0x18,
  0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x0F, 0x1C, 0x78, 0x7F, 0x60, 0xF9, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x39, 0xF9, 0xDF,
  0x8F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x7F, 0x86,
  0x0E, 0x70, 0x33, 0x80, 0x1E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x70, 0x01,
  0xB8, 0x1C, 0xC0, 0xC7, 0xFC, 0x1F, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x07, 0xFF, 0xFF, 0x8E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0x87, 0xE0, 0x30, 0x3B, 0x81, 0x98,
  0x0C, 0xC0, 0x66, 0x07, 0x30, 0x3B, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x07,
  0x30, 0x39, 0xC7, 0x8F, 0xEC, 0x3E, 0x60, 0xE0, 0x1F, 0x80, 0x66, 0x03,
  0x98, 0x1C, 0x70, 0x61, 0xC3, 0x83, 0x0C, 0x0C, 0x70, 0x31, 0x80, 0xCC,
  0x03, 0xB0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0xE0, 0x0C, 0xE3, 0x8C, 0xE7, 0x9C, 0xE7, 0x98, 0xED, 0x98,
  0xED, 0xB8, 0xD8, 0xB0, 0xD8, 0xB0, 0xF0, 0xB0, 0xF0, 0xE0, 0xE0, 0xE0,
  0x1C, 0x0E, 0x18, 0x18, 0x38, 0x60, 0x31, 0x80, 0x76, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x06, 0xC0, 0x19, 0xC0, 0x71, 0x81, 0xC3, 0x87, 0x03,
  0x1C, 0x07, 0x00, 0x38, 0x07, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x1C,
  0x18, 0x1C, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0E, 0xC0, 0x06,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xF8, 0x1F, 0xC1, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x0F,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC0, 0x7F, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x80, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xFE, 0x34, 0x3F, 0xA0, 0x3C,
};

const GFXglyph LiberationMono_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 17, 16, 5, -17 },
  { 14, 9, 8, 16, 5, -19 },
  { 23, 16, 17, 16, 0, -17 },
  { 57, 15, 21, 16, 0, -19 },
  { 97, 17, 17, 16, 0, -17 },
  { 134, 14, 17, 16, 0, -17 },
  { 164, 4, 8, 16, 8, -19 },
  { 168, 10, 24, 16, 4, -19 },
  { 198, 10, 24, 16, 2, -19 },
  { 228, 9, 9, 16, 5, -19 },
  { 239, 13, 12, 16, 1, -15 },
  { 259, 7, 8, 16, 1, -4 },
  { 266, 8, 2, 16, 4, -7 },
  { 268, 4, 4, 16, 5, -4 },
  { 270, 16, 19, 16, 0, -19 },
  { 308, 13, 17, 16, 2, -17 },
  { 336, 12, 17, 16, 1, -17 },
  { 362, 15, 17, 16, 0, -17 },
  { 394, 14, 17, 16, 1, -17 },
  { 424, 13, 17, 16, 1, -17 },
  { 452, 14, 17, 16, 1, -17 },
  { 482, 13, 17, 16, 2, -17 },
  { 510, 12, 17, 16, 4, -17 },
  { 536, 14, 17, 16, 1, -17 },
  { 566, 14, 17, 16, 1, -17 },
  { 596, 6, 14, 16, 5, -14 },
  { 607, 9, 18, 16, 2, -14 },
  { 628, 13, 13, 16, 1, -15 },
  { 650, 13, 8, 16, 1, -13 },
  { 663, 13, 13, 16, 1, -15 },
  { 685, 13, 17, 16, 2, -17 },
  { 713, 16, 22, 16, 0, -19 },
  { 757, 15, 17, 16, -1, -17 },
  { 789, 14, 17, 16, 1, -17 },
  { 819, 14, 17, 16, 1, -17 },
  { 849, 14, 17, 16, 1, -17 },
  { 879, 15, 17, 16, 1, -17 },
  { 911, 15, 17, 16, 1, -17 },
  { 943, 14, 17, 16, 1, -17 },
  { 973, 15, 17, 16, 1, -17 },
  { 1005, 14, 17, 16, 1, -17 },
  { 1035, 13, 17, 16, 2, -17 },
  { 1063, 16, 17, 16, 1, -17 },
  { 1097, 11, 17, 16, 2, -17 },
  { 1121, 16, 17, 16, 0, -17 },
  { 1155, 15, 17, 16, 1, -17 },
  { 1187, 14, 17, 16, 1, -17 },
  { 1217, 14, 17, 16, 1, -17 },
  { 1247, 14, 22, 16, 1, -17 },
  { 1286, 14, 17, 16, 1, -17 },
  { 1316, 14, 17, 16, 1, -17 },
  { 1346, 14, 17, 16, 3, -17 },
  { 1376, 15, 17, 16, 1, -17 },
  { 1408, 15, 17, 16, 2, -17 },
  { 1440, 17, 17, 16, 1, -17 },
  { 1477, 18, 17, 16, -1, -17 },
  { 1516, 15, 17, 16, 2, -17 },
  { 1548, 16, 17, 16, 0, -17 },
  { 1582, 11, 24, 16, 3, -19 },
  { 1615, 9, 19, 16, 4, -19 },
  { 1637, 12, 24, 16, 1, -19 },
  { 1673, 13, 12, 16, 1, -17 },
  { 1693, 16, 1, 16, -2, 2 },
  { 1695, 5, 3, 16, 7, -18 },
  { 1697, 13, 14, 16, 1, -14 },
  { 1720, 13, 19, 16, 1, -19 },
  { 1751, 13, 14, 16, 1, -14 },
  { 1774, 15, 19, 16, 1, -19 },
  { 1810, 13, 14, 16, 1, -14 },
  { 1833, 13, 19, 16, 3, -19 },
  { 1864, 14, 19, 16, 1, -14 },
  { 1898, 13, 19, 16, 1, -19 },
  { 1929, 13, 19, 16, 0, -19 },
  { 1960, 14, 24, 16, -1, -19 },
  { 2002, 13, 19, 16, 2, -19 },
  { 2033, 13, 19, 16, 0, -19 },
  { 2064, 15, 14, 16, 0, -14 },
  { 2091, 13, 14, 16, 1, -14 },
  { 2114, 13, 14, 16, 1, -14 },
  { 2137, 14, 19, 16, 0, -14 },
  { 2171, 14, 19, 16, 1, -14 },
  { 2205, 13, 14, 16, 2, -14 },
  { 2228, 13, 14, 16, 1, -14 },
  { 2251, 11, 18, 16, 3, -18 },
  { 2276, 13, 14, 16, 2, -14 },
  { 2299, 14, 14, 16, 2, -14 },
  { 2324, 16, 14, 16, 1, -14 },
  { 2352, 15, 14, 16, 0, -14 },
  { 2379, 16, 19, 16, 0, -14 },
  { 2417, 13, 14, 16, 1, -14 },
  { 2440, 13, 24, 16, 3, -19 },
  { 2479, 2, 24, 16, 7, -19 },
  { 2485, 13, 24, 16, 0, -19 },
  { 2524, 14, 4, 16, 1, -11 },
};

const GFXfont LiberationMono_Italic26pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic26pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic26pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _LIBERATIONMONO_ITALIC26PT7B_H_
