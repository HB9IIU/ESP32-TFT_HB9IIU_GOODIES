#ifndef _LIBERATIONMONO_ITALIC7PT7B_H_
#define _LIBERATIONMONO_ITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xB4, 0x07, 0x5F, 0x80, 0x36, 0x63, 0xE0, 0x4B, 0x67,
  0xB0, 0x25, 0x6A, 0xE0, 0xC0, 0x4A, 0x49, 0x00, 0x24, 0x92, 0x80, 0x48,
  0x2F, 0x20, 0x60, 0x40, 0x80, 0x12, 0x24, 0x80, 0x25, 0xB9, 0x60, 0x06,
  0x22, 0xF0, 0x35, 0x34, 0xE0, 0x35, 0x21, 0xE0, 0x13, 0x5F, 0x20, 0x74,
  0x71, 0xE0, 0x34, 0x79, 0x60, 0xE5, 0x48, 0x25, 0x69, 0xE0, 0x25, 0x53,
  0xE0, 0x42, 0x42, 0x80, 0x3C, 0x60, 0x6F, 0x43, 0x60, 0xC5, 0x08, 0x7B,
  0xFB, 0xEE, 0x26, 0x5F, 0x90, 0x65, 0x69, 0xE0, 0x35, 0x88, 0x60, 0x65,
  0x99, 0xE0, 0x74, 0x78, 0xF0, 0x74, 0x68, 0x80, 0x35, 0x89, 0x70, 0x45,
  0x79, 0x90, 0x72, 0x22, 0xE0, 0x31, 0x12, 0x60, 0x56, 0x4A, 0x90, 0x44,
  0x44, 0x60, 0x55, 0xB9, 0x90, 0x45, 0xBB, 0xA0, 0x25, 0x99, 0x60, 0x65,
  0xF8, 0x80, 0x25, 0x99, 0x66, 0x75, 0xDA, 0x90, 0x35, 0x61, 0xE0, 0xE9,
  0x28, 0x45, 0x99, 0xE0, 0x1A, 0xAC, 0x80, 0x0C, 0x6D, 0xEA, 0x00, 0x45,
  0x26, 0x90, 0x1A, 0x44, 0x80, 0x71, 0x24, 0xF0, 0x4A, 0x49, 0x00, 0xA5,
  0x40, 0x24, 0x92, 0xC0, 0x26, 0x50, 0x78, 0x80, 0x63, 0xDE, 0x47, 0x59,
  0xE0, 0x68, 0x8E, 0x17, 0x99, 0xE0, 0x69, 0xEE, 0x7E, 0x48, 0x79, 0x96,
  0x60, 0x47, 0x59, 0x90, 0x26, 0x22, 0x60, 0x0C, 0x93, 0x80, 0x45, 0x66,
  0xA0, 0x22, 0x22, 0x60, 0x5B, 0xBD, 0x75, 0x99, 0x69, 0x9E, 0x75, 0x9E,
  0x80, 0x79, 0x9E, 0x20, 0xF2, 0x40, 0x64, 0x2E, 0x1E, 0x48, 0x55, 0x9E,
  0x17, 0x40, 0x8B, 0xFA, 0x56, 0x6A, 0x05, 0x64, 0xC0, 0x72, 0x4C, 0x49,
  0x49, 0x00, 0xFC, 0x24, 0x94, 0x80, 0x60,
};

const GFXglyph LiberationMono_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 3, 6, 4, 1, -5 },
  { 20, 3, 6, 4, 0, -5 },
  { 23, 3, 2, 4, 1, -5 },
  { 24, 4, 3, 4, 0, -4 },
  { 26, 2, 2, 4, 0, -1 },
  { 27, 2, 1, 4, 1, -2 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 3, 5, 4, 1, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 2, 5, 4, 1, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 2, 4, 0, -3 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 5, 4, 1, -5 },
  { 71, 4, 6, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 6, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 3, 5, 4, 1, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 1, -5 },
  { 139, 5, 5, 4, 0, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 4, 5, 4, 1, -5 },
  { 149, 4, 5, 4, 0, -5 },
  { 152, 3, 6, 4, 1, -5 },
  { 155, 2, 5, 4, 1, -5 },
  { 157, 3, 6, 4, 0, -5 },
  { 160, 4, 3, 4, 0, -5 },
  { 162, 5, 1, 4, -1, 0 },
  { 163, 1, 1, 4, 2, -5 },
  { 164, 4, 4, 4, 0, -4 },
  { 166, 4, 5, 4, 0, -5 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 3, 5, 4, 1, -5 },
  { 178, 4, 5, 4, 0, -4 },
  { 181, 4, 5, 4, 0, -5 },
  { 184, 4, 5, 4, 0, -5 },
  { 187, 3, 6, 4, 0, -5 },
  { 190, 4, 5, 4, 0, -5 },
  { 193, 4, 5, 4, 0, -5 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 4, 4, 4, 0, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 5, 4, 0, -4 },
  { 205, 4, 5, 4, 0, -4 },
  { 208, 3, 4, 4, 1, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 3, 5, 4, 1, -5 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 3, 4, 4, 1, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 4, 5, 4, 0, -4 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 3, 6, 4, 1, -5 },
  { 230, 1, 6, 4, 2, -5 },
  { 231, 3, 6, 4, 0, -5 },
  { 234, 4, 1, 4, 0, -3 },
};

const GFXfont LiberationMono_Italic7pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic7pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _LIBERATIONMONO_ITALIC7PT7B_H_
