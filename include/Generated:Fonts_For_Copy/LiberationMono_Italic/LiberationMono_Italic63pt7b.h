#ifndef _LIBERATIONMONO_ITALIC63PT7B_H_
#define _LIBERATIONMONO_ITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0xF1,
  0xFE, 0x01, 0xFC, 0x0F, 0x07, 0xF0, 0x1F, 0x80, 0xF0, 0x3F, 0x03, 0xF0,
  0x1E, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x01, 0x80,
  0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x01, 0xFF,
  0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0x0F, 0xF8, 0x00, 0x00,
  0xF0, 0x3F, 0x80, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0x00, 0x1E, 0x00,
  0xFC, 0x1C, 0x01, 0xE0, 0x0F, 0x8F, 0xC0, 0x1E, 0x00, 0xF8, 0xFC, 0x01,
  0xE0, 0x1F, 0x8F, 0xC0, 0x1E, 0x01, 0xF0, 0xFE, 0x03, 0xC0, 0x3F, 0x07,
  0xF0, 0x3C, 0x0F, 0xE0, 0x7F, 0xE3, 0xC7, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x3E, 0x1F,
  0x00, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x03,
  0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x1F,
  0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x03, 0xC1, 0xF0, 0x00, 0x1E,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x81, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xF1,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0xF8,
  0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x78, 0x7C, 0x3E,
  0x00, 0x00, 0x78, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x7C, 0x07, 0xC0, 0x00,
  0x78, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x3E,
  0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x00, 0x3C,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x87, 0xE0,
  0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x7F, 0x80,
  0x00, 0x1F, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x7F, 0xF0,
  0x01, 0xF0, 0x3F, 0xFC, 0x00, 0x78, 0x1F, 0x9F, 0x00, 0x3E, 0x0F, 0xC7,
  0xE0, 0x0F, 0x87, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x01, 0xF0, 0xF8,
  0x07, 0xC0, 0x78, 0x7E, 0x01, 0xF8, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x07,
  0xC0, 0x0F, 0xC7, 0xC3, 0xF0, 0x01, 0xFB, 0xE0, 0xF8, 0x00, 0x7E, 0xF0,
  0x3E, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x03, 0xFE, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x07,
  0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xF0, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7C, 0x3F,
  0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F,
  0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x0C, 0x0F, 0x01, 0x1E, 0x1E, 0x1E, 0x7F, 0xBD, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x8F, 0x00, 0x3E, 0x1F,
  0x00, 0x78, 0x3E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x01, 0x00, 0x40,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x3F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFD, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x07, 0xF0, 0x3E, 0x7E,
  0x07, 0xF0, 0x3E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7C, 0x0F, 0xE0, 0x7E, 0xFC,
  0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x7C, 0xFC, 0x0F, 0xE0, 0x7C, 0xFC,
  0x1F, 0xE0, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFB, 0xE0, 0x03, 0xFF, 0x8F,
  0x80, 0x0F, 0xF8, 0x7E, 0x00, 0x7F, 0x81, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x07, 0x81, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xFC, 0x00, 0x0F, 0xCF,
  0xFF, 0x80, 0x07, 0xDF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x81, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0x01,
  0xFB, 0xFF, 0xFF, 0x03, 0xEF, 0xFF, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xF8, 0xFE,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xE3, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0xE3,
  0xE0, 0x0F, 0xFF, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0xFC, 0x03, 0xC0, 0x3C, 0x07, 0xFC, 0x73, 0xC0,
  0x78, 0x1F, 0xF9, 0xE7, 0x81, 0xE0, 0x7C, 0x7B, 0x8F, 0x03, 0xC1, 0xE0,
  0x7F, 0x1E, 0x0F, 0x07, 0x80, 0xFE, 0x3C, 0x1E, 0x1F, 0x00, 0xF8, 0x70,
  0x78, 0x3C, 0x01, 0xF0, 0xE0, 0xF0, 0xF0, 0x07, 0xE3, 0xC3, 0xC1, 0xE0,
  0x0F, 0x87, 0x87, 0x87, 0x80, 0x1F, 0x0F, 0x0F, 0x0F, 0x00, 0x3C, 0x1E,
  0x1E, 0x3C, 0x00, 0x78, 0x38, 0x78, 0x78, 0x01, 0xF0, 0x70, 0xF1, 0xF0,
  0x03, 0xC1, 0xE1, 0xE3, 0xC0, 0x07, 0x83, 0xC3, 0x87, 0x80, 0x1E, 0x07,
  0x0F, 0x0F, 0x00, 0x3C, 0x0E, 0x1E, 0x3C, 0x00, 0xF8, 0x3C, 0x3C, 0x78,
  0x01, 0xE0, 0x70, 0x78, 0xF0, 0x03, 0xC0, 0xE0, 0xF1, 0xE0, 0x0F, 0x83,
  0xC1, 0xC3, 0xC0, 0x3E, 0x07, 0x07, 0x87, 0x80, 0x7C, 0x1E, 0x0F, 0x0F,
  0x01, 0xF8, 0x38, 0x1E, 0x1E, 0x07, 0xE0, 0xE0, 0x3C, 0x3C, 0x1D, 0xC3,
  0xC0, 0x78, 0x7C, 0x7B, 0x8F, 0x00, 0xF0, 0x7F, 0xE7, 0xFC, 0x01, 0xF0,
  0xFF, 0x0F, 0xF0, 0x01, 0xE0, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x03, 0xFC, 0x0F, 0xC0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xF8, 0x1F, 0x80,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xC3, 0xF8, 0x00, 0x01, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x03, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xF3,
  0xF0, 0x03, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xFC,
  0x7E, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x3F, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x0E, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F,
  0x83, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0xFF, 0x00,
  0x00, 0x07, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x00, 0xFD,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xC0, 0x00, 0x07, 0xFE,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x0F, 0xFC, 0x03, 0xEF,
  0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0x9F,
  0x00, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x1F, 0x1F,
  0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0xF8, 0xF8,
  0x07, 0xC7, 0xC7, 0xC7, 0xC0, 0x3E, 0x1F, 0x1E, 0x1F, 0x00, 0xF8, 0x7C,
  0xF8, 0x7C, 0x03, 0xE0, 0xF3, 0xC1, 0xF0, 0x0F, 0x83, 0xDF, 0x07, 0xC0,
  0x3E, 0x0F, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0xE0, 0xF8, 0x07, 0xC0, 0xFF,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x3E, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x00, 0x3E, 0x01, 0xFF,
  0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x07, 0xC0,
  0x3F, 0xF8, 0x00, 0x7C, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0x3E, 0xF8, 0x00,
  0x7C, 0x03, 0xEF, 0x80, 0x0F, 0xC0, 0x3E, 0x7C, 0x00, 0xF8, 0x07, 0xE7,
  0xC0, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0xFC, 0x3E, 0x01,
  0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x81,
  0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x01,
  0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x87,
  0xE0, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x00,
  0x7C, 0x7C, 0x03, 0xE0, 0x07, 0xE7, 0xC0, 0x3E, 0x00, 0x7E, 0x7C, 0x03,
  0xE0, 0x03, 0xEF, 0xC0, 0x3E, 0x00, 0x3E, 0xF8, 0x07, 0xE0, 0x03, 0xFF,
  0x80, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x7C, 0x00,
  0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0x80, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xF8, 0x1F, 0x80,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0xFF,
  0xC0, 0x7C, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x0C, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x03,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0x7C,
  0x0F, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x7C,
  0x1F, 0x00, 0x7C, 0x1E, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x7C, 0x3E, 0x00,
  0x7C, 0x3C, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x3C, 0x7C, 0x00, 0x7C, 0x78,
  0x3C, 0x7C, 0x00, 0x7C, 0xF8, 0x3C, 0x7C, 0x00, 0x7C, 0xF0, 0x3C, 0x78,
  0x00, 0x7C, 0xF0, 0x3C, 0xF8, 0x00, 0x7D, 0xF0, 0x3C, 0xF8, 0x00, 0x79,
  0xE0, 0x3C, 0xF0, 0x00, 0x7B, 0xE0, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x3D,
  0xF0, 0x00, 0xFB, 0xC0, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFF,
  0x0F, 0xC0, 0x03, 0xFE, 0x1F, 0xC0, 0x1E, 0xFC, 0x1F, 0xC0, 0xF9, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0x3F, 0xFF, 0x83, 0xFE, 0x3F, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0xFF, 0xF8,
  0x01, 0xF1, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFE, 0x03, 0xF7, 0x81, 0xFE,
  0x03, 0xEE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C,
  0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0xC0, 0x07, 0xF0,
  0x7F, 0xE0, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC0, 0x7C, 0xFF, 0xFF, 0x80,
  0x7C, 0x7F, 0xFF, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F,
  0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x7F, 0xFC, 0x3E, 0x00, 0x1F, 0xFF,
  0xCF, 0xC0, 0x07, 0xFF, 0xFD, 0xF8, 0x01, 0xFC, 0x07, 0xBF, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFE, 0x07, 0xDF, 0x80, 0x1F, 0xFF, 0xF3, 0xE0, 0x01, 0xFF, 0xFC, 0x7C,
  0x00, 0x1F, 0xFE, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0x0F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xF0, 0x03,
  0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0x07, 0xDF, 0x80,
  0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x3D, 0xF0, 0x07, 0xF8, 0x3E, 0xFC, 0x01, 0xFF, 0xFF,
  0x3F, 0x00, 0x3F, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0x83, 0xE0, 0x00, 0x7F,
  0x80, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0xE0, 0x01, 0xF0, 0xFF, 0xF8, 0x01, 0xF1, 0xFF, 0xFC, 0x03, 0xF3,
  0xFF, 0xFE, 0x03, 0xF7, 0xC1, 0xFE, 0x03, 0xEE, 0x00, 0x7E, 0x03, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0x1F, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xE1, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x3F, 0xC3, 0xFE, 0x03,
  0xEF, 0xFC, 0x7F, 0xF0, 0x3C, 0xFF, 0xCF, 0xFF, 0x03, 0xDC, 0x7E, 0xE3,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0x07, 0xF0, 0x3F, 0x81, 0xF0, 0x7E, 0x03,
  0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x7E, 0x1F,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x07,
  0xC3, 0xF0, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x7F, 0xF8, 0x03, 0xF1, 0xFF, 0xFC, 0x03,
  0xF3, 0xFF, 0xFE, 0x03, 0xE7, 0xC1, 0xFE, 0x03, 0xEE, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0x0F, 0xFF, 0x80, 0x07, 0xC7, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xFE,
  0x00, 0xFD, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xFE,
  0x00, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0x80, 0x1F,
  0x1F, 0xFF, 0xC0, 0x07, 0xC3, 0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x0F, 0x80,
  0x1F, 0xFF, 0xC7, 0xC0, 0x1F, 0xFF, 0xF7, 0xE0, 0x1F, 0xC0, 0xFB, 0xF0,
  0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xDF, 0x80, 0x7F,
  0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0x87, 0xE0, 0x00,
  0xFF, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x3E, 0x03, 0xFF,
  0xC1, 0xF0, 0x7F, 0xFE, 0x0F, 0x87, 0xFF, 0xF0, 0x7C, 0x7F, 0xFF, 0x83,
  0xE7, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x60, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x77, 0xC0,
  0x7F, 0x01, 0xE7, 0xC0, 0x7F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0x8F, 0x80,
  0x1F, 0xFE, 0x0F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x07, 0xC3, 0xE0,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0xFE, 0x03, 0xE0, 0xF8, 0x0F, 0xF0, 0x1F,
  0x07, 0xC0, 0x7F, 0x81, 0xF8, 0x3E, 0x07, 0xBC, 0x0F, 0x83, 0xF0, 0x3D,
  0xE0, 0x7C, 0x1F, 0x83, 0xCF, 0x07, 0xE0, 0xFC, 0x1E, 0x78, 0x3E, 0x07,
  0xE1, 0xE3, 0xC1, 0xF0, 0x3F, 0x1F, 0x1E, 0x1F, 0x81, 0xF8, 0xF0, 0xF8,
  0xF8, 0x0F, 0x8F, 0x87, 0xC7, 0xC0, 0x7C, 0x78, 0x1E, 0x7C, 0x03, 0xE7,
  0xC0, 0xF3, 0xE0, 0x1F, 0x3C, 0x07, 0x9F, 0x00, 0xFB, 0xE0, 0x3D, 0xF0,
  0x07, 0xDE, 0x01, 0xEF, 0x80, 0x3E, 0xF0, 0x0F, 0x7C, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x1E,
  0xF0, 0x1F, 0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xE0,
};

const GFXglyph LiberationMono_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 14, 42, 38, 13, -42 },
  { 75, 23, 20, 38, 12, -46 },
  { 133, 37, 42, 38, 1, -42 },
  { 328, 36, 51, 38, 1, -46 },
  { 558, 41, 44, 38, -1, -43 },
  { 784, 34, 44, 38, 0, -43 },
  { 971, 9, 20, 38, 19, -46 },
  { 994, 24, 59, 38, 9, -46 },
  { 1171, 23, 59, 38, 5, -46 },
  { 1341, 23, 22, 38, 11, -46 },
  { 1405, 30, 30, 38, 4, -36 },
  { 1518, 17, 20, 38, 3, -9 },
  { 1561, 18, 5, 38, 10, -19 },
  { 1573, 9, 9, 38, 12, -9 },
  { 1584, 40, 47, 38, 0, -46 },
  { 1819, 32, 44, 38, 4, -43 },
  { 1995, 30, 42, 38, 2, -42 },
  { 2153, 35, 43, 38, 1, -43 },
  { 2342, 33, 44, 38, 3, -43 },
  { 2524, 32, 42, 38, 2, -42 },
  { 2692, 33, 43, 38, 3, -42 },
  { 2870, 31, 44, 38, 5, -43 },
  { 3041, 29, 42, 38, 9, -42 },
  { 3194, 33, 44, 38, 3, -43 },
  { 3376, 31, 44, 38, 4, -43 },
  { 3547, 14, 33, 38, 12, -33 },
  { 3605, 21, 44, 38, 5, -33 },
  { 3721, 30, 32, 38, 4, -37 },
  { 3841, 30, 20, 38, 4, -31 },
  { 3916, 30, 32, 38, 4, -37 },
  { 4036, 31, 43, 38, 5, -43 },
  { 4203, 39, 55, 38, 0, -46 },
  { 4472, 38, 42, 38, -3, -42 },
  { 4672, 34, 42, 38, 2, -42 },
  { 4851, 33, 44, 38, 4, -43 },
  { 5033, 34, 42, 38, 2, -42 },
  { 5212, 36, 42, 38, 2, -42 },
  { 5401, 35, 42, 38, 3, -42 },
  { 5585, 33, 44, 38, 4, -43 },
  { 5767, 36, 42, 38, 2, -42 },
  { 5956, 33, 42, 38, 3, -42 },
  { 6130, 31, 43, 38, 4, -42 },
  { 6297, 38, 42, 38, 2, -42 },
  { 6497, 28, 42, 38, 4, -42 },
  { 6644, 38, 42, 38, 1, -42 },
  { 6844, 36, 42, 38, 2, -42 },
  { 7033, 33, 44, 38, 3, -43 },
  { 7215, 35, 42, 38, 2, -42 },
  { 7399, 33, 56, 38, 3, -43 },
  { 7630, 35, 42, 38, 2, -42 },
  { 7814, 36, 44, 38, 1, -43 },
  { 8012, 34, 42, 38, 6, -42 },
  { 8191, 35, 43, 38, 3, -42 },
  { 8380, 37, 42, 38, 5, -42 },
  { 8575, 40, 42, 38, 3, -42 },
  { 8785, 42, 42, 38, -2, -42 },
  { 9006, 36, 42, 38, 6, -42 },
  { 9195, 40, 42, 38, -1, -42 },
  { 9405, 28, 59, 38, 7, -46 },
  { 9612, 22, 47, 38, 9, -46 },
  { 9742, 28, 59, 38, 3, -46 },
  { 9949, 30, 28, 38, 3, -42 },
  { 10054, 39, 3, 38, -5, 4 },
  { 10069, 11, 8, 38, 18, -45 },
  { 10080, 31, 35, 38, 2, -34 },
  { 10216, 32, 47, 38, 2, -46 },
  { 10404, 32, 35, 38, 3, -34 },
  { 10544, 35, 47, 38, 3, -46 },
  { 10750, 30, 35, 38, 4, -34 },
  { 10882, 32, 46, 38, 7, -46 },
  { 11066, 34, 47, 38, 2, -34 },
  { 11266, 32, 46, 38, 2, -46 },
  { 11450, 31, 46, 38, 1, -46 },
  { 11629, 33, 59, 38, -2, -46 },
  { 11873, 33, 46, 38, 4, -46 },
  { 12063, 31, 46, 38, 1, -46 },
  { 12242, 36, 34, 38, 0, -34 },
  { 12395, 32, 34, 38, 2, -34 },
  { 12531, 31, 35, 38, 3, -34 },
  { 12667, 34, 47, 38, 0, -34 },
  { 12867, 33, 47, 38, 3, -34 },
  { 13061, 29, 34, 38, 6, -34 },
  { 13185, 31, 35, 38, 3, -34 },
  { 13321, 25, 43, 38, 8, -42 },
  { 13456, 32, 34, 38, 4, -33 },
  { 13592, 34, 33, 38, 5, -33 },
  { 13733, 37, 33, 38, 3, -33 },
  { 13886, 37, 33, 38, 0, -33 },
  { 14039, 40, 46, 38, -1, -33 },
  { 14269, 34, 33, 38, 1, -33 },
  { 14410, 31, 59, 38, 7, -46 },
  { 14639, 5, 59, 38, 16, -46 },
  { 14676, 32, 59, 38, -1, -46 },
  { 14912, 32, 8, 38, 4, -25 },
};

const GFXfont LiberationMono_Italic63pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic63pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic63pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _LIBERATIONMONO_ITALIC63PT7B_H_
