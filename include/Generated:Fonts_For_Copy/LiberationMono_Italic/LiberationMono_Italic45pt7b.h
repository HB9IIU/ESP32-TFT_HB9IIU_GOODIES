#ifndef _LIBERATIONMONO_ITALIC45PT7B_H_
#define _LIBERATIONMONO_ITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3,
  0xC1, 0xF3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0E,
  0x1C, 0x07, 0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC0, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x18,
  0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x30, 0x00,
  0x60, 0x1C, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0,
  0x01, 0xC0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x03, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x30, 0x00,
  0x60, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0xE0,
  0x01, 0xC0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x39, 0xF8, 0x1E, 0x0E,
  0x1E, 0x0F, 0x03, 0x07, 0x83, 0xC1, 0xC0, 0xF0, 0xF0, 0x70, 0x30, 0x3C,
  0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x7E, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xDF,
  0xC0, 0x00, 0x71, 0xF8, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x70, 0x18, 0x0F, 0x3C, 0x0E, 0x03, 0x8F,
  0x03, 0x81, 0xE3, 0xC0, 0xE0, 0xF8, 0xF8, 0x38, 0x7C, 0x1F, 0x8E, 0x7E,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x38, 0x0F, 0xF8, 0x01, 0xE0, 0x78, 0xF0, 0x0F, 0x03,
  0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x0E, 0x01, 0xE0,
  0x70, 0x70, 0x07, 0x03, 0xC3, 0x80, 0x1C, 0x0E, 0x1C, 0x00, 0x70, 0x38,
  0xF0, 0x01, 0xC0, 0xE7, 0x80, 0x07, 0x07, 0x1C, 0x00, 0x1E, 0x3C, 0xE0,
  0x00, 0x3F, 0xE7, 0x00, 0x00, 0x7E, 0x38, 0x00, 0x00, 0x01, 0xC7, 0xE0,
  0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x79, 0xC7, 0x80, 0x03, 0xCE, 0x0E, 0x00,
  0x0E, 0x78, 0x38, 0x00, 0x71, 0xC0, 0xE0, 0x03, 0x87, 0x03, 0x80, 0x1C,
  0x3C, 0x0E, 0x00, 0xE0, 0xF0, 0x38, 0x07, 0x03, 0xC1, 0xE0, 0x3C, 0x0E,
  0x07, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x00, 0x70, 0xE0, 0x38, 0x01, 0xFF,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0xF8, 0x00,
  0xE3, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x06, 0x07,
  0xF8, 0x07, 0x0F, 0x78, 0x0F, 0x1E, 0x38, 0x0E, 0x3C, 0x3C, 0x1E, 0x78,
  0x1C, 0x1C, 0x78, 0x1E, 0x3C, 0xF0, 0x0F, 0x38, 0xF0, 0x0F, 0x78, 0xF0,
  0x07, 0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xF0, 0x7C,
  0x1F, 0xF9, 0x7F, 0xFE, 0xFF, 0x3F, 0xFC, 0x7F, 0x0F, 0xE0, 0x1E, 0x3E,
  0x7C, 0xF1, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x61, 0xC1, 0x71, 0xC7,
  0xFD, 0xFF, 0x3F, 0xFE, 0x0F, 0xE0, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x3C, 0xF0, 0x78, 0x70, 0x70, 0x70, 0x20, 0x20, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80,
  0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7D, 0xFF,
  0xFE, 0xFB, 0xEF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF8, 0x3E, 0x0F,
  0x80, 0x7C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00,
  0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x7C, 0x3D,
  0xE1, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x07,
  0xC1, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0xFD,
  0xE0, 0x1F, 0xEF, 0x00, 0xFE, 0x3C, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0x03, 0xE0,
  0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0x03, 0xF0, 0x7C, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF8, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x1F, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77,
  0x80, 0x01, 0xCF, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0,
  0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80, 0x38, 0x0F, 0x00,
  0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x3F, 0x80, 0x1E, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0x87, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE1, 0xFC, 0x03, 0xCF, 0xFC, 0x0F, 0x7F, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F,
  0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0xF8, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0x80, 0xF8, 0x3E, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0x03, 0xF0, 0x7C, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0,
  0x1F, 0x81, 0xF0, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF,
  0x80, 0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0xF1, 0xF0, 0x03, 0xE1, 0xF8, 0x1F, 0x83, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xF8, 0x7E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF1, 0xE0, 0x03,
  0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xDF,
  0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0x80,
  0x7E, 0x3F, 0x07, 0xF8, 0x7F, 0xFD, 0xE0, 0xFF, 0xC7, 0x80, 0xFC, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0,
  0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x3E, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0x83, 0xC7,
  0xE0, 0x70, 0xFE, 0x67, 0x07, 0x1E, 0x7E, 0x70, 0xE3, 0x83, 0xE7, 0x0E,
  0x38, 0x3C, 0x71, 0xC7, 0x03, 0xC6, 0x1C, 0xE0, 0x38, 0x63, 0x8E, 0x03,
  0x8E, 0x39, 0xC0, 0x38, 0xE3, 0x9C, 0x07, 0x0E, 0x71, 0xC0, 0x70, 0xC7,
  0x38, 0x07, 0x0C, 0x73, 0x80, 0xE1, 0xC7, 0x38, 0x0E, 0x1C, 0x63, 0x81,
  0xE1, 0x8E, 0x38, 0x1C, 0x38, 0xE3, 0x03, 0xC3, 0x0E, 0x30, 0x3C, 0x70,
  0xE3, 0x87, 0x86, 0x0E, 0x38, 0xD8, 0xC0, 0xE3, 0xF9, 0xF8, 0x0E, 0x1E,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x20,
  0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0xF0, 0x07, 0xE0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0xFC, 0x0F, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3C, 0x00,
  0x3E, 0x1E, 0x00, 0x7E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07,
  0xE0, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1F, 0x3C, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x20, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x7E, 0x0F, 0x80, 0x3F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xF0, 0x1F, 0xC0, 0x78, 0x03, 0xE0,
  0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x1E, 0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x3F, 0x07, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC7,
  0xC0, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x18, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xFF, 0x78, 0x0F, 0xFE, 0xF0, 0x1F, 0xF9, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x1F, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC1, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF8,
  0x07, 0x83, 0xE0, 0x3C, 0x07, 0xC3, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x03,
  0xC0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x07,
  0xC0, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0xF0, 0xFC, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x7C,
  0x00, 0x01, 0xEF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xDF, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x78,
  0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0E, 0xE0, 0x77, 0x83, 0xDC, 0x0E, 0x70, 0x77, 0x83, 0xCE,
  0x1E, 0xF0, 0x79, 0xC3, 0x9E, 0x0F, 0x3C, 0xE3, 0x81, 0xC7, 0x9C, 0x70,
  0x38, 0xF7, 0x1E, 0x0F, 0x0E, 0xE3, 0xC1, 0xE1, 0xF8, 0x78, 0x3C, 0x3F,
  0x0E, 0x07, 0x07, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x1C, 0x0E, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3F, 0x00, 0x38, 0x1F, 0xC0, 0x1E, 0x07,
  0xF0, 0x07, 0x81, 0xDC, 0x01, 0xE0, 0x77, 0x80, 0x78, 0x1D, 0xE0, 0x1C,
  0x0F, 0x78, 0x0F, 0x03, 0xCE, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0xF0,
  0x3C, 0x0E, 0x3C, 0x0E, 0x07, 0x87, 0x07, 0x81, 0xE1, 0xE1, 0xE0, 0x78,
  0x78, 0x78, 0x1E, 0x0E, 0x1E, 0x07, 0x03, 0xC7, 0x83, 0xC0, 0xF1, 0xC0,
  0xF0, 0x3C, 0xF0, 0x3C, 0x07, 0x3C, 0x0F, 0x01, 0xEF, 0x03, 0x80, 0x7B,
  0xC1, 0xE0, 0x1E, 0xE0, 0x78, 0x03, 0xB8, 0x1E, 0x00, 0xFE, 0x07, 0x80,
  0x3F, 0x81, 0xC0, 0x0F, 0xE0, 0x70, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7E,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0xFE, 0x07, 0x80, 0x0F, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F,
  0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x7E, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x0F, 0x80,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x3C,
  0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE1, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x78, 0xF8, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x01, 0xF0,
  0x1F, 0x81, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0,
  0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x81,
  0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x83, 0xE0, 0x70, 0x78, 0x3E, 0x0F,
  0x07, 0x87, 0xE0, 0xF0, 0x78, 0x77, 0x0E, 0x07, 0x8E, 0x71, 0xE0, 0x78,
  0xE7, 0x1E, 0x07, 0x9E, 0x71, 0xC0, 0x71, 0xC7, 0x3C, 0x07, 0x1C, 0x73,
  0xC0, 0x73, 0x87, 0x38, 0x07, 0x38, 0x73, 0x80, 0x77, 0x07, 0x78, 0x07,
  0x70, 0x77, 0x00, 0x7E, 0x07, 0x70, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xE7,
  0x00, 0x07, 0x1E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80,
  0x3C, 0x0E, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xE0,
  0x07, 0x07, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xE0, 0x00, 0xE7, 0x80, 0x03,
  0x9C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0E, 0x07, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xF0, 0x3E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x7E, 0x3C, 0x03, 0x78, 0xF8,
  0x39, 0xE3, 0xFF, 0xC7, 0xF7, 0xFE, 0x1F, 0x8F, 0xE0, 0x3E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x1F, 0xC0, 0x3C, 0xFF, 0xC0, 0x7B, 0xFF, 0xC0, 0xFE, 0x0F, 0xC3,
  0xF8, 0x07, 0x87, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3E, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0xE0, 0xF8,
  0x3D, 0xFF, 0xE0, 0x79, 0xFF, 0x80, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07, 0xE0, 0xF8, 0x03, 0xC3,
  0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x0F, 0x00, 0x7F, 0xE7, 0x80, 0xFF, 0xFB, 0xC0, 0x7C, 0x1D, 0xE0, 0x78,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x7E, 0x07, 0x80, 0x7F,
  0x03, 0xE0, 0x7F, 0x00, 0xFF, 0xF7, 0x80, 0x7F, 0xF3, 0xC0, 0x0F, 0xE1,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x83,
  0xE1, 0xF0, 0x0F, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x71, 0xF0, 0x07, 0xC7, 0xC0, 0xFC, 0x3F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x0E, 0x03, 0xFF, 0x3C, 0x0F, 0xFF,
  0x78, 0x3E, 0x0E, 0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x0F, 0x87, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE3,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0xC3, 0xC0,
  0x3F, 0x87, 0xE0, 0xEE, 0x07, 0xFF, 0xBC, 0x0F, 0xFE, 0x78, 0x07, 0xF0,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0x78, 0x1F, 0x83, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x3F, 0x80, 0xF3, 0xFF, 0x83, 0xDF, 0xFE,
  0x0F, 0xF0, 0xFC, 0x7F, 0x01, 0xF1, 0xF8, 0x03, 0xC7, 0xC0, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x20, 0x1F, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x3C, 0x00, 0x7C, 0x3E, 0x00,
  0x78, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x1E, 0x0F, 0x03, 0xDF, 0xCF, 0xE0, 0xEF,
  0xF7, 0xFC, 0x3B, 0x3D, 0x8F, 0x0F, 0x87, 0xC3, 0xC3, 0xC1, 0xE0, 0xF1,
  0xF0, 0x78, 0x3C, 0x78, 0x1C, 0x0F, 0x1E, 0x0F, 0x03, 0x87, 0x83, 0xC0,
  0xE1, 0xC0, 0xF0, 0x78, 0xF0, 0x3C, 0x1E, 0x3C, 0x0E, 0x07, 0x8F, 0x07,
  0x81, 0xC3, 0xC1, 0xE0, 0x70, 0xE0, 0x78, 0x3C, 0x78, 0x1E, 0x0F, 0x1E,
  0x07, 0x03, 0xC7, 0x83, 0xC0, 0xE1, 0xE0, 0xF0, 0x38, 0x70, 0x3C, 0x1E,
  0x3C, 0x0F, 0x07, 0x8F, 0x03, 0x81, 0xE3, 0xC1, 0xE0, 0x70, 0x0F, 0x07,
  0xE0, 0x3C, 0xFF, 0xE0, 0xF7, 0xFF, 0x83, 0xFC, 0x3F, 0x0F, 0xC0, 0x7C,
  0x7E, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0x07, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F,
  0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x1E, 0x7C,
  0x00, 0x3C, 0xF8, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xE0,
  0x1F, 0x03, 0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x03, 0xC3, 0xF8, 0x01, 0xE7, 0xFF, 0x00, 0xF7, 0xFF, 0x80, 0x7F,
  0x07, 0xE0, 0x7F, 0x00, 0xF0, 0x3F, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F,
  0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x03, 0xDC, 0x1F, 0x01, 0xEF, 0xFF, 0x80, 0xF3, 0xFF,
  0x00, 0x78, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1E,
  0x03, 0xFF, 0x3C, 0x1F, 0xFF, 0x78, 0x3E, 0x0E, 0xF0, 0xF0, 0x0F, 0xC3,
  0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE1, 0xE0, 0x0F, 0xC3, 0xC0, 0x3F, 0x07, 0xE0, 0xFE, 0x07, 0xFF, 0xBC,
  0x0F, 0xFE, 0x78, 0x07, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0E, 0x07, 0xF8, 0x70,
  0xFF, 0xC3, 0xCF, 0xFE, 0x1E, 0xFF, 0xF0, 0xEF, 0x80, 0x07, 0x70, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x1F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x87, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x61, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x01, 0xF8, 0xF8, 0x1D, 0xC1, 0xFF,
  0xEF, 0x07, 0xFF, 0x3C, 0x07, 0xF0, 0xF0, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x81, 0xF0, 0x78, 0x70, 0x3E,
  0x0F, 0x0E, 0x0F, 0xC1, 0xC3, 0xC1, 0xF8, 0x78, 0x78, 0x77, 0x0F, 0x0F,
  0x0E, 0xE1, 0xC1, 0xE3, 0x9C, 0x78, 0x3C, 0xF1, 0xCF, 0x07, 0x9C, 0x3B,
  0xC0, 0xF7, 0x87, 0x78, 0x1E, 0xE0, 0xEE, 0x03, 0xFC, 0x1D, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x0B, 0xFF,
  0xF0, 0x77, 0x07, 0xFF, 0xE8, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00,
};

const GFXglyph LiberationMono_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 10, 30, 27, 9, -30 },
  { 39, 17, 14, 27, 8, -33 },
  { 69, 26, 30, 27, 1, -30 },
  { 167, 26, 37, 27, 1, -33 },
  { 288, 30, 30, 27, -1, -30 },
  { 401, 24, 30, 27, 0, -30 },
  { 491, 7, 14, 27, 13, -33 },
  { 504, 17, 42, 27, 7, -33 },
  { 594, 17, 42, 27, 3, -33 },
  { 684, 16, 16, 27, 8, -33 },
  { 716, 21, 21, 27, 3, -26 },
  { 772, 12, 15, 27, 2, -7 },
  { 795, 13, 4, 27, 7, -13 },
  { 802, 6, 7, 27, 9, -7 },
  { 808, 28, 33, 27, 0, -33 },
  { 924, 22, 30, 27, 3, -30 },
  { 1007, 22, 30, 27, 1, -30 },
  { 1090, 24, 30, 27, 1, -30 },
  { 1180, 23, 30, 27, 2, -30 },
  { 1267, 23, 30, 27, 1, -30 },
  { 1354, 24, 30, 27, 2, -30 },
  { 1444, 23, 30, 27, 3, -30 },
  { 1531, 21, 30, 27, 6, -30 },
  { 1610, 23, 30, 27, 2, -30 },
  { 1697, 22, 30, 27, 3, -30 },
  { 1780, 9, 24, 27, 9, -24 },
  { 1807, 14, 32, 27, 4, -24 },
  { 1863, 21, 23, 27, 3, -26 },
  { 1924, 21, 14, 27, 3, -22 },
  { 1961, 21, 23, 27, 3, -26 },
  { 2022, 22, 30, 27, 4, -30 },
  { 2105, 28, 39, 27, 0, -33 },
  { 2242, 27, 30, 27, -2, -30 },
  { 2344, 25, 30, 27, 1, -30 },
  { 2438, 24, 30, 27, 3, -30 },
  { 2528, 25, 30, 27, 1, -30 },
  { 2622, 26, 30, 27, 1, -30 },
  { 2720, 25, 30, 27, 2, -30 },
  { 2814, 23, 30, 27, 3, -30 },
  { 2901, 26, 30, 27, 1, -30 },
  { 2999, 24, 30, 27, 2, -30 },
  { 3089, 22, 30, 27, 3, -30 },
  { 3172, 28, 30, 27, 1, -30 },
  { 3277, 20, 30, 27, 3, -30 },
  { 3352, 27, 30, 27, 1, -30 },
  { 3454, 26, 30, 27, 1, -30 },
  { 3552, 24, 30, 27, 2, -30 },
  { 3642, 26, 30, 27, 1, -30 },
  { 3740, 24, 39, 27, 2, -30 },
  { 3857, 26, 30, 27, 1, -30 },
  { 3955, 25, 30, 27, 1, -30 },
  { 4049, 25, 30, 27, 4, -30 },
  { 4143, 25, 30, 27, 2, -30 },
  { 4237, 26, 30, 27, 4, -30 },
  { 4335, 28, 30, 27, 2, -30 },
  { 4440, 31, 30, 27, -2, -30 },
  { 4557, 26, 30, 27, 4, -30 },
  { 4655, 29, 30, 27, -1, -30 },
  { 4764, 20, 42, 27, 5, -33 },
  { 4869, 15, 33, 27, 7, -33 },
  { 4931, 20, 42, 27, 2, -33 },
  { 5036, 22, 20, 27, 2, -30 },
  { 5091, 27, 2, 27, -3, 3 },
  { 5098, 8, 6, 27, 13, -32 },
  { 5104, 22, 24, 27, 2, -24 },
  { 5170, 23, 33, 27, 2, -33 },
  { 5265, 23, 24, 27, 2, -24 },
  { 5334, 25, 33, 27, 2, -33 },
  { 5438, 21, 24, 27, 3, -24 },
  { 5501, 23, 33, 27, 5, -33 },
  { 5596, 23, 33, 27, 2, -24 },
  { 5691, 22, 33, 27, 2, -33 },
  { 5782, 22, 33, 27, 1, -33 },
  { 5873, 23, 42, 27, -1, -33 },
  { 5994, 24, 33, 27, 3, -33 },
  { 6093, 22, 33, 27, 1, -33 },
  { 6184, 26, 24, 27, 0, -24 },
  { 6262, 22, 24, 27, 2, -24 },
  { 6328, 23, 24, 27, 2, -24 },
  { 6397, 25, 33, 27, 0, -24 },
  { 6501, 23, 33, 27, 2, -24 },
  { 6596, 21, 24, 27, 4, -24 },
  { 6659, 22, 24, 27, 2, -24 },
  { 6725, 18, 30, 27, 6, -30 },
  { 6793, 22, 24, 27, 3, -24 },
  { 6859, 24, 24, 27, 4, -24 },
  { 6931, 27, 24, 27, 2, -24 },
  { 7012, 27, 24, 27, 0, -24 },
  { 7093, 28, 33, 27, 0, -24 },
  { 7209, 24, 24, 27, 1, -24 },
  { 7281, 22, 42, 27, 5, -33 },
  { 7397, 3, 42, 27, 12, -33 },
  { 7413, 22, 42, 27, 0, -33 },
  { 7529, 23, 6, 27, 3, -18 },
};

const GFXfont LiberationMono_Italic45pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic45pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic45pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _LIBERATIONMONO_ITALIC45PT7B_H_
