#ifndef _LIBERATIONMONO_ITALIC37PT7B_H_
#define _LIBERATIONMONO_ITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xE0, 0xF7, 0x07,
  0x38, 0x3B, 0xC1, 0xDC, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0x81, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x30, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x30,
  0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3E, 0x73,
  0xE3, 0xC3, 0x0F, 0x1C, 0x18, 0x38, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x3C,
  0x70, 0x01, 0xF3, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0x0F, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xCE, 0x0E,
  0x0E, 0x70, 0x70, 0x73, 0xC3, 0x07, 0x9F, 0x18, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0x03, 0xFC, 0x03, 0x03, 0x8E, 0x03, 0x03, 0x83,
  0x03, 0x81, 0xC1, 0x83, 0x80, 0xC1, 0xC3, 0x80, 0x60, 0xE3, 0x80, 0x70,
  0x73, 0x80, 0x38, 0x33, 0x80, 0x0E, 0x39, 0x80, 0x07, 0xF9, 0x80, 0x01,
  0xF1, 0x80, 0x00, 0x01, 0x8F, 0x80, 0x01, 0xDF, 0xE0, 0x01, 0xDC, 0x38,
  0x01, 0xCE, 0x1C, 0x01, 0xCE, 0x0E, 0x01, 0xC7, 0x07, 0x01, 0xC3, 0x83,
  0x00, 0xC1, 0xC3, 0x80, 0xC0, 0xE1, 0xC0, 0xC0, 0x71, 0xC0, 0xC0, 0x1F,
  0xC0, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1E, 0x1E, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x81, 0xC0, 0x38, 0x78,
  0x01, 0x9E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x60, 0xFC, 0x07, 0x1C, 0xE0,
  0xE3, 0x8E, 0x0E, 0x70, 0x71, 0xC7, 0x07, 0x1C, 0xE0, 0x3B, 0x8E, 0x03,
  0xF8, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0xF8, 0x3F, 0x87, 0xFF, 0xFF, 0x7F,
  0xF3, 0xF1, 0xF8, 0x0E, 0x7B, 0xDE, 0xF7, 0x39, 0xDE, 0xE7, 0x39, 0xC0,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x86, 0x3F, 0x77, 0xBF, 0xF8, 0x7E, 0x01, 0xE0,
  0x1F, 0x01, 0xDC, 0x1C, 0x60, 0xC3, 0x84, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7B, 0xDF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xE0, 0xE0, 0x1E, 0x38,
  0x03, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xEF, 0x00, 0x1D, 0xC3,
  0xC7, 0xB8, 0x78, 0xE7, 0x1F, 0x1D, 0xE3, 0xC3, 0xBC, 0x00, 0xF7, 0x00,
  0x1C, 0xE0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x83,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xEE, 0x07, 0xE3, 0x81, 0xE1, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1F,
  0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x81, 0xF1,
  0xE0, 0x1E, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E, 0x78,
  0x07, 0x8F, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00,
  0x77, 0x80, 0x1C, 0xF0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x0C,
  0x1E, 0x03, 0x83, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC3, 0x80,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3E, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x9C, 0x00, 0xF3, 0x80, 0x1E, 0x78, 0x07, 0x8F, 0x83, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3E, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x71,
  0xF8, 0x1D, 0xFF, 0x87, 0xFF, 0xF3, 0xF8, 0x7C, 0xF8, 0x07, 0xBC, 0x01,
  0xEE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3,
  0xC0, 0x78, 0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xF1,
  0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0xC3,
  0xC0, 0xF0, 0x3F, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x78, 0x1F, 0x1E,
  0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x1E, 0x78,
  0x07, 0x8F, 0x81, 0xF1, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xE1, 0xE0, 0x1C, 0x78,
  0x03, 0xCE, 0x00, 0x79, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x3C, 0xE0,
  0x0F, 0x1F, 0x07, 0xE3, 0xFF, 0xDC, 0x3F, 0xF7, 0x81, 0xF8, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE3, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x87,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x0F, 0x1F, 0x1E,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x78, 0x78, 0xF8, 0xF0, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1F, 0x3C,
  0x03, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xE0, 0x01, 0xC1, 0xE0, 0x0F, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60,
  0x01, 0x81, 0xC0, 0x03, 0x07, 0x0F, 0x37, 0x0C, 0x3F, 0x6E, 0x38, 0xE6,
  0xDC, 0x63, 0x87, 0x39, 0xCE, 0x0E, 0x73, 0x18, 0x1C, 0xC6, 0x70, 0x31,
  0x9C, 0xC0, 0xE3, 0x33, 0x81, 0x8E, 0x67, 0x03, 0x18, 0xCC, 0x0E, 0x31,
  0x98, 0x18, 0x67, 0x30, 0x71, 0x8E, 0x60, 0xE3, 0x1C, 0xC2, 0x8C, 0x39,
  0x8F, 0x38, 0x73, 0xF7, 0xE0, 0xE3, 0x87, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x08, 0x03, 0x80, 0x38, 0x07, 0x83, 0xC0, 0x07, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x0E, 0x07, 0x00, 0x78,
  0x1C, 0x01, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x81, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x3C,
  0x00, 0x3C, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x07, 0x07, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x1F, 0x0E, 0x00, 0xF0, 0xE0,
  0x07, 0x1E, 0x00, 0xF1, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x3C, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xC0, 0x3E, 0x38, 0x01, 0xE3,
  0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x00, 0x3C,
  0x70, 0x07, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1F, 0x00, 0xE1, 0xE0,
  0x0F, 0x3C, 0x00, 0x43, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0x0F, 0x00, 0x3C, 0xF0, 0x07, 0x87, 0x80, 0xF0,
  0x7C, 0x1F, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF0, 0x7E, 0x0E, 0x01, 0xF0, 0xE0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0x73, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x00, 0xF0,
  0x70, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1F,
  0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xC3, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x03, 0xFC, 0xF0, 0x3F, 0xCF, 0x07, 0xFC,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0, 0x03,
  0x87, 0x80, 0x78, 0x7C, 0x0F, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1E,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0xC3, 0xC0,
  0x1E, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x81, 0xE0, 0xF0, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x3C, 0x1E, 0x00,
  0xF0, 0x3C, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0xE0, 0x7C, 0x01, 0xC1, 0xF0,
  0x07, 0x87, 0xC0, 0x0F, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x39, 0xE0, 0x00,
  0x77, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0x00, 0x0F,
  0x8F, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x78, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xEC, 0x0F, 0xC1, 0xDC, 0x3B,
  0x83, 0xB8, 0x7E, 0x07, 0x71, 0xDC, 0x1C, 0xE3, 0x38, 0x39, 0xCE, 0x70,
  0x73, 0x98, 0xE0, 0xE3, 0x73, 0x81, 0xC6, 0xC7, 0x07, 0x0F, 0x0E, 0x0E,
  0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x1C, 0x00,
  0x70, 0x30, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x7C, 0x01, 0xC3, 0xE0, 0x1E,
  0x1F, 0x80, 0xE0, 0xFC, 0x07, 0x07, 0xE0, 0x38, 0x77, 0x81, 0xC3, 0x9C,
  0x1E, 0x1C, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x1C, 0x38, 0x78, 0xE1, 0xC3,
  0x87, 0x1E, 0x1C, 0x38, 0xE0, 0xE0, 0xE7, 0x07, 0x07, 0x38, 0x78, 0x39,
  0xC3, 0x81, 0xEE, 0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x38,
  0x07, 0xC3, 0x80, 0x3E, 0x1C, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xC1, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x39,
  0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0x9E,
  0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x87, 0xC3, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1E, 0x03, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x78, 0x78, 0x0F, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xC1, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x39,
  0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0x9E,
  0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x87, 0xC3, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1E, 0x01, 0xF0, 0xE0, 0x07,
  0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xE0,
  0x07, 0x87, 0x00, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0xE0, 0xF0, 0x07, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0xE0, 0x1E, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0x03,
  0xE0, 0xF0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0x00,
  0x0F, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0xC0, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00,
  0xF1, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80,
  0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x70,
  0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x03, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xF8, 0x3E, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1C,
  0x1E, 0x00, 0xF0, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x0F,
  0x03, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x38, 0x38, 0xF0, 0xF0,
  0x71, 0xE1, 0xE0, 0xE3, 0xC7, 0xC3, 0x87, 0x8D, 0x87, 0x0E, 0x3B, 0x0E,
  0x1C, 0x67, 0x38, 0x39, 0xCE, 0x70, 0x73, 0x9C, 0xE0, 0xE6, 0x3B, 0x81,
  0xDC, 0x77, 0x03, 0xB0, 0xEC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x01,
  0xE0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x07, 0x07, 0x80, 0x03, 0xC7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x7B, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC7,
  0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x7B, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x3C,
  0x0E, 0x03, 0xC0, 0x78, 0x1C, 0x01, 0xC1, 0xC0, 0x0F, 0x1C, 0x00, 0x39,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3B, 0x00, 0x1D,
  0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x18, 0x0E, 0x0C, 0x06, 0x07, 0x07,
  0x03, 0x87, 0x01, 0xC3, 0x80, 0x63, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xF0, 0xF0,
  0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3E, 0x0F, 0x0E, 0x03,
  0xC7, 0x80, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF8, 0xF8, 0x0E, 0x78, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0xF3, 0xC0,
  0x7C, 0xF0, 0x77, 0x1F, 0xF9, 0xF7, 0xFC, 0x7C, 0xFC, 0x0F, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0xF8, 0x0E, 0x7F, 0xC1, 0xDF, 0xF8, 0x3F, 0x0F,
  0x8F, 0x80, 0xF1, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C,
  0xF0, 0x07, 0x1F, 0x01, 0xE3, 0xF0, 0x78, 0x77, 0xFE, 0x0E, 0xFF, 0x83,
  0xC7, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1F,
  0x3C, 0x03, 0xCE, 0x00, 0x77, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x7B, 0xC0, 0x3C, 0x78, 0x1E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x1F, 0x1E, 0x07, 0xFD, 0xE0, 0xFF,
  0xFC, 0x1F, 0x0F, 0xC3, 0xC0, 0x7C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8E,
  0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x87, 0xF0,
  0x7F, 0xEF, 0x07, 0xFC, 0xE0, 0x1F, 0x8E, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x3C, 0x03, 0xCE, 0x00, 0x77, 0x80, 0x1D,
  0xC0, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x63, 0xC0, 0x3C, 0x78, 0x3E, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x81, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x70, 0x3F, 0xEF, 0x07, 0xFE, 0xE0, 0xF8, 0x7E, 0x1E, 0x03, 0xE1, 0xE0,
  0x1E, 0x1C, 0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x07, 0x87,
  0x80, 0xF8, 0x7C, 0x3B, 0x83, 0xFF, 0x78, 0x3F, 0xE7, 0x00, 0xFC, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0x78, 0x3C,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0xF8, 0x0E, 0x7F, 0xC1, 0xDF, 0xF8, 0x3F, 0x0F, 0x8F, 0x80,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x3C, 0x01,
  0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x38, 0xF0, 0x07,
  0x1E, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x04, 0x07, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x0E, 0x03,
  0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0x1C, 0x3C, 0x01, 0xC7,
  0x80, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xEF, 0x00, 0x38, 0x78, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x07,
  0x01, 0xC0, 0x70, 0x1E, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C,
  0x70, 0xF0, 0xEF, 0xCF, 0xC7, 0x7E, 0xFE, 0x3E, 0x7C, 0x71, 0xE3, 0xE3,
  0x8E, 0x1E, 0x1C, 0x70, 0xF0, 0xE7, 0x87, 0x07, 0x38, 0x38, 0x39, 0xC1,
  0xC3, 0x8E, 0x0E, 0x1C, 0x70, 0xE0, 0xE7, 0x87, 0x07, 0x38, 0x38, 0x39,
  0xC1, 0xC3, 0x8E, 0x0E, 0x1C, 0x70, 0xE0, 0xE7, 0x87, 0x07, 0x38, 0x38,
  0x39, 0xC1, 0xC3, 0xC0, 0x0E, 0x1F, 0x81, 0xCF, 0xF8, 0x3B, 0xFF, 0x07,
  0xE1, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0E, 0x1C,
  0x01, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70,
  0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xF1, 0xC0,
  0x1C, 0x38, 0x03, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C,
  0x1F, 0x3C, 0x03, 0xCF, 0x00, 0x77, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xEF,
  0x00, 0x73, 0xC0, 0x3C, 0x78, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0x00, 0x07, 0x0F, 0x80, 0x73, 0xFE, 0x07, 0x7F, 0xE0, 0x7E, 0x1F, 0x0F,
  0x80, 0xF0, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E,
  0x3C, 0x01, 0xC3, 0xE0, 0x3C, 0x3F, 0x07, 0x83, 0xBF, 0xF0, 0x3B, 0xFE,
  0x03, 0x8F, 0xC0, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF8, 0xE0, 0xFF, 0xBC, 0x3F, 0xFF, 0x0F, 0x87, 0xE3, 0xC0, 0x7C, 0x70,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0xC0,
  0x1E, 0x78, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0xF8, 0xF8, 0x7F, 0x0F, 0xFD, 0xC1, 0xFF, 0x38, 0x0F, 0xC7, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1C, 0x1F, 0xC7, 0x1F, 0xF1, 0xCF,
  0xF8, 0x77, 0x80, 0x1D, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x78, 0x0F,
  0x1C, 0x01, 0xC7, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x73, 0x80, 0x1C, 0xF0, 0x1E, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0x80,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x4F, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x1C, 0x01, 0xE3, 0x80,
  0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x07, 0x8E, 0x00,
  0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03,
  0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x37,
  0x0F, 0xFF, 0xE1, 0xFF, 0x38, 0x0F, 0xC7, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x1E, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x78, 0x78,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x83, 0xC1, 0xCE, 0x1F, 0x0E, 0x38, 0x6C, 0x38, 0xE1, 0xB0, 0xE3, 0x8C,
  0xC7, 0x0E, 0x33, 0x1C, 0x39, 0xCC, 0xF0, 0xE6, 0x33, 0x83, 0xB8, 0xEE,
  0x0E, 0xC3, 0xB0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x78,
  0x0F, 0x00, 0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x07, 0x1E, 0x00, 0x1E, 0x70,
  0x00, 0x3B, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xF0, 0x03, 0x81,
  0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0x70,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC0,
  0xF0, 0x07, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07,
  0x01, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE0, 0x01, 0xF8,
};

const GFXglyph LiberationMono_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 24, 22, 7, -24 },
  { 28, 13, 12, 22, 7, -27 },
  { 48, 22, 24, 22, 0, -24 },
  { 114, 21, 30, 22, 1, -27 },
  { 193, 25, 24, 22, -1, -24 },
  { 268, 20, 24, 22, 0, -24 },
  { 328, 5, 12, 22, 11, -27 },
  { 336, 13, 35, 22, 6, -27 },
  { 393, 14, 35, 22, 3, -27 },
  { 455, 13, 13, 22, 7, -27 },
  { 477, 18, 19, 22, 2, -22 },
  { 520, 11, 12, 22, 1, -5 },
  { 537, 10, 3, 22, 6, -11 },
  { 541, 5, 5, 22, 7, -5 },
  { 545, 23, 27, 22, 0, -27 },
  { 623, 19, 24, 22, 2, -24 },
  { 680, 18, 24, 22, 1, -24 },
  { 734, 20, 24, 22, 1, -24 },
  { 794, 19, 24, 22, 2, -24 },
  { 851, 19, 24, 22, 1, -24 },
  { 908, 19, 24, 22, 2, -24 },
  { 965, 18, 24, 22, 3, -24 },
  { 1019, 17, 24, 22, 5, -24 },
  { 1070, 19, 24, 22, 2, -24 },
  { 1127, 19, 24, 22, 2, -24 },
  { 1184, 8, 20, 22, 7, -20 },
  { 1204, 12, 27, 22, 3, -20 },
  { 1245, 18, 19, 22, 2, -22 },
  { 1288, 18, 12, 22, 2, -18 },
  { 1315, 18, 19, 22, 2, -22 },
  { 1358, 18, 24, 22, 3, -24 },
  { 1412, 23, 32, 22, 0, -27 },
  { 1504, 22, 24, 22, -2, -24 },
  { 1570, 20, 24, 22, 1, -24 },
  { 1630, 20, 24, 22, 2, -24 },
  { 1690, 20, 24, 22, 1, -24 },
  { 1750, 21, 24, 22, 1, -24 },
  { 1813, 20, 24, 22, 2, -24 },
  { 1873, 20, 24, 22, 2, -24 },
  { 1933, 21, 24, 22, 1, -24 },
  { 1996, 19, 24, 22, 2, -24 },
  { 2053, 18, 24, 22, 3, -24 },
  { 2107, 23, 24, 22, 1, -24 },
  { 2176, 17, 24, 22, 2, -24 },
  { 2227, 23, 24, 22, 0, -24 },
  { 2296, 21, 24, 22, 1, -24 },
  { 2359, 19, 24, 22, 2, -24 },
  { 2416, 21, 24, 22, 1, -24 },
  { 2479, 19, 32, 22, 2, -24 },
  { 2555, 21, 24, 22, 1, -24 },
  { 2618, 21, 24, 22, 1, -24 },
  { 2681, 20, 24, 22, 4, -24 },
  { 2741, 20, 24, 22, 2, -24 },
  { 2801, 22, 24, 22, 3, -24 },
  { 2867, 23, 24, 22, 2, -24 },
  { 2936, 25, 24, 22, -1, -24 },
  { 3011, 21, 24, 22, 3, -24 },
  { 3074, 24, 24, 22, -1, -24 },
  { 3146, 17, 35, 22, 4, -27 },
  { 3221, 13, 27, 22, 5, -27 },
  { 3265, 17, 35, 22, 1, -27 },
  { 3340, 17, 16, 22, 2, -24 },
  { 3374, 23, 2, 22, -3, 2 },
  { 3380, 7, 5, 22, 10, -27 },
  { 3385, 18, 20, 22, 1, -20 },
  { 3430, 19, 27, 22, 1, -27 },
  { 3495, 18, 20, 22, 2, -20 },
  { 3540, 20, 27, 22, 2, -27 },
  { 3608, 18, 20, 22, 2, -20 },
  { 3653, 19, 27, 22, 4, -27 },
  { 3718, 20, 28, 22, 1, -20 },
  { 3788, 19, 27, 22, 1, -27 },
  { 3853, 18, 27, 22, 1, -27 },
  { 3914, 19, 35, 22, -1, -27 },
  { 3998, 20, 27, 22, 2, -27 },
  { 4066, 18, 27, 22, 1, -27 },
  { 4127, 21, 20, 22, 0, -20 },
  { 4180, 19, 20, 22, 1, -20 },
  { 4228, 18, 20, 22, 2, -20 },
  { 4273, 20, 28, 22, 0, -20 },
  { 4343, 19, 28, 22, 2, -20 },
  { 4410, 18, 20, 22, 3, -20 },
  { 4455, 18, 20, 22, 2, -20 },
  { 4500, 14, 25, 22, 5, -25 },
  { 4544, 19, 20, 22, 2, -20 },
  { 4592, 20, 20, 22, 3, -20 },
  { 4642, 22, 20, 22, 2, -20 },
  { 4697, 22, 20, 22, 0, -20 },
  { 4752, 23, 28, 22, 0, -20 },
  { 4833, 20, 20, 22, 1, -20 },
  { 4883, 18, 35, 22, 4, -27 },
  { 4962, 3, 35, 22, 10, -27 },
  { 4976, 18, 35, 22, 0, -27 },
  { 5055, 19, 5, 22, 2, -15 },
};

const GFXfont LiberationMono_Italic37pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic37pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic37pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _LIBERATIONMONO_ITALIC37PT7B_H_
