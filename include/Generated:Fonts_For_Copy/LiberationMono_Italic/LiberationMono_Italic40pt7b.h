#ifndef _LIBERATIONMONO_ITALIC40PT7B_H_
#define _LIBERATIONMONO_ITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x38, 0x1C, 0x70, 0x38,
  0xE0, 0xF1, 0xC1, 0xC7, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x18,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x00,
  0x38, 0x0C, 0x00, 0x60, 0x30, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x06,
  0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80,
  0xC0, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x60, 0x18,
  0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x30, 0x1C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xF3, 0x9F, 0x07, 0x87, 0x1E, 0x0E, 0x0C, 0x1E, 0x3C,
  0x18, 0x38, 0x78, 0x30, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x01, 0xF3,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xE3, 0xE0, 0x01, 0x83, 0xC0, 0x03, 0x03, 0x8C, 0x0E, 0x07,
  0x38, 0x1C, 0x1E, 0x78, 0x30, 0x38, 0xF0, 0x60, 0xF0, 0xF8, 0xC7, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0xFF, 0x80, 0x70,
  0x3C, 0x70, 0x0C, 0x07, 0x0E, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x38, 0x38,
  0x38, 0x07, 0x07, 0x0E, 0x00, 0xE0, 0xE3, 0x80, 0x18, 0x18, 0xE0, 0x03,
  0x87, 0x38, 0x00, 0x71, 0xCE, 0x00, 0x0F, 0xF3, 0x80, 0x00, 0x7C, 0x60,
  0x00, 0x00, 0x1C, 0xFC, 0x00, 0x07, 0x7F, 0xC0, 0x01, 0xCE, 0x38, 0x00,
  0x73, 0x87, 0x00, 0x1C, 0x60, 0x60, 0x07, 0x1C, 0x1C, 0x01, 0xC3, 0x83,
  0x80, 0x70, 0x70, 0x70, 0x1C, 0x0E, 0x0E, 0x03, 0x01, 0xC3, 0x80, 0xE0,
  0x38, 0xF0, 0x38, 0x03, 0xFC, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC3, 0xC0, 0x07, 0x7C,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x04, 0x0F, 0xE0, 0x38, 0x7B, 0xC0, 0xE3,
  0xC7, 0x07, 0x1E, 0x1E, 0x1C, 0x70, 0x38, 0xE3, 0xC0, 0xF3, 0x8E, 0x01,
  0xDC, 0x38, 0x07, 0xF0, 0xE0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x83, 0xFE,
  0x5F, 0xFF, 0xFE, 0x3F, 0xF1, 0xF8, 0x3F, 0x01, 0xE0, 0x7D, 0xE7, 0x9E,
  0x79, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x61, 0x85, 0xEE,
  0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0x80, 0x37, 0x01, 0xDC, 0x0E, 0x38, 0x70,
  0xE0, 0x81, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x07,
  0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x00, 0x7F, 0xF7, 0xFE,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0,
  0xF0, 0x0F, 0x07, 0x00, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00,
  0x79, 0xC0, 0x03, 0xCE, 0x1E, 0x1C, 0xF1, 0xF0, 0xE7, 0x8F, 0x87, 0x38,
  0x7C, 0x79, 0xC3, 0xC3, 0xDE, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x71, 0xE0, 0x07, 0x87, 0x00, 0x78, 0x3C, 0x03, 0xC1, 0xF0,
  0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x0F, 0xF7, 0x00, 0xFC,
  0x70, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0xF8, 0x3E, 0x07, 0x80, 0x7C, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0x83, 0xE0, 0xF0, 0x0F, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x03,
  0xE3, 0xF0, 0x3E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xEF, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x3C, 0x00, 0x71, 0xE0,
  0x07, 0x0F, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x70, 0x3C, 0x07, 0x01,
  0xE0, 0x70, 0x0F, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE7, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0, 0x7E, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0xC0,
  0x03, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xF0, 0x7C, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7C, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x0E, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x8F, 0xC0, 0x7B, 0xFF, 0x07, 0x7F, 0xF8,
  0x7E, 0x0F, 0xCF, 0xC0, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x1C, 0xF0, 0x01,
  0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00,
  0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F,
  0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x78,
  0x1F, 0x07, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7C, 0x1F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00,
  0x73, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00, 0xF3, 0xC0,
  0x0F, 0x3C, 0x03, 0xF3, 0xF0, 0x7F, 0x1F, 0xFE, 0xE0, 0xFF, 0xCE, 0x03,
  0xF1, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x00, 0xF0, 0x78, 0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF0, 0x3E, 0x3C, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0x07, 0x00, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0C,
  0x00, 0x0C, 0x0E, 0x0E, 0x36, 0x0E, 0x1F, 0xBB, 0x06, 0x1C, 0x79, 0xC7,
  0x1C, 0x3C, 0xE3, 0x1C, 0x1E, 0x61, 0x8C, 0x0E, 0x31, 0xCE, 0x07, 0x18,
  0xC6, 0x03, 0x0C, 0x67, 0x03, 0x8E, 0x73, 0x81, 0xC7, 0x31, 0x80, 0xC3,
  0x19, 0xC0, 0xE1, 0x8C, 0xE0, 0x71, 0xCE, 0x70, 0x70, 0xC7, 0x38, 0x38,
  0xE3, 0x9C, 0x3C, 0x61, 0xCE, 0x14, 0x70, 0xE7, 0x3E, 0x70, 0x71, 0xFB,
  0xF0, 0x38, 0xF0, 0xF0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x04, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38,
  0x00, 0xF0, 0x38, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x0E,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xC0, 0x3F, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x78, 0x03,
  0xC1, 0xE0, 0x1E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x83,
  0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x7E,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x7E, 0x0F, 0x80, 0x78, 0x7C,
  0x01, 0xE1, 0xE0, 0x03, 0xCF, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0x0F, 0x00,
  0x0E, 0x3C, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0xE0, 0xF8,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xC0, 0xFC, 0x0F, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0x80,
  0x0F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x81, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF8,
  0x07, 0x8F, 0x80, 0x3C, 0x78, 0x00, 0xE7, 0x80, 0x04, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xFF, 0x3C, 0x1F,
  0xFB, 0xC0, 0xFF, 0xDE, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xF8, 0x3F,
  0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x80,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xE0,
  0x78, 0x3E, 0x1F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x1F, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x1F, 0x00,
  0xF0, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x1E, 0x00,
  0x0E, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x03, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xE0,
  0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81,
  0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0x70, 0x7F, 0x03, 0xF0,
  0x3B, 0x83, 0xB8, 0x1D, 0xE1, 0xDC, 0x0E, 0x71, 0xCE, 0x07, 0x38, 0xEF,
  0x03, 0x9C, 0xE7, 0x03, 0x8E, 0x73, 0x81, 0xC7, 0x71, 0xC0, 0xE3, 0xB8,
  0xE0, 0x70, 0xF8, 0x70, 0x38, 0x78, 0x78, 0x38, 0x3C, 0x38, 0x1C, 0x1C,
  0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x70,
  0x3F, 0x00, 0xE0, 0xFE, 0x01, 0xC1, 0xDC, 0x07, 0x83, 0xB8, 0x0F, 0x07,
  0x78, 0x1C, 0x0E, 0x70, 0x38, 0x3C, 0xE0, 0x70, 0x79, 0xC1, 0xE0, 0xE3,
  0xC3, 0xC1, 0xC3, 0x87, 0x03, 0x87, 0x0E, 0x0F, 0x0F, 0x1C, 0x1E, 0x1E,
  0x78, 0x38, 0x1C, 0xF0, 0x70, 0x39, 0xC0, 0xE0, 0x7B, 0x83, 0xC0, 0x77,
  0x07, 0x80, 0xEE, 0x0E, 0x01, 0xDC, 0x1C, 0x03, 0xF0, 0x38, 0x03, 0xE0,
  0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x01,
  0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x3C, 0x03, 0xC1, 0xF0, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x38, 0x07, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0,
  0x07, 0xC1, 0xC0, 0x3F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x01,
  0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x3C, 0x03, 0xC1, 0xF0, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x38, 0x03, 0xE0,
  0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x0F, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81,
  0xF0, 0x3F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE7, 0x00, 0x07, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xE0, 0x07, 0x87, 0xC0, 0x7E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x70,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x1E, 0x07, 0xC1, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0x38, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x1C, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x70, 0x38,
  0x1C, 0x38, 0x3C, 0x1E, 0x1C, 0x1E, 0x0E, 0x0E, 0x1F, 0x87, 0x07, 0x0D,
  0xC7, 0x83, 0x8E, 0xE3, 0x83, 0xC7, 0x71, 0xC1, 0xE7, 0x39, 0xE0, 0xF3,
  0x9C, 0xE0, 0x7B, 0x8E, 0x70, 0x3D, 0xC7, 0x78, 0x1D, 0xC3, 0xB8, 0x0E,
  0xE1, 0xDC, 0x07, 0x60, 0xEC, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x01, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x3C, 0x01,
  0xE0, 0xF0, 0x0F, 0x01, 0xC0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x0E, 0x00,
  0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xDC, 0x00, 0x3B,
  0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x70, 0xC0, 0x0C, 0x1C, 0x03, 0x83,
  0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x1C, 0x38, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0xF8, 0x78, 0x3C, 0x0E, 0x07, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xE0, 0xE0,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x01, 0xC7, 0xC0, 0x1C, 0x78, 0x03, 0xC7,
  0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF8, 0x3B, 0xC7, 0xFF, 0x3F,
  0x7F, 0xE3, 0xF1, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE1, 0xF8, 0x07, 0x3F, 0xE0, 0x7B, 0xFF, 0x83, 0xF8, 0x7C, 0x1F, 0x01,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x03, 0xC3, 0xF8,
  0x7C, 0x1D, 0xFF, 0xC0, 0xE7, 0xFC, 0x07, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x01, 0xF1, 0xC0,
  0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x78, 0x7C, 0x1F, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x3F, 0x1C, 0x03, 0xFE, 0x70, 0x3F, 0xFF, 0xC0, 0xF8, 0x7F, 0x07,
  0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0,
  0x0F, 0x81, 0xE0, 0xFE, 0x07, 0xFF, 0x78, 0x0F, 0xF9, 0xE0, 0x1F, 0x87,
  0x80, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1E,
  0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0x07, 0x80, 0x78, 0x7C, 0x0F,
  0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x78, 0x1F, 0xF3, 0x83, 0xFF, 0xDC, 0x1F, 0x0F, 0xE1,
  0xE0, 0x3F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0xC0, 0x7C,
  0x1F, 0x0E, 0xE0, 0xFF, 0xEF, 0x03, 0xFE, 0x78, 0x0F, 0xC3, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0xFC, 0x0E, 0x7F, 0xC3, 0xDF, 0xFC, 0x77, 0x0F, 0x8F, 0x80,
  0xF1, 0xE0, 0x0E, 0x3C, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x0F, 0x38, 0x01,
  0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x07,
  0x9C, 0x00, 0xF3, 0x80, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x1E,
  0x70, 0x03, 0xCE, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x04, 0x07, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x1E, 0x0E, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x1E, 0x01,
  0xC1, 0xE0, 0x0E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xE0,
  0x01, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0xFD, 0xE0, 0x07, 0xCF, 0x00, 0x3C,
  0x3C, 0x01, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x78, 0x3C, 0x1D, 0xF9, 0xFC,
  0x3F, 0xF7, 0xF8, 0xEC, 0xEC, 0xF1, 0xF1, 0xF0, 0xE3, 0xC3, 0xC1, 0xC7,
  0x87, 0x83, 0x8E, 0x0E, 0x0F, 0x1C, 0x1C, 0x1C, 0x78, 0x38, 0x38, 0xF0,
  0x70, 0x71, 0xC1, 0xE0, 0xE3, 0x83, 0x83, 0xC7, 0x07, 0x07, 0x9E, 0x0E,
  0x0E, 0x3C, 0x1C, 0x1C, 0x70, 0x78, 0x38, 0xE0, 0xE0, 0xF1, 0xC1, 0xC1,
  0xE7, 0x83, 0x83, 0x8F, 0x07, 0x07, 0x1C, 0x1E, 0x0E, 0x00, 0x1E, 0x1F,
  0x83, 0xCF, 0xF8, 0x7B, 0xFF, 0x8E, 0xE1, 0xF1, 0xF0, 0x1E, 0x3C, 0x01,
  0xCF, 0x80, 0x39, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x07,
  0x9C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0x80, 0x1E,
  0x70, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x03, 0xCE, 0x00, 0x79,
  0xC0, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xF8,
  0x3E, 0x1E, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x87, 0x80, 0x78,
  0x7C, 0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0x87,
  0xE0, 0x1E, 0x7F, 0xC0, 0x7B, 0xFF, 0x81, 0xFC, 0x1E, 0x07, 0xC0, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0x83,
  0xF8, 0x7C, 0x0E, 0xFF, 0xF0, 0x39, 0xFF, 0x00, 0xE3, 0xF0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x70,
  0x1F, 0xF3, 0x83, 0xFF, 0xFC, 0x1F, 0x0F, 0xE1, 0xE0, 0x1F, 0x1E, 0x00,
  0xF8, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C,
  0x00, 0x78, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x0F, 0xE0, 0xFF,
  0xEF, 0x03, 0xFE, 0x78, 0x0F, 0xC3, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x1F, 0xC7, 0x1F, 0xF1, 0xCF, 0xFC, 0x77,
  0x80, 0x1D, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xC0, 0xF0, 0xE0, 0x0E, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x60, 0x03, 0xDE, 0x00,
  0x73, 0xE0, 0x3E, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x1C, 0x00, 0xE3, 0xC0, 0x0E,
  0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01,
  0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xCF, 0x00,
  0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0xE0,
  0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x77, 0x0F, 0xFE, 0x70, 0x7F, 0xCF, 0x03,
  0xF0, 0xF0, 0x70, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x07, 0x80, 0x1E,
  0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70,
  0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x78, 0x38,
  0xF0, 0xF8, 0x38, 0xF0, 0xD8, 0x78, 0xF1, 0xD8, 0x70, 0xF1, 0x98, 0x70,
  0xF3, 0x98, 0xF0, 0xE3, 0x9C, 0xE0, 0xE7, 0x1C, 0xE0, 0xE7, 0x1D, 0xE0,
  0xEE, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0xF0,
  0x01, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xCF, 0x00, 0x03, 0x87, 0x80, 0x07, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x78, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0xDF, 0xFF, 0xFD, 0x81, 0xFF, 0xE0, 0x00,
  0xFC, 0x00,
};

const GFXglyph LiberationMono_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 9, 26, 24, 8, -26 },
  { 31, 15, 12, 24, 7, -29 },
  { 54, 23, 26, 24, 1, -26 },
  { 129, 23, 32, 24, 1, -29 },
  { 221, 27, 26, 24, -1, -26 },
  { 309, 22, 26, 24, 0, -26 },
  { 381, 6, 12, 24, 12, -29 },
  { 390, 15, 37, 24, 6, -29 },
  { 460, 15, 37, 24, 3, -29 },
  { 530, 14, 14, 24, 7, -29 },
  { 555, 20, 19, 24, 2, -23 },
  { 603, 11, 13, 24, 2, -6 },
  { 621, 12, 3, 24, 6, -11 },
  { 626, 5, 6, 24, 8, -6 },
  { 630, 25, 29, 24, 0, -29 },
  { 721, 21, 26, 24, 2, -26 },
  { 790, 20, 26, 24, 1, -26 },
  { 855, 22, 26, 24, 1, -26 },
  { 927, 21, 26, 24, 2, -26 },
  { 996, 21, 26, 24, 1, -26 },
  { 1065, 21, 26, 24, 2, -26 },
  { 1134, 20, 26, 24, 3, -26 },
  { 1199, 18, 26, 24, 6, -26 },
  { 1258, 21, 26, 24, 2, -26 },
  { 1327, 20, 26, 24, 2, -26 },
  { 1392, 8, 22, 24, 8, -22 },
  { 1414, 13, 29, 24, 3, -22 },
  { 1462, 20, 20, 24, 2, -23 },
  { 1512, 20, 13, 24, 2, -20 },
  { 1545, 20, 20, 24, 2, -23 },
  { 1595, 20, 26, 24, 3, -26 },
  { 1660, 25, 34, 24, 0, -29 },
  { 1767, 24, 26, 24, -2, -26 },
  { 1845, 22, 26, 24, 1, -26 },
  { 1917, 22, 26, 24, 2, -26 },
  { 1989, 22, 26, 24, 1, -26 },
  { 2061, 23, 26, 24, 1, -26 },
  { 2136, 22, 26, 24, 2, -26 },
  { 2208, 21, 26, 24, 2, -26 },
  { 2277, 23, 26, 24, 1, -26 },
  { 2352, 21, 26, 24, 2, -26 },
  { 2421, 19, 26, 24, 3, -26 },
  { 2483, 25, 26, 24, 1, -26 },
  { 2565, 17, 26, 24, 3, -26 },
  { 2621, 25, 26, 24, 0, -26 },
  { 2703, 23, 26, 24, 1, -26 },
  { 2778, 21, 26, 24, 2, -26 },
  { 2847, 23, 26, 24, 1, -26 },
  { 2922, 21, 34, 24, 2, -26 },
  { 3012, 23, 26, 24, 1, -26 },
  { 3087, 22, 26, 24, 1, -26 },
  { 3159, 22, 26, 24, 4, -26 },
  { 3231, 22, 26, 24, 2, -26 },
  { 3303, 24, 26, 24, 3, -26 },
  { 3381, 25, 26, 24, 2, -26 },
  { 3463, 27, 26, 24, -1, -26 },
  { 3551, 22, 26, 24, 4, -26 },
  { 3623, 26, 26, 24, -1, -26 },
  { 3708, 18, 37, 24, 4, -29 },
  { 3792, 14, 29, 24, 6, -29 },
  { 3843, 18, 37, 24, 2, -29 },
  { 3927, 19, 18, 24, 2, -26 },
  { 3970, 25, 2, 24, -3, 2 },
  { 3977, 8, 5, 24, 11, -28 },
  { 3982, 20, 22, 24, 1, -22 },
  { 4037, 21, 29, 24, 1, -29 },
  { 4114, 20, 22, 24, 2, -22 },
  { 4169, 22, 29, 24, 2, -29 },
  { 4249, 20, 22, 24, 2, -22 },
  { 4304, 21, 29, 24, 4, -29 },
  { 4381, 21, 30, 24, 2, -22 },
  { 4460, 19, 29, 24, 2, -29 },
  { 4529, 19, 29, 24, 1, -29 },
  { 4598, 21, 37, 24, -1, -29 },
  { 4696, 21, 29, 24, 3, -29 },
  { 4773, 19, 29, 24, 1, -29 },
  { 4842, 23, 22, 24, 0, -22 },
  { 4906, 19, 22, 24, 2, -22 },
  { 4959, 20, 22, 24, 2, -22 },
  { 5014, 22, 30, 24, 0, -22 },
  { 5097, 21, 30, 24, 2, -22 },
  { 5176, 18, 22, 24, 4, -22 },
  { 5226, 19, 22, 24, 2, -22 },
  { 5279, 16, 28, 24, 5, -28 },
  { 5335, 20, 22, 24, 3, -22 },
  { 5390, 22, 22, 24, 3, -22 },
  { 5451, 24, 22, 24, 2, -22 },
  { 5517, 24, 22, 24, 0, -22 },
  { 5583, 25, 30, 24, 0, -22 },
  { 5677, 21, 22, 24, 1, -22 },
  { 5735, 20, 37, 24, 4, -29 },
  { 5828, 4, 37, 24, 10, -29 },
  { 5847, 20, 37, 24, 0, -29 },
  { 5940, 21, 5, 24, 2, -16 },
};

const GFXfont LiberationMono_Italic40pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic40pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic40pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _LIBERATIONMONO_ITALIC40PT7B_H_
