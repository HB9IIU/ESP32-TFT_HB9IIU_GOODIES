#ifndef _LIBERATIONMONO_ITALIC51PT7B_H_
#define _LIBERATIONMONO_ITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE7, 0xE0, 0xFC, 0xF8, 0x1F, 0x9F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C,
  0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x1E, 0x1C, 0x03, 0x87, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x18, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38,
  0x03, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x1C, 0x7E, 0x03, 0xE0, 0xE1, 0xF8, 0x3E,
  0x07, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0xC0, 0xF8, 0x1C,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x07, 0xF3, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1C,
  0x3F, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x38, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x60, 0x1C, 0x03, 0xCF, 0x00, 0xE0, 0x3E, 0x7C,
  0x07, 0x01, 0xE3, 0xE0, 0x38, 0x1F, 0x1F, 0x83, 0xC1, 0xF0, 0x7F, 0x1C,
  0x3F, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x70, 0x1F, 0x1F, 0x00, 0x3C,
  0x07, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x07,
  0x80, 0x38, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC1, 0xE0, 0x07, 0x80, 0xE0,
  0x70, 0x01, 0xE0, 0x78, 0x38, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x1E, 0x0F,
  0x0F, 0x00, 0x07, 0xC7, 0xC7, 0x80, 0x00, 0xFF, 0xE3, 0xC0, 0x00, 0x3F,
  0xF1, 0xE0, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x07, 0x8F, 0xFC,
  0x00, 0x03, 0xC7, 0xFF, 0x00, 0x01, 0xE3, 0xE3, 0xE0, 0x00, 0xF0, 0xE0,
  0x78, 0x00, 0x78, 0x78, 0x1E, 0x00, 0x1C, 0x1C, 0x07, 0x80, 0x0E, 0x0F,
  0x01, 0xE0, 0x07, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x1C, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x3C,
  0x00, 0xF8, 0xF8, 0x0E, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0x80,
  0x07, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78,
  0xFC, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0xC0, 0x3F, 0xC0, 0x0E, 0x07, 0xFE, 0x01, 0xE0, 0xF9,
  0xE0, 0x1E, 0x1F, 0x1E, 0x03, 0xC3, 0xE1, 0xF0, 0x3C, 0x7C, 0x0F, 0x07,
  0x87, 0x80, 0xF8, 0x78, 0x78, 0x07, 0xCF, 0x0F, 0x80, 0x7C, 0xF0, 0xF0,
  0x03, 0xFE, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x0F,
  0x80, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x3F, 0xE0, 0x7E, 0x0F, 0xFF, 0xB3,
  0xFF, 0xF9, 0xFE, 0x1F, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x3C, 0x3F, 0x3E,
  0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x0C, 0x38, 0x37, 0xEE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0x9E, 0x03, 0xC3, 0xC1,
  0xE0, 0xF0, 0x38, 0x1C, 0x04, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x7E, 0xFD, 0xFF, 0xEF, 0xDF, 0xBF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F,
  0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x7C, 0x1F,
  0x7C, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0xFB, 0xE0, 0xFC,
  0x3E, 0xF8, 0x3E, 0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x1F,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFB, 0xC0,
  0x1F, 0xF9, 0xE0, 0x0F, 0xF9, 0xF0, 0x07, 0xF0, 0xF8, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x00,
  0xF8, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0xFE, 0x00,
  0x1E, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0xFE, 0x01, 0xF3,
  0xFF, 0xC0, 0xF3, 0xFF, 0xF0, 0x7B, 0xFF, 0xFC, 0x3F, 0xE0, 0xFE, 0x3F,
  0xC0, 0x1F, 0x9F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x0F, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x80,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x78,
  0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xF8,
  0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80,
  0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0xE3, 0xF0, 0x07, 0xF8, 0x7F, 0x07, 0xFC, 0x1F, 0xFF, 0xEF,
  0x03, 0xFF, 0xF3, 0xC0, 0x7F, 0xF1, 0xF0, 0x07, 0xF0, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x3F, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0xFC, 0x00,
  0xFC, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x81, 0xF0, 0x1C, 0x0E,
  0x0F, 0xF3, 0xB8, 0x3C, 0x3F, 0xE6, 0x70, 0x70, 0xF0, 0xDC, 0xE1, 0xC3,
  0xC1, 0xB9, 0xC3, 0x8F, 0x01, 0xE3, 0x8F, 0x1C, 0x03, 0xC7, 0x1C, 0x78,
  0x07, 0x0E, 0x38, 0xE0, 0x1E, 0x1C, 0xE3, 0xC0, 0x38, 0x71, 0xC7, 0x00,
  0x70, 0xE3, 0x9E, 0x00, 0xE1, 0xCF, 0x3C, 0x03, 0x83, 0x9C, 0x70, 0x07,
  0x0E, 0x38, 0xE0, 0x1C, 0x1C, 0x73, 0xC0, 0x38, 0x78, 0xE7, 0x80, 0xF0,
  0xE3, 0xCF, 0x01, 0xC1, 0xC7, 0x9E, 0x07, 0x87, 0x0F, 0x3C, 0x1F, 0x1C,
  0x1C, 0x78, 0xEE, 0x78, 0x3C, 0x7F, 0x9F, 0xE0, 0x78, 0xFE, 0x3F, 0x80,
  0xF0, 0xF8, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x40, 0x07, 0x80, 0x03, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xE0, 0x07,
  0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x87, 0xC0, 0x07, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0x20, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x83, 0xE0, 0x00,
  0x3C, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xE0,
  0x3F, 0xC0, 0x3E, 0x00, 0xFE, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x60, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xF3, 0xE0, 0x1F, 0xFE, 0x7C,
  0x03, 0xFF, 0xCF, 0x80, 0x7F, 0xF9, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1F, 0x80, 0x0F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x1C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x01, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xC0,
  0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x07, 0x8F,
  0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF7,
  0xC0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x07, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xDE, 0x0F, 0x3C,
  0x0F, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF3, 0xC1, 0xCF, 0x03, 0xCF, 0x0F,
  0x3C, 0x0F, 0x3C, 0x38, 0xF0, 0x3C, 0xF1, 0xE3, 0xC1, 0xE1, 0xE7, 0x1F,
  0x07, 0x87, 0xBC, 0x78, 0x1E, 0x1E, 0xE1, 0xE0, 0x78, 0x7F, 0x87, 0x81,
  0xE1, 0xFC, 0x1E, 0x0F, 0x03, 0xF0, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x03, 0xC0, 0xFE, 0x00, 0x1E, 0x07,
  0xF0, 0x01, 0xF0, 0x3F, 0xC0, 0x0F, 0x81, 0xFE, 0x00, 0x78, 0x0F, 0xF0,
  0x03, 0xC0, 0xFF, 0x80, 0x1E, 0x07, 0x9E, 0x00, 0xF0, 0x3C, 0xF0, 0x0F,
  0x81, 0xE7, 0x80, 0x78, 0x0F, 0x3E, 0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x07,
  0xC7, 0x80, 0xF0, 0x3C, 0x3C, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x0F, 0x07,
  0x83, 0xC0, 0x78, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x0F, 0x8F,
  0x81, 0xE0, 0x3C, 0x7C, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x1E, 0x07,
  0xC0, 0x7C, 0xF0, 0x3C, 0x01, 0xE7, 0x81, 0xE0, 0x0F, 0x7C, 0x0F, 0x00,
  0x7F, 0xC0, 0x78, 0x03, 0xFE, 0x07, 0xC0, 0x0F, 0xF0, 0x3E, 0x00, 0x7F,
  0x81, 0xE0, 0x03, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x03,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0xFC, 0x0F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03,
  0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xFC, 0x1F,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x3E, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xF0, 0x3E, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x78, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xE0,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x0E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0,
  0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x8F, 0x81,
  0xF8, 0x1E, 0x1F, 0x03, 0xF0, 0x3C, 0x3E, 0x0F, 0xE0, 0xF0, 0x7C, 0x1F,
  0xC1, 0xE0, 0xF8, 0x7F, 0x83, 0xC1, 0xF0, 0xEF, 0x0F, 0x03, 0xC3, 0xCE,
  0x1E, 0x07, 0x87, 0x9C, 0x3C, 0x0F, 0x0E, 0x38, 0xF0, 0x1E, 0x3C, 0x71,
  0xE0, 0x3C, 0x70, 0xE3, 0xC0, 0x79, 0xE1, 0xCF, 0x00, 0xF3, 0x83, 0x9E,
  0x01, 0xEF, 0x07, 0x3C, 0x03, 0xDC, 0x0F, 0x70, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x1D, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x78, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01,
  0xC0, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x83, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0x80, 0x7C, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3,
  0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xF0, 0xF8, 0x07, 0x78, 0x7E, 0x0F, 0x3E,
  0x1F, 0xFF, 0x1F, 0xEF, 0xFF, 0x0F, 0xF1, 0xFC, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0xFF, 0xE0, 0x1E, 0x7F,
  0xFC, 0x07, 0xBC, 0x1F, 0x83, 0xFC, 0x03, 0xE0, 0xFE, 0x00, 0xF8, 0x3F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0x87,
  0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0xC0, 0x3E,
  0x0F, 0xB8, 0x1F, 0x03, 0xEF, 0xFF, 0x80, 0xF1, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7C, 0x0F, 0xE0, 0x7C, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x01, 0xFF, 0xC7, 0x80,
  0x3F, 0xFE, 0x78, 0x07, 0xE0, 0xF7, 0x80, 0xF8, 0x03, 0xF8, 0x0F, 0x00,
  0x3F, 0x81, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0x80, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x37, 0x80, 0x7E, 0x0F, 0x78, 0x07,
  0xFF, 0xCF, 0x80, 0x3F, 0xF8, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFC, 0x7C, 0x07, 0xFF, 0xCF, 0x01, 0xF8, 0x3D, 0xE0,
  0x7C, 0x03, 0xBC, 0x0F, 0x00, 0x3F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x83, 0xF0, 0x0D, 0xE0, 0x3F, 0x07, 0xBC, 0x07, 0xFF,
  0xE7, 0x80, 0x7F, 0xF1, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x01,
  0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x01, 0xF3, 0xFF, 0x80, 0xF3, 0xFF, 0xE0,
  0x7B, 0xC1, 0xF8, 0x3F, 0x80, 0x7C, 0x3F, 0x80, 0x3E, 0x1F, 0x80, 0x0F,
  0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x06, 0x01, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3C, 0x3F, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFB, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xFC, 0x00, 0x78, 0x0F,
  0x80, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x3C, 0xFE, 0x3F, 0xC1, 0xEF, 0xF3, 0xFE, 0x0E, 0xC7, 0xB9, 0xF0,
  0xFC, 0x3D, 0x87, 0x87, 0xC1, 0xF8, 0x3C, 0x3E, 0x0F, 0x81, 0xE1, 0xE0,
  0x7C, 0x0F, 0x0F, 0x03, 0xE0, 0x78, 0xF8, 0x1E, 0x03, 0xC7, 0xC0, 0xF0,
  0x3E, 0x3C, 0x07, 0x81, 0xF1, 0xE0, 0x7C, 0x0F, 0x0F, 0x03, 0xE0, 0x78,
  0x78, 0x1E, 0x03, 0xC7, 0xC0, 0xF0, 0x3E, 0x3C, 0x07, 0x81, 0xF1, 0xE0,
  0x3C, 0x0F, 0x0F, 0x03, 0xE0, 0x78, 0x78, 0x1E, 0x03, 0xC7, 0xC0, 0xF0,
  0x1E, 0x3C, 0x07, 0x81, 0xF1, 0xE0, 0x3C, 0x0F, 0x0F, 0x03, 0xE0, 0x78,
  0x78, 0x1E, 0x03, 0xC7, 0xC0, 0xF0, 0x1E, 0x3E, 0x07, 0x81, 0xF1, 0xE0,
  0x3C, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xC3, 0xFF, 0x01, 0xE7, 0xFF,
  0xC0, 0xF7, 0x83, 0xF0, 0xFF, 0x00, 0xF8, 0x7F, 0x00, 0x7C, 0x3F, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x8F,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9E,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x3F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1E, 0x3F, 0xF8, 0x01, 0xE7, 0xFF,
  0xC0, 0x1E, 0xE0, 0x7E, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x1E, 0x03,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x01, 0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xEE, 0x07, 0xE0, 0x3E, 0xFF, 0xFC,
  0x03, 0xE7, 0xFF, 0x00, 0x3E, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF1, 0xF0, 0x3F, 0xFE, 0x78, 0x1F, 0x83, 0xDE, 0x0F, 0x80, 0x3F, 0x83,
  0xC0, 0x0F, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xE0, 0xFC, 0x03, 0x78, 0x1F, 0x83, 0xBE, 0x07, 0xFF, 0xCF, 0x80, 0xFF,
  0xE3, 0xE0, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0x07, 0xFE, 0x0F, 0x0F, 0xFE, 0x0F,
  0x1F, 0xFE, 0x0F, 0x3E, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xE0, 0x3F, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x10, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x07,
  0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83,
  0xF0, 0x0D, 0xE0, 0x7E, 0x0F, 0x78, 0x1F, 0xFF, 0x9E, 0x03, 0xFF, 0x8F,
  0x80, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x07, 0xC0, 0x78, 0x78, 0x1F, 0x81, 0xF0, 0xF0,
  0x3F, 0x03, 0xC1, 0xE0, 0xFE, 0x07, 0x83, 0xC1, 0xDC, 0x1E, 0x07, 0x87,
  0xBC, 0x3C, 0x0F, 0x0E, 0x78, 0xF8, 0x1E, 0x3C, 0xF1, 0xE0, 0x3C, 0x71,
  0xE3, 0xC0, 0x79, 0xE1, 0xCF, 0x80, 0xF3, 0x83, 0x9E, 0x01, 0xEF, 0x07,
  0x3C, 0x03, 0xDC, 0x0E, 0xF8, 0x07, 0xF8, 0x1D, 0xE0, 0x0E, 0xE0, 0x3B,
  0xC0, 0x1D, 0xC0, 0x77, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0x00,
};

const GFXglyph LiberationMono_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 12, 34, 31, 10, -34 },
  { 52, 19, 16, 31, 9, -37 },
  { 90, 30, 34, 31, 1, -34 },
  { 218, 29, 41, 31, 1, -37 },
  { 367, 34, 36, 31, -1, -35 },
  { 520, 28, 36, 31, 0, -35 },
  { 646, 8, 16, 31, 15, -37 },
  { 662, 19, 48, 31, 8, -37 },
  { 776, 19, 48, 31, 4, -37 },
  { 890, 18, 18, 31, 9, -37 },
  { 931, 25, 26, 31, 3, -30 },
  { 1013, 14, 16, 31, 2, -7 },
  { 1041, 15, 4, 31, 8, -15 },
  { 1049, 7, 7, 31, 10, -7 },
  { 1056, 32, 38, 31, 0, -37 },
  { 1208, 26, 36, 31, 3, -35 },
  { 1325, 25, 34, 31, 1, -34 },
  { 1432, 28, 35, 31, 1, -35 },
  { 1555, 27, 36, 31, 2, -35 },
  { 1677, 27, 34, 31, 1, -34 },
  { 1792, 27, 35, 31, 2, -34 },
  { 1911, 25, 36, 31, 4, -35 },
  { 2024, 24, 34, 31, 7, -34 },
  { 2126, 27, 36, 31, 2, -35 },
  { 2248, 26, 36, 31, 3, -35 },
  { 2365, 11, 27, 31, 10, -27 },
  { 2403, 17, 36, 31, 4, -27 },
  { 2480, 25, 26, 31, 3, -30 },
  { 2562, 25, 16, 31, 3, -25 },
  { 2612, 25, 26, 31, 3, -30 },
  { 2694, 25, 35, 31, 4, -35 },
  { 2804, 31, 43, 31, 0, -37 },
  { 2971, 31, 34, 31, -3, -34 },
  { 3103, 28, 34, 31, 1, -34 },
  { 3222, 27, 36, 31, 3, -35 },
  { 3344, 28, 34, 31, 1, -34 },
  { 3463, 30, 34, 31, 1, -34 },
  { 3591, 29, 34, 31, 2, -34 },
  { 3715, 27, 36, 31, 3, -35 },
  { 3837, 29, 34, 31, 1, -34 },
  { 3961, 27, 34, 31, 2, -34 },
  { 4076, 25, 35, 31, 3, -34 },
  { 4186, 32, 34, 31, 1, -34 },
  { 4322, 23, 34, 31, 3, -34 },
  { 4420, 30, 34, 31, 1, -34 },
  { 4548, 29, 34, 31, 1, -34 },
  { 4672, 26, 36, 31, 3, -35 },
  { 4789, 29, 34, 31, 1, -34 },
  { 4913, 26, 46, 31, 3, -35 },
  { 5063, 29, 34, 31, 1, -34 },
  { 5187, 29, 36, 31, 1, -35 },
  { 5318, 28, 34, 31, 5, -34 },
  { 5437, 28, 35, 31, 3, -34 },
  { 5560, 30, 34, 31, 4, -34 },
  { 5688, 31, 34, 31, 3, -34 },
  { 5820, 35, 34, 31, -2, -34 },
  { 5969, 29, 34, 31, 5, -34 },
  { 6093, 33, 34, 31, -1, -34 },
  { 6234, 22, 48, 31, 6, -37 },
  { 6366, 18, 38, 31, 7, -37 },
  { 6452, 23, 48, 31, 2, -37 },
  { 6590, 24, 23, 31, 3, -34 },
  { 6659, 32, 2, 31, -4, 3 },
  { 6667, 10, 6, 31, 14, -36 },
  { 6675, 25, 29, 31, 2, -28 },
  { 6766, 26, 38, 31, 2, -37 },
  { 6890, 25, 29, 31, 3, -28 },
  { 6981, 28, 38, 31, 3, -37 },
  { 7114, 25, 29, 31, 3, -28 },
  { 7205, 27, 37, 31, 5, -37 },
  { 7330, 27, 39, 31, 2, -28 },
  { 7462, 25, 37, 31, 2, -37 },
  { 7578, 25, 37, 31, 1, -37 },
  { 7694, 27, 48, 31, -2, -37 },
  { 7856, 27, 37, 31, 3, -37 },
  { 7981, 25, 37, 31, 1, -37 },
  { 8097, 29, 28, 31, 0, -28 },
  { 8199, 25, 28, 31, 2, -28 },
  { 8287, 25, 29, 31, 3, -28 },
  { 8378, 28, 39, 31, 0, -28 },
  { 8515, 26, 39, 31, 3, -28 },
  { 8642, 24, 28, 31, 5, -28 },
  { 8726, 24, 29, 31, 3, -28 },
  { 8813, 20, 35, 31, 7, -34 },
  { 8901, 26, 28, 31, 3, -27 },
  { 8992, 27, 27, 31, 4, -27 },
  { 9084, 31, 27, 31, 2, -27 },
  { 9189, 30, 27, 31, 0, -27 },
  { 9291, 32, 38, 31, 0, -27 },
  { 9443, 27, 27, 31, 1, -27 },
  { 9535, 26, 48, 31, 5, -37 },
  { 9691, 4, 48, 31, 13, -37 },
  { 9715, 26, 48, 31, -1, -37 },
  { 9871, 26, 6, 31, 3, -20 },
};

const GFXfont LiberationMono_Italic51pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic51pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic51pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _LIBERATIONMONO_ITALIC51PT7B_H_
