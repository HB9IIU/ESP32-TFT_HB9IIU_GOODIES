#ifndef _LIBERATIONMONO_ITALIC44PT7B_H_
#define _LIBERATIONMONO_ITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x00, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x3C,
  0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x18, 0x07,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x60, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00,
  0xC0, 0x01, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x0C,
  0x03, 0x00, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00,
  0x38, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x70,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x1F, 0x8C, 0x7C, 0x0F, 0x0E, 0x1F, 0x0F, 0x07, 0x07, 0x87, 0x83, 0x83,
  0xC3, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0x00, 0xF0, 0x60, 0x00, 0x78, 0x70,
  0x00, 0x3F, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x8F, 0xC0, 0x01, 0xC1, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0x60, 0x78, 0xE0, 0x70, 0x3C, 0xF0, 0x38, 0x1E, 0x78,
  0x1C, 0x0F, 0x3C, 0x0E, 0x0F, 0x1F, 0x06, 0x0F, 0x87, 0xE7, 0x1F, 0x81,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x1F,
  0xF0, 0x03, 0x81, 0xC3, 0x80, 0x38, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0xF0,
  0x38, 0x0F, 0x07, 0x83, 0x80, 0x70, 0x3C, 0x38, 0x03, 0x81, 0xC3, 0xC0,
  0x1C, 0x0E, 0x1C, 0x00, 0xE0, 0x71, 0xC0, 0x07, 0x07, 0x1C, 0x00, 0x38,
  0x39, 0xC0, 0x01, 0xE3, 0x9C, 0x00, 0x07, 0xF9, 0xC0, 0x00, 0x1F, 0x9C,
  0x7E, 0x00, 0x01, 0xCF, 0xF8, 0x00, 0x1E, 0xF1, 0xC0, 0x00, 0xE7, 0x0F,
  0x00, 0x0E, 0x70, 0x38, 0x00, 0xE3, 0x81, 0xC0, 0x0E, 0x3C, 0x0E, 0x00,
  0xE1, 0xC0, 0xF0, 0x0E, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x38, 0x0F, 0x03,
  0x81, 0xC0, 0xF0, 0x1C, 0x1C, 0x07, 0x00, 0xF1, 0xC0, 0x70, 0x03, 0xFC,
  0x07, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE1, 0xF0, 0x00,
  0xE7, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x04, 0x0F,
  0xF8, 0x0E, 0x1E, 0x78, 0x0E, 0x3C, 0x38, 0x1E, 0x38, 0x3C, 0x1C, 0x78,
  0x1C, 0x3C, 0x70, 0x1E, 0x38, 0xF0, 0x0F, 0x70, 0xF0, 0x0F, 0xF0, 0xF0,
  0x07, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0xF9, 0x7F,
  0xFE, 0xFF, 0x3F, 0xF8, 0x7E, 0x0F, 0xE0, 0x1E, 0x3C, 0x79, 0xF3, 0xE7,
  0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC2, 0x71, 0x8E, 0xFD,
  0xBF, 0x7F, 0xFC, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1C, 0xE0, 0x3C,
  0xE0, 0x78, 0xF0, 0x70, 0x70, 0x20, 0x40, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xF1, 0xE0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0x78, 0x7C, 0x3F, 0xC3, 0xE1, 0xEF, 0x0F, 0x87, 0xBC, 0x3E,
  0x1E, 0xF0, 0xF8, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x38, 0x00, 0x3C,
  0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8,
  0x07, 0x81, 0xF0, 0x7C, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xEF, 0x00, 0xFE, 0x3C, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x03, 0xE0,
  0x78, 0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF8, 0x01, 0xE0,
  0xFC, 0x0F, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xF0, 0x7E, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF8, 0x03, 0xE0,
  0xF8, 0x1F, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xF8, 0x3E, 0x07,
  0xC0, 0x7C, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0x87, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC3, 0xF0, 0x0E, 0x7F, 0xF0, 0x7B, 0xFF, 0xE1,
  0xFE, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0x8F, 0x00, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xF8, 0x3E, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0x03, 0xE0, 0x78, 0x03, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xF0, 0xF8, 0x00,
  0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1F,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF8, 0x01, 0xE0, 0xF8, 0x0F, 0x81,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x7E, 0x0F, 0x00, 0xF8, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE3,
  0xC0, 0x1F, 0x8F, 0xC1, 0xDE, 0x1F, 0xFE, 0x70, 0x3F, 0xF3, 0xC0, 0x3F,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x3C,
  0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xE0, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0x03, 0xE3, 0xE0, 0x0F, 0xBE, 0x00,
  0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0x78, 0x1C, 0x00, 0x07, 0x07, 0x83, 0xC6, 0xE0, 0xE1, 0xFD, 0xDC,
  0x38, 0x71, 0xB3, 0x87, 0x1C, 0x16, 0x71, 0xC7, 0x03, 0xCE, 0x38, 0xC0,
  0x71, 0xC6, 0x38, 0x0E, 0x39, 0xC6, 0x03, 0x86, 0x39, 0xC0, 0x70, 0xC6,
  0x38, 0x0E, 0x39, 0xCE, 0x01, 0x87, 0x39, 0xC0, 0x70, 0xC7, 0x38, 0x0E,
  0x18, 0xC7, 0x03, 0x87, 0x19, 0xC0, 0x70, 0xC7, 0x38, 0x1E, 0x38, 0xE7,
  0x03, 0x86, 0x1C, 0xE0, 0xF1, 0xC3, 0x8E, 0x76, 0x70, 0x71, 0xFC, 0xFC,
  0x0E, 0x1E, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x01, 0x00, 0x78, 0x00, 0x60, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C,
  0x70, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE1, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x3F, 0x07, 0x80,
  0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0xFC, 0x1E, 0x00,
  0x3E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0x78, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x1F, 0x00,
  0x0F, 0x1E, 0x00, 0x08, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x30, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x7C, 0x00,
  0xF0, 0x7C, 0x01, 0xE0, 0x3F, 0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0x80, 0xFC, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0x80,
  0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x7C, 0x00,
  0xF8, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x0F, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x1F, 0x00,
  0x0C, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0xFC, 0x78, 0x0F,
  0xFC, 0x78, 0x1F, 0xFC, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x7C, 0x00,
  0xF0, 0x7C, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x03,
  0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x07, 0xC3, 0xC0, 0x1E, 0x0F,
  0x00, 0x78, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xC0,
  0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x07,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xBF, 0x00, 0x01,
  0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1E,
  0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xB8,
  0x0F, 0xE0, 0xEE, 0x03, 0xF8, 0x3B, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7, 0x07,
  0xBC, 0x39, 0xC1, 0xE7, 0x1E, 0xF0, 0x71, 0xC7, 0x3C, 0x1C, 0x73, 0x8F,
  0x07, 0x1C, 0xE3, 0x83, 0xC7, 0xF0, 0xE0, 0xF0, 0xFC, 0x78, 0x38, 0x3E,
  0x1E, 0x0E, 0x0F, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x78,
  0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01,
  0xE0, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC1,
  0xF8, 0x01, 0xE0, 0xFE, 0x00, 0xF0, 0x7F, 0x00, 0x70, 0x3F, 0x80, 0x78,
  0x1D, 0xC0, 0x3C, 0x1E, 0xF0, 0x1E, 0x0F, 0x78, 0x0F, 0x07, 0x9C, 0x07,
  0x03, 0x8E, 0x03, 0x81, 0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF0, 0xE0,
  0xF0, 0x78, 0x78, 0x70, 0x3C, 0x3C, 0x38, 0x1C, 0x1E, 0x3C, 0x1E, 0x07,
  0x1E, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0xF3, 0x81, 0xC0,
  0x39, 0xC1, 0xE0, 0x1F, 0xE0, 0xF0, 0x0F, 0xF0, 0x78, 0x03, 0xF8, 0x3C,
  0x01, 0xF8, 0x1C, 0x00, 0xFC, 0x1E, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xE0,
  0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x07,
  0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xC0,
  0x7C, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xF0, 0x07,
  0xE0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x1E, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xC0, 0x7C, 0x1F, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xF0, 0x78, 0x00,
  0xF8, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0,
  0x07, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xE0,
  0x78, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x3E, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE3, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3F, 0x01,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0,
  0x03, 0xC1, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x3D, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x87, 0x81, 0xE0, 0x70, 0x78, 0x3E, 0x0F, 0x07, 0x83,
  0xE0, 0xF0, 0x78, 0x7E, 0x0E, 0x07, 0x87, 0xE1, 0xE0, 0x78, 0xEE, 0x1E,
  0x07, 0x0E, 0xE1, 0xC0, 0x71, 0xEE, 0x3C, 0x07, 0x1C, 0xE3, 0xC0, 0x71,
  0xCE, 0x38, 0x07, 0x38, 0xF7, 0x80, 0x73, 0x87, 0x78, 0x07, 0x70, 0x77,
  0x00, 0x77, 0x07, 0x70, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0x83, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1E, 0x07,
  0xC0, 0x0F, 0x03, 0xC0, 0x07, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF3,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77,
  0x80, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01,
  0xC1, 0xE0, 0x1E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0F,
  0x07, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x7B, 0xC0,
  0x03, 0xDC, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x01,
  0xFF, 0xFC, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xF0, 0x1E, 0x3E, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x3F, 0x8F, 0x83,
  0xBE, 0x7F, 0xF9, 0xFD, 0xFF, 0x87, 0xE7, 0xF0, 0x3F, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x0F, 0xC0, 0x3C, 0xFF,
  0xC0, 0xF7, 0xFF, 0x83, 0xB8, 0x3E, 0x1F, 0x80, 0x7C, 0x7C, 0x00, 0xF1,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0xC0, 0x1E, 0x1F,
  0x00, 0xF8, 0xFF, 0x07, 0xC3, 0xDF, 0xFE, 0x0F, 0x3F, 0xF0, 0x38, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x3E,
  0x0F, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1F, 0x00, 0xF8, 0x3E, 0x0F, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x1E, 0x01, 0xFF,
  0x9E, 0x07, 0xFF, 0xBC, 0x0F, 0xC1, 0xFC, 0x0F, 0x00, 0xFC, 0x1E, 0x00,
  0x7C, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0x78, 0x07, 0xE0, 0x7C, 0x1D, 0xE0, 0x7F, 0xFD,
  0xE0, 0x3F, 0xF1, 0xC0, 0x0F, 0xC1, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF1,
  0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0C, 0x1F,
  0x00, 0x78, 0x3E, 0x07, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x1E, 0x03, 0xFE, 0x3C, 0x1F,
  0xFE, 0x70, 0x7E, 0x0F, 0xE0, 0xF0, 0x0F, 0xC3, 0xC0, 0x1F, 0x87, 0x80,
  0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x0F, 0x83,
  0xC0, 0x3F, 0x07, 0xC1, 0xDE, 0x07, 0xFF, 0xBC, 0x0F, 0xFC, 0x78, 0x07,
  0xE0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x0F, 0xC0, 0x3C, 0xFF, 0xC0, 0xF7, 0xFF, 0x83, 0xB8,
  0x3E, 0x1F, 0xC0, 0x78, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x10, 0x0F,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x3C, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xEF,
  0x00, 0x0F, 0x9F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x3C,
  0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x3E, 0x1F, 0x07, 0x3F, 0x1F,
  0xC3, 0xBF, 0xDF, 0xE1, 0xF1, 0xF8, 0xF0, 0xF8, 0xFC, 0x38, 0x78, 0x7C,
  0x1C, 0x78, 0x3C, 0x0E, 0x3C, 0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x8E, 0x07,
  0x83, 0xC7, 0x03, 0x81, 0xE7, 0x81, 0xC0, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0,
  0xF0, 0x78, 0xE0, 0x78, 0x3C, 0x70, 0x38, 0x1E, 0x78, 0x1C, 0x0E, 0x3C,
  0x1E, 0x07, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x03, 0x81, 0xE7,
  0x81, 0xC0, 0xE3, 0xC1, 0xE0, 0x71, 0xE0, 0xF0, 0x78, 0x0F, 0x0F, 0xE0,
  0x3C, 0xFF, 0xC0, 0xE7, 0xFF, 0x83, 0xB8, 0x3E, 0x1F, 0xC0, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF8,
  0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1F, 0x00, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xC3, 0xF0,
  0x03, 0xCF, 0xFC, 0x03, 0xDF, 0xFE, 0x03, 0xB8, 0x3E, 0x03, 0xE0, 0x1F,
  0x07, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x3F, 0xC1, 0xF0,
  0x3D, 0xFF, 0xE0, 0x3C, 0xFF, 0xC0, 0x3C, 0x7F, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x1E, 0x07, 0xFF, 0x38, 0x1F, 0xFE, 0xF0, 0x7E, 0x0F, 0xE0,
  0xF0, 0x0F, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x01,
  0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x83, 0xC0, 0x3F, 0x07, 0xC1, 0xDE,
  0x0F, 0xFF, 0x3C, 0x0F, 0xFC, 0xF0, 0x07, 0xE1, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x1E,
  0x07, 0xF8, 0xF0, 0xFF, 0xC7, 0x8F, 0xFC, 0x3C, 0xFF, 0xE1, 0xEF, 0x80,
  0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0x81,
  0xF0, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x9C, 0x00, 0x39, 0xE0, 0x03, 0xC7, 0xC0, 0x7C, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x01, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0x80, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00,
  0x7C, 0x3C, 0x03, 0xF0, 0xF8, 0x3F, 0xC3, 0xFF, 0xEF, 0x07, 0xFE, 0x3C,
  0x07, 0xE0, 0xE0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x7C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x1E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1, 0xC0,
  0xF0, 0x3C, 0xF0, 0x7C, 0x1E, 0x3C, 0x1F, 0x87, 0x8F, 0x0E, 0xE1, 0xC3,
  0xC3, 0xB8, 0xF0, 0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x8E, 0x0F, 0x38, 0xE7,
  0x83, 0xCE, 0x39, 0xE0, 0xF7, 0x0E, 0x70, 0x3D, 0xC1, 0xBC, 0x0F, 0xE0,
  0x6F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xF0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xF8, 0x0D, 0xFF, 0xFF, 0xFB, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
};

const GFXglyph LiberationMono_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 29, 26, 9, -29 },
  { 38, 16, 14, 26, 8, -32 },
  { 66, 26, 29, 26, 1, -29 },
  { 161, 25, 35, 26, 1, -32 },
  { 271, 29, 29, 26, -1, -29 },
  { 377, 24, 29, 26, 0, -29 },
  { 464, 7, 14, 26, 13, -32 },
  { 477, 16, 41, 26, 7, -32 },
  { 559, 17, 41, 26, 3, -32 },
  { 647, 16, 16, 26, 8, -32 },
  { 679, 22, 21, 26, 2, -25 },
  { 737, 12, 14, 26, 2, -6 },
  { 758, 13, 3, 26, 7, -13 },
  { 763, 7, 6, 26, 8, -6 },
  { 769, 28, 32, 26, 0, -32 },
  { 881, 22, 29, 26, 3, -29 },
  { 961, 22, 29, 26, 1, -29 },
  { 1041, 24, 29, 26, 1, -29 },
  { 1128, 23, 29, 26, 2, -29 },
  { 1212, 23, 29, 26, 1, -29 },
  { 1296, 23, 29, 26, 2, -29 },
  { 1380, 22, 29, 26, 3, -29 },
  { 1460, 20, 29, 26, 6, -29 },
  { 1533, 23, 29, 26, 2, -29 },
  { 1617, 22, 29, 26, 3, -29 },
  { 1697, 10, 24, 26, 8, -24 },
  { 1727, 14, 32, 26, 4, -24 },
  { 1783, 22, 23, 26, 2, -26 },
  { 1847, 22, 15, 26, 2, -22 },
  { 1889, 22, 23, 26, 2, -26 },
  { 1953, 21, 29, 26, 4, -29 },
  { 2030, 27, 38, 26, 0, -32 },
  { 2159, 26, 29, 26, -2, -29 },
  { 2254, 24, 29, 26, 1, -29 },
  { 2341, 24, 29, 26, 2, -29 },
  { 2428, 24, 29, 26, 1, -29 },
  { 2515, 26, 29, 26, 1, -29 },
  { 2610, 25, 29, 26, 2, -29 },
  { 2701, 24, 29, 26, 2, -29 },
  { 2788, 25, 29, 26, 1, -29 },
  { 2879, 23, 29, 26, 2, -29 },
  { 2963, 22, 29, 26, 3, -29 },
  { 3043, 27, 29, 26, 1, -29 },
  { 3141, 19, 29, 26, 3, -29 },
  { 3210, 26, 29, 26, 1, -29 },
  { 3305, 25, 29, 26, 1, -29 },
  { 3396, 23, 29, 26, 2, -29 },
  { 3480, 25, 29, 26, 1, -29 },
  { 3571, 23, 38, 26, 2, -29 },
  { 3681, 25, 29, 26, 1, -29 },
  { 3772, 25, 29, 26, 1, -29 },
  { 3863, 24, 29, 26, 4, -29 },
  { 3950, 25, 29, 26, 2, -29 },
  { 4041, 26, 29, 26, 4, -29 },
  { 4136, 28, 29, 26, 2, -29 },
  { 4238, 29, 29, 26, -1, -29 },
  { 4344, 25, 29, 26, 4, -29 },
  { 4435, 28, 29, 26, -1, -29 },
  { 4537, 20, 41, 26, 5, -32 },
  { 4640, 16, 32, 26, 6, -32 },
  { 4704, 19, 41, 26, 2, -32 },
  { 4802, 21, 19, 26, 2, -29 },
  { 4852, 27, 2, 26, -3, 3 },
  { 4859, 9, 6, 26, 12, -32 },
  { 4866, 21, 24, 26, 2, -24 },
  { 4929, 22, 32, 26, 2, -32 },
  { 5017, 22, 24, 26, 2, -24 },
  { 5083, 24, 32, 26, 2, -32 },
  { 5179, 22, 24, 26, 2, -24 },
  { 5245, 22, 32, 26, 5, -32 },
  { 5333, 23, 33, 26, 2, -24 },
  { 5428, 22, 32, 26, 2, -32 },
  { 5516, 22, 32, 26, 1, -32 },
  { 5604, 23, 41, 26, -1, -32 },
  { 5722, 23, 32, 26, 3, -32 },
  { 5814, 21, 32, 26, 1, -32 },
  { 5898, 25, 24, 26, 0, -24 },
  { 5973, 22, 24, 26, 2, -24 },
  { 6039, 22, 24, 26, 2, -24 },
  { 6105, 24, 33, 26, 0, -24 },
  { 6204, 23, 33, 26, 2, -24 },
  { 6299, 21, 24, 26, 4, -24 },
  { 6362, 21, 24, 26, 2, -24 },
  { 6425, 17, 30, 26, 6, -30 },
  { 6489, 22, 24, 26, 3, -24 },
  { 6555, 23, 24, 26, 4, -24 },
  { 6624, 26, 24, 26, 2, -24 },
  { 6702, 26, 24, 26, 0, -24 },
  { 6780, 27, 33, 26, 0, -24 },
  { 6892, 23, 24, 26, 1, -24 },
  { 6961, 22, 41, 26, 5, -32 },
  { 7074, 4, 41, 26, 11, -32 },
  { 7095, 22, 41, 26, 0, -32 },
  { 7208, 23, 5, 26, 2, -17 },
};

const GFXfont LiberationMono_Italic44pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic44pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic44pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _LIBERATIONMONO_ITALIC44PT7B_H_
