#ifndef _LIBERATIONMONO_ITALIC16PT7B_H_
#define _LIBERATIONMONO_ITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x26, 0x44, 0x0C, 0xC0, 0x4F, 0x2C, 0xA2, 0x88, 0x04,
  0x82, 0x20, 0x91, 0xFF, 0x11, 0x04, 0x82, 0x23, 0xFE, 0x24, 0x11, 0x04,
  0x80, 0x02, 0x0F, 0x8D, 0x24, 0x92, 0x41, 0xA0, 0x78, 0x13, 0x09, 0xE4,
  0xD2, 0x4F, 0xC1, 0x00, 0x38, 0x52, 0x24, 0x91, 0x28, 0x74, 0x03, 0x00,
  0xB8, 0x52, 0x24, 0x91, 0x28, 0x70, 0x0F, 0x08, 0x84, 0x42, 0x41, 0xC1,
  0xCD, 0x25, 0x96, 0x86, 0x63, 0x1E, 0xE0, 0xFA, 0x80, 0x0C, 0x21, 0x0C,
  0x21, 0x84, 0x10, 0x43, 0x0C, 0x10, 0x41, 0x82, 0x00, 0x18, 0x20, 0xC1,
  0x04, 0x10, 0x43, 0x0C, 0x21, 0x84, 0x30, 0x84, 0x00, 0x10, 0x8F, 0xDC,
  0x50, 0x40, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x36, 0x48, 0x78,
  0xF0, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10,
  0x08, 0x06, 0x03, 0x00, 0x1E, 0x23, 0x61, 0x41, 0xD9, 0xDB, 0x83, 0x82,
  0x86, 0xC4, 0x78, 0x02, 0x0E, 0x36, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0x7F, 0x0F, 0x08, 0xCC, 0x20, 0x30, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x3F, 0xC0, 0x1E, 0x23, 0x41, 0x03, 0x06, 0x18, 0x06, 0x02, 0x82,
  0xC6, 0x78, 0x01, 0x01, 0x81, 0x41, 0x61, 0x31, 0x11, 0x08, 0xFF, 0x06,
  0x03, 0x01, 0x80, 0x3F, 0x20, 0x60, 0x40, 0x7C, 0x46, 0x03, 0x02, 0x82,
  0xC4, 0x78, 0x1E, 0x33, 0x60, 0x40, 0x5E, 0xE2, 0xC3, 0xC2, 0xC2, 0x44,
  0x78, 0xFE, 0x02, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x1E, 0x23, 0x61, 0x43, 0x62, 0x3C, 0x42, 0x82, 0x82, 0xC6, 0x78, 0x1E,
  0x23, 0x43, 0x41, 0x43, 0x47, 0x3A, 0x02, 0x86, 0xCC, 0x78, 0x26, 0x00,
  0x00, 0x0C, 0xC0, 0x08, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x21, 0x84, 0x00,
  0x03, 0x0C, 0x70, 0x80, 0x70, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x70, 0x0E, 0x01, 0x0E, 0x70, 0x80, 0x1E, 0x63, 0x41, 0x03, 0x02, 0x0C,
  0x18, 0x30, 0x00, 0x20, 0x20, 0x07, 0x06, 0x21, 0x04, 0x9D, 0x4B, 0x54,
  0xD5, 0x26, 0x8A, 0xA2, 0xA9, 0x2A, 0xD2, 0xD8, 0x80, 0x10, 0x83, 0xC0,
  0x03, 0x01, 0xC0, 0x50, 0x36, 0x09, 0x86, 0x61, 0x08, 0xFE, 0x20, 0x98,
  0x3C, 0x0C, 0x3F, 0x18, 0xCC, 0x24, 0x32, 0x13, 0xF1, 0x86, 0xC3, 0x41,
  0xA1, 0x9F, 0x80, 0x1E, 0x33, 0x61, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0xC3,
  0xC6, 0x78, 0x3F, 0x18, 0xC8, 0x64, 0x12, 0x0B, 0x0D, 0x86, 0xC2, 0x43,
  0x23, 0x1F, 0x00, 0x3F, 0xCC, 0x03, 0x00, 0x80, 0x20, 0x1F, 0xC6, 0x01,
  0x80, 0x40, 0x10, 0x07, 0xF0, 0x3F, 0xB0, 0x18, 0x0C, 0x04, 0x03, 0xF1,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x00, 0x1E, 0x23, 0x61, 0x40, 0xC0, 0xCF,
  0xC3, 0x82, 0xC2, 0xC6, 0x7C, 0x30, 0x8C, 0x23, 0x08, 0x86, 0x21, 0x9F,
  0xE6, 0x11, 0x84, 0x43, 0x10, 0xC4, 0x30, 0x3F, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x10, 0xFC, 0x0F, 0x03, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x06, 0xC4, 0xCC, 0x78, 0x30, 0xCC, 0x62, 0x30, 0x98, 0x2C, 0x1F,
  0x06, 0x41, 0x98, 0x42, 0x10, 0xC4, 0x18, 0x20, 0x40, 0x83, 0x06, 0x0C,
  0x10, 0x20, 0xC1, 0x83, 0xF8, 0x30, 0xCC, 0x73, 0x98, 0xEA, 0x6E, 0x93,
  0x24, 0x99, 0x04, 0x41, 0x30, 0x4C, 0x10, 0x30, 0x8E, 0x22, 0x88, 0xA2,
  0x29, 0x9B, 0x66, 0x51, 0x14, 0x45, 0x11, 0xC4, 0x30, 0x1E, 0x23, 0x61,
  0x41, 0xC1, 0xC3, 0x83, 0x82, 0x86, 0xC4, 0x78, 0x3F, 0x18, 0x48, 0x24,
  0x12, 0x1B, 0xF1, 0x80, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x23, 0x61,
  0x41, 0xC1, 0xC3, 0x83, 0x82, 0x86, 0xC4, 0x78, 0x10, 0x18, 0x1E, 0x3F,
  0x8C, 0x22, 0x08, 0x82, 0x21, 0x9F, 0x86, 0x41, 0x98, 0x42, 0x10, 0xC4,
  0x30, 0x0F, 0x18, 0xC8, 0x24, 0x03, 0x80, 0xF8, 0x0E, 0x03, 0xC1, 0x21,
  0x8F, 0x80, 0xFF, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x60, 0x61, 0xB0, 0x90, 0x48, 0x2C, 0x36, 0x1B, 0x09, 0x04, 0x82, 0x62,
  0x1E, 0x00, 0xC0, 0x90, 0x64, 0x11, 0x0C, 0x62, 0x19, 0x86, 0x40, 0xB0,
  0x28, 0x0E, 0x03, 0x00, 0xC0, 0xF0, 0x2C, 0x0A, 0x26, 0x99, 0x26, 0x4A,
  0xB2, 0xA8, 0xEA, 0x32, 0x8C, 0xC0, 0x18, 0x61, 0x18, 0x32, 0x06, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0xD8, 0x11, 0x04, 0x31, 0x02, 0x00, 0x81, 0x61,
  0x11, 0x0D, 0x87, 0x81, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x00, 0x3F,
  0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0F,
  0xF0, 0x1E, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C,
  0x10, 0x3C, 0x00, 0xC1, 0x06, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x20, 0x83,
  0x3E, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02,
  0x3C, 0x00, 0x0C, 0x28, 0x51, 0x36, 0x28, 0x60, 0x80, 0xFF, 0xC0, 0x4C,
  0x80, 0x3C, 0xC5, 0x08, 0x17, 0xF8, 0xE1, 0x46, 0xF6, 0x20, 0x20, 0x60,
  0x7E, 0x63, 0x43, 0x43, 0xC3, 0xC2, 0xC6, 0xC4, 0xB8, 0x1E, 0x63, 0x43,
  0xC0, 0x80, 0x80, 0x80, 0xC6, 0x7C, 0x01, 0x00, 0x80, 0x47, 0xA6, 0x32,
  0x1B, 0x09, 0x84, 0x86, 0x43, 0x33, 0x8E, 0x80, 0x1E, 0x62, 0x43, 0xC3,
  0xFF, 0x80, 0x80, 0xC6, 0x78, 0x1F, 0x30, 0x20, 0xFE, 0x20, 0x60, 0x60,
  0x60, 0x40, 0x40, 0x40, 0xC0, 0x3D, 0x67, 0x43, 0xC2, 0xC2, 0x82, 0x86,
  0xCE, 0x74, 0x04, 0x8C, 0xF8, 0x20, 0x20, 0x60, 0x7E, 0x63, 0x43, 0x42,
  0xC2, 0xC2, 0x86, 0x86, 0x84, 0x02, 0x06, 0x00, 0x1E, 0x04, 0x04, 0x04,
  0x0C, 0x0C, 0x08, 0x08, 0xFF, 0x03, 0x03, 0x00, 0x1E, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x18, 0xF0, 0x30, 0x20, 0x20, 0x23,
  0x66, 0x6C, 0x50, 0x78, 0x48, 0xCC, 0xC4, 0xC6, 0x1E, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0xFF, 0x3D, 0xB3, 0x5B, 0x29,
  0x94, 0x9A, 0x4F, 0x25, 0x92, 0x99, 0x00, 0x5E, 0x63, 0x43, 0x42, 0xC2,
  0xC2, 0x86, 0x86, 0x84, 0x1E, 0x62, 0x43, 0xC3, 0x83, 0x82, 0x86, 0xC4,
  0x78, 0x3F, 0x18, 0xC8, 0x64, 0x36, 0x1B, 0x09, 0x8C, 0xC4, 0x5C, 0x60,
  0x30, 0x10, 0x00, 0x3D, 0x63, 0x43, 0xC2, 0xC2, 0x86, 0x86, 0xCE, 0x74,
  0x04, 0x04, 0x0C, 0x27, 0x38, 0x30, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40,
  0x3E, 0x63, 0x40, 0x60, 0x3C, 0x06, 0x02, 0x84, 0x78, 0x20, 0x8F, 0xD8,
  0x61, 0x04, 0x10, 0xC3, 0x07, 0x80, 0x61, 0x43, 0x43, 0x42, 0xC2, 0xC2,
  0xC6, 0xCE, 0x74, 0xC1, 0xA1, 0x90, 0x8C, 0xC6, 0x43, 0x60, 0xA0, 0x70,
  0x30, 0x00, 0x80, 0xC0, 0xE6, 0x53, 0x2A, 0xB5, 0x53, 0x29, 0x9C, 0xCC,
  0x00, 0x21, 0x8C, 0x41, 0x20, 0x30, 0x0C, 0x05, 0x03, 0x61, 0x88, 0xC3,
  0x00, 0x60, 0xC8, 0x22, 0x10, 0xC4, 0x32, 0x04, 0x81, 0x40, 0x50, 0x18,
  0x04, 0x03, 0x03, 0x80, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0,
  0xC0, 0xFF, 0x00, 0x0F, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0xC0, 0x60,
  0x60, 0x60, 0x60, 0x40, 0x40, 0x78, 0xFF, 0xFE, 0x1C, 0x06, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x03, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0xE0, 0xF0,
  0x0F,
};

const GFXglyph LiberationMono_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 11, 10, 3, -11 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 9, 13, 10, 0, -12 },
  { 40, 10, 11, 10, 0, -11 },
  { 54, 9, 11, 10, 0, -11 },
  { 67, 2, 5, 10, 5, -12 },
  { 69, 6, 15, 10, 2, -12 },
  { 81, 6, 15, 10, 1, -12 },
  { 93, 6, 6, 10, 3, -12 },
  { 98, 8, 7, 10, 1, -9 },
  { 105, 4, 4, 10, 1, -2 },
  { 107, 5, 1, 10, 2, -5 },
  { 108, 2, 2, 10, 3, -2 },
  { 109, 10, 12, 10, 0, -12 },
  { 124, 8, 11, 10, 1, -11 },
  { 135, 8, 11, 10, 0, -11 },
  { 146, 9, 11, 10, 0, -11 },
  { 159, 8, 11, 10, 1, -11 },
  { 170, 9, 11, 10, 0, -11 },
  { 183, 8, 11, 10, 1, -11 },
  { 194, 8, 11, 10, 1, -11 },
  { 205, 8, 11, 10, 2, -11 },
  { 216, 8, 11, 10, 1, -11 },
  { 227, 8, 11, 10, 1, -11 },
  { 238, 4, 9, 10, 3, -9 },
  { 243, 6, 11, 10, 1, -9 },
  { 252, 8, 7, 10, 1, -9 },
  { 259, 8, 4, 10, 1, -7 },
  { 263, 8, 7, 10, 1, -9 },
  { 270, 8, 11, 10, 1, -11 },
  { 281, 10, 15, 10, 0, -12 },
  { 300, 10, 11, 10, -1, -11 },
  { 314, 9, 11, 10, 0, -11 },
  { 327, 8, 11, 10, 1, -11 },
  { 338, 9, 11, 10, 0, -11 },
  { 351, 10, 11, 10, 0, -11 },
  { 365, 9, 11, 10, 1, -11 },
  { 378, 8, 11, 10, 1, -11 },
  { 389, 10, 11, 10, 0, -11 },
  { 403, 8, 11, 10, 1, -11 },
  { 414, 8, 11, 10, 1, -11 },
  { 425, 10, 11, 10, 0, -11 },
  { 439, 7, 11, 10, 1, -11 },
  { 449, 10, 11, 10, 0, -11 },
  { 463, 10, 11, 10, 0, -11 },
  { 477, 8, 11, 10, 1, -11 },
  { 488, 9, 11, 10, 0, -11 },
  { 501, 8, 14, 10, 1, -11 },
  { 515, 10, 11, 10, 0, -11 },
  { 529, 9, 11, 10, 0, -11 },
  { 542, 8, 11, 10, 2, -11 },
  { 553, 9, 11, 10, 1, -11 },
  { 566, 10, 11, 10, 1, -11 },
  { 580, 10, 11, 10, 1, -11 },
  { 594, 11, 11, 10, -1, -11 },
  { 610, 9, 11, 10, 2, -11 },
  { 623, 10, 11, 10, 0, -11 },
  { 637, 7, 15, 10, 2, -12 },
  { 651, 6, 12, 10, 2, -12 },
  { 660, 7, 15, 10, 1, -12 },
  { 674, 7, 7, 10, 1, -11 },
  { 681, 10, 1, 10, -1, 1 },
  { 683, 3, 3, 10, 4, -13 },
  { 685, 7, 9, 10, 1, -9 },
  { 693, 8, 12, 10, 1, -12 },
  { 705, 8, 9, 10, 1, -9 },
  { 714, 9, 12, 10, 1, -12 },
  { 728, 8, 9, 10, 1, -9 },
  { 737, 8, 12, 10, 2, -12 },
  { 749, 8, 12, 10, 1, -9 },
  { 761, 8, 12, 10, 1, -12 },
  { 773, 8, 12, 10, 0, -12 },
  { 785, 8, 15, 10, 0, -12 },
  { 800, 8, 12, 10, 1, -12 },
  { 812, 8, 12, 10, 0, -12 },
  { 824, 9, 9, 10, 0, -9 },
  { 835, 8, 9, 10, 1, -9 },
  { 844, 8, 9, 10, 1, -9 },
  { 853, 9, 12, 10, 0, -9 },
  { 867, 8, 12, 10, 1, -9 },
  { 879, 8, 9, 10, 1, -9 },
  { 888, 8, 9, 10, 1, -9 },
  { 897, 6, 11, 10, 2, -11 },
  { 906, 8, 9, 10, 1, -9 },
  { 915, 9, 9, 10, 1, -9 },
  { 926, 9, 9, 10, 1, -9 },
  { 937, 10, 9, 10, 0, -9 },
  { 949, 10, 12, 10, 0, -9 },
  { 964, 9, 9, 10, 0, -9 },
  { 975, 8, 15, 10, 2, -12 },
  { 990, 1, 15, 10, 4, -12 },
  { 992, 8, 15, 10, 0, -12 },
  { 1007, 8, 2, 10, 1, -6 },
};

const GFXfont LiberationMono_Italic16pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Italic16pt7bBitmaps,
  (GFXglyph *)LiberationMono_Italic16pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _LIBERATIONMONO_ITALIC16PT7B_H_
