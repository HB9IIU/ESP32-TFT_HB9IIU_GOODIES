#ifndef _ROBOTOMONO_BOLD10PT7B_H_
#define _ROBOTOMONO_BOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xCC, 0xB6, 0x80, 0x28, 0xA7, 0xCC, 0xF9, 0x45, 0x00, 0x27,
  0xA7, 0x87, 0x0A, 0x7E, 0x20, 0xE2, 0xA7, 0x08, 0x3D, 0x51, 0xC0, 0x71,
  0x67, 0x18, 0xD7, 0x67, 0xC0, 0xE0, 0x5A, 0xAA, 0xD0, 0xA5, 0x55, 0xA0,
  0x25, 0x5C, 0xCD, 0x00, 0x31, 0xBE, 0x63, 0x00, 0xE0, 0xF0, 0xF0, 0x12,
  0x26, 0x44, 0xC8, 0xF9, 0x9F, 0x99, 0xF0, 0x7C, 0x92, 0x48, 0x7E, 0x42,
  0x23, 0x33, 0xE0, 0x7A, 0x42, 0x70, 0xE5, 0xE0, 0x19, 0xCE, 0xBF, 0x8C,
  0x60, 0xF8, 0xEB, 0x19, 0xF0, 0x6C, 0xEB, 0x99, 0xF0, 0xF8, 0x46, 0x23,
  0x11, 0x80, 0xF9, 0x9E, 0x99, 0xF0, 0x7A, 0x72, 0xB2, 0x8C, 0xC0, 0xF0,
  0xF0, 0x70, 0x16, 0x3C, 0xE3, 0xFF, 0xFF, 0xC3, 0x7C, 0xF9, 0x12, 0x60,
  0x60, 0x39, 0x5B, 0x6D, 0xB6, 0xA7, 0x00, 0x30, 0xC3, 0x9A, 0x79, 0xFC,
  0xC0, 0xF4, 0xE5, 0xE9, 0xCF, 0xC0, 0x79, 0x3C, 0x30, 0xC1, 0x37, 0x80,
  0xE4, 0xA7, 0x39, 0x4B, 0x80, 0xFC, 0x21, 0xE8, 0x43, 0xE0, 0xFC, 0x21,
  0xE8, 0x42, 0x00, 0x79, 0x3C, 0x37, 0xCD, 0x37, 0x80, 0x99, 0x9F, 0x99,
  0x90, 0xF6, 0x66, 0x66, 0xF0, 0x11, 0x11, 0x19, 0xF0, 0x9D, 0xB9, 0xCB,
  0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0x9F, 0xFF, 0xD9, 0x90, 0x9D, 0xDF,
  0xBB, 0x90, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x80, 0xF4, 0xE7, 0xE8, 0x42,
  0x00, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x83, 0xF4, 0xE7, 0xEB, 0x4A, 0x60,
  0x79, 0x36, 0x0E, 0x0F, 0x37, 0x80, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x00,
  0x99, 0x99, 0x99, 0xF0, 0xCD, 0x24, 0x9E, 0x30, 0xC3, 0x00, 0xB7, 0xFF,
  0xDE, 0x79, 0xE4, 0x80, 0xCD, 0xA3, 0x0C, 0x39, 0xAC, 0xC0, 0xCD, 0x27,
  0x8C, 0x30, 0xC3, 0x00, 0xFC, 0x21, 0x0C, 0x21, 0x0F, 0xC0, 0xEA, 0xAA,
  0xB0, 0xC4, 0x46, 0x22, 0x31, 0xD5, 0x55, 0x70, 0x66, 0x59, 0xF0, 0xC0,
  0xF1, 0xF9, 0xF0, 0x88, 0x8F, 0x99, 0x9F, 0xF9, 0x89, 0xF0, 0x11, 0x1F,
  0x99, 0x9F, 0xF4, 0xBF, 0x2F, 0x00, 0x3B, 0x11, 0xE4, 0x21, 0x08, 0xF9,
  0x99, 0xF9, 0xF0, 0x88, 0x8F, 0x99, 0x99, 0x60, 0xE2, 0x22, 0xF0, 0x23,
  0x92, 0x49, 0xE0, 0x84, 0x23, 0x6E, 0x72, 0xD3, 0xEE, 0x22, 0x22, 0x2F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0x99, 0x90, 0x7A, 0x72, 0x97, 0x80, 0xF9,
  0x99, 0xF8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xFC, 0xCC, 0xC0, 0xF8, 0x79,
  0xF0, 0x44, 0xF4, 0x44, 0x70, 0x99, 0x99, 0xF0, 0xCD, 0x27, 0x8C, 0x30,
  0xBF, 0xE7, 0x9E, 0x48, 0xEC, 0xE3, 0x1E, 0xCC, 0xCD, 0x27, 0x8C, 0x30,
  0x86, 0x00, 0xF1, 0x99, 0x8F, 0x80, 0x29, 0x2D, 0x92, 0x44, 0xFF, 0x80,
  0x93, 0x66, 0xB6, 0x90, 0x66, 0x60,
};

const GFXglyph RobotoMono_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 1, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 9, 6, 1, -8 },
  { 17, 6, 7, 6, 0, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 1, 3, 6, 2, -8 },
  { 30, 2, 10, 6, 2, -8 },
  { 33, 2, 10, 6, 2, -8 },
  { 36, 5, 5, 6, 1, -7 },
  { 40, 5, 5, 6, 0, -6 },
  { 44, 1, 3, 6, 2, -1 },
  { 45, 4, 1, 6, 1, -4 },
  { 46, 2, 2, 6, 2, -2 },
  { 47, 4, 8, 6, 1, -7 },
  { 51, 4, 7, 6, 1, -7 },
  { 55, 3, 7, 6, 1, -7 },
  { 58, 5, 7, 6, 0, -7 },
  { 63, 5, 7, 6, 0, -7 },
  { 68, 5, 7, 6, 0, -7 },
  { 73, 4, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 5, 7, 6, 0, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 5, 7, 6, 0, -7 },
  { 95, 2, 6, 6, 2, -6 },
  { 97, 2, 8, 6, 2, -6 },
  { 99, 4, 4, 6, 1, -5 },
  { 101, 4, 4, 6, 1, -5 },
  { 103, 4, 4, 6, 1, -5 },
  { 105, 4, 7, 6, 1, -7 },
  { 109, 6, 7, 6, 0, -7 },
  { 115, 6, 7, 6, 0, -7 },
  { 121, 5, 7, 6, 1, -7 },
  { 126, 6, 7, 6, 0, -7 },
  { 132, 5, 7, 6, 1, -7 },
  { 137, 5, 7, 6, 1, -7 },
  { 142, 5, 7, 6, 1, -7 },
  { 147, 6, 7, 6, 0, -7 },
  { 153, 4, 7, 6, 1, -7 },
  { 157, 4, 7, 6, 1, -7 },
  { 161, 4, 7, 6, 1, -7 },
  { 165, 5, 7, 6, 1, -7 },
  { 170, 4, 7, 6, 1, -7 },
  { 174, 4, 7, 6, 1, -7 },
  { 178, 4, 7, 6, 1, -7 },
  { 182, 6, 7, 6, 0, -7 },
  { 188, 5, 7, 6, 1, -7 },
  { 193, 6, 8, 6, 0, -7 },
  { 199, 5, 7, 6, 1, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 4, 7, 6, 1, -7 },
  { 220, 6, 7, 6, 0, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 6, 7, 6, 0, -7 },
  { 238, 6, 7, 6, 0, -7 },
  { 244, 6, 7, 6, 0, -7 },
  { 250, 2, 10, 6, 2, -8 },
  { 253, 4, 8, 6, 1, -7 },
  { 257, 2, 10, 6, 2, -8 },
  { 260, 4, 4, 6, 1, -7 },
  { 262, 4, 1, 6, 1, 0 },
  { 263, 2, 1, 6, 2, -7 },
  { 264, 4, 5, 6, 1, -5 },
  { 267, 4, 8, 6, 1, -8 },
  { 271, 4, 5, 6, 1, -5 },
  { 274, 4, 8, 6, 1, -8 },
  { 278, 5, 5, 6, 1, -5 },
  { 282, 5, 8, 6, 1, -8 },
  { 287, 4, 7, 6, 1, -5 },
  { 291, 4, 8, 6, 1, -8 },
  { 295, 4, 7, 6, 1, -7 },
  { 299, 3, 9, 6, 1, -7 },
  { 303, 5, 8, 6, 1, -8 },
  { 308, 4, 8, 6, 1, -8 },
  { 312, 6, 5, 6, 0, -5 },
  { 316, 4, 5, 6, 1, -5 },
  { 319, 5, 5, 6, 0, -5 },
  { 323, 4, 7, 6, 1, -5 },
  { 327, 4, 7, 6, 1, -5 },
  { 331, 4, 5, 6, 1, -5 },
  { 334, 4, 5, 6, 1, -5 },
  { 337, 4, 7, 6, 1, -7 },
  { 341, 4, 5, 6, 1, -5 },
  { 344, 6, 5, 6, 0, -5 },
  { 348, 6, 5, 6, 0, -5 },
  { 352, 6, 5, 6, 0, -5 },
  { 356, 6, 7, 6, 0, -5 },
  { 362, 5, 5, 6, 1, -5 },
  { 366, 3, 10, 6, 2, -8 },
  { 370, 1, 9, 6, 3, -7 },
  { 372, 3, 10, 6, 2, -8 },
  { 376, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_Bold10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold10pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_BOLD10PT7B_H_
