#ifndef _ROBOTOMONO_BOLD50PT7B_H_
#define _ROBOTOMONO_BOLD50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF,
  0x03, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x07, 0x80,
  0x03, 0xE0, 0xF0, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0xC1, 0xE0, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF0,
  0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xF8, 0x1F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0xF8, 0x10, 0x0F, 0x87, 0xC1,
  0xC0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0x7C, 0x7C, 0x0F,
  0x87, 0xC7, 0x80, 0xF8, 0x7C, 0xF0, 0x0F, 0xFF, 0x8F, 0x00, 0x7F, 0xF9,
  0xE0, 0x03, 0xFF, 0x1E, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x3C, 0xFF,
  0xC0, 0x07, 0x9F, 0xFE, 0x00, 0x79, 0xFF, 0xE0, 0x0F, 0x1F, 0x1F, 0x01,
  0xF3, 0xE1, 0xF0, 0x1E, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0xF0, 0x3C, 0x3E,
  0x0F, 0x00, 0x83, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x7E, 0x3F, 0xFF, 0x07, 0xE3,
  0xFF, 0xF8, 0x7E, 0x7F, 0x3F, 0xC7, 0xEF, 0xE1, 0xFC, 0x7E, 0xFE, 0x0F,
  0xEF, 0xCF, 0xE0, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xCF, 0xE0, 0x3F, 0xF8,
  0xFE, 0x01, 0xFF, 0x8F, 0xF0, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xDF,
  0xE0, 0x7F, 0xF0, 0xFF, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x60, 0x07, 0x80, 0x3F,
  0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0x80, 0x40,
  0x01, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x03, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0xC0, 0x78, 0x04, 0x78, 0x3C, 0x0F, 0x3F, 0x1E, 0x1F,
  0xBF, 0xEF, 0x3F, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1E, 0x01, 0xE0, 0x02, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7C, 0xFC,
  0x78, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0x7F, 0xFE, 0x7E, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3F,
  0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFE, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFF, 0xBF, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFF, 0x07, 0xFC,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x03, 0xFE, 0x06, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x0F, 0x00, 0xFE, 0x7F, 0xE0, 0xFE, 0xFF, 0xF0, 0xFD, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC,
  0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x01, 0xFC,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xF7, 0xFC,
  0x3F, 0x81, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF,
  0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xC0, 0x3F, 0x1F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xE0, 0xF8,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x3C, 0x1C, 0x3E, 0x1F, 0xF1, 0xE3, 0xC3,
  0xFF, 0x9E, 0x3C, 0x3F, 0xF8, 0xE7, 0x87, 0xC7, 0x8E, 0x78, 0xF8, 0x78,
  0xF7, 0x8F, 0x07, 0x0F, 0xF0, 0xF0, 0x70, 0xFF, 0x1F, 0x0F, 0x0F, 0xF1,
  0xE0, 0xF0, 0xEF, 0x1E, 0x0F, 0x0E, 0xF1, 0xE0, 0xF0, 0xEF, 0x1E, 0x0F,
  0x1E, 0xF1, 0xE0, 0xF1, 0xEF, 0x1E, 0x0F, 0x1E, 0xF1, 0xF0, 0xF1, 0xCF,
  0x1F, 0x9F, 0x3C, 0xF8, 0xFF, 0xFF, 0x87, 0x8F, 0xF7, 0xF0, 0x78, 0x7E,
  0x3E, 0x07, 0xC0, 0x00, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x30, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xE0, 0x1F, 0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFE, 0x01,
  0xFF, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x07,
  0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x3F,
  0x8F, 0xE0, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F,
  0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x80,
  0x3F, 0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xFE, 0x07,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFE,
  0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFD, 0xE7,
  0xFF, 0xFD, 0xFF, 0xBF, 0xFD, 0xFF, 0xBF, 0xFC, 0xFF, 0xBF, 0xFC, 0xFF,
  0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x3C,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x7F, 0xFE, 0xF8,
  0x7F, 0xFE, 0xFC, 0x7F, 0xFE, 0x7C, 0x7F, 0xFE, 0x7E, 0x7F, 0xFE, 0x3E,
  0x7F, 0xFE, 0x3F, 0x7F, 0xFE, 0x1F, 0x7F, 0xFE, 0x1F, 0x7F, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF1,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x8F,
  0xE0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xF8,
  0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x30, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xF3,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x0F, 0xF3,
  0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xFC,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x1F, 0x03, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xE1, 0xF8, 0x3F, 0xFE, 0x1F, 0x87, 0xF7, 0xE3, 0xF8, 0x7E, 0x7E,
  0x3F, 0xC7, 0xE7, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE7, 0xE3, 0xFC,
  0x7E, 0x7E, 0x3F, 0xC7, 0xE7, 0xE3, 0xFC, 0x7E, 0x3F, 0x7F, 0xCF, 0xE3,
  0xF7, 0xFE, 0xFC, 0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xFE, 0xFC, 0x3F, 0x7B,
  0xEF, 0xC3, 0xF7, 0x9E, 0xFC, 0x3F, 0x79, 0xEF, 0xC1, 0xFF, 0x9F, 0xFC,
  0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFE, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x7C, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x7E, 0x03, 0xF3, 0xE0,
  0x0F, 0xBF, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x87, 0xFC, 0x7F,
  0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFE, 0xFE, 0x0F,
  0xFC, 0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x0F, 0xCF, 0xFC, 0x1F, 0xBF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFD, 0xFE, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFE, 0xFF, 0x83,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xDF, 0xFE,
  0x1F, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F,
  0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFB, 0xF8,
  0x03, 0xF7, 0xF0, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC3, 0xF0,
  0x7F, 0xE7, 0xE1, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0x03, 0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0xC3, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7, 0xE0,
  0x7F, 0x8F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x01, 0x07, 0xF8, 0x01, 0xC1, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x7F,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x7F, 0xC1, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0x7F,
  0x03, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x08, 0x00, 0xFE,
  0x1C, 0x01, 0xFE, 0x1F, 0x03, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0xFE, 0x3F, 0xF0,
  0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0x80, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x2F, 0xC0, 0x1F, 0xE7, 0xE0, 0x1F, 0xE3, 0xF0,
  0x1F, 0xE1, 0xF8, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0xE0, 0x3F,
  0x1F, 0xF0, 0x1F, 0x9F, 0xF0, 0x0F, 0xCF, 0xF0, 0x07, 0xEF, 0xF0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xF0, 0xFF,
  0x03, 0xF0, 0x3F, 0xC1, 0xF8, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x7E, 0x01,
  0xFE, 0x3F, 0x00, 0xFF, 0x9F, 0x80, 0x3F, 0xCF, 0xC0, 0x0F, 0xF7, 0xE0,
  0x03, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x3C, 0x3F, 0x7F, 0xBF, 0xCF, 0xDF, 0xEF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF1, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0,
  0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x3F, 0xF0, 0xFE, 0x7F, 0xF8,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0x7F, 0x00, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0x01, 0xF9, 0xFF, 0x83, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0x7F, 0x00, 0xFE, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F,
  0xDF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFB, 0xFF, 0xC3, 0xF1, 0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFC, 0xFC, 0x3F, 0xFD, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF,
  0xF8, 0x7F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFE, 0xFC, 0x0F, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xEF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0xE3, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x02, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0x00,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0x1F, 0xFC, 0xFE,
  0x1F, 0xF0, 0xFC, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x03, 0xFF, 0xC1,
  0xF0, 0x7F, 0xFC, 0x1F, 0x87, 0xEF, 0xC1, 0xF8, 0x7E, 0x7E, 0x1F, 0x87,
  0xE7, 0xE3, 0xF8, 0x7E, 0x7E, 0x3F, 0x87, 0xE7, 0xE3, 0xF8, 0x7C, 0x7E,
  0x3F, 0xC7, 0xC7, 0xE3, 0xFC, 0xFC, 0x3E, 0x7B, 0xCF, 0xC3, 0xE7, 0xBC,
  0xFC, 0x3F, 0x7B, 0xCF, 0xC3, 0xF7, 0x9E, 0xF8, 0x3F, 0x79, 0xEF, 0x81,
  0xF7, 0x1E, 0xF8, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x07, 0xF0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F,
  0x80, 0x1F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x78, 0xFF, 0xF0, 0x0F, 0xBF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD,
  0xFF, 0xFF, 0xBE, 0x07, 0xFF, 0xF7, 0x80, 0x7F, 0xFC, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoMono_Bold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 8, 36, 30, 11, -36 },
  { 37, 15, 13, 30, 7, -38 },
  { 62, 27, 36, 30, 1, -36 },
  { 184, 25, 46, 30, 3, -41 },
  { 328, 28, 36, 30, 1, -36 },
  { 454, 28, 37, 30, 2, -36 },
  { 584, 5, 14, 30, 11, -38 },
  { 593, 14, 51, 30, 8, -40 },
  { 683, 14, 51, 30, 8, -40 },
  { 773, 25, 26, 30, 4, -36 },
  { 855, 25, 25, 30, 2, -29 },
  { 934, 8, 16, 30, 9, -6 },
  { 950, 20, 5, 30, 7, -18 },
  { 963, 10, 8, 30, 10, -8 },
  { 973, 20, 39, 30, 5, -36 },
  { 1071, 24, 37, 30, 3, -36 },
  { 1182, 16, 36, 30, 4, -36 },
  { 1254, 25, 36, 30, 2, -36 },
  { 1367, 25, 36, 30, 2, -36 },
  { 1480, 26, 36, 30, 1, -36 },
  { 1597, 24, 36, 30, 3, -36 },
  { 1705, 24, 36, 30, 3, -36 },
  { 1813, 25, 36, 30, 2, -36 },
  { 1926, 24, 36, 30, 3, -36 },
  { 2034, 24, 36, 30, 2, -36 },
  { 2142, 9, 28, 30, 11, -28 },
  { 2174, 10, 38, 30, 11, -28 },
  { 2222, 21, 23, 30, 4, -27 },
  { 2283, 23, 16, 30, 4, -23 },
  { 2329, 22, 24, 30, 4, -27 },
  { 2395, 23, 36, 30, 4, -36 },
  { 2499, 28, 35, 30, 1, -35 },
  { 2622, 29, 36, 30, 1, -36 },
  { 2753, 26, 36, 30, 3, -36 },
  { 2870, 26, 37, 30, 2, -36 },
  { 2991, 25, 36, 30, 3, -36 },
  { 3104, 24, 36, 30, 4, -36 },
  { 3212, 24, 36, 30, 4, -36 },
  { 3320, 26, 36, 30, 2, -36 },
  { 3437, 24, 36, 30, 3, -36 },
  { 3545, 20, 36, 30, 5, -36 },
  { 3635, 24, 36, 30, 3, -36 },
  { 3743, 28, 36, 30, 3, -36 },
  { 3869, 23, 36, 30, 4, -36 },
  { 3973, 24, 36, 30, 3, -36 },
  { 4081, 24, 36, 30, 3, -36 },
  { 4189, 26, 36, 30, 2, -36 },
  { 4306, 24, 36, 30, 4, -36 },
  { 4414, 28, 42, 30, 2, -36 },
  { 4561, 26, 36, 30, 3, -36 },
  { 4678, 26, 36, 30, 2, -36 },
  { 4795, 28, 36, 30, 1, -36 },
  { 4921, 24, 36, 30, 3, -36 },
  { 5029, 28, 36, 30, 1, -36 },
  { 5155, 28, 36, 30, 1, -36 },
  { 5281, 29, 36, 30, 1, -36 },
  { 5412, 29, 36, 30, 1, -36 },
  { 5543, 26, 36, 30, 2, -36 },
  { 5660, 11, 49, 30, 10, -41 },
  { 5728, 20, 39, 30, 6, -36 },
  { 5826, 11, 49, 30, 10, -41 },
  { 5894, 21, 19, 30, 5, -36 },
  { 5944, 22, 5, 30, 4, 0 },
  { 5958, 12, 7, 30, 10, -36 },
  { 5969, 24, 27, 30, 3, -27 },
  { 6050, 23, 38, 30, 4, -38 },
  { 6160, 23, 28, 30, 3, -27 },
  { 6241, 23, 38, 30, 3, -38 },
  { 6351, 25, 27, 30, 3, -27 },
  { 6436, 25, 39, 30, 3, -39 },
  { 6558, 24, 37, 30, 3, -27 },
  { 6669, 24, 38, 30, 3, -38 },
  { 6783, 22, 37, 30, 5, -37 },
  { 6885, 17, 48, 30, 5, -37 },
  { 6987, 25, 38, 30, 4, -38 },
  { 7106, 22, 38, 30, 5, -38 },
  { 7211, 26, 27, 30, 2, -27 },
  { 7299, 24, 27, 30, 3, -27 },
  { 7380, 24, 28, 30, 3, -27 },
  { 7464, 23, 37, 30, 4, -27 },
  { 7571, 23, 37, 30, 3, -27 },
  { 7678, 20, 27, 30, 7, -27 },
  { 7746, 24, 28, 30, 3, -27 },
  { 7830, 24, 34, 30, 3, -33 },
  { 7932, 23, 27, 30, 4, -26 },
  { 8010, 26, 26, 30, 2, -26 },
  { 8095, 28, 26, 30, 1, -26 },
  { 8186, 27, 26, 30, 2, -26 },
  { 8274, 29, 37, 30, 1, -26 },
  { 8409, 25, 26, 30, 3, -26 },
  { 8491, 16, 48, 30, 8, -39 },
  { 8587, 4, 46, 30, 13, -36 },
  { 8610, 16, 48, 30, 8, -39 },
  { 8706, 27, 11, 30, 1, -20 },
};

const GFXfont RobotoMono_Bold50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold50pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_BOLD50PT7B_H_
