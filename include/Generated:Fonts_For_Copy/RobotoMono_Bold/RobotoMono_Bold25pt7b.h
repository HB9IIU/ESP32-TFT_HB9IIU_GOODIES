#ifndef _ROBOTOMONO_BOLD25PT7B_H_
#define _ROBOTOMONO_BOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x17, 0xFC, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0x03, 0x30, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x71,
  0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x3F, 0xFE,
  0xFF, 0xF8, 0x63, 0x01, 0x8C, 0x06, 0x70, 0x19, 0x80, 0xE6, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x01, 0xF8, 0x3F, 0xC7, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x0F, 0xE0,
  0xFF, 0x0F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x3C,
  0x00, 0xFC, 0x01, 0x98, 0x87, 0x31, 0x8E, 0x66, 0x0C, 0xDC, 0x1F, 0xB0,
  0x1C, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x40, 0x37, 0xE0, 0x6F, 0xC1,
  0x99, 0xC7, 0x33, 0x84, 0x67, 0x00, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0x7F,
  0x03, 0xFC, 0x0E, 0x70, 0x38, 0xC0, 0xE7, 0x03, 0xB8, 0x0F, 0xE0, 0x1E,
  0x00, 0xF8, 0x77, 0xF1, 0xFD, 0xEE, 0xE3, 0xFB, 0x87, 0xEF, 0x1F, 0x3E,
  0xFC, 0x7F, 0xF8, 0xFE, 0xF0, 0xFF, 0xFC, 0x02, 0x1C, 0x30, 0xE3, 0x86,
  0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1, 0xC3,
  0x83, 0x87, 0x07, 0x07, 0x06, 0x04, 0x81, 0x83, 0x83, 0x83, 0x87, 0x07,
  0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE3,
  0x87, 0x1C, 0x70, 0xC1, 0x00, 0x07, 0x00, 0x60, 0x06, 0x08, 0x60, 0xE6,
  0x7F, 0xFF, 0x3F, 0xE0, 0xF0, 0x1F, 0x81, 0x98, 0x39, 0xC7, 0x0E, 0x10,
  0x80, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7B, 0xDE, 0xF7,
  0x3B, 0x8C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x77, 0xFE, 0xE0, 0x03, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0x1F,
  0x07, 0xF9, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0xE7, 0xFF,
  0xDF, 0xE3, 0xF8, 0x7E, 0x0F, 0xC1, 0xFC, 0x7B, 0xDE, 0x7F, 0xC7, 0xF0,
  0x01, 0x0F, 0x7F, 0xFF, 0xF7, 0x87, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F,
  0xE0, 0xFE, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x83, 0xFE,
  0x7F, 0xE7, 0x0F, 0xF0, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0, 0xFE,
  0x01, 0xF0, 0x07, 0x00, 0x7F, 0x07, 0xF0, 0x77, 0xFF, 0x7F, 0xE1, 0xFC,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x77, 0x83,
  0xBC, 0x39, 0xE3, 0x8F, 0x1C, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x80,
  0x78, 0x07, 0x00, 0x73, 0x07, 0xFE, 0x7F, 0xE3, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x7F, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC, 0x03, 0xC0, 0xFC,
  0x1F, 0xC3, 0xE0, 0x78, 0x07, 0x00, 0x73, 0x8F, 0xFE, 0xFF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x8F, 0x70, 0xF7, 0x0F,
  0x70, 0xF3, 0xFE, 0x1F, 0xC3, 0xFC, 0x79, 0xE7, 0x0F, 0xF0, 0x7F, 0x07,
  0xF0, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0xDF, 0x3F, 0xF1, 0xF7,
  0x00, 0xE0, 0x0E, 0x01, 0xE1, 0xFC, 0x1F, 0x81, 0xE0, 0x77, 0xFE, 0xE0,
  0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x79, 0xE7, 0xDE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x79, 0xE7, 0x9C, 0x73, 0x86, 0x00, 0x00, 0xE0, 0x7C,
  0x3F, 0xBF, 0xCF, 0xC1, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3C, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC0, 0x1F, 0x03, 0xF8, 0x1F, 0xE0, 0x7E, 0x03, 0xC3, 0xFB,
  0xFC, 0xFE, 0x1E, 0x03, 0x00, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0xF8, 0x7E,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x01, 0x80, 0x3F, 0xC1, 0xE7,
  0x8E, 0x06, 0x31, 0xCD, 0x9F, 0xB6, 0x66, 0xDB, 0x9B, 0x6C, 0x6D, 0xB1,
  0xBE, 0xC4, 0xDB, 0x33, 0x6F, 0xF9, 0x9D, 0xE7, 0x00, 0x0E, 0x00, 0x1F,
  0xE0, 0x3F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xB8, 0x07, 0x78, 0x1E, 0x70, 0x38, 0xE0, 0x71, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x9E, 0x0F, 0x3C, 0x0E, 0x70, 0x1F, 0xE0,
  0x3C, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE,
  0x1E, 0xFF, 0xCF, 0xFE, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF0, 0xEF, 0x07,
  0xF8, 0x3F, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x07, 0xF8, 0x3D, 0xC1, 0xEF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F,
  0xF8, 0xFF, 0xCE, 0x3E, 0xE1, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xFC,
  0xF0, 0xE7, 0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x9F, 0xFC,
  0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xE1, 0xEF, 0xFF, 0x3F, 0xF0, 0xFF,
  0x00, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC, 0xE0, 0x7F, 0x07, 0xB8,
  0x79, 0xC3, 0xCE, 0x3C, 0x73, 0xC3, 0xBC, 0x1D, 0xE0, 0xFE, 0x07, 0xF8,
  0x3F, 0xE1, 0xEF, 0x0E, 0x3C, 0x70, 0xF3, 0x87, 0x9C, 0x1E, 0xE0, 0xF7,
  0x03, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0xBF, 0xFB,
  0xFF, 0xB7, 0xFB, 0x7F, 0xF7, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E, 0xE7, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFE, 0x7F, 0xE7, 0xF7, 0x7F, 0x77, 0xF3,
  0x7F, 0x3F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0x0F,
  0x81, 0xFF, 0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x3D, 0xC3, 0xCF,
  0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xFF, 0xFE, 0xFF, 0xCE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0xFF, 0x87,
  0xFF, 0x1E, 0x3C, 0x70, 0x7B, 0xC1, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B,
  0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xC1, 0xE7, 0x07, 0x1F, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x10, 0xFF, 0x07, 0xFE,
  0x3F, 0xF9, 0xC3, 0xEE, 0x0F, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xE3, 0xE7,
  0xFE, 0x3F, 0xE1, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0,
  0xF7, 0x03, 0xC0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xF7, 0x03, 0xB8,
  0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0xFE, 0x03,
  0xF8, 0x1F, 0xC1, 0xEF, 0xFF, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x7F, 0xFF, 0x7F, 0xC7, 0xF0, 0xF0, 0x1E, 0xF0, 0x39,
  0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x8F, 0x0F, 0x1E, 0x0E, 0x38, 0x1C,
  0x70, 0x3D, 0xE0, 0x7B, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0xF3, 0x8F, 0xE7, 0x3D, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0xF3, 0x9D, 0xF7, 0x3B, 0xEE, 0x76, 0xDC, 0x7D,
  0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0x1E, 0x1E, 0x3C,
  0x1C, 0x70, 0x38, 0xE0, 0xF8, 0x1E, 0xF0, 0x78, 0xF0, 0xF1, 0xE3, 0xC1,
  0xE7, 0x03, 0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0xEF, 0x03, 0xCE, 0x0F, 0x1E, 0x1E, 0x1E, 0x78, 0x3D,
  0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x39, 0xE0, 0xF1, 0xE1, 0xC3, 0xC7, 0x83,
  0x8E, 0x07, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xF8, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0xFF,
  0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9F, 0xFF, 0xF8, 0x1C, 0x07, 0x01, 0xE0, 0xF8, 0x37, 0x1D, 0xC7, 0x3B,
  0x8E, 0xE1, 0xB0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0xC0,
  0x1F, 0xC7, 0xFE, 0x78, 0xF7, 0x0F, 0x00, 0xF1, 0xFF, 0x7F, 0xF7, 0x8F,
  0xF0, 0xFF, 0x0F, 0x79, 0xF7, 0xFF, 0x3F, 0x70, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0x8F, 0xFC, 0xF9, 0xEE, 0x0E, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x0E, 0xFF, 0xEF, 0xFC, 0xEF,
  0x80, 0x1F, 0xC3, 0xFE, 0x7C, 0xF7, 0x07, 0x70, 0x7F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x77, 0x87, 0x7D, 0xF3, 0xFE, 0x1F, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1F, 0x73, 0xFF, 0x7D, 0xF7, 0x07,
  0x70, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x0F, 0x7F, 0xF3, 0xFF,
  0x1F, 0x70, 0x1F, 0xC1, 0xFF, 0x1F, 0x3C, 0xF0, 0xE7, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x70, 0x03, 0xC1, 0x1F, 0xFE, 0x7F, 0xE0, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x0F, 0xB1, 0xE0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x1F, 0xF3, 0xFF, 0x7C, 0xF7, 0x07, 0x70,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x87, 0x7F, 0xF3, 0xFF, 0x1F,
  0x70, 0x07, 0x20, 0xF3, 0xBF, 0x7F, 0xE1, 0xFC, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0xCF, 0xFE, 0xF9, 0xEE, 0x0E, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE3, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0xBE, 0xFE, 0xFC, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x87, 0xDC, 0x78,
  0xE7, 0x87, 0x7C, 0x3B, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xDE, 0x1C,
  0x78, 0xE1, 0xE7, 0x0F, 0x38, 0x3E, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0xF7, 0xFF, 0xF9, 0xDF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7,
  0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0x80, 0xEF, 0xCF, 0xFE,
  0xF9, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0x7C, 0xE0, 0xEF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x73, 0x83, 0x9F, 0x7C, 0x7F,
  0xC1, 0xFC, 0x00, 0xEF, 0x8F, 0xFC, 0xF3, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xFB, 0xEF, 0xFC, 0xEF, 0x8E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0x73, 0xFF, 0x7C, 0xF7, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x87, 0x7F, 0xF3, 0xFF,
  0x1F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xF7, 0xFF, 0xFB,
  0xFF, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x1F, 0xE1, 0xFF, 0x9E, 0x3C, 0xE0, 0xE7, 0x80, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x80, 0x73, 0x83, 0xDE, 0x3C, 0x7F, 0xE1, 0xFC,
  0x00, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0xFF, 0xFE, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xC7, 0xF8, 0x7F, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE,
  0x1F, 0xFF, 0xBF, 0xF3, 0xEE, 0xF0, 0x7B, 0x83, 0x9C, 0x1C, 0xF1, 0xE3,
  0x8E, 0x1C, 0x70, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x1F,
  0x00, 0x70, 0x00, 0xF3, 0x9D, 0xCE, 0x77, 0x39, 0xDC, 0xE7, 0x77, 0x9D,
  0xDB, 0x63, 0x6F, 0x8D, 0xBE, 0x3E, 0xF8, 0xF3, 0xE3, 0xC7, 0x8F, 0x1C,
  0x1C, 0x70, 0xF0, 0x7B, 0xC7, 0x8F, 0x38, 0x3B, 0xC1, 0xFC, 0x07, 0xC0,
  0x1E, 0x01, 0xF8, 0x1F, 0xC1, 0xEF, 0x0F, 0x3C, 0xF0, 0xEF, 0x07, 0x80,
  0xF0, 0x3F, 0xC0, 0xE7, 0x07, 0x9E, 0x1C, 0x38, 0xF0, 0xF3, 0x81, 0xCE,
  0x07, 0x78, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x17, 0x80, 0x7C, 0x01, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x07, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0xF8, 0xE0, 0xF8, 0x38, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0xE0, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x1C, 0x1F, 0x07, 0x1F, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0xF0, 0xE0, 0x3C, 0x01, 0xFC, 0x77, 0xFB, 0xF8, 0xFE, 0x61, 0xF8,
};

const GFXglyph RobotoMono_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 8, 7, 15, 3, -19 },
  { 15, 14, 18, 15, 0, -18 },
  { 47, 12, 24, 15, 2, -21 },
  { 83, 15, 18, 15, 0, -18 },
  { 117, 14, 18, 15, 1, -18 },
  { 149, 2, 7, 15, 6, -19 },
  { 151, 7, 26, 15, 4, -20 },
  { 174, 7, 26, 15, 4, -20 },
  { 197, 12, 13, 15, 2, -18 },
  { 217, 12, 13, 15, 1, -15 },
  { 237, 5, 8, 15, 4, -3 },
  { 242, 11, 3, 15, 3, -9 },
  { 247, 5, 4, 15, 5, -4 },
  { 250, 10, 20, 15, 3, -18 },
  { 275, 11, 18, 15, 2, -18 },
  { 300, 8, 18, 15, 2, -18 },
  { 318, 12, 18, 15, 1, -18 },
  { 345, 12, 18, 15, 1, -18 },
  { 372, 13, 18, 15, 1, -18 },
  { 402, 12, 18, 15, 1, -18 },
  { 429, 12, 18, 15, 1, -18 },
  { 456, 12, 18, 15, 1, -18 },
  { 483, 12, 18, 15, 1, -18 },
  { 510, 12, 18, 15, 1, -18 },
  { 537, 5, 14, 15, 5, -14 },
  { 546, 6, 19, 15, 5, -14 },
  { 561, 11, 11, 15, 2, -13 },
  { 577, 11, 9, 15, 2, -12 },
  { 590, 11, 11, 15, 2, -13 },
  { 606, 11, 18, 15, 2, -18 },
  { 631, 14, 18, 15, 0, -18 },
  { 663, 15, 18, 15, 0, -18 },
  { 697, 12, 18, 15, 2, -18 },
  { 724, 13, 18, 15, 1, -18 },
  { 754, 12, 18, 15, 2, -18 },
  { 781, 12, 18, 15, 2, -18 },
  { 808, 12, 18, 15, 2, -18 },
  { 835, 13, 18, 15, 1, -18 },
  { 865, 12, 18, 15, 1, -18 },
  { 892, 11, 18, 15, 2, -18 },
  { 917, 12, 18, 15, 1, -18 },
  { 944, 13, 18, 15, 2, -18 },
  { 974, 12, 18, 15, 2, -18 },
  { 1001, 12, 18, 15, 2, -18 },
  { 1028, 12, 18, 15, 1, -18 },
  { 1055, 13, 18, 15, 1, -18 },
  { 1085, 12, 18, 15, 2, -18 },
  { 1112, 14, 21, 15, 1, -18 },
  { 1149, 13, 18, 15, 2, -18 },
  { 1179, 13, 18, 15, 1, -18 },
  { 1209, 15, 18, 15, 0, -18 },
  { 1243, 11, 18, 15, 2, -18 },
  { 1268, 15, 18, 15, 0, -18 },
  { 1302, 15, 18, 15, 0, -18 },
  { 1336, 15, 18, 15, 0, -18 },
  { 1370, 15, 18, 15, 0, -18 },
  { 1404, 13, 18, 15, 1, -18 },
  { 1434, 5, 25, 15, 5, -21 },
  { 1450, 10, 20, 15, 3, -18 },
  { 1475, 5, 25, 15, 5, -21 },
  { 1491, 10, 10, 15, 3, -18 },
  { 1504, 11, 3, 15, 2, 0 },
  { 1509, 6, 3, 15, 5, -18 },
  { 1512, 12, 13, 15, 1, -13 },
  { 1532, 12, 19, 15, 2, -19 },
  { 1561, 12, 13, 15, 1, -13 },
  { 1581, 12, 19, 15, 1, -19 },
  { 1610, 13, 13, 15, 1, -13 },
  { 1632, 12, 19, 15, 2, -19 },
  { 1661, 12, 18, 15, 1, -13 },
  { 1688, 12, 19, 15, 2, -19 },
  { 1717, 10, 18, 15, 3, -18 },
  { 1740, 8, 23, 15, 3, -18 },
  { 1763, 13, 19, 15, 2, -19 },
  { 1794, 12, 19, 15, 2, -19 },
  { 1823, 13, 13, 15, 1, -13 },
  { 1845, 12, 13, 15, 2, -13 },
  { 1865, 13, 13, 15, 1, -13 },
  { 1887, 12, 18, 15, 2, -13 },
  { 1914, 12, 18, 15, 1, -13 },
  { 1941, 11, 13, 15, 3, -13 },
  { 1959, 13, 13, 15, 1, -13 },
  { 1981, 11, 16, 15, 2, -16 },
  { 2003, 11, 13, 15, 2, -13 },
  { 2021, 13, 13, 15, 1, -13 },
  { 2043, 14, 13, 15, 0, -13 },
  { 2066, 13, 13, 15, 1, -13 },
  { 2088, 14, 18, 15, 1, -13 },
  { 2120, 13, 13, 15, 1, -13 },
  { 2142, 8, 24, 15, 4, -20 },
  { 2166, 3, 23, 15, 6, -18 },
  { 2175, 8, 24, 15, 4, -20 },
  { 2199, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_Bold25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold25pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_BOLD25PT7B_H_
