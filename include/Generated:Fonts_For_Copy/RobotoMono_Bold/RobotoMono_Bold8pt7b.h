#ifndef _ROBOTOMONO_BOLD8PT7B_H_
#define _ROBOTOMONO_BOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x32, 0xBE, 0xAE, 0x30, 0x27, 0x54, 0x3D, 0x72, 0xC6,
  0x98, 0x66, 0x8C, 0x62, 0x98, 0xDB, 0x3C, 0xC0, 0x6A, 0x48, 0x91, 0x95,
  0x56, 0x4D, 0x6A, 0x22, 0xF2, 0x58, 0xE0, 0x80, 0x25, 0x25, 0x00, 0xD6,
  0xFB, 0xC0, 0x75, 0x50, 0x6D, 0x12, 0x4F, 0x6D, 0x13, 0x97, 0x13, 0x55,
  0xF1, 0x74, 0x61, 0xD7, 0x24, 0x7D, 0xD7, 0xF1, 0x12, 0x24, 0x65, 0x57,
  0xD7, 0x6D, 0xD7, 0x16, 0x90, 0x9C, 0x71, 0x80, 0xE3, 0x80, 0xC7, 0x00,
  0xF4, 0xA0, 0x80, 0x33, 0x77, 0xAB, 0x30, 0x21, 0x14, 0xA7, 0x44, 0xF6,
  0xB5, 0xED, 0xF8, 0x75, 0x88, 0xD7, 0xED, 0xDD, 0xDF, 0xF2, 0x79, 0xC0,
  0xF2, 0x79, 0x00, 0x75, 0x8B, 0xD7, 0xDD, 0xDF, 0xDD, 0xE9, 0x25, 0xC0,
  0x11, 0x11, 0xD7, 0xDE, 0xB9, 0xCD, 0x6C, 0x92, 0x49, 0xC0, 0xDD, 0xBB,
  0xDD, 0xDD, 0xFF, 0xDD, 0x65, 0x99, 0xD7, 0xEA, 0xBE, 0x88, 0x62, 0xA7,
  0x3D, 0x38, 0x20, 0xEA, 0xBE, 0xAB, 0x72, 0xD0, 0x69, 0xB8, 0xF9, 0x08,
  0x42, 0x10, 0xDD, 0xDD, 0x57, 0x9E, 0x94, 0xA6, 0x10, 0xAD, 0x6C, 0xA5,
  0x28, 0xDA, 0x98, 0x45, 0x6C, 0x9A, 0x94, 0x42, 0x10, 0xF0, 0x88, 0x44,
  0x7C, 0xFF, 0x91, 0x24, 0x40, 0xFF, 0x5A, 0x80, 0xE0, 0xC0, 0x73, 0xD7,
  0x93, 0xDB, 0xC0, 0x7C, 0x47, 0x11, 0x7D, 0xD7, 0x7F, 0xC7, 0x39, 0x3C,
  0x42, 0x10, 0x7D, 0xD7, 0x56, 0x93, 0xDB, 0x40, 0x43, 0x25, 0xC0, 0x4D,
  0x57, 0x88, 0xEC, 0xEB, 0xC9, 0x25, 0xC0, 0xFB, 0xBB, 0xF6, 0xD0, 0x7D,
  0xD7, 0xF6, 0xF9, 0x00, 0x7D, 0xD7, 0x11, 0xF2, 0x40, 0x76, 0x97, 0x6F,
  0x66, 0x30, 0xB6, 0xF0, 0xDA, 0x94, 0x40, 0xAD, 0x94, 0xA0, 0xD9, 0x1D,
  0xB0, 0xDA, 0x94, 0x42, 0x20, 0x72, 0x6F, 0x69, 0x44, 0x98, 0xFF, 0xC9,
  0x14, 0xB0, 0xF1,
};

const GFXglyph RobotoMono_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 2, 5, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 0, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 5, 2, -6 },
  { 20, 3, 8, 5, 1, -6 },
  { 23, 2, 8, 5, 1, -6 },
  { 25, 4, 4, 5, 1, -6 },
  { 27, 4, 4, 5, 0, -5 },
  { 29, 2, 3, 5, 1, -1 },
  { 30, 3, 1, 5, 1, -3 },
  { 31, 1, 1, 5, 2, -1 },
  { 32, 3, 6, 5, 1, -6 },
  { 35, 3, 6, 5, 1, -6 },
  { 38, 2, 6, 5, 1, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 1, 4, 5, 2, -4 },
  { 65, 1, 6, 5, 2, -4 },
  { 66, 3, 3, 5, 1, -4 },
  { 68, 3, 3, 5, 1, -4 },
  { 70, 3, 3, 5, 1, -4 },
  { 72, 3, 6, 5, 1, -6 },
  { 75, 5, 6, 5, 0, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 5, 6, 5, 0, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 4, 6, 5, 0, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 4, 6, 5, 0, -6 },
  { 102, 4, 6, 5, 0, -6 },
  { 105, 3, 6, 5, 1, -6 },
  { 108, 4, 6, 5, 0, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 3, 6, 5, 1, -6 },
  { 118, 4, 6, 5, 0, -6 },
  { 121, 4, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 0, -6 },
  { 127, 4, 6, 5, 1, -6 },
  { 130, 5, 7, 5, 0, -6 },
  { 135, 4, 6, 5, 1, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 5, 6, 5, 0, -6 },
  { 146, 4, 6, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 6, 5, 0, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 1, 8, 5, 2, -7 },
  { 170, 3, 6, 5, 1, -6 },
  { 173, 1, 8, 5, 2, -7 },
  { 174, 3, 3, 5, 1, -6 },
  { 176, 3, 1, 5, 1, 0 },
  { 177, 2, 1, 5, 2, -6 },
  { 178, 4, 4, 5, 0, -4 },
  { 180, 3, 6, 5, 1, -6 },
  { 183, 4, 4, 5, 0, -4 },
  { 185, 4, 6, 5, 0, -6 },
  { 188, 4, 4, 5, 0, -4 },
  { 190, 5, 6, 5, 0, -6 },
  { 194, 4, 6, 5, 0, -4 },
  { 197, 3, 6, 5, 1, -6 },
  { 200, 3, 6, 5, 1, -6 },
  { 203, 2, 8, 5, 1, -6 },
  { 205, 4, 6, 5, 1, -6 },
  { 208, 3, 6, 5, 1, -6 },
  { 211, 4, 4, 5, 0, -4 },
  { 213, 3, 4, 5, 1, -4 },
  { 215, 4, 4, 5, 0, -4 },
  { 217, 3, 6, 5, 1, -4 },
  { 220, 4, 6, 5, 0, -4 },
  { 223, 3, 4, 5, 1, -4 },
  { 225, 4, 4, 5, 0, -4 },
  { 227, 4, 5, 5, 0, -5 },
  { 230, 3, 4, 5, 1, -4 },
  { 232, 5, 4, 5, 0, -4 },
  { 235, 5, 4, 5, 0, -4 },
  { 238, 5, 4, 5, 0, -4 },
  { 241, 5, 6, 5, 0, -4 },
  { 245, 4, 4, 5, 0, -4 },
  { 247, 3, 7, 5, 1, -6 },
  { 250, 1, 8, 5, 2, -6 },
  { 251, 3, 7, 5, 1, -6 },
  { 254, 4, 2, 5, 0, -3 },
};

const GFXfont RobotoMono_Bold8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold8pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_BOLD8PT7B_H_
