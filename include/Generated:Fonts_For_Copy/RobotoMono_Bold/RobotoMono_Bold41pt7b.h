#ifndef _ROBOTOMONO_BOLD41PT7B_H_
#define _ROBOTOMONO_BOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x7D, 0xFB,
  0xFF, 0xE7, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x03,
  0x87, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87,
  0x00, 0x1E, 0x1C, 0x00, 0x70, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x38,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x3F, 0x7C, 0x03,
  0xF7, 0xC0, 0x3F, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0x1E, 0x08, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0x70,
  0xF1, 0xC0, 0xF1, 0xE7, 0x81, 0xE3, 0xCE, 0x03, 0xFF, 0x3C, 0x03, 0xFE,
  0x70, 0x03, 0xF1, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x8F, 0xC0, 0x0F, 0x3F,
  0xE0, 0x1C, 0xFF, 0xC0, 0x79, 0xE3, 0xC0, 0xE7, 0x87, 0x83, 0xCF, 0x0F,
  0x07, 0x1E, 0x1E, 0x06, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0x8F, 0x80,
  0x1F, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x8F, 0x80,
  0x0F, 0x9F, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x3E, 0x3F, 0xFC, 0x3E,
  0x3F, 0x7E, 0x3E, 0x7E, 0x7F, 0x3E, 0x7C, 0x3F, 0x7C, 0x7C, 0x1F, 0xFC,
  0xFC, 0x0F, 0xFC, 0x7C, 0x0F, 0xF8, 0x7E, 0x07, 0xF8, 0x7F, 0x0F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x3C, 0x0F, 0x83, 0xE0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0E, 0x00, 0x40, 0x60, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x07, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x20, 0x38, 0x09, 0xC1, 0xC1, 0xCF,
  0xCE, 0x7E, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x78, 0x01, 0xF1, 0xE0, 0x1F,
  0x0F, 0x81, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x08, 0x06, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0xF9,
  0xE7, 0xC3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C,
  0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0xFC, 0x3F, 0x9F, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xCF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x3E, 0x7C,
  0x0F, 0xCF, 0xE3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0x87, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x40, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE,
  0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7,
  0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xF7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0x0F, 0xE0, 0x40, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xFF, 0x0F, 0xDF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0,
  0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF9, 0xFC, 0x7E, 0x07, 0xE7,
  0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x81, 0xF7, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x81, 0xFB, 0xF0, 0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xFD, 0xF0, 0x18, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0x3C, 0x7E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x07,
  0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x7E, 0x1F, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x0F, 0x07,
  0x0F, 0x1C, 0x3F, 0xCE, 0x78, 0xFF, 0x9C, 0xE3, 0xE7, 0x39, 0xC7, 0x8E,
  0x77, 0x9E, 0x3C, 0xEE, 0x3C, 0x71, 0xDC, 0x70, 0xE3, 0xB8, 0xE1, 0xC7,
  0x71, 0xC3, 0x8E, 0xE7, 0x87, 0x1D, 0xC7, 0x0E, 0x3B, 0x8E, 0x1C, 0xE7,
  0x1E, 0x79, 0xCF, 0x3F, 0xFF, 0x1E, 0x3F, 0x7E, 0x1C, 0x3C, 0x70, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x06, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80, 0x03,
  0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F,
  0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x83, 0xFE, 0x7C, 0x03, 0xFB,
  0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00,
  0xF9, 0xF0, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xF0,
  0x07, 0xEF, 0x80, 0x3E, 0x7E, 0x03, 0xF3, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xC7, 0xFC, 0x7E, 0x07, 0xF3,
  0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC3, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xFC, 0x3F, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0x80, 0x7F, 0x3E, 0x03,
  0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0x83, 0xF8, 0x3E, 0x1F, 0xC0,
  0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0xC0, 0x3E, 0xFE, 0x00, 0xFB,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFD, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x83,
  0xE0, 0x7F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF8, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0xCF, 0x80, 0x3F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xB9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFD, 0xFD, 0xFF,
  0xBF, 0xBF, 0xF7, 0xE7, 0xFE, 0xFC, 0xFF, 0xCF, 0x9F, 0xF9, 0xF3, 0xFF,
  0x3C, 0x7F, 0xE3, 0x8F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xDE, 0x3F, 0xFD, 0xF3,
  0xFF, 0xCF, 0x3F, 0xFC, 0xF3, 0xFF, 0xCF, 0xBF, 0xFC, 0x7B, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0xDF,
  0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7E, 0x07, 0xF3, 0xFC,
  0x7F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x3F,
  0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC,
  0x01, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01,
  0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x00, 0xFC, 0x7E, 0x07, 0xF0, 0xFE, 0x3F,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x02, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0x83, 0xFE, 0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x7E,
  0x7C, 0x1F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3,
  0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x00,
  0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF8,
  0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFB, 0xF8, 0x3F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0x7E,
  0x1F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E,
  0x01, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xCF, 0xC0,
  0x0F, 0x9F, 0x80, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x78, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87,
  0xC7, 0xFF, 0x1F, 0x8F, 0xBE, 0x3F, 0x1F, 0x3E, 0x7E, 0x3E, 0x7C, 0xFE,
  0x7C, 0xF9, 0xFC, 0xF9, 0xF3, 0xF9, 0xF3, 0xE7, 0xF3, 0xE7, 0xDF, 0xEF,
  0x8F, 0xBD, 0xDF, 0x0F, 0x7B, 0xBE, 0x1F, 0xF7, 0xFC, 0x3F, 0xEF, 0xF8,
  0x7F, 0x9F, 0xF0, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x07,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0xFE,
  0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF8,
  0x3F, 0x83, 0xF0, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x81, 0xF8, 0x7E,
  0x03, 0xF9, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC3, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xEF, 0xC0, 0x03,
  0xEF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x3E, 0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xE7, 0xC0,
  0xF3, 0xC0, 0x7B, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0,
  0x7E, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x03, 0xE7, 0xE0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xE0, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFB, 0xF0, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x9F, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD,
  0xFF, 0x7F, 0xBF, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF9, 0xF7, 0xFE, 0x3E, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xDF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03,
  0xF7, 0xC0, 0x3F, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x7E,
  0x03, 0xE3, 0xF0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x3F, 0x3F, 0x0F, 0xFB, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xF1, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F, 0x81, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x08, 0x7F, 0x00, 0xC1, 0xFC, 0x1F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0xDF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xDF, 0xF7, 0xF0, 0x7F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF3, 0xF8, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x18, 0x07, 0xE1, 0xC0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x0F, 0xC3, 0xE7, 0xFC, 0x7D, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xE7, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xBE, 0x03, 0xF9, 0xF0, 0x3F, 0x8F, 0x83,
  0xF8, 0x7C, 0x3F, 0x83, 0xE3, 0xF8, 0x1F, 0x3F, 0x80, 0xF9, 0xF8, 0x07,
  0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFB, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F, 0x07, 0xC1, 0xFC, 0x3E,
  0x07, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFE, 0x7C, 0x03, 0xFB, 0xE0, 0x0F,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0xF1, 0xE3, 0xEF, 0xEF, 0xEF, 0xBF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF1, 0xFF, 0xC7, 0xC7, 0xFF, 0x1F, 0x1F, 0xFC, 0x7C, 0x7F,
  0xF1, 0xF1, 0xFF, 0xC7, 0xC7, 0xFF, 0x1F, 0x1F, 0xFC, 0x7C, 0x7F, 0xF1,
  0xF1, 0xFF, 0xC7, 0xC7, 0xFF, 0x1F, 0x1F, 0xFC, 0x7C, 0x7F, 0xF1, 0xF1,
  0xFF, 0xC7, 0xC7, 0xFF, 0x1F, 0x1F, 0xFC, 0x7C, 0x7F, 0xF1, 0xF1, 0xF0,
  0xF8, 0x7E, 0x1F, 0x3F, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFB, 0xFF,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xDF,
  0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7E,
  0x07, 0xF3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0xF8, 0xFC, 0x1F, 0x7F, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFB, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xBF, 0xF1, 0xF3, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xDF, 0xF7, 0xF0, 0x7F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x18, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xEF, 0xC3, 0xFD, 0xFF, 0xFF, 0x9F,
  0xFD, 0xF3, 0xFF, 0x3E, 0x1F, 0xC7, 0xC0, 0xFC, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC1,
  0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x78, 0x3F, 0xF0,
  0xF0, 0xFB, 0xE1, 0xE1, 0xF7, 0xC3, 0xE3, 0xEF, 0x8F, 0xC7, 0xDF, 0x1F,
  0x8F, 0x9E, 0x3F, 0x1F, 0x3E, 0x7E, 0x3C, 0x7C, 0xFC, 0x78, 0xF9, 0xFD,
  0xF1, 0xF7, 0xBB, 0xE1, 0xEE, 0x77, 0xC3, 0xDC, 0xEF, 0x07, 0xB9, 0xDE,
  0x0F, 0x73, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x00,
  0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x7E,
  0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x7E, 0x01, 0xFB, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x03, 0xE0,
  0x1F, 0x80, 0x7D, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xFC, 0x03, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7F,
  0x81, 0xFE, 0x03, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xDF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x7F, 0xE3, 0xFF, 0xEF, 0x07, 0xFF, 0xB8, 0x0F, 0xFC, 0x00, 0x0F, 0xE0,
};

const GFXglyph RobotoMono_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 29, 25, 9, -29 },
  { 27, 12, 11, 25, 6, -31 },
  { 44, 22, 29, 25, 1, -29 },
  { 124, 20, 38, 25, 3, -34 },
  { 219, 23, 30, 25, 1, -30 },
  { 306, 24, 30, 25, 1, -30 },
  { 396, 4, 11, 25, 9, -31 },
  { 402, 11, 41, 25, 7, -32 },
  { 459, 12, 41, 25, 6, -32 },
  { 521, 21, 20, 25, 3, -29 },
  { 574, 20, 21, 25, 2, -24 },
  { 627, 7, 13, 25, 7, -5 },
  { 639, 16, 4, 25, 6, -15 },
  { 647, 8, 7, 25, 8, -7 },
  { 654, 17, 32, 25, 4, -29 },
  { 722, 19, 30, 25, 3, -30 },
  { 794, 13, 29, 25, 3, -29 },
  { 842, 21, 30, 25, 1, -30 },
  { 921, 20, 30, 25, 2, -30 },
  { 996, 21, 29, 25, 1, -29 },
  { 1073, 20, 29, 25, 2, -29 },
  { 1146, 20, 29, 25, 2, -29 },
  { 1219, 21, 29, 25, 1, -29 },
  { 1296, 20, 30, 25, 2, -30 },
  { 1371, 19, 30, 25, 2, -30 },
  { 1443, 7, 24, 25, 9, -24 },
  { 1464, 8, 32, 25, 9, -24 },
  { 1496, 18, 19, 25, 3, -22 },
  { 1539, 19, 13, 25, 3, -19 },
  { 1570, 18, 19, 25, 3, -22 },
  { 1613, 19, 30, 25, 3, -30 },
  { 1685, 23, 29, 25, 1, -29 },
  { 1769, 24, 29, 25, 1, -29 },
  { 1856, 21, 29, 25, 3, -29 },
  { 1933, 21, 30, 25, 2, -30 },
  { 2012, 21, 29, 25, 2, -29 },
  { 2089, 20, 29, 25, 3, -29 },
  { 2162, 20, 29, 25, 3, -29 },
  { 2235, 21, 30, 25, 2, -30 },
  { 2314, 20, 29, 25, 2, -29 },
  { 2387, 17, 29, 25, 4, -29 },
  { 2449, 20, 29, 25, 2, -29 },
  { 2522, 22, 29, 25, 3, -29 },
  { 2602, 19, 29, 25, 3, -29 },
  { 2671, 19, 29, 25, 3, -29 },
  { 2740, 20, 29, 25, 2, -29 },
  { 2813, 21, 30, 25, 2, -30 },
  { 2892, 20, 29, 25, 3, -29 },
  { 2965, 22, 35, 25, 2, -30 },
  { 3062, 21, 29, 25, 3, -29 },
  { 3139, 21, 30, 25, 2, -30 },
  { 3218, 23, 29, 25, 1, -29 },
  { 3302, 19, 29, 25, 3, -29 },
  { 3371, 23, 29, 25, 1, -29 },
  { 3455, 23, 29, 25, 1, -29 },
  { 3539, 23, 29, 25, 1, -29 },
  { 3623, 24, 29, 25, 1, -29 },
  { 3710, 21, 29, 25, 2, -29 },
  { 3787, 9, 41, 25, 8, -34 },
  { 3834, 16, 32, 25, 5, -29 },
  { 3898, 9, 41, 25, 8, -34 },
  { 3945, 17, 15, 25, 4, -29 },
  { 3977, 18, 4, 25, 3, 0 },
  { 3986, 10, 6, 25, 8, -30 },
  { 3994, 20, 22, 25, 2, -22 },
  { 4049, 19, 31, 25, 3, -31 },
  { 4123, 20, 22, 25, 2, -22 },
  { 4178, 20, 31, 25, 2, -31 },
  { 4256, 21, 22, 25, 2, -22 },
  { 4314, 20, 32, 25, 3, -32 },
  { 4394, 20, 31, 25, 2, -22 },
  { 4472, 19, 31, 25, 3, -31 },
  { 4546, 18, 30, 25, 4, -30 },
  { 4614, 14, 39, 25, 4, -30 },
  { 4683, 21, 31, 25, 3, -31 },
  { 4765, 18, 31, 25, 4, -31 },
  { 4835, 22, 22, 25, 1, -22 },
  { 4896, 19, 22, 25, 3, -22 },
  { 4949, 21, 22, 25, 2, -22 },
  { 5007, 19, 30, 25, 3, -22 },
  { 5079, 20, 30, 25, 2, -22 },
  { 5154, 16, 22, 25, 6, -22 },
  { 5198, 20, 22, 25, 2, -22 },
  { 5253, 19, 27, 25, 3, -27 },
  { 5318, 19, 22, 25, 3, -22 },
  { 5371, 22, 22, 25, 1, -22 },
  { 5432, 23, 22, 25, 1, -22 },
  { 5496, 22, 22, 25, 2, -22 },
  { 5557, 24, 31, 25, 1, -22 },
  { 5650, 21, 22, 25, 2, -22 },
  { 5708, 14, 39, 25, 6, -32 },
  { 5777, 3, 37, 25, 11, -29 },
  { 5791, 13, 39, 25, 7, -32 },
  { 5855, 22, 9, 25, 1, -17 },
};

const GFXfont RobotoMono_Bold41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold41pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_BOLD41PT7B_H_
