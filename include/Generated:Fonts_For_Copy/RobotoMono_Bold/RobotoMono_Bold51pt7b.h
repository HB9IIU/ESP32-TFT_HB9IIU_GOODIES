#ifndef _ROBOTOMONO_BOLD51PT7B_H_
#define _ROBOTOMONO_BOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x3E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0xC1, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x3C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x07,
  0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xF0, 0x0F,
  0xF7, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x3E, 0x04, 0x03, 0xE1, 0xF0, 0x78,
  0x1F, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x3C, 0x07, 0xC3, 0xE3, 0xE0, 0x3E,
  0x1F, 0x1E, 0x01, 0xF0, 0xF9, 0xF0, 0x07, 0xFF, 0x8F, 0x00, 0x3F, 0xFC,
  0xF0, 0x00, 0xFF, 0xC7, 0x80, 0x01, 0xF8, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x07,
  0x9F, 0xFC, 0x00, 0x78, 0xFF, 0xF0, 0x03, 0xCF, 0xFF, 0x80, 0x3C, 0x7C,
  0x7C, 0x01, 0xE3, 0xC1, 0xF0, 0x1E, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x7C,
  0x0F, 0x07, 0x83, 0xE0, 0x18, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x07, 0xE1, 0xFF, 0xF0, 0x3F, 0x1F, 0xFF, 0xC1,
  0xF9, 0xFE, 0xFE, 0x0F, 0xCF, 0xE7, 0xF8, 0xFC, 0xFF, 0x1F, 0xE7, 0xE7,
  0xF0, 0x7F, 0xBF, 0x3F, 0x81, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0x8F, 0xE0,
  0x3F, 0xFC, 0x7F, 0x00, 0xFF, 0xC3, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0x9F, 0xE0, 0x7F, 0xF0, 0xFF, 0x80, 0x10, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x00, 0x10, 0x03,
  0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x0C, 0x60, 0x01, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x00, 0xF8, 0x00,
  0xE0, 0x3C, 0x06, 0x7C, 0x1E, 0x1F, 0x7F, 0xCF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x0E, 0x00, 0xE0, 0x02, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE0,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0x04, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFB, 0xFF, 0xEF, 0xE7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xF8,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFF,
  0x83, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F,
  0x80, 0x3F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x1F, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0x01, 0xFE, 0x02, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0xFE, 0x7F, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xE7, 0xFE, 0xFF,
  0x81, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x3F,
  0xC3, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x83, 0xFE, 0x7F, 0x01,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0xE7,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0xC3,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0xDF, 0xE0, 0x3F, 0xE7, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x7E, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x08, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x7F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x41, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB,
  0xF8, 0x20, 0x0C, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0xFF,
  0x3F, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C,
  0x3F, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x1E, 0x07, 0xF1, 0xE3, 0xE1, 0xFF,
  0x8E, 0x3C, 0x3F, 0xF8, 0xF7, 0xC7, 0xF7, 0x8F, 0x78, 0x7C, 0x78, 0xF7,
  0x8F, 0x87, 0x8F, 0x78, 0xF0, 0x78, 0xFF, 0x8F, 0x07, 0x8F, 0xF0, 0xF0,
  0x78, 0xFF, 0x1F, 0x07, 0x8F, 0xF1, 0xF0, 0x78, 0xFF, 0x1E, 0x07, 0x0F,
  0xF1, 0xE0, 0xF0, 0xFF, 0x1F, 0x0F, 0x0E, 0xF1, 0xF0, 0xF1, 0xEF, 0x1F,
  0x0F, 0x1E, 0xF8, 0xFF, 0xFB, 0xC7, 0x8F, 0xFF, 0xFC, 0x78, 0x7F, 0x7F,
  0x87, 0xC3, 0xE3, 0xF0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x1F, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x80,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFC, 0x03,
  0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xF1, 0xFF, 0xE3, 0xF8, 0x0F, 0xF9, 0xFC, 0x03,
  0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xDF, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0x7F, 0xC1,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x03, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F,
  0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xEF,
  0xFF, 0x7D, 0xF7, 0xFF, 0xBE, 0xFB, 0xFF, 0xDF, 0x7D, 0xFF, 0xE7, 0xFC,
  0xFF, 0xF3, 0xFE, 0x7F, 0xF9, 0xFF, 0x3F, 0xFC, 0xFF, 0x1F, 0xFE, 0x3F,
  0x8F, 0xFF, 0x1F, 0xC7, 0xFF, 0x8F, 0xC3, 0xFF, 0xE3, 0xE1, 0xFF, 0xF1,
  0xF0, 0xFF, 0xF8, 0xF0, 0x7F, 0xFC, 0x78, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x7F, 0xFE, 0xFC, 0x7F, 0xFE, 0x7C,
  0x7F, 0xFE, 0x7E, 0x7F, 0xFE, 0x3E, 0x7F, 0xFE, 0x3F, 0x7F, 0xFE, 0x1F,
  0x7F, 0xFE, 0x1F, 0x7F, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF8,
  0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xF0,
  0x3F, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x01, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x7F,
  0x83, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x47,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFC, 0x0F, 0xFE, 0x3F, 0x80, 0x3F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03,
  0xFC, 0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x1F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x07,
  0xE0, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0xE1, 0xF8, 0x3F, 0x7F, 0x0F, 0xE1,
  0xF9, 0xF8, 0x7F, 0x0F, 0xCF, 0xC3, 0xF8, 0x7E, 0x7E, 0x3F, 0xC3, 0xF3,
  0xF1, 0xFE, 0x3F, 0x9F, 0x8F, 0xF1, 0xFC, 0xFC, 0x7F, 0x8F, 0xC7, 0xF3,
  0xFE, 0x7E, 0x1F, 0x9F, 0xF3, 0xF0, 0xFC, 0xFF, 0x9F, 0x87, 0xEF, 0xFC,
  0xFC, 0x3F, 0x7D, 0xE7, 0xE1, 0xFB, 0xEF, 0x7F, 0x0F, 0xDF, 0x7F, 0xF0,
  0x7E, 0xFB, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0x7F,
  0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0xFC,
  0x0F, 0x87, 0xC0, 0x7E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xFF, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0x80,
  0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x0F, 0xFC, 0x7F, 0x00, 0x40,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x7F,
  0xC0, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFD, 0xFF, 0xE0, 0xFC, 0x7F, 0xC0, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80,
  0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x7F, 0x0F, 0xFF,
  0x7F, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x7F, 0xC3,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0x7F, 0x03, 0xFE, 0x3F, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF,
  0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x87, 0xFC, 0x01,
  0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF8, 0x20, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0x07, 0xFF, 0xBF,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF,
  0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x7F, 0xE1, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0x7F,
  0x03, 0xFE, 0x7F, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x7F, 0x08, 0x00, 0x7F,
  0x0C, 0x00, 0xFF, 0x1F, 0x03, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xE0,
  0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0x83, 0xFE, 0xFE, 0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x10, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x3F,
  0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x3F, 0x8F, 0xF8, 0x0F, 0xE7, 0xFC, 0x03, 0xFB, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F,
  0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x1F, 0xF0, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0xFC, 0x7F, 0x3F, 0x7F, 0xBF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0,
  0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFC, 0xFC, 0x3F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xDF,
  0xE0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0xFC, 0x7F, 0xC0, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x01,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F,
  0xC0, 0xFE, 0x04, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0x0F, 0xFF,
  0x3F, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x7F, 0xC1,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0x7F, 0x03, 0xFE, 0x7F, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xF7, 0xDF, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF3, 0xFC, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xBF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFB, 0xF8, 0x03, 0xF9, 0xFF, 0xDF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x7F, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xBF, 0x3F, 0xFF, 0x7E, 0x3F, 0xFC,
  0xFC, 0x3F, 0xE1, 0xF8, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0x03, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFE, 0x1F, 0x83, 0xF7, 0xE1, 0xF8, 0x7E,
  0x7E, 0x1F, 0xC7, 0xE7, 0xE3, 0xFC, 0x7E, 0x7E, 0x3F, 0xC7, 0xE7, 0xE3,
  0xFC, 0x7E, 0x3E, 0x3F, 0xC7, 0xE3, 0xE3, 0xFC, 0x7C, 0x3F, 0x79, 0xE7,
  0xC3, 0xF7, 0x9E, 0xFC, 0x3F, 0x79, 0xEF, 0xC3, 0xF7, 0x9E, 0xFC, 0x1F,
  0x79, 0xEF, 0x81, 0xF7, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF1, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x9F, 0xC0,
  0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x07, 0xBF, 0xFF, 0x01, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xF8, 0x0F, 0xFF, 0xDE,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x00,
};

const GFXglyph RobotoMono_Bold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 36, 31, 11, -36 },
  { 37, 15, 13, 31, 7, -38 },
  { 62, 28, 36, 31, 1, -36 },
  { 188, 25, 47, 31, 3, -42 },
  { 335, 29, 38, 31, 1, -37 },
  { 473, 29, 38, 31, 2, -37 },
  { 611, 6, 13, 31, 11, -38 },
  { 621, 13, 51, 31, 9, -40 },
  { 704, 14, 51, 31, 8, -40 },
  { 794, 25, 25, 31, 4, -36 },
  { 873, 25, 26, 31, 2, -30 },
  { 955, 9, 16, 31, 9, -6 },
  { 973, 21, 6, 31, 7, -19 },
  { 989, 9, 10, 31, 11, -9 },
  { 1001, 21, 39, 31, 5, -36 },
  { 1104, 23, 38, 31, 4, -37 },
  { 1214, 16, 36, 31, 4, -36 },
  { 1286, 25, 37, 31, 2, -37 },
  { 1402, 25, 38, 31, 2, -37 },
  { 1521, 27, 36, 31, 1, -36 },
  { 1643, 24, 37, 31, 3, -36 },
  { 1754, 24, 38, 31, 3, -37 },
  { 1868, 25, 36, 31, 2, -36 },
  { 1981, 24, 38, 31, 3, -37 },
  { 2095, 25, 37, 31, 2, -37 },
  { 2211, 9, 31, 31, 11, -30 },
  { 2246, 10, 40, 31, 11, -30 },
  { 2296, 22, 23, 31, 4, -27 },
  { 2360, 24, 17, 31, 4, -24 },
  { 2411, 22, 23, 31, 4, -27 },
  { 2475, 23, 37, 31, 4, -37 },
  { 2582, 28, 36, 31, 1, -36 },
  { 2708, 30, 36, 31, 1, -36 },
  { 2843, 26, 36, 31, 3, -36 },
  { 2960, 26, 38, 31, 2, -37 },
  { 3084, 25, 36, 31, 3, -36 },
  { 3197, 24, 36, 31, 4, -36 },
  { 3305, 24, 36, 31, 4, -36 },
  { 3413, 26, 38, 31, 2, -37 },
  { 3537, 24, 36, 31, 3, -36 },
  { 3645, 21, 36, 31, 5, -36 },
  { 3740, 24, 37, 31, 3, -36 },
  { 3851, 28, 36, 31, 3, -36 },
  { 3977, 24, 36, 31, 4, -36 },
  { 4085, 25, 36, 31, 3, -36 },
  { 4198, 24, 36, 31, 3, -36 },
  { 4306, 27, 38, 31, 2, -37 },
  { 4435, 25, 36, 31, 4, -36 },
  { 4548, 28, 43, 31, 2, -37 },
  { 4699, 27, 36, 31, 3, -36 },
  { 4821, 27, 37, 31, 2, -37 },
  { 4946, 29, 36, 31, 1, -36 },
  { 5077, 24, 37, 31, 3, -36 },
  { 5188, 29, 36, 31, 1, -36 },
  { 5319, 29, 36, 31, 1, -36 },
  { 5450, 29, 36, 31, 1, -36 },
  { 5581, 29, 36, 31, 1, -36 },
  { 5712, 27, 36, 31, 2, -36 },
  { 5834, 11, 50, 31, 10, -42 },
  { 5903, 20, 39, 31, 6, -36 },
  { 6001, 11, 50, 31, 10, -42 },
  { 6070, 21, 19, 31, 5, -36 },
  { 6120, 22, 5, 31, 4, 0 },
  { 6134, 12, 7, 31, 10, -37 },
  { 6145, 24, 28, 31, 3, -27 },
  { 6229, 24, 39, 31, 4, -38 },
  { 6346, 24, 28, 31, 3, -27 },
  { 6430, 24, 39, 31, 3, -38 },
  { 6547, 25, 28, 31, 3, -27 },
  { 6635, 26, 39, 31, 3, -39 },
  { 6762, 24, 38, 31, 3, -27 },
  { 6876, 24, 38, 31, 4, -38 },
  { 6990, 22, 38, 31, 5, -38 },
  { 7095, 16, 49, 31, 6, -38 },
  { 7193, 26, 38, 31, 4, -38 },
  { 7317, 23, 38, 31, 5, -38 },
  { 7427, 26, 27, 31, 2, -27 },
  { 7515, 24, 27, 31, 4, -27 },
  { 7596, 25, 28, 31, 3, -27 },
  { 7684, 24, 37, 31, 4, -27 },
  { 7795, 24, 37, 31, 3, -27 },
  { 7906, 21, 27, 31, 7, -27 },
  { 7977, 25, 28, 31, 3, -27 },
  { 8065, 24, 35, 31, 3, -34 },
  { 8170, 23, 28, 31, 4, -27 },
  { 8251, 27, 27, 31, 2, -27 },
  { 8343, 28, 27, 31, 1, -27 },
  { 8438, 28, 27, 31, 2, -27 },
  { 8533, 30, 38, 31, 1, -27 },
  { 8676, 25, 27, 31, 3, -27 },
  { 8761, 16, 49, 31, 8, -40 },
  { 8859, 5, 46, 31, 13, -36 },
  { 8888, 17, 49, 31, 8, -40 },
  { 8993, 27, 12, 31, 1, -21 },
};

const GFXfont RobotoMono_Bold51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold51pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_BOLD51PT7B_H_
