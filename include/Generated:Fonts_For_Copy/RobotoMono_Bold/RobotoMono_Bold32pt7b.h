#ifndef _ROBOTOMONO_BOLD32PT7B_H_
#define _ROBOTOMONO_BOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xE0, 0x00,
  0x09, 0xFF, 0xFD, 0xC0, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x63, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0x83, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x0C, 0x01, 0x8E, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0x7E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x1F, 0x78,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x3C, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0x9C, 0x30, 0xC3, 0x1C,
  0x30, 0xC6, 0x0E, 0x73, 0x83, 0xFC, 0xC0, 0x7E, 0x70, 0x0F, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE3, 0x00, 0x33, 0xF0, 0x1D,
  0xFE, 0x06, 0x73, 0x83, 0x9C, 0x71, 0xC7, 0x1C, 0x11, 0xC7, 0x00, 0x73,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0x7D, 0xE0, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF9, 0xE0, 0x1E,
  0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0xC3, 0xDF, 0xF8,
  0xF7, 0x9F, 0x3B, 0xE3, 0xDE, 0xF8, 0xFF, 0xBE, 0x1F, 0xEF, 0x83, 0xF1,
  0xF1, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0x7C, 0xFF, 0xFF, 0xFF,
  0x01, 0x01, 0xC1, 0xE1, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03,
  0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x02,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x07, 0x87, 0x87, 0x83, 0x80, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC0, 0x71, 0xC7,
  0x7D, 0xDF, 0xFF, 0xFF, 0x0F, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x70,
  0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1C, 0x08, 0x18, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x7B, 0xDE, 0xF7, 0xBD, 0xFE, 0xF7, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFB, 0xEF, 0xFE, 0xF8, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83,
  0xCF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE7, 0xFF,
  0xDE, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0,
  0x7D, 0xE0, 0xF3, 0xE3, 0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xF8, 0x00, 0x00,
  0x40, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7E, 0x7C, 0x1F,
  0x78, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7E, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x78, 0x0F, 0x78, 0x1F, 0x7E, 0x3F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x07,
  0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7B, 0xE0, 0xFF, 0xF1, 0xFF, 0xF7, 0xE7, 0xE1,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE3, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF3, 0xF1, 0xEF, 0xF3, 0xFF, 0xF7, 0xE7, 0xEF, 0x83, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xE3, 0xFF,
  0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xF7, 0xEF, 0x83,
  0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0x78, 0x3C, 0xFD, 0xF0, 0xFF, 0xE0,
  0xFF, 0x87, 0xFF, 0x8F, 0x8F, 0xBE, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE3, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xCF, 0x87, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC3, 0xF7, 0xFF, 0xEF,
  0xFF, 0xCF, 0xFF, 0x03, 0x9E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x7F,
  0x81, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x7D, 0xFF, 0xDF,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xCF, 0x38, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFB,
  0xFF, 0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0x03, 0xFC, 0x7F, 0xCF, 0xFC, 0x3F, 0xC0,
  0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xF7, 0x83, 0xEF, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0x40, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0x80,
  0x73, 0x87, 0x1D, 0xCF, 0xEE, 0xC7, 0xF3, 0xE7, 0x39, 0xF3, 0x1C, 0xF3,
  0x8E, 0x79, 0xC7, 0x3C, 0xE3, 0x1E, 0x71, 0x8F, 0x38, 0xCF, 0x9E, 0xE6,
  0xE7, 0xFF, 0x71, 0xCF, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xE3, 0x00, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x07, 0x83, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x1F,
  0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0xFF, 0xC0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFE,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xC1, 0xF3, 0xE0, 0x79, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0xBC, 0x07, 0xDF, 0x03,
  0xC7, 0xC7, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3,
  0xC1, 0xF3, 0xE0, 0x79, 0xE0, 0x3E, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0x1F, 0x78, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xE7, 0xE3, 0xF1, 0xFF, 0xF8,
  0x7F, 0xF0, 0x1F, 0xE0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xF0, 0x0F,
  0xBC, 0x07, 0xCF, 0x03, 0xF3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F,
  0x1F, 0x83, 0xC7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xE3, 0xE0, 0xF0, 0x7C,
  0x3C, 0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xEF,
  0x00, 0xFC, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xEF,
  0xFE, 0xEF, 0xF7, 0xEF, 0xF7, 0xCF, 0xF7, 0xCF, 0xF7, 0xCF, 0xF3, 0xCF,
  0xF3, 0x8F, 0xF3, 0x9F, 0xF3, 0x9F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFF,
  0x1F, 0xEE, 0x3F, 0xDE, 0x7F, 0x9C, 0xFF, 0x3D, 0xFE, 0x3B, 0xFC, 0x77,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0x9F, 0x07, 0xC7, 0xC7, 0xC3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7C, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xF9, 0xE0, 0x3E, 0xF8, 0x07, 0xBE,
  0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0x7B, 0xE0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xC7, 0xC1, 0xF0, 0xF8, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x10, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78,
  0x0F, 0xBC, 0x0F, 0x9F, 0xFF, 0xCF, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1,
  0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x3C, 0x0F, 0x9E, 0x07, 0xCF, 0x01,
  0xF7, 0x80, 0xFB, 0xC0, 0x3E, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xBC, 0x03, 0xDF, 0x03, 0xEF, 0xC3, 0xF3,
  0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFB, 0xE3, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xF8, 0x03, 0xEF,
  0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x0F, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xE3, 0xE0, 0x3C, 0x7C, 0x07,
  0x8F, 0x00, 0xF9, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0xF0, 0xE1, 0xEF, 0x1C, 0x3D, 0xE3, 0x87, 0xBC,
  0x79, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7, 0x9E, 0x7C, 0xF3, 0xCF, 0x9E, 0x39,
  0xF3, 0xC7, 0xBF, 0x78, 0xF6, 0xEE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F,
  0x7F, 0x0F, 0xEF, 0xE1, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xC0, 0x7C,
  0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x1E,
  0x3E, 0x03, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D,
  0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xE0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0x7C, 0xF8, 0x0F, 0xBF, 0x00, 0xF8, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0x80,
  0xF9, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0xF8,
  0x1F, 0x3C, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0xFF, 0xFF, 0x80, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x0E, 0xF0, 0x73, 0x87, 0x9C, 0x38, 0xF3,
  0xC3, 0x9E, 0x1F, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x3C, 0x1E, 0x0F, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0xC3, 0xEF, 0x83,
  0xC0, 0x07, 0xC0, 0x0F, 0x8F, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0x3F, 0x9E, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7D, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xF9, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0xC7, 0xFF, 0xFF, 0xBD, 0xFE, 0x79, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xF3, 0xEF, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xFF, 0x83, 0xEF, 0x8F, 0x8F, 0xFF,
  0x1F, 0xFC, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0xCF, 0x3F, 0xDE, 0xFF, 0xFD, 0xFB,
  0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC7, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F,
  0xCF, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x78, 0x1E, 0xF8,
  0x1E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x04, 0x7E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00,
  0x1C, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xDE, 0x7F, 0xFD, 0xFF, 0xFB, 0xF3, 0xFF, 0x83, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x83, 0xEF, 0xCF, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xDE, 0x00, 0x3C, 0x80,
  0xF9, 0x83, 0xF7, 0xFF, 0xCF, 0xFF, 0x07, 0xFC, 0x03, 0x80, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0xF8, 0xFF, 0xFD, 0xFF, 0xFB, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x01, 0x00, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x80, 0x78, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x01, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x3F, 0xE7, 0xF8, 0xFE, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x7E, 0xF8, 0x7E, 0x7C, 0x7E, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0xBE, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7E, 0xF8, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0xFD, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x9E, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7D, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7,
  0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7,
  0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0x80, 0xF1, 0xF9, 0xEF, 0xFB, 0xFF, 0xF7,
  0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1E, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7E, 0xFC, 0xF8, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0,
  0xF3, 0xF1, 0xEF, 0xF3, 0xFF, 0xF7, 0xE7, 0xEF, 0x83, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x8F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFB, 0xF1, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x9E, 0x7F,
  0xFD, 0xFF, 0xFB, 0xF3, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x83, 0xEF, 0x8F, 0xDF,
  0xFF, 0x9F, 0xFF, 0x1F, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF9, 0xFF, 0xEF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xFE, 0x0B, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x1F,
  0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xDF, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x84, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x83,
  0xEF, 0x8F, 0xDF, 0xFF, 0x9F, 0xEF, 0x1F, 0x9E, 0xF8, 0x0F, 0xBC, 0x07,
  0xDE, 0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C,
  0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x77, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0xE3, 0xDE,
  0x38, 0xF7, 0x8E, 0x3D, 0xE7, 0xCF, 0x79, 0xF3, 0xDE, 0x7C, 0xF3, 0x9F,
  0x38, 0xE6, 0xCE, 0x3B, 0xB7, 0x8F, 0xEF, 0xE3, 0xFB, 0xF8, 0xFC, 0xFC,
  0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x0F, 0x00,
  0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x83, 0xE1, 0xF1, 0xF0, 0x3E,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0xF0, 0x7C, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F,
  0x8F, 0xC3, 0xC0, 0xFC, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x1F, 0x03,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0x0F, 0xE1, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x0F,
  0x81, 0xE0, 0x10, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x77, 0xFC, 0x3D, 0xFF,
  0xFF, 0x70, 0xFF, 0xB8, 0x1F, 0xE0, 0x03, 0xE0,
};

const GFXglyph RobotoMono_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 10, 8, 19, 4, -24 },
  { 26, 17, 23, 19, 1, -23 },
  { 75, 16, 29, 19, 2, -26 },
  { 133, 18, 23, 19, 1, -23 },
  { 185, 18, 23, 19, 1, -23 },
  { 237, 3, 8, 19, 7, -24 },
  { 240, 9, 32, 19, 5, -25 },
  { 276, 9, 32, 19, 5, -25 },
  { 312, 16, 16, 19, 2, -23 },
  { 344, 15, 17, 19, 2, -19 },
  { 376, 5, 10, 19, 6, -4 },
  { 383, 13, 4, 19, 4, -12 },
  { 390, 6, 5, 19, 7, -5 },
  { 394, 13, 25, 19, 3, -23 },
  { 435, 15, 23, 19, 2, -23 },
  { 479, 10, 23, 19, 3, -23 },
  { 508, 16, 23, 19, 1, -23 },
  { 554, 16, 23, 19, 1, -23 },
  { 600, 17, 23, 19, 1, -23 },
  { 649, 15, 23, 19, 2, -23 },
  { 693, 15, 23, 19, 2, -23 },
  { 737, 16, 23, 19, 1, -23 },
  { 783, 15, 23, 19, 2, -23 },
  { 827, 15, 23, 19, 2, -23 },
  { 871, 6, 18, 19, 7, -18 },
  { 885, 6, 24, 19, 7, -18 },
  { 903, 14, 15, 19, 2, -17 },
  { 930, 15, 11, 19, 2, -15 },
  { 951, 14, 15, 19, 3, -17 },
  { 978, 15, 23, 19, 2, -23 },
  { 1022, 17, 23, 19, 1, -23 },
  { 1071, 19, 23, 19, 0, -23 },
  { 1126, 16, 23, 19, 2, -23 },
  { 1172, 17, 23, 19, 1, -23 },
  { 1221, 16, 23, 19, 2, -23 },
  { 1267, 16, 23, 19, 2, -23 },
  { 1313, 16, 23, 19, 2, -23 },
  { 1359, 17, 23, 19, 1, -23 },
  { 1408, 15, 23, 19, 2, -23 },
  { 1452, 13, 23, 19, 3, -23 },
  { 1490, 15, 23, 19, 2, -23 },
  { 1534, 18, 23, 19, 2, -23 },
  { 1586, 15, 23, 19, 2, -23 },
  { 1630, 16, 23, 19, 2, -23 },
  { 1676, 15, 23, 19, 2, -23 },
  { 1720, 17, 23, 19, 1, -23 },
  { 1769, 16, 23, 19, 2, -23 },
  { 1815, 18, 27, 19, 1, -23 },
  { 1876, 17, 23, 19, 2, -23 },
  { 1925, 17, 23, 19, 1, -23 },
  { 1974, 19, 23, 19, 0, -23 },
  { 2029, 15, 23, 19, 2, -23 },
  { 2073, 19, 23, 19, 0, -23 },
  { 2128, 19, 23, 19, 0, -23 },
  { 2183, 19, 23, 19, 0, -23 },
  { 2238, 18, 23, 19, 1, -23 },
  { 2290, 17, 23, 19, 1, -23 },
  { 2339, 7, 31, 19, 6, -26 },
  { 2367, 12, 25, 19, 4, -23 },
  { 2405, 7, 31, 19, 6, -26 },
  { 2433, 13, 12, 19, 3, -23 },
  { 2453, 15, 3, 19, 2, 0 },
  { 2459, 8, 4, 19, 6, -23 },
  { 2463, 15, 17, 19, 2, -17 },
  { 2495, 15, 24, 19, 2, -24 },
  { 2540, 15, 17, 19, 2, -17 },
  { 2572, 15, 24, 19, 2, -24 },
  { 2617, 16, 17, 19, 2, -17 },
  { 2651, 16, 25, 19, 2, -25 },
  { 2701, 15, 24, 19, 2, -17 },
  { 2746, 15, 24, 19, 2, -24 },
  { 2791, 14, 24, 19, 3, -24 },
  { 2833, 11, 31, 19, 3, -24 },
  { 2876, 17, 24, 19, 2, -24 },
  { 2927, 14, 24, 19, 3, -24 },
  { 2969, 17, 17, 19, 1, -17 },
  { 3006, 15, 17, 19, 2, -17 },
  { 3038, 16, 17, 19, 2, -17 },
  { 3072, 15, 24, 19, 2, -17 },
  { 3117, 15, 24, 19, 2, -17 },
  { 3162, 14, 17, 19, 4, -17 },
  { 3192, 15, 17, 19, 2, -17 },
  { 3224, 15, 21, 19, 2, -21 },
  { 3264, 15, 17, 19, 2, -17 },
  { 3296, 17, 17, 19, 1, -17 },
  { 3333, 18, 17, 19, 0, -17 },
  { 3372, 18, 17, 19, 1, -17 },
  { 3411, 18, 24, 19, 1, -17 },
  { 3465, 16, 17, 19, 2, -17 },
  { 3499, 10, 31, 19, 5, -25 },
  { 3538, 3, 29, 19, 8, -23 },
  { 3549, 11, 31, 19, 5, -25 },
  { 3592, 18, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_Bold32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold32pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_BOLD32PT7B_H_
