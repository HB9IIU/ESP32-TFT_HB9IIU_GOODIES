#ifndef _ROBOTOMONO_BOLD12PT7B_H_
#define _ROBOTOMONO_BOLD12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA2, 0xC0, 0xB6, 0x80, 0x14, 0x68, 0x93, 0xF2, 0x85, 0x3F,
  0x24, 0x58, 0x20, 0xCF, 0xB3, 0xC1, 0xC1, 0xA3, 0xCD, 0xE2, 0x00, 0x61,
  0x5A, 0xE3, 0x41, 0x02, 0x8A, 0x95, 0x0E, 0x10, 0xF1, 0xA3, 0xC3, 0x0F,
  0x77, 0xA6, 0x7E, 0xE0, 0x29, 0x69, 0x26, 0xC8, 0x90, 0x89, 0x92, 0x49,
  0x6B, 0x40, 0x30, 0x8A, 0x5E, 0x31, 0x20, 0x21, 0x3F, 0xF2, 0x10, 0x5C,
  0xF8, 0x7C, 0x18, 0xC4, 0x63, 0x11, 0x8C, 0x46, 0x00, 0x37, 0xF3, 0x1B,
  0xE6, 0x3B, 0x70, 0x17, 0xF3, 0x33, 0x33, 0x30, 0x31, 0xFC, 0xC3, 0x0C,
  0x63, 0x18, 0x7C, 0x77, 0xE2, 0x37, 0x0C, 0x3B, 0xF8, 0x0C, 0x38, 0x71,
  0x66, 0xC9, 0xBF, 0x86, 0x0C, 0xFF, 0xF1, 0xEF, 0x84, 0x3B, 0x70, 0x13,
  0xB1, 0x6F, 0xC6, 0x3B, 0x70, 0xFF, 0xF0, 0xC2, 0x18, 0x61, 0x0C, 0x60,
  0x77, 0xE3, 0xB7, 0x6E, 0x3B, 0xF8, 0x67, 0xE7, 0x1D, 0xFC, 0x66, 0x60,
  0xF0, 0x3C, 0xF0, 0x0F, 0x80, 0x1F, 0xB0, 0xF0, 0x80, 0xFF, 0xC1, 0xF0,
  0xC3, 0xC7, 0xEC, 0x00, 0x37, 0xF2, 0x11, 0x98, 0x04, 0x30, 0x3C, 0xB6,
  0xAD, 0x5A, 0xB7, 0x90, 0x1C, 0x10, 0x30, 0xE1, 0x42, 0xCD, 0x9F, 0x23,
  0xC6, 0xE3, 0xE8, 0xE3, 0xFA, 0x38, 0xE3, 0xF8, 0x18, 0xF9, 0x1A, 0x0C,
  0x18, 0x11, 0xB2, 0x3C, 0xC3, 0xE9, 0xA3, 0x8E, 0x38, 0xA6, 0xF0, 0xFF,
  0xFC, 0x30, 0xFB, 0x0C, 0x30, 0xFC, 0xFF, 0xFC, 0x30, 0xFB, 0x0C, 0x30,
  0xC0, 0x33, 0xE8, 0xE0, 0x82, 0x78, 0xF3, 0x78, 0x8C, 0x63, 0x1F, 0xC6,
  0x31, 0x88, 0xFF, 0xC8, 0x42, 0x10, 0x84, 0xF8, 0x08, 0x42, 0x10, 0x86,
  0x3B, 0x70, 0x8E, 0x29, 0xAC, 0xF3, 0xC9, 0xA2, 0x8C, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xFC, 0xCF, 0x7D, 0xFF, 0xBE, 0xB8, 0xE3, 0x8C, 0x8E,
  0x73, 0xDA, 0xDE, 0x73, 0x88, 0x18, 0xF9, 0x16, 0x3C, 0x78, 0xD1, 0xB6,
  0x38, 0xE3, 0xEC, 0xF3, 0xDF, 0xCC, 0x30, 0xC0, 0x18, 0xF9, 0x1A, 0x3C,
  0x78, 0xD1, 0xB6, 0x3C, 0x0C, 0x08, 0xE3, 0xE8, 0xE3, 0xFB, 0xC9, 0xA2,
  0x8C, 0x33, 0xE8, 0xF0, 0x70, 0x68, 0xF3, 0x78, 0xFF, 0xFC, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x3B, 0x78, 0xC7, 0x8D,
  0x93, 0x66, 0xC5, 0x0E, 0x1C, 0x18, 0xD3, 0xAF, 0x5A, 0xF7, 0xED, 0x9B,
  0x36, 0x6C, 0xC6, 0xCD, 0xB1, 0xC1, 0x87, 0x0B, 0x36, 0xC6, 0xC6, 0x8D,
  0xB1, 0x63, 0x83, 0x04, 0x08, 0x10, 0xFF, 0xF1, 0x84, 0x31, 0x84, 0x30,
  0xFC, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xC2, 0x18, 0xC2, 0x18, 0xC2, 0x18,
  0x40, 0xED, 0xB6, 0xDB, 0x6D, 0xF0, 0x21, 0x9C, 0xBC, 0x80, 0xF8, 0xC4,
  0xFC, 0x5F, 0x99, 0xFC, 0x82, 0x08, 0x3E, 0xCA, 0x38, 0xF6, 0xB8, 0xFE,
  0x61, 0x0C, 0xBC, 0x08, 0x43, 0xFC, 0xC6, 0x3B, 0x78, 0xFB, 0x2F, 0xE0,
  0xC9, 0xE0, 0x3C, 0x86, 0x3E, 0x61, 0x86, 0x18, 0x60, 0xFE, 0x63, 0x1C,
  0xBE, 0x3F, 0x20, 0x82, 0x08, 0x3E, 0x8A, 0x38, 0xE3, 0x8C, 0x31, 0x81,
  0xE3, 0x18, 0xC6, 0xF8, 0x33, 0x07, 0x33, 0x33, 0x33, 0xF4, 0x82, 0x08,
  0x66, 0xB3, 0x8F, 0x26, 0x8C, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC,
  0xFF, 0xAF, 0x5E, 0xBD, 0x7A, 0xC0, 0xFC, 0x63, 0x18, 0xC4, 0xFB, 0x28,
  0xE3, 0xD9, 0xE0, 0xFA, 0x28, 0xE2, 0xDA, 0xE8, 0x20, 0xFE, 0x63, 0x1D,
  0xBC, 0x21, 0xFE, 0x21, 0x08, 0x40, 0xFA, 0x2F, 0x06, 0x8D, 0xE0, 0x63,
  0x3E, 0xC6, 0x31, 0x87, 0xCE, 0x73, 0x9C, 0xBC, 0xC6, 0xC8, 0xB1, 0x43,
  0x83, 0x00, 0xD7, 0xAD, 0xB3, 0x66, 0xCD, 0x80, 0xCD, 0xE3, 0x1C, 0x5B,
  0x30, 0xC6, 0xC8, 0xB1, 0xE3, 0x83, 0x04, 0x38, 0x40, 0xFC, 0x63, 0x18,
  0xC3, 0xF0, 0x36, 0x66, 0x4C, 0x66, 0x66, 0x30, 0xFF, 0xE0, 0xC4, 0x44,
  0x63, 0x64, 0x44, 0xC0, 0x65, 0xFC, 0x30,
};

const GFXglyph RobotoMono_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 9, 7, 3, -9 },
  { 4, 3, 3, 7, 2, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 6, 11, 7, 1, -10 },
  { 23, 7, 9, 7, 0, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 1, 3, 7, 3, -9 },
  { 40, 3, 12, 7, 2, -9 },
  { 45, 3, 12, 7, 2, -9 },
  { 50, 6, 6, 7, 1, -9 },
  { 55, 5, 6, 7, 1, -7 },
  { 59, 2, 3, 7, 2, -1 },
  { 60, 5, 1, 7, 2, -4 },
  { 61, 3, 2, 7, 2, -2 },
  { 62, 5, 10, 7, 1, -9 },
  { 69, 5, 9, 7, 1, -9 },
  { 75, 4, 9, 7, 1, -9 },
  { 80, 6, 9, 7, 0, -9 },
  { 87, 5, 9, 7, 1, -9 },
  { 93, 7, 9, 7, 0, -9 },
  { 101, 5, 9, 7, 1, -9 },
  { 107, 5, 9, 7, 1, -9 },
  { 113, 6, 9, 7, 0, -9 },
  { 120, 5, 9, 7, 1, -9 },
  { 126, 5, 9, 7, 1, -9 },
  { 132, 2, 7, 7, 3, -7 },
  { 134, 2, 9, 7, 3, -7 },
  { 137, 5, 5, 7, 1, -6 },
  { 141, 5, 4, 7, 1, -6 },
  { 144, 5, 5, 7, 1, -6 },
  { 148, 5, 9, 7, 1, -9 },
  { 154, 7, 8, 7, 0, -8 },
  { 161, 7, 9, 7, 0, -9 },
  { 169, 6, 9, 7, 1, -9 },
  { 176, 7, 9, 7, 0, -9 },
  { 184, 6, 9, 7, 1, -9 },
  { 191, 6, 9, 7, 1, -9 },
  { 198, 6, 9, 7, 1, -9 },
  { 205, 6, 9, 7, 1, -9 },
  { 212, 5, 9, 7, 1, -9 },
  { 218, 5, 9, 7, 1, -9 },
  { 224, 5, 9, 7, 1, -9 },
  { 230, 6, 9, 7, 1, -9 },
  { 237, 6, 9, 7, 1, -9 },
  { 244, 6, 9, 7, 1, -9 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 7, 9, 7, 0, -9 },
  { 265, 6, 9, 7, 1, -9 },
  { 272, 7, 11, 7, 0, -9 },
  { 282, 6, 9, 7, 1, -9 },
  { 289, 6, 9, 7, 1, -9 },
  { 296, 7, 9, 7, 0, -9 },
  { 304, 5, 9, 7, 1, -9 },
  { 310, 7, 9, 7, 0, -9 },
  { 318, 7, 9, 7, 0, -9 },
  { 326, 7, 9, 7, 0, -9 },
  { 334, 7, 9, 7, 0, -9 },
  { 342, 6, 9, 7, 1, -9 },
  { 349, 3, 12, 7, 2, -10 },
  { 354, 5, 10, 7, 1, -9 },
  { 361, 3, 12, 7, 2, -10 },
  { 366, 5, 5, 7, 1, -9 },
  { 370, 5, 1, 7, 1, 0 },
  { 371, 3, 2, 7, 2, -9 },
  { 372, 5, 6, 7, 1, -6 },
  { 376, 6, 9, 7, 1, -9 },
  { 383, 5, 6, 7, 1, -6 },
  { 387, 5, 9, 7, 1, -9 },
  { 393, 6, 6, 7, 1, -6 },
  { 398, 6, 9, 7, 1, -9 },
  { 405, 5, 9, 7, 1, -6 },
  { 411, 6, 9, 7, 1, -9 },
  { 418, 5, 9, 7, 1, -9 },
  { 424, 4, 12, 7, 1, -9 },
  { 430, 6, 9, 7, 1, -9 },
  { 437, 6, 9, 7, 1, -9 },
  { 444, 7, 6, 7, 0, -6 },
  { 450, 5, 6, 7, 1, -6 },
  { 454, 6, 6, 7, 1, -6 },
  { 459, 6, 8, 7, 1, -6 },
  { 465, 5, 8, 7, 1, -6 },
  { 470, 5, 6, 7, 2, -6 },
  { 474, 6, 6, 7, 1, -6 },
  { 479, 5, 8, 7, 1, -8 },
  { 484, 5, 6, 7, 1, -6 },
  { 488, 7, 6, 7, 0, -6 },
  { 494, 7, 6, 7, 0, -6 },
  { 500, 6, 6, 7, 1, -6 },
  { 505, 7, 9, 7, 0, -6 },
  { 513, 6, 6, 7, 1, -6 },
  { 518, 4, 11, 7, 2, -9 },
  { 524, 1, 11, 7, 3, -9 },
  { 526, 4, 11, 7, 2, -9 },
  { 532, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_Bold12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold12pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_BOLD12PT7B_H_
