#ifndef _ROBOTOMONO_BOLD16PT7B_H_
#define _ROBOTOMONO_BOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x1B, 0x0D, 0x84, 0x8F, 0xF1,
  0x20, 0xB3, 0xFD, 0xFE, 0x24, 0x12, 0x0B, 0x00, 0x08, 0x18, 0x7E, 0x67,
  0xE3, 0x60, 0x78, 0x3E, 0x07, 0xC3, 0xC3, 0x7F, 0x7E, 0x18, 0x18, 0x20,
  0x38, 0x36, 0xDB, 0x47, 0x40, 0x20, 0x20, 0x16, 0x17, 0x9A, 0x41, 0x20,
  0xF0, 0x10, 0x3E, 0x1B, 0x0D, 0x86, 0xC3, 0xC1, 0xC5, 0xB6, 0xDF, 0x67,
  0xBF, 0x8F, 0x70, 0xF0, 0x13, 0x66, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x63,
  0x10, 0x46, 0x18, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x33, 0x19, 0x98, 0x80,
  0x18, 0x08, 0xEB, 0x7F, 0x18, 0x34, 0x66, 0x24, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x6F, 0x6C, 0xFF, 0xFC, 0x7D, 0x80, 0x0C, 0x61,
  0x86, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x30, 0x10, 0x7C, 0x66, 0xC6, 0xC7,
  0xCF, 0xDF, 0xE7, 0xC6, 0xE6, 0x7E, 0x3C, 0x1F, 0xFE, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x10, 0x7C, 0xEE, 0xC6, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60,
  0xFF, 0xFF, 0x10, 0x7E, 0xE6, 0xC6, 0x06, 0x3E, 0x3C, 0x06, 0x07, 0xC6,
  0xFE, 0x7C, 0x06, 0x07, 0x07, 0x83, 0xC3, 0x61, 0x31, 0x99, 0xFF, 0x7F,
  0x83, 0x01, 0x80, 0x7E, 0x60, 0x60, 0xC0, 0xFE, 0x46, 0x06, 0x07, 0xC6,
  0xFE, 0x7C, 0x3C, 0x70, 0x60, 0xC8, 0xFE, 0xE6, 0xC7, 0xC7, 0xC6, 0x7E,
  0x3C, 0xFF, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60,
  0x10, 0xFB, 0x9E, 0x3C, 0x6F, 0xDF, 0x63, 0xC7, 0x8F, 0xFB, 0xE0, 0x10,
  0xFB, 0xBE, 0x3C, 0x78, 0xFB, 0xBF, 0x06, 0x1D, 0xF3, 0x80, 0x7D, 0x80,
  0x1F, 0x60, 0x67, 0x70, 0x00, 0x06, 0x66, 0x6C, 0x02, 0x1C, 0xFF, 0x8E,
  0x0F, 0x83, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xC3, 0xE0, 0xF0,
  0xEF, 0xBC, 0x40, 0x18, 0x7E, 0xE6, 0xC7, 0x06, 0x0E, 0x1C, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x1F, 0x10, 0x93, 0xAB, 0x5D, 0x2E, 0x97, 0x5B, 0xBE,
  0x4A, 0x31, 0x0F, 0x80, 0x0C, 0x07, 0x81, 0xE0, 0x78, 0x37, 0x0C, 0xC3,
  0x31, 0xFC, 0x7F, 0x98, 0x6E, 0x1C, 0xFE, 0xC7, 0xC3, 0xC3, 0xFE, 0xFE,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0x18, 0x7E, 0xE6, 0xC3, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC3, 0xC7, 0x7E, 0x3C, 0xFC, 0xCE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC7, 0xC6, 0xFE, 0xF8, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x10, 0x7E, 0xE6, 0xC3, 0xC0, 0xC0, 0xCF, 0xCF, 0xC3, 0xC3,
  0x7F, 0x3E, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xFF, 0xC0, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xC6, 0xFE, 0x7C, 0xC7, 0xE3, 0x33,
  0x9B, 0x8F, 0x87, 0xC3, 0xB1, 0x9C, 0xC6, 0x63, 0xB0, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE7, 0xEF, 0xEF,
  0xFB, 0xFB, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0xE7, 0xE7, 0xF7,
  0xD7, 0xDF, 0xDF, 0xCF, 0xCF, 0xC7, 0xC7, 0x10, 0x7C, 0xE6, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x7C, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7,
  0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x10, 0x3F, 0x39, 0x98, 0xEC, 0x36,
  0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x9F, 0x87, 0xC0, 0x78, 0x08, 0xFE, 0xC7,
  0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xCE, 0xC6, 0xC7, 0xC3, 0x08, 0x7E, 0xE7,
  0xC3, 0xE0, 0x78, 0x3E, 0x07, 0xC3, 0xC3, 0xFF, 0x7E, 0xFF, 0x86, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0x7E, 0x7C, 0xE1, 0xB1, 0xD8,
  0xCE, 0x63, 0x31, 0xB8, 0xD8, 0x3C, 0x1E, 0x0E, 0x03, 0x00, 0xCD, 0xE6,
  0xDB, 0x6F, 0xB7, 0xDB, 0xED, 0xDC, 0xEE, 0x77, 0x19, 0x8C, 0xC0, 0xE3,
  0x9C, 0xC3, 0x70, 0x78, 0x1E, 0x07, 0x01, 0xE0, 0xFC, 0x33, 0x1C, 0xEE,
  0x1C, 0xE1, 0xD8, 0xE3, 0x30, 0xDC, 0x1E, 0x07, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x70, 0xE0,
  0xFF, 0xFF, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0x86,
  0x18, 0x30, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0xF7, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0xFF, 0x31, 0xE7, 0x92, 0xCE, 0x30, 0xFF, 0xFC, 0xE6, 0x30,
  0x18, 0x7E, 0xC6, 0x06, 0x7E, 0xE6, 0xC6, 0xFE, 0x7F, 0xC0, 0xC0, 0xC0,
  0xC8, 0xFE, 0xE6, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xDC, 0x18, 0xFF, 0x9E,
  0x3C, 0x18, 0x31, 0xBF, 0x3C, 0x06, 0x0C, 0x19, 0xB7, 0xFC, 0xF1, 0xE3,
  0xC7, 0x8F, 0xFB, 0xF0, 0x18, 0x7E, 0xE6, 0xC3, 0xFF, 0xC0, 0xC2, 0x7F,
  0x3E, 0x1F, 0x1D, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0x7F, 0x7F, 0x06, 0xEE,
  0x7C, 0xC0, 0xC0, 0xC0, 0xCC, 0xFE, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0x30, 0x60, 0x40, 0x0F, 0x06, 0x0C, 0x18, 0x30, 0x63, 0xFF, 0xF0,
  0x11, 0xC4, 0x0F, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x9F, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC1, 0xCE, 0xCC, 0xD8, 0xF8, 0xFC, 0xCE, 0xC6, 0xC7, 0xF1, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x63, 0xFF, 0xF0, 0x16, 0xFF, 0xDB,
  0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0xDB, 0x0C, 0xFE, 0xE7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0x18, 0x7E, 0xE6, 0xC7, 0xC3, 0xC3, 0xC7, 0x7E, 0x7C,
  0x08, 0xFE, 0xE6, 0xC7, 0xC3, 0xC7, 0xC6, 0xFE, 0xDC, 0xC0, 0xC0, 0xC0,
  0x30, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xFF, 0x7E, 0x0C, 0x18, 0x30, 0x0D,
  0xBF, 0xF7, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x18, 0x7E, 0xC7, 0xE0, 0x7C,
  0x1E, 0xC3, 0xE6, 0x7E, 0x30, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x3E, 0x1F, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0x7F, 0x7B, 0xC7,
  0xC6, 0x66, 0x66, 0x6C, 0x3C, 0x38, 0x18, 0xCD, 0xA6, 0xDF, 0x6F, 0xB7,
  0x53, 0xB9, 0xCC, 0x66, 0xE7, 0x6E, 0x3C, 0x18, 0x3C, 0x7E, 0x66, 0xC3,
  0xE1, 0xDC, 0xE3, 0x30, 0xCC, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x06,
  0x07, 0x80, 0xFF, 0x0E, 0x0C, 0x18, 0x30, 0x70, 0xFF, 0xFF, 0x1C, 0x63,
  0x0C, 0x30, 0xCF, 0x38, 0x30, 0xC3, 0x0C, 0x10, 0x70, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC3, 0x18, 0xC6, 0x30, 0xE7, 0x63, 0x18, 0xC6, 0x62, 0x00,
  0x79, 0xEF, 0xD1, 0xC0,
};

const GFXglyph RobotoMono_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 5, 4, 10, 2, -12 },
  { 7, 9, 11, 10, 0, -11 },
  { 20, 8, 15, 10, 1, -13 },
  { 35, 9, 12, 10, 0, -12 },
  { 49, 9, 12, 10, 1, -12 },
  { 63, 1, 4, 10, 4, -12 },
  { 64, 4, 17, 10, 3, -13 },
  { 73, 5, 17, 10, 2, -13 },
  { 84, 8, 8, 10, 1, -11 },
  { 92, 8, 8, 10, 1, -9 },
  { 100, 3, 5, 10, 3, -2 },
  { 102, 7, 2, 10, 2, -6 },
  { 104, 3, 3, 10, 3, -3 },
  { 106, 6, 12, 10, 2, -11 },
  { 115, 8, 12, 10, 1, -12 },
  { 127, 5, 11, 10, 1, -11 },
  { 134, 8, 12, 10, 1, -12 },
  { 146, 8, 12, 10, 1, -12 },
  { 158, 9, 11, 10, 0, -11 },
  { 171, 8, 11, 10, 1, -11 },
  { 182, 8, 11, 10, 1, -11 },
  { 193, 8, 11, 10, 1, -11 },
  { 204, 7, 12, 10, 1, -12 },
  { 215, 7, 12, 10, 1, -12 },
  { 226, 3, 9, 10, 3, -9 },
  { 230, 4, 12, 10, 3, -9 },
  { 236, 7, 8, 10, 1, -9 },
  { 243, 8, 5, 10, 1, -7 },
  { 248, 7, 8, 10, 1, -9 },
  { 255, 8, 12, 10, 1, -12 },
  { 267, 9, 11, 10, 0, -11 },
  { 280, 10, 11, 10, 0, -11 },
  { 294, 8, 11, 10, 1, -11 },
  { 305, 8, 12, 10, 1, -12 },
  { 317, 8, 11, 10, 1, -11 },
  { 328, 8, 11, 10, 1, -11 },
  { 339, 8, 11, 10, 1, -11 },
  { 350, 8, 12, 10, 1, -12 },
  { 362, 8, 11, 10, 1, -11 },
  { 373, 6, 11, 10, 2, -11 },
  { 382, 8, 11, 10, 1, -11 },
  { 393, 9, 11, 10, 1, -11 },
  { 406, 8, 11, 10, 1, -11 },
  { 417, 8, 11, 10, 1, -11 },
  { 428, 8, 11, 10, 1, -11 },
  { 439, 8, 12, 10, 1, -12 },
  { 451, 8, 11, 10, 1, -11 },
  { 462, 9, 14, 10, 1, -12 },
  { 478, 8, 11, 10, 1, -11 },
  { 489, 8, 12, 10, 1, -12 },
  { 501, 9, 11, 10, 0, -11 },
  { 514, 8, 11, 10, 1, -11 },
  { 525, 9, 11, 10, 0, -11 },
  { 538, 9, 11, 10, 0, -11 },
  { 551, 10, 11, 10, 0, -11 },
  { 565, 10, 11, 10, 0, -11 },
  { 579, 8, 11, 10, 1, -11 },
  { 590, 4, 16, 10, 3, -13 },
  { 598, 6, 12, 10, 2, -11 },
  { 607, 4, 16, 10, 3, -13 },
  { 615, 6, 6, 10, 2, -11 },
  { 620, 7, 2, 10, 1, 0 },
  { 622, 4, 3, 10, 3, -12 },
  { 624, 8, 9, 10, 1, -9 },
  { 633, 8, 12, 10, 1, -12 },
  { 645, 7, 9, 10, 1, -9 },
  { 653, 7, 12, 10, 1, -12 },
  { 664, 8, 9, 10, 1, -9 },
  { 673, 8, 12, 10, 1, -12 },
  { 685, 8, 12, 10, 1, -9 },
  { 697, 8, 12, 10, 1, -12 },
  { 709, 7, 12, 10, 2, -12 },
  { 720, 5, 15, 10, 2, -12 },
  { 730, 8, 12, 10, 1, -12 },
  { 742, 7, 12, 10, 2, -12 },
  { 753, 8, 9, 10, 1, -9 },
  { 762, 8, 9, 10, 1, -9 },
  { 771, 8, 9, 10, 1, -9 },
  { 780, 8, 12, 10, 1, -9 },
  { 792, 7, 12, 10, 1, -9 },
  { 803, 7, 9, 10, 2, -9 },
  { 811, 8, 9, 10, 1, -9 },
  { 820, 8, 11, 10, 1, -11 },
  { 831, 8, 8, 10, 1, -8 },
  { 839, 8, 8, 10, 1, -8 },
  { 847, 9, 8, 10, 0, -8 },
  { 856, 8, 8, 10, 1, -8 },
  { 864, 10, 11, 10, 0, -8 },
  { 878, 8, 8, 10, 1, -8 },
  { 886, 6, 15, 10, 2, -12 },
  { 898, 2, 14, 10, 4, -11 },
  { 902, 5, 15, 10, 3, -12 },
  { 912, 9, 3, 10, 0, -6 },
};

const GFXfont RobotoMono_Bold16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold16pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_BOLD16PT7B_H_
