#ifndef _ROBOTOMONO_BOLD59PT7B_H_
#define _ROBOTOMONO_BOLD59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F,
  0x80, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x06, 0x01,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0,
  0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8,
  0x07, 0xE1, 0xF8, 0xF8, 0x01, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xFC, 0x7C,
  0x00, 0x3F, 0xFC, 0x7C, 0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE3, 0xFF, 0x00, 0x03,
  0xE3, 0xFF, 0xC0, 0x01, 0xF3, 0xFF, 0xF0, 0x01, 0xF1, 0xFF, 0xFC, 0x00,
  0xF9, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x1F, 0x00, 0x7C, 0x7C, 0x0F, 0x80,
  0x7C, 0x3E, 0x07, 0xC0, 0x3C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x81, 0xF0,
  0x06, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xC3,
  0xFC, 0xFF, 0x87, 0xF1, 0xFF, 0x1F, 0xF1, 0xFC, 0x7F, 0x87, 0xFC, 0x7F,
  0x3F, 0xE0, 0xFF, 0xBF, 0xCF, 0xF0, 0x1F, 0xFF, 0xE3, 0xFC, 0x03, 0xFF,
  0xF8, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF, 0x0F, 0xF8, 0x03,
  0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x0F, 0xFC,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x0E, 0x00, 0x06, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x07,
  0xC0, 0x10, 0xF0, 0x1F, 0x01, 0xC7, 0xF8, 0x78, 0x3F, 0x9F, 0xF9, 0xE3,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFE, 0x0F,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0x07, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7,
  0xF0, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFE,
  0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF,
  0xCF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE,
  0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x7F,
  0xC0, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x03,
  0xFD, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01,
  0xFD, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC,
  0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x04, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xF0, 0x0C, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xF3, 0xFF, 0xC0, 0x7F, 0x3F,
  0xFF, 0x07, 0xFB, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xDF, 0xFE, 0x7F, 0xF0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xDF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0x07,
  0xFE, 0x3F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x7F,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x7F,
  0xC0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x03, 0xFF,
  0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFE, 0x01, 0xFF, 0x9F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0x0F, 0xF3, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x0F, 0xF3, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7,
  0xF0, 0x10, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFE, 0x3F, 0xE1, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x07, 0xC0, 0xFF, 0xC7, 0xC3, 0xE0, 0xFF, 0xF1, 0xE3, 0xE0,
  0xFF, 0xF8, 0xF1, 0xF0, 0xFF, 0xFC, 0x78, 0xF0, 0x7C, 0x3C, 0x3E, 0xF8,
  0x7C, 0x1E, 0x1F, 0x7C, 0x3E, 0x0F, 0x0F, 0xBE, 0x3E, 0x07, 0x87, 0xDE,
  0x1F, 0x03, 0xC3, 0xFF, 0x0F, 0x81, 0xE1, 0xFF, 0x87, 0xC1, 0xF0, 0xFF,
  0xC3, 0xE0, 0xF8, 0x7B, 0xE3, 0xE0, 0x7C, 0x3D, 0xF1, 0xF0, 0x3E, 0x1E,
  0xF8, 0xF8, 0x1F, 0x0F, 0x7C, 0x7E, 0x0F, 0x87, 0xBE, 0x1F, 0x07, 0x87,
  0x9F, 0x0F, 0x87, 0xC3, 0xC7, 0x87, 0xE7, 0xF3, 0xE3, 0xE3, 0xFF, 0xFF,
  0xE1, 0xF0, 0xFF, 0xBF, 0xE0, 0xF8, 0x3F, 0xDF, 0xE0, 0x7E, 0x0F, 0x83,
  0xE0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC, 0xFF, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFB,
  0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x01,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFE,
  0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xF0,
  0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE,
  0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0xDF,
  0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x3F, 0xC0,
  0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xF7, 0xF8,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFE, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFC,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF9, 0xF7, 0xFF, 0xEF, 0xBF, 0x7F, 0xFE, 0xFB, 0xF7,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFE, 0xFF, 0xE7, 0xFF, 0xE7, 0xFE, 0x7F, 0xFE,
  0x7F, 0xE7, 0xFF, 0xE7, 0xFC, 0x7F, 0xFE, 0x7F, 0xC7, 0xFF, 0xE3, 0xFC,
  0x7F, 0xFE, 0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF,
  0xE1, 0xF0, 0x7F, 0xFE, 0x1F, 0x07, 0xFF, 0xE1, 0xF0, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xEF, 0xC3, 0xFF,
  0xFD, 0xFC, 0x7F, 0xFF, 0x9F, 0x8F, 0xFF, 0xF3, 0xF9, 0xFF, 0xFE, 0x3F,
  0x3F, 0xFF, 0xC7, 0xE7, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE,
  0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0xBF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x39, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xF8,
  0xFF, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F,
  0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x0F,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFE,
  0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF,
  0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFF, 0x01, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x3F,
  0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFB, 0xFC, 0x1F, 0xC0,
  0xFE, 0xFF, 0x07, 0xF0, 0x3F, 0xBF, 0xC1, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F,
  0x03, 0xF9, 0xFC, 0x1F, 0xE1, 0xFE, 0x7F, 0x07, 0xF8, 0x7F, 0x9F, 0xC3,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x87, 0xF1, 0xFE, 0x3F, 0xE1, 0xFC, 0x7F,
  0x8F, 0xF8, 0x7F, 0x0F, 0xE3, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0xC7, 0xF0,
  0xFE, 0x3F, 0xF3, 0xFC, 0x3F, 0x9F, 0xFC, 0xFE, 0x0F, 0xE7, 0xFF, 0x3F,
  0x83, 0xF9, 0xF7, 0xCF, 0xE0, 0xFE, 0x7D, 0xF3, 0xF8, 0x1F, 0xDF, 0x7E,
  0xFE, 0x07, 0xF7, 0xDF, 0xBF, 0x81, 0xFD, 0xF7, 0xEF, 0xE0, 0x7F, 0xFC,
  0xFF, 0xF8, 0x1F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x07,
  0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF8,
  0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xF8,
  0x3F, 0xFF, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0x0F, 0xF1, 0xFF, 0x80,
  0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFE, 0x07, 0xFE,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0x3F, 0xFE, 0x0F, 0xF1, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF7, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xFC, 0x00,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x3E, 0x0F, 0xF0, 0x1F, 0xF8, 0xFF, 0x03, 0xFF,
  0xEF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F,
  0x03, 0xFF, 0xE7, 0xF0, 0x1F, 0xF8, 0x7F, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x30, 0x3F, 0xF0, 0x01, 0xE0, 0xFF, 0xE0, 0x1F,
  0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFD,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0x3F, 0xE0, 0x0F, 0xFB, 0xFE,
  0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x81, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0x9F, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0x0C,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0x00, 0x03, 0xFC, 0x0C, 0x00, 0x3F,
  0xE0, 0xF0, 0x03, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0x0F, 0xF7,
  0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xEF, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x00, 0xFF, 0xC3, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0x0F, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x0F,
  0xF3, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xFE,
  0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0x0F,
  0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xF3, 0xFC,
  0x00, 0x7F, 0xEF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x01,
  0xC1, 0xFC, 0x7F, 0x1F, 0xE3, 0xF9, 0xFF, 0x7F, 0xE7, 0xF7, 0xFE, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0,
  0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83,
  0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F,
  0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0x0F,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF1,
  0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF1, 0xFF, 0x80,
  0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xFE, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0x7F, 0xFC, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x03, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0x03, 0xFF,
  0xE7, 0xF0, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xEF, 0xF0, 0x1F, 0xF8, 0xFF, 0x00, 0x08, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFC, 0x0E, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0,
  0x7F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x60, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xF7, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xCF, 0xF0, 0xFF,
  0xF8, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x83, 0xF9, 0xFC,
  0x1F, 0xC1, 0xFC, 0xFE, 0x1F, 0xE0, 0xFE, 0x7F, 0x0F, 0xF8, 0x7E, 0x1F,
  0x87, 0xFC, 0x7F, 0x0F, 0xC3, 0xFE, 0x3F, 0x87, 0xF1, 0xFF, 0x1F, 0xC3,
  0xF9, 0xF7, 0x8F, 0xE1, 0xFC, 0xFB, 0xE7, 0xF0, 0xFE, 0x7D, 0xF3, 0xF0,
  0x3F, 0x3C, 0xF9, 0xF8, 0x1F, 0x9E, 0x7C, 0xFC, 0x0F, 0xDF, 0x1E, 0xFE,
  0x07, 0xEF, 0x8F, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x3F,
  0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xFE, 0xF8,
  0x01, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_Bold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 42, 35, 13, -42 },
  { 49, 18, 15, 35, 8, -44 },
  { 83, 32, 42, 35, 1, -42 },
  { 251, 29, 55, 35, 4, -49 },
  { 451, 33, 44, 35, 1, -43 },
  { 633, 34, 44, 35, 2, -43 },
  { 820, 6, 15, 35, 13, -44 },
  { 832, 16, 60, 35, 10, -47 },
  { 952, 16, 60, 35, 9, -47 },
  { 1072, 30, 30, 35, 4, -42 },
  { 1185, 29, 31, 35, 3, -35 },
  { 1298, 10, 19, 35, 10, -7 },
  { 1322, 24, 7, 35, 8, -22 },
  { 1343, 11, 11, 35, 12, -10 },
  { 1359, 24, 46, 35, 6, -42 },
  { 1497, 27, 44, 35, 4, -43 },
  { 1646, 19, 42, 35, 5, -42 },
  { 1746, 29, 43, 35, 2, -43 },
  { 1902, 29, 44, 35, 3, -43 },
  { 2062, 30, 42, 35, 2, -42 },
  { 2220, 29, 43, 35, 3, -42 },
  { 2376, 29, 43, 35, 3, -42 },
  { 2532, 29, 42, 35, 2, -42 },
  { 2685, 28, 44, 35, 3, -43 },
  { 2839, 28, 43, 35, 3, -43 },
  { 2990, 11, 35, 35, 13, -34 },
  { 3039, 12, 46, 35, 13, -34 },
  { 3108, 26, 28, 35, 4, -32 },
  { 3199, 27, 19, 35, 5, -27 },
  { 3264, 26, 28, 35, 5, -32 },
  { 3355, 27, 43, 35, 5, -43 },
  { 3501, 33, 42, 35, 1, -42 },
  { 3675, 34, 42, 35, 1, -42 },
  { 3854, 30, 42, 35, 4, -42 },
  { 4012, 31, 44, 35, 2, -43 },
  { 4183, 29, 42, 35, 4, -42 },
  { 4336, 29, 42, 35, 4, -42 },
  { 4489, 29, 42, 35, 4, -42 },
  { 4642, 31, 44, 35, 2, -43 },
  { 4813, 27, 42, 35, 4, -42 },
  { 4955, 24, 42, 35, 6, -42 },
  { 5081, 29, 43, 35, 3, -42 },
  { 5237, 32, 42, 35, 4, -42 },
  { 5405, 28, 42, 35, 4, -42 },
  { 5552, 28, 42, 35, 4, -42 },
  { 5699, 27, 42, 35, 4, -42 },
  { 5841, 31, 44, 35, 2, -43 },
  { 6012, 30, 42, 35, 4, -42 },
  { 6170, 33, 50, 35, 2, -43 },
  { 6377, 31, 42, 35, 4, -42 },
  { 6540, 31, 44, 35, 3, -43 },
  { 6711, 34, 42, 35, 1, -42 },
  { 6890, 28, 43, 35, 4, -42 },
  { 7041, 34, 42, 35, 1, -42 },
  { 7220, 34, 42, 35, 1, -42 },
  { 7399, 34, 42, 35, 1, -42 },
  { 7578, 34, 42, 35, 1, -42 },
  { 7757, 30, 42, 35, 3, -42 },
  { 7915, 12, 59, 35, 12, -49 },
  { 8004, 23, 46, 35, 7, -42 },
  { 8137, 12, 59, 35, 12, -49 },
  { 8226, 24, 22, 35, 6, -42 },
  { 8292, 27, 6, 35, 4, 0 },
  { 8313, 14, 8, 35, 12, -43 },
  { 8327, 29, 33, 35, 3, -32 },
  { 8447, 28, 45, 35, 4, -44 },
  { 8605, 28, 33, 35, 3, -32 },
  { 8721, 28, 45, 35, 3, -44 },
  { 8879, 30, 33, 35, 3, -32 },
  { 9003, 29, 46, 35, 4, -46 },
  { 9170, 29, 44, 35, 3, -32 },
  { 9330, 28, 44, 35, 4, -44 },
  { 9484, 26, 43, 35, 6, -43 },
  { 9624, 19, 56, 35, 6, -43 },
  { 9757, 30, 44, 35, 4, -44 },
  { 9922, 26, 44, 35, 6, -44 },
  { 10065, 31, 32, 35, 2, -32 },
  { 10189, 28, 32, 35, 4, -32 },
  { 10301, 29, 33, 35, 3, -32 },
  { 10421, 28, 44, 35, 4, -32 },
  { 10575, 28, 44, 35, 3, -32 },
  { 10729, 24, 32, 35, 8, -32 },
  { 10825, 28, 33, 35, 4, -32 },
  { 10941, 28, 40, 35, 4, -39 },
  { 11081, 28, 32, 35, 4, -31 },
  { 11193, 31, 31, 35, 2, -31 },
  { 11314, 33, 31, 35, 1, -31 },
  { 11442, 31, 31, 35, 3, -31 },
  { 11563, 34, 44, 35, 1, -31 },
  { 11750, 30, 31, 35, 3, -31 },
  { 11867, 19, 56, 35, 9, -46 },
  { 12000, 5, 54, 35, 15, -42 },
  { 12034, 19, 56, 35, 10, -46 },
  { 12167, 32, 13, 35, 1, -24 },
};

const GFXfont RobotoMono_Bold59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold59pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_BOLD59PT7B_H_
