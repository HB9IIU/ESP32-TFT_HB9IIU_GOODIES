#ifndef _ROBOTOMONO_BOLD70PT7B_H_
#define _ROBOTOMONO_BOLD70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold70pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFF, 0x7F, 0xE7,
  0xFE, 0x7F, 0xC3, 0xF8, 0x04, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x3F, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x18, 0x00, 0xFE, 0x07, 0xF0, 0x1E,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0xF8, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x00,
  0x7F, 0x9F, 0xE3, 0xF0, 0x00, 0x7F, 0xFF, 0xE3, 0xF0, 0x00, 0x3F, 0xFF,
  0xC7, 0xE0, 0x00, 0x1F, 0xFF, 0x87, 0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xF0, 0x00, 0x03, 0xF1, 0xFF,
  0xF8, 0x00, 0x07, 0xE3, 0xFF, 0xFC, 0x00, 0x07, 0xE7, 0xFF, 0xFE, 0x00,
  0x0F, 0xC7, 0xFF, 0xFE, 0x00, 0x0F, 0x87, 0xF0, 0xFE, 0x00, 0x1F, 0x8F,
  0xE0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x7F,
  0x00, 0x7E, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x7F, 0x00, 0x3C,
  0x0F, 0xE0, 0x7F, 0x00, 0x0C, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0xFF,
  0xC0, 0x7F, 0x9F, 0xFD, 0xFF, 0xC1, 0xFF, 0x3F, 0xF1, 0xFF, 0xC3, 0xFC,
  0xFF, 0xC1, 0xFF, 0xC7, 0xF9, 0xFF, 0x81, 0xFF, 0x9F, 0xF3, 0xFE, 0x03,
  0xFF, 0xBF, 0xE7, 0xFC, 0x03, 0xFF, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0xFF,
  0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xE0,
  0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x1F, 0xFC, 0x01,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x07, 0xE0, 0x06, 0x1F, 0x80, 0xFC, 0x03, 0xE7, 0xFC, 0x1F, 0x83,
  0xFC, 0xFF, 0xE3, 0xE1, 0xFF, 0x9F, 0xFF, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE1,
  0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0x1E, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1F, 0xFE,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF,
  0x07, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0xFF,
  0x9F, 0xF1, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF8, 0x07, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xFC,
  0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x78, 0x00, 0x0F, 0xFB, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x07,
  0xFF, 0x81, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0xBF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0xCF,
  0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFB, 0xFE,
  0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x01, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x9F, 0xFC, 0x7F,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0xC7, 0xFC, 0x07, 0x00,
  0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x3C, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xE0, 0x7E, 0x03, 0xFF, 0x87, 0xE1,
  0xF8, 0x0F, 0xFF, 0xC7, 0xC3, 0xF0, 0x3F, 0xFF, 0x0F, 0x87, 0xC0, 0xFF,
  0xFE, 0x1F, 0x9F, 0x83, 0xFE, 0x7C, 0x3F, 0x3F, 0x07, 0xF0, 0xF8, 0x3E,
  0x7C, 0x1F, 0xC1, 0xF0, 0x7D, 0xF8, 0x3F, 0x03, 0xE0, 0xFB, 0xF0, 0xFC,
  0x07, 0xC1, 0xF7, 0xE1, 0xF8, 0x0F, 0x83, 0xEF, 0x83, 0xF0, 0x3F, 0x07,
  0xDF, 0x07, 0xE0, 0x7E, 0x0F, 0xBE, 0x1F, 0x80, 0xFC, 0x1F, 0xFC, 0x3F,
  0x01, 0xF8, 0x3F, 0xF8, 0x7E, 0x03, 0xE0, 0x7F, 0xF0, 0xFC, 0x07, 0xC1,
  0xF7, 0xE1, 0xF8, 0x0F, 0x83, 0xEF, 0xC3, 0xF0, 0x1F, 0x07, 0xDF, 0x87,
  0xE0, 0x3E, 0x0F, 0x9F, 0x0F, 0xE0, 0x7C, 0x3E, 0x3E, 0x1F, 0xC1, 0xF8,
  0x7C, 0x7E, 0x1F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0xF7, 0xFF, 0x03, 0xF0, 0x7F, 0xCF,
  0xFC, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x02, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x40, 0x00, 0x3F, 0xF8, 0x0F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFC, 0x00,
  0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F,
  0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xC3,
  0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xC7,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xF3,
  0xFF, 0x00, 0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x07, 0xFF, 0x8F, 0xFC, 0x00,
  0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xF0,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x7F,
  0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xF0,
  0x00, 0x1F, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F,
  0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xEF, 0xFF, 0xFF, 0xF3, 0xFB,
  0xFF, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xBF, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF,
  0xCF, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xF0, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0xFE, 0x0F, 0xC0,
  0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0xFF, 0xE0, 0x78, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xFE, 0xFF, 0x07,
  0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0x9F, 0xE1, 0xFF, 0xFF, 0xC7, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0x9F, 0xFF, 0xFC, 0x3F, 0xCF, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF, 0x07,
  0xFB, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0,
  0x0F, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xF3, 0xFF,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0xC1,
  0xFF, 0x01, 0xFE, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x83,
  0xFE, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x3F,
  0xC1, 0xFF, 0x83, 0xFE, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF,
  0x83, 0xFC, 0x3F, 0xE3, 0xFF, 0xC3, 0xFC, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC,
  0x3F, 0xE3, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC, 0x1F, 0xE3,
  0xFF, 0xC7, 0xFC, 0x1F, 0xE3, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xFF, 0xE7,
  0xF8, 0x1F, 0xE7, 0xFF, 0xE7, 0xF8, 0x1F, 0xE7, 0xFF, 0xE7, 0xF8, 0x1F,
  0xF7, 0xE7, 0xEF, 0xF8, 0x1F, 0xF7, 0xE7, 0xEF, 0xF8, 0x1F, 0xF7, 0xE7,
  0xEF, 0xF8, 0x0F, 0xF7, 0xE7, 0xEF, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x3F,
  0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x80,
  0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xC7, 0xFF,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF7, 0xFE, 0x07, 0xFF,
  0xF9, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xE7, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8,
  0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F,
  0xEF, 0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xEF, 0xFF, 0xFC, 0x1F, 0xF3, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xF0,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0x03, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xFC,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8,
  0x1F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0x1F, 0xF0, 0x07, 0xFF,
  0x0F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x07, 0xFF, 0x00, 0x01,
  0xE0, 0x7F, 0xF8, 0x00, 0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xCF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x1F, 0xF7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xF8,
  0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0xF0, 0x1F,
  0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x87, 0xFC, 0x00, 0x1C, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x81, 0x00, 0x00, 0xFF, 0xC1,
  0xC0, 0x00, 0xFF, 0xE1, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x78, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0xF8, 0x3F,
  0xE3, 0xFF, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF0, 0x3F, 0xFE,
  0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF8,
  0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0x00,
  0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0x9F, 0xFE,
  0x00, 0x0F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x0F, 0xFF,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF8,
  0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x0F, 0xF1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x3F, 0xF1, 0xFF, 0xCF, 0xF7, 0xFF, 0xBF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xC1,
  0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1,
  0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1,
  0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1,
  0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0x0F,
  0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0xF0, 0x03, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC3,
  0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xE0,
  0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF7, 0xFF, 0xFC, 0x0F, 0xF9,
  0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x03, 0xFE, 0x01, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xF0, 0x3F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xDF, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x1C, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x2F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x38, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xFE, 0x3F, 0xE0,
  0xFF, 0xFE, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x01,
  0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFB, 0xFC,
  0x07, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF0, 0x3F, 0xEF, 0xF0, 0x3F, 0xE0,
  0x7F, 0x9F, 0xE0, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x7F,
  0xC1, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xFE,
  0x1F, 0xF1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0xF0, 0xFF, 0x07, 0xF0, 0xFB, 0xE1, 0xFE, 0x0F, 0xF1, 0xF7,
  0xE3, 0xFC, 0x1F, 0xE7, 0xEF, 0xC7, 0xF0, 0x3F, 0xCF, 0xDF, 0x9F, 0xE0,
  0x7F, 0x9F, 0x9F, 0x3F, 0xC0, 0xFF, 0x3E, 0x3E, 0x7F, 0x80, 0xFE, 0x7C,
  0x7E, 0xFF, 0x01, 0xFC, 0xF8, 0xFD, 0xFE, 0x03, 0xFB, 0xF1, 0xFB, 0xF8,
  0x07, 0xFF, 0xE1, 0xF7, 0xF0, 0x0F, 0xFF, 0x83, 0xEF, 0xE0, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x40, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xC7, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0xFF, 0xF8, 0x01,
  0xFD, 0xFF, 0xFF, 0xF0, 0x0F, 0xF7, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFF,
  0xCF, 0xE0, 0x07, 0xFF, 0xFF, 0x3F, 0x00, 0x0F, 0xFF, 0xF8, 0x7C, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00,
};

const GFXglyph RobotoMono_Bold70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 12, 51, 42, 15, -50 },
  { 78, 21, 19, 42, 10, -53 },
  { 128, 39, 50, 42, 1, -50 },
  { 372, 35, 65, 42, 4, -58 },
  { 657, 40, 51, 42, 1, -50 },
  { 912, 39, 51, 42, 3, -50 },
  { 1161, 7, 19, 42, 16, -53 },
  { 1178, 19, 71, 42, 12, -55 },
  { 1347, 19, 71, 42, 11, -55 },
  { 1516, 35, 35, 42, 5, -50 },
  { 1670, 35, 36, 42, 3, -41 },
  { 1828, 12, 22, 42, 12, -8 },
  { 1861, 28, 8, 42, 10, -26 },
  { 1889, 14, 13, 42, 14, -12 },
  { 1912, 27, 54, 42, 8, -50 },
  { 2095, 32, 51, 42, 5, -50 },
  { 2299, 22, 50, 42, 6, -50 },
  { 2437, 35, 50, 42, 2, -50 },
  { 2656, 34, 51, 42, 3, -50 },
  { 2873, 36, 50, 42, 2, -50 },
  { 3098, 33, 51, 42, 4, -50 },
  { 3309, 34, 51, 42, 4, -50 },
  { 3526, 35, 50, 42, 2, -50 },
  { 3745, 33, 51, 42, 4, -50 },
  { 3956, 34, 50, 42, 3, -50 },
  { 4169, 13, 41, 42, 15, -40 },
  { 4236, 14, 54, 42, 15, -40 },
  { 4331, 31, 33, 42, 5, -38 },
  { 4459, 33, 22, 42, 5, -32 },
  { 4550, 31, 33, 42, 5, -38 },
  { 4678, 33, 50, 42, 5, -50 },
  { 4885, 39, 49, 42, 1, -49 },
  { 5124, 41, 50, 42, 1, -50 },
  { 5381, 36, 50, 42, 4, -50 },
  { 5606, 36, 51, 42, 3, -50 },
  { 5836, 35, 50, 42, 4, -50 },
  { 6055, 34, 50, 42, 5, -50 },
  { 6268, 34, 50, 42, 5, -50 },
  { 6481, 36, 51, 42, 3, -50 },
  { 6711, 33, 50, 42, 4, -50 },
  { 6918, 28, 50, 42, 7, -50 },
  { 7093, 34, 51, 42, 4, -50 },
  { 7310, 39, 50, 42, 4, -50 },
  { 7554, 33, 50, 42, 5, -50 },
  { 7761, 34, 50, 42, 4, -50 },
  { 7974, 33, 50, 42, 4, -50 },
  { 8181, 36, 51, 42, 3, -50 },
  { 8411, 35, 50, 42, 5, -50 },
  { 8630, 39, 59, 42, 3, -50 },
  { 8918, 37, 50, 42, 4, -50 },
  { 9150, 37, 51, 42, 3, -50 },
  { 9386, 40, 50, 42, 1, -50 },
  { 9636, 34, 51, 42, 4, -50 },
  { 9853, 40, 50, 42, 1, -50 },
  { 10103, 40, 50, 42, 1, -50 },
  { 10353, 41, 50, 42, 1, -50 },
  { 10610, 41, 50, 42, 1, -50 },
  { 10867, 36, 50, 42, 3, -50 },
  { 11092, 15, 69, 42, 14, -58 },
  { 11222, 28, 54, 42, 8, -50 },
  { 11411, 15, 69, 42, 14, -58 },
  { 11541, 29, 27, 42, 7, -50 },
  { 11639, 31, 7, 42, 5, 0 },
  { 11667, 17, 10, 42, 14, -51 },
  { 11689, 34, 39, 42, 4, -38 },
  { 11855, 33, 54, 42, 5, -53 },
  { 12078, 33, 39, 42, 4, -38 },
  { 12239, 33, 54, 42, 4, -53 },
  { 12462, 35, 39, 42, 4, -38 },
  { 12633, 35, 54, 42, 4, -54 },
  { 12870, 33, 53, 42, 4, -38 },
  { 13089, 33, 53, 42, 5, -53 },
  { 13308, 31, 52, 42, 7, -52 },
  { 13510, 22, 67, 42, 8, -52 },
  { 13695, 36, 53, 42, 5, -53 },
  { 13934, 31, 53, 42, 7, -53 },
  { 14140, 36, 38, 42, 3, -38 },
  { 14311, 33, 38, 42, 5, -38 },
  { 14468, 34, 39, 42, 4, -38 },
  { 14634, 33, 52, 42, 5, -38 },
  { 14849, 33, 52, 42, 4, -38 },
  { 15064, 28, 38, 42, 10, -38 },
  { 15197, 34, 39, 42, 4, -38 },
  { 15363, 34, 47, 42, 4, -46 },
  { 15563, 33, 38, 42, 5, -37 },
  { 15720, 38, 37, 42, 2, -37 },
  { 15896, 39, 37, 42, 1, -37 },
  { 16077, 38, 37, 42, 3, -37 },
  { 16253, 40, 52, 42, 2, -37 },
  { 16513, 35, 37, 42, 4, -37 },
  { 16675, 22, 67, 42, 11, -55 },
  { 16860, 6, 64, 42, 18, -50 },
  { 16908, 23, 67, 42, 11, -55 },
  { 17101, 38, 15, 42, 1, -28 },
};

const GFXfont RobotoMono_Bold70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold70pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_BOLD70PT7B_H_
