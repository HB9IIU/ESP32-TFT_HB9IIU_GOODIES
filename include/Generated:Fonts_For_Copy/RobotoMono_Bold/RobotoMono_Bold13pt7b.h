#ifndef _ROBOTOMONO_BOLD13PT7B_H_
#define _ROBOTOMONO_BOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xBB, 0xBB, 0x14, 0x29, 0xF9, 0x22, 0xDF, 0xCA,
  0x14, 0x48, 0x10, 0x47, 0xB3, 0xCF, 0x83, 0x83, 0xCF, 0x37, 0x84, 0xF0,
  0x94, 0xFC, 0x68, 0x10, 0x16, 0x2B, 0x2B, 0x0E, 0x3C, 0x6C, 0x6C, 0x38,
  0x33, 0x7B, 0xCE, 0x6E, 0x7F, 0xF0, 0x36, 0x44, 0xCC, 0xCC, 0xC4, 0x62,
  0x10, 0x84, 0x62, 0x23, 0x33, 0x22, 0x6C, 0x80, 0x12, 0x5F, 0xCC, 0x69,
  0x30, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x6D, 0x64, 0xFF, 0xC0, 0xF0,
  0x0C, 0x61, 0x84, 0x30, 0xC2, 0x18, 0x43, 0x00, 0x7B, 0x3C, 0xF7, 0xFF,
  0x3C, 0xF3, 0x78, 0x3F, 0xB3, 0x33, 0x33, 0x30, 0x7C, 0xCF, 0x18, 0x60,
  0xC3, 0x0C, 0x30, 0x7E, 0xFB, 0x30, 0xC6, 0x38, 0x38, 0xF3, 0x78, 0x0C,
  0x38, 0x71, 0x66, 0xC9, 0xBF, 0x86, 0x0C, 0xFF, 0x0C, 0x3E, 0xCC, 0x38,
  0xF3, 0x78, 0x39, 0x8C, 0x2E, 0xCE, 0x3C, 0xF3, 0x78, 0xFE, 0x0C, 0x30,
  0x60, 0x83, 0x04, 0x18, 0x70, 0x7B, 0x3C, 0xF6, 0x7B, 0x38, 0xF3, 0x78,
  0x7B, 0x28, 0xE3, 0xDD, 0xF0, 0x8E, 0x70, 0xF0, 0x3C, 0xF0, 0x3F, 0xE0,
  0x0C, 0xFE, 0x38, 0x3C, 0x30, 0xFC, 0x00, 0x3F, 0x83, 0xC3, 0xC7, 0xF2,
  0x00, 0x7B, 0x30, 0xC3, 0x18, 0xC0, 0x0C, 0x30, 0x3C, 0x85, 0x7D, 0x3A,
  0xB5, 0x7D, 0xA0, 0x3C, 0x18, 0x18, 0x3C, 0x3C, 0x24, 0x66, 0x7E, 0x46,
  0xC3, 0xFF, 0x3C, 0xF3, 0xFF, 0x1C, 0x73, 0xF8, 0x3C, 0xCD, 0x1A, 0x0C,
  0x08, 0x11, 0xB3, 0x3C, 0xFB, 0x7C, 0xF3, 0xCF, 0x3C, 0xF6, 0xF0, 0xFF,
  0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30,
  0xC0, 0x7B, 0x38, 0xE0, 0x9E, 0x7C, 0xF3, 0x78, 0xCF, 0x3C, 0xF3, 0xFF,
  0x3C, 0xF3, 0xCC, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x0C, 0x30,
  0xC3, 0x0C, 0x3C, 0xF3, 0x78, 0xCF, 0xBB, 0x67, 0x8F, 0x1B, 0x36, 0x66,
  0xC6, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0xCF, 0x7F, 0x6D, 0xB6,
  0xB8, 0xE3, 0x8C, 0xCF, 0x3E, 0xFB, 0xFF, 0x7D, 0xF7, 0xCC, 0x7B, 0x38,
  0xE3, 0x8E, 0x38, 0xF3, 0x78, 0xFB, 0x3C, 0x73, 0xFF, 0xCC, 0x30, 0xC0,
  0x79, 0x9A, 0x34, 0x28, 0x50, 0xA3, 0x66, 0x7C, 0x1C, 0x10, 0xF9, 0x9B,
  0x16, 0x6F, 0xDF, 0x36, 0x66, 0xCE, 0x7F, 0x3C, 0x38, 0x78, 0x38, 0x73,
  0x78, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0x78, 0xC7, 0x66, 0x66, 0x64, 0x2C, 0x3C, 0x3C,
  0x18, 0x18, 0xDB, 0xDA, 0x5A, 0x5A, 0x5E, 0x7E, 0x6E, 0x66, 0x64, 0xE7,
  0x66, 0x3C, 0x3C, 0x18, 0x3C, 0x3C, 0x66, 0xE7, 0xC7, 0x66, 0x24, 0x3C,
  0x38, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x31, 0x84, 0x31, 0x84, 0x30, 0xFC,
  0xFA, 0xAA, 0xAA, 0xC0, 0x86, 0x30, 0x86, 0x10, 0xC6, 0x10, 0xC0, 0xF5,
  0x55, 0x55, 0xC0, 0x30, 0xC7, 0x92, 0xCC, 0xFC, 0xE0, 0x7B, 0x70, 0xFF,
  0xCF, 0x7F, 0xC0, 0xC3, 0x0C, 0x3E, 0xDF, 0x3C, 0xF3, 0xCF, 0xE0, 0x7B,
  0x7C, 0xF0, 0xC3, 0x37, 0x80, 0x0C, 0x30, 0xDF, 0xDF, 0x38, 0xF3, 0xCD,
  0xF0, 0x7B, 0xFC, 0xFF, 0xC3, 0x37, 0x80, 0x1C, 0xD2, 0x3F, 0x20, 0x82,
  0x08, 0x20, 0x80, 0x7F, 0xFC, 0xE3, 0xCF, 0x37, 0xC3, 0xF9, 0xC0, 0xC3,
  0x0C, 0x3E, 0xDF, 0x3C, 0xF3, 0xCF, 0x30, 0x10, 0xC0, 0x3C, 0xF0, 0xC3,
  0x0C, 0x33, 0xF0, 0x10, 0xC0, 0xE7, 0x08, 0x42, 0x10, 0x85, 0xEE, 0x00,
  0xC1, 0x83, 0x06, 0x6D, 0x9E, 0x3C, 0x6C, 0xD9, 0x9C, 0xF3, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x33, 0xF0, 0xF7, 0xBF, 0x6E, 0xDD, 0xBB, 0x76, 0x80,
  0xFB, 0x7C, 0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x7C, 0xE3, 0xCF, 0x37, 0x80,
  0xFB, 0x7C, 0xF3, 0xCF, 0x3F, 0xB0, 0xC3, 0x00, 0x7F, 0x7C, 0xE3, 0xCF,
  0x37, 0xC3, 0x0C, 0x30, 0xBF, 0xF1, 0x8C, 0x63, 0x00, 0x7B, 0x3C, 0x1E,
  0x0F, 0x37, 0x80, 0x61, 0x8F, 0xD8, 0x61, 0x86, 0x1D, 0x3C, 0xCF, 0x3C,
  0xF3, 0xCF, 0x37, 0xC0, 0xC6, 0xCD, 0x91, 0x63, 0xC3, 0x06, 0x00, 0xD3,
  0xDA, 0x5A, 0x5E, 0x6E, 0x6E, 0x64, 0xCC, 0x99, 0xE1, 0x87, 0x8D, 0xB3,
  0x80, 0xC3, 0x66, 0x66, 0x34, 0x3C, 0x18, 0x18, 0x18, 0x70, 0x60, 0xFF,
  0xF1, 0x8C, 0x63, 0x0F, 0xC0, 0x32, 0x22, 0x6E, 0xC6, 0x22, 0x23, 0xFF,
  0xF0, 0xC6, 0x66, 0x63, 0x36, 0x66, 0x6C, 0x73, 0xBC, 0x10,
};

const GFXglyph RobotoMono_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 12, 8, 1, -11 },
  { 23, 8, 9, 8, 0, -9 },
  { 32, 8, 9, 8, 0, -9 },
  { 41, 1, 4, 8, 3, -10 },
  { 42, 4, 13, 8, 2, -10 },
  { 49, 4, 13, 8, 2, -10 },
  { 56, 6, 6, 8, 1, -9 },
  { 61, 6, 7, 8, 1, -8 },
  { 67, 3, 5, 8, 2, -2 },
  { 69, 5, 2, 8, 2, -5 },
  { 71, 2, 2, 8, 3, -2 },
  { 72, 6, 10, 8, 1, -9 },
  { 80, 6, 9, 8, 1, -9 },
  { 87, 4, 9, 8, 1, -9 },
  { 92, 7, 9, 8, 0, -9 },
  { 100, 6, 9, 8, 1, -9 },
  { 107, 7, 9, 8, 0, -9 },
  { 115, 6, 9, 8, 1, -9 },
  { 122, 6, 9, 8, 1, -9 },
  { 129, 7, 9, 8, 0, -9 },
  { 137, 6, 9, 8, 1, -9 },
  { 144, 6, 9, 8, 1, -9 },
  { 151, 2, 7, 8, 3, -7 },
  { 153, 2, 10, 8, 3, -7 },
  { 156, 6, 6, 8, 1, -7 },
  { 161, 6, 4, 8, 1, -6 },
  { 164, 6, 6, 8, 1, -7 },
  { 169, 6, 9, 8, 1, -9 },
  { 176, 7, 9, 8, 0, -9 },
  { 184, 8, 9, 8, 0, -9 },
  { 193, 6, 9, 8, 1, -9 },
  { 200, 7, 9, 8, 0, -9 },
  { 208, 6, 9, 8, 1, -9 },
  { 215, 6, 9, 8, 1, -9 },
  { 222, 6, 9, 8, 1, -9 },
  { 229, 6, 9, 8, 1, -9 },
  { 236, 6, 9, 8, 1, -9 },
  { 243, 6, 9, 8, 1, -9 },
  { 250, 6, 9, 8, 1, -9 },
  { 257, 7, 9, 8, 1, -9 },
  { 265, 6, 9, 8, 1, -9 },
  { 272, 6, 9, 8, 1, -9 },
  { 279, 6, 9, 8, 1, -9 },
  { 286, 6, 9, 8, 1, -9 },
  { 293, 6, 9, 8, 1, -9 },
  { 300, 7, 11, 8, 1, -9 },
  { 310, 7, 9, 8, 1, -9 },
  { 318, 6, 9, 8, 1, -9 },
  { 325, 8, 9, 8, 0, -9 },
  { 334, 6, 9, 8, 1, -9 },
  { 341, 8, 9, 8, 0, -9 },
  { 350, 8, 9, 8, 0, -9 },
  { 359, 8, 9, 8, 0, -9 },
  { 368, 8, 9, 8, 0, -9 },
  { 377, 6, 9, 8, 1, -9 },
  { 384, 2, 13, 8, 3, -11 },
  { 388, 5, 10, 8, 2, -9 },
  { 395, 2, 13, 8, 3, -11 },
  { 399, 6, 5, 8, 1, -9 },
  { 403, 6, 1, 8, 1, 0 },
  { 404, 3, 1, 8, 3, -9 },
  { 405, 6, 7, 8, 1, -7 },
  { 411, 6, 10, 8, 1, -10 },
  { 419, 6, 7, 8, 1, -7 },
  { 425, 6, 10, 8, 1, -10 },
  { 433, 6, 7, 8, 1, -7 },
  { 439, 6, 10, 8, 1, -10 },
  { 447, 6, 10, 8, 1, -7 },
  { 455, 6, 10, 8, 1, -10 },
  { 463, 6, 10, 8, 1, -10 },
  { 471, 5, 13, 8, 1, -10 },
  { 480, 7, 10, 8, 1, -10 },
  { 489, 6, 10, 8, 1, -10 },
  { 497, 7, 7, 8, 0, -7 },
  { 504, 6, 7, 8, 1, -7 },
  { 510, 6, 7, 8, 1, -7 },
  { 516, 6, 10, 8, 1, -7 },
  { 524, 6, 10, 8, 1, -7 },
  { 532, 5, 7, 8, 2, -7 },
  { 537, 6, 7, 8, 1, -7 },
  { 543, 6, 9, 8, 1, -9 },
  { 550, 6, 7, 8, 1, -7 },
  { 556, 7, 7, 8, 0, -7 },
  { 563, 8, 7, 8, 0, -7 },
  { 570, 7, 7, 8, 1, -7 },
  { 577, 8, 10, 8, 0, -7 },
  { 587, 6, 7, 8, 1, -7 },
  { 593, 4, 12, 8, 2, -10 },
  { 599, 1, 12, 8, 3, -9 },
  { 601, 4, 12, 8, 2, -10 },
  { 607, 7, 3, 8, 0, -5 },
};

const GFXfont RobotoMono_Bold13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold13pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_BOLD13PT7B_H_
