#ifndef _ROBOTOMONO_BOLD43PT7B_H_
#define _ROBOTOMONO_BOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x79,
  0xFB, 0xFF, 0xEF, 0xDF, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E, 0xF0, 0x77, 0x83, 0xBC, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE0, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x81, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0x9F, 0x80, 0xFC, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFD,
  0xFE, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0xF1, 0xF0, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF0, 0xF1, 0xC0,
  0xF0, 0xF3, 0xC0, 0xF1, 0xE3, 0x80, 0xFF, 0xE7, 0x80, 0x7F, 0xCF, 0x00,
  0x3F, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x71, 0xF8, 0x00, 0xF3, 0xFC,
  0x00, 0xE7, 0xFE, 0x01, 0xE7, 0xFF, 0x03, 0xCF, 0x0F, 0x03, 0xCF, 0x0F,
  0x07, 0x8F, 0x0F, 0x07, 0x0F, 0x0F, 0x01, 0x0F, 0x0F, 0x00, 0x0F, 0x8F,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0x8F, 0x80, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0xBF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x3E,
  0x3F, 0xF8, 0x3E, 0x7F, 0xFC, 0x3E, 0xFE, 0xFE, 0x3E, 0xFC, 0x7F, 0x7E,
  0xFC, 0x3F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xFC, 0xFC, 0x0F, 0xF8,
  0xFC, 0x07, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x20, 0x0E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0E, 0x00, 0x60, 0x02, 0x40, 0x0E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x08, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x06, 0x07, 0x80, 0x9E, 0x1E, 0x1E, 0x7E, 0x79,
  0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x80, 0x3E,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x06, 0x03, 0x80, 0x08, 0x04,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0xFB, 0xE7, 0x87, 0x04, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xBF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7F, 0x9F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x7E, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F,
  0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF8, 0x0F,
  0xDF, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0x9F, 0xE3, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80,
  0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x07,
  0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0,
  0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7D, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xF3, 0xFE, 0x1E, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xEF, 0x80,
  0x3F, 0x7E, 0x03, 0xFB, 0xF8, 0x1F, 0x9F, 0xE3, 0xFC, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0xFE, 0x07, 0xDF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xF1, 0xFE, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x03, 0xFB, 0xF8, 0x1F, 0x8F, 0xF3, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80,
  0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xC1, 0xFC, 0xFC, 0x07,
  0xE7, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0xE3, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0xDF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xF3, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x3F, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE3, 0xE0, 0xE0,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xF0, 0x7F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x1C, 0x3C, 0x1F, 0x1E, 0x38, 0x7F, 0xCE, 0x78, 0xFF, 0xCE, 0x78, 0xFB,
  0xCE, 0x71, 0xE3, 0xCF, 0xF1, 0xE3, 0x8F, 0xF3, 0xC3, 0x8F, 0xF3, 0xC3,
  0x8F, 0xE3, 0xC3, 0x8E, 0xE3, 0xC3, 0x8E, 0xE3, 0xC3, 0x8E, 0xE3, 0xC3,
  0x8E, 0xE3, 0xC3, 0x8E, 0xF3, 0xC7, 0x9C, 0xF3, 0xFF, 0xFC, 0xF1, 0xFF,
  0xF8, 0x70, 0xF9, 0xF0, 0x78, 0x20, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x81, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80,
  0x0F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC,
  0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xF0,
  0x0F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x01,
  0xF9, 0xFC, 0x0F, 0xE3, 0xFC, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7E, 0x1F, 0xE3, 0xF0, 0x3F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x0F, 0xE7,
  0xE0, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x3E, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x03, 0xF3,
  0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x03, 0xFB,
  0xF0, 0x1F, 0x9F, 0xF7, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x0F,
  0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07,
  0xE7, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFB,
  0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFB, 0xFF,
  0xBF, 0xDF, 0xFD, 0xFE, 0xFF, 0xE7, 0xE7, 0xFF, 0x3F, 0x3F, 0xF9, 0xF9,
  0xFF, 0xCF, 0x8F, 0xFE, 0x3C, 0x7F, 0xF1, 0xE3, 0xFF, 0x8E, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xE0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFD, 0xF3, 0xFF, 0xDF, 0x3F, 0xFC, 0xF3, 0xFF, 0xCF, 0xBF, 0xFC,
  0x7B, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F,
  0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xC3, 0xFD, 0xFF, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E,
  0x07, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0x87, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7F,
  0x03, 0xF8, 0x3F, 0xDF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F,
  0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9,
  0xFC, 0x07, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0x7D, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xFC, 0x7F,
  0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7E, 0x7F, 0x9F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F,
  0xF8, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0x7C, 0x7E, 0x3E,
  0x7C, 0x7E, 0x3E, 0x7C, 0xFE, 0x3E, 0x7C, 0xFE, 0x3E, 0x7C, 0xFF, 0x3E,
  0x7C, 0xFF, 0x7E, 0x7E, 0xFF, 0x7E, 0x7E, 0xFF, 0x7C, 0x3E, 0xEF, 0x7C,
  0x3F, 0xEF, 0x7C, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC,
  0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xFE, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xE3,
  0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3E, 0x07, 0xC7, 0x81, 0xE1,
  0xF0, 0x78, 0x7C, 0x3E, 0x0F, 0x0F, 0x03, 0xE7, 0xC0, 0x79, 0xF0, 0x1F,
  0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0xFF,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x81, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x9F, 0xC3,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0xFC, 0x3F, 0xC7, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xCF,
  0xE0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE,
  0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x8F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x81, 0xF9,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x8F, 0xC3,
  0xFF, 0x7E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x80, 0x3F,
  0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE, 0x7F, 0x1F, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xF7, 0xE0, 0xFF, 0x3F, 0x00, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE,
  0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x20, 0xFE, 0x01, 0xC3, 0xFE,
  0x3F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0xF8, 0x7F, 0xF7, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x81, 0xFD, 0xFC, 0x07, 0xEF, 0xC0,
  0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF8, 0x1F, 0xCF, 0xF3, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x40, 0x1F,
  0xC7, 0x01, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0xFC, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x00, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x02,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3,
  0xF0, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80, 0xFD, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0,
  0x3F, 0xBF, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF1, 0xF3, 0xEF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE3,
  0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F, 0xE3, 0xE1, 0xFF,
  0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F,
  0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87,
  0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xC0,
  0xF8, 0x7F, 0x0F, 0x9F, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xC3,
  0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xF8, 0xFE, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0xFF,
  0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFC, 0xFE, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0xF8, 0x7F, 0xEF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0x81, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF0,
  0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x1F, 0xCF, 0xE3, 0xFE,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFE, 0xFC, 0x1F, 0xE7, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x3F,
  0xFF, 0x3F, 0xEF, 0xDF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x87,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x1F, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x3E, 0x00, 0x7C,
  0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x3C, 0x3F, 0xF8, 0x3C, 0x3F, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E,
  0xF8, 0x7C, 0x3E, 0xFC, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFE, 0x3E,
  0x7C, 0xFE, 0x7C, 0x7C, 0xEE, 0x7C, 0x7C, 0xEF, 0x7C, 0x3C, 0xEF, 0x7C,
  0x3D, 0xEF, 0x7C, 0x3F, 0xE7, 0x78, 0x3F, 0xC7, 0x78, 0x3F, 0xC7, 0x78,
  0x3F, 0xC7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x83, 0xF0,
  0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0xFE, 0x00, 0xFE,
  0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x01,
  0xF8, 0xFC, 0x03, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F,
  0xBF, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80,
  0x1F, 0xCF, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01,
  0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xFC, 0x3F, 0xE0, 0xFE,
  0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x3F, 0xC1, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x02, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x3D, 0xFF, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xBC, 0x0F, 0xFE, 0x70, 0x07, 0xFC, 0x00,
  0x03, 0xE0,
};

const GFXglyph RobotoMono_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 31, 26, 9, -31 },
  { 29, 13, 11, 26, 6, -32 },
  { 47, 23, 31, 26, 1, -31 },
  { 137, 21, 39, 26, 3, -35 },
  { 240, 24, 31, 26, 1, -31 },
  { 333, 24, 31, 26, 2, -31 },
  { 426, 4, 11, 26, 10, -32 },
  { 432, 12, 44, 26, 7, -34 },
  { 498, 12, 44, 26, 7, -34 },
  { 564, 22, 22, 26, 3, -31 },
  { 625, 21, 22, 26, 2, -25 },
  { 683, 7, 14, 26, 8, -5 },
  { 696, 17, 5, 26, 6, -16 },
  { 707, 8, 7, 26, 9, -7 },
  { 714, 17, 34, 26, 5, -31 },
  { 787, 20, 31, 26, 3, -31 },
  { 865, 13, 31, 26, 4, -31 },
  { 916, 22, 31, 26, 1, -31 },
  { 1002, 21, 31, 26, 2, -31 },
  { 1084, 23, 31, 26, 1, -31 },
  { 1174, 21, 31, 26, 2, -31 },
  { 1256, 21, 31, 26, 2, -31 },
  { 1338, 22, 31, 26, 1, -31 },
  { 1424, 21, 31, 26, 2, -31 },
  { 1506, 20, 31, 26, 2, -31 },
  { 1584, 8, 24, 26, 9, -24 },
  { 1608, 9, 33, 26, 9, -24 },
  { 1646, 19, 20, 26, 3, -23 },
  { 1694, 20, 14, 26, 3, -20 },
  { 1729, 19, 20, 26, 3, -23 },
  { 1777, 20, 31, 26, 3, -31 },
  { 1855, 24, 30, 26, 1, -30 },
  { 1945, 25, 31, 26, 1, -31 },
  { 2042, 22, 31, 26, 3, -31 },
  { 2128, 22, 31, 26, 2, -31 },
  { 2214, 21, 31, 26, 3, -31 },
  { 2296, 21, 31, 26, 3, -31 },
  { 2378, 21, 31, 26, 3, -31 },
  { 2460, 22, 31, 26, 2, -31 },
  { 2546, 20, 31, 26, 3, -31 },
  { 2624, 18, 31, 26, 4, -31 },
  { 2694, 21, 31, 26, 2, -31 },
  { 2776, 23, 31, 26, 3, -31 },
  { 2866, 20, 31, 26, 3, -31 },
  { 2944, 21, 31, 26, 3, -31 },
  { 3026, 20, 31, 26, 3, -31 },
  { 3104, 22, 31, 26, 2, -31 },
  { 3190, 21, 31, 26, 3, -31 },
  { 3272, 24, 36, 26, 2, -31 },
  { 3380, 22, 31, 26, 3, -31 },
  { 3466, 22, 31, 26, 2, -31 },
  { 3552, 24, 31, 26, 1, -31 },
  { 3645, 20, 31, 26, 3, -31 },
  { 3723, 24, 31, 26, 1, -31 },
  { 3816, 24, 31, 26, 1, -31 },
  { 3909, 25, 31, 26, 1, -31 },
  { 4006, 25, 31, 26, 1, -31 },
  { 4103, 22, 31, 26, 2, -31 },
  { 4189, 10, 42, 26, 8, -35 },
  { 4242, 17, 34, 26, 5, -31 },
  { 4315, 10, 42, 26, 8, -35 },
  { 4368, 18, 17, 26, 4, -31 },
  { 4407, 19, 5, 26, 3, 0 },
  { 4419, 10, 6, 26, 9, -31 },
  { 4427, 21, 23, 26, 2, -23 },
  { 4488, 20, 32, 26, 3, -32 },
  { 4568, 21, 23, 26, 2, -23 },
  { 4629, 21, 32, 26, 2, -32 },
  { 4713, 22, 23, 26, 2, -23 },
  { 4777, 21, 33, 26, 3, -33 },
  { 4864, 21, 32, 26, 2, -23 },
  { 4948, 20, 32, 26, 3, -32 },
  { 5028, 18, 32, 26, 5, -32 },
  { 5100, 14, 41, 26, 5, -32 },
  { 5172, 22, 32, 26, 3, -32 },
  { 5260, 19, 32, 26, 4, -32 },
  { 5336, 22, 23, 26, 2, -23 },
  { 5400, 20, 23, 26, 3, -23 },
  { 5458, 22, 23, 26, 2, -23 },
  { 5522, 20, 32, 26, 3, -23 },
  { 5602, 21, 32, 26, 2, -23 },
  { 5686, 18, 23, 26, 6, -23 },
  { 5738, 20, 23, 26, 3, -23 },
  { 5796, 20, 28, 26, 3, -28 },
  { 5866, 20, 23, 26, 3, -23 },
  { 5924, 22, 23, 26, 2, -23 },
  { 5988, 24, 23, 26, 1, -23 },
  { 6057, 23, 23, 26, 2, -23 },
  { 6124, 25, 32, 26, 1, -23 },
  { 6224, 22, 23, 26, 2, -23 },
  { 6288, 14, 42, 26, 6, -34 },
  { 6362, 4, 40, 26, 11, -31 },
  { 6382, 14, 42, 26, 7, -34 },
  { 6456, 23, 9, 26, 1, -17 },
};

const GFXfont RobotoMono_Bold43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold43pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_BOLD43PT7B_H_
