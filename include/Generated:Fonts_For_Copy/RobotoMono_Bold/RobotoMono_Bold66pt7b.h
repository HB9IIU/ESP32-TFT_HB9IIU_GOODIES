#ifndef _ROBOTOMONO_BOLD66PT7B_H_
#define _ROBOTOMONO_BOLD66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x80, 0x1F, 0xC1, 0xF8, 0x0E, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x83, 0xF0,
  0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x3F,
  0x0F, 0x80, 0x0F, 0xE3, 0xF8, 0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xC0, 0x01,
  0xFF, 0xFC, 0x7E, 0x00, 0x07, 0xFF, 0xC7, 0xE0, 0x00, 0x1F, 0xFC, 0x3E,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xE0,
  0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0xFF, 0xFE, 0x00, 0x0F, 0x8F,
  0xFF, 0xF0, 0x00, 0xFC, 0x7F, 0xBF, 0xC0, 0x07, 0xC7, 0xF0, 0x7E, 0x00,
  0x7E, 0x3F, 0x03, 0xF0, 0x03, 0xE1, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0xFC, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x38,
  0x1F, 0x81, 0xF8, 0x00, 0x40, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0x80, 0x7F,
  0x83, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0xDF,
  0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFC,
  0x7F, 0xC0, 0xFF, 0xDF, 0xF1, 0xFF, 0x03, 0xFF, 0x7F, 0x8F, 0xF8, 0x07,
  0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0xC3,
  0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0x80,
  0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xF8, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x10, 0x20, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x18, 0x01, 0xF0, 0x03, 0x1F, 0x00, 0xF8, 0x07,
  0x8F, 0xF0, 0x7C, 0x0F, 0xE7, 0xFE, 0x3E, 0x1F, 0xF3, 0xFF, 0xDF, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0x7F, 0x1F,
  0xC3, 0xF8, 0x3E, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0x70, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE7, 0xFC,
  0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0xF8,
  0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x7F,
  0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xC0, 0x1F, 0xFC, 0x02, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0xC0, 0x7F,
  0xDF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF,
  0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x3F,
  0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F,
  0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xF3, 0xFE, 0x00, 0x1F, 0x83, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFE,
  0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xFE, 0x3F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE7, 0xFE, 0x1F,
  0xE0, 0x18, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x3F,
  0xF0, 0xFC, 0x3F, 0x03, 0xFF, 0xC3, 0xE1, 0xF0, 0x3F, 0xFF, 0x1F, 0x1F,
  0x83, 0xFF, 0xF8, 0xF8, 0xF8, 0x3F, 0xC7, 0xC3, 0xC7, 0xC1, 0xF8, 0x7C,
  0x1F, 0x7E, 0x1F, 0x83, 0xE0, 0xFB, 0xF0, 0xFC, 0x1F, 0x07, 0xDF, 0x07,
  0xC0, 0xF8, 0x3E, 0xF8, 0x7E, 0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0x3E, 0x0F,
  0xBE, 0x1F, 0x01, 0xF0, 0x7F, 0xF0, 0xF8, 0x0F, 0x83, 0xDF, 0x87, 0xC0,
  0x7C, 0x1E, 0xFC, 0x3E, 0x03, 0xE0, 0xF7, 0xE3, 0xF0, 0x1F, 0x0F, 0xBF,
  0x1F, 0x81, 0xF8, 0x7D, 0xF8, 0x7C, 0x0F, 0x83, 0xEF, 0xC3, 0xF0, 0x7C,
  0x1E, 0x3E, 0x1F, 0x83, 0xE1, 0xF1, 0xF0, 0xFE, 0x3F, 0x8F, 0x0F, 0x87,
  0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0x83, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0x83, 0xFE, 0x7F, 0xC0, 0x7E, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0x80, 0x07, 0xFF,
  0x3F, 0xE0, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xF8, 0x00, 0xFF, 0xF3, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xF8,
  0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xE3,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x1F, 0xFC, 0x03,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0x3F, 0xF0, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xE0, 0x00, 0x7F,
  0xF1, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xC0,
  0x03, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0xE0, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xDF, 0xF8,
  0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFC, 0x00, 0x1F,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0xFF,
  0xFF, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0x3F, 0xFC, 0xFF,
  0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF,
  0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xFF,
  0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0x07, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0xFE,
  0x0F, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xF9, 0xFC, 0x3F, 0xFF, 0xF3, 0xF8,
  0x7F, 0xFF, 0xE3, 0xF8, 0xFF, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF, 0x8F, 0xF3,
  0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xFE, 0x1F, 0xCF, 0xFF, 0xFC, 0x1F, 0xDF,
  0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xC0, 0x03,
  0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xF7, 0xFC,
  0x00, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xE3, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0x07,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0x01, 0xFE, 0xFF, 0x81,
  0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x7F,
  0x9F, 0xE0, 0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x07, 0xF9, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE7, 0xF8, 0x3F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xC3, 0xFC, 0x3F, 0xC7, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xF9, 0xFE, 0x0F, 0xF1, 0xFF,
  0xE7, 0xF8, 0x1F, 0xE7, 0xFF, 0x9F, 0xE0, 0x7F, 0xBF, 0x7E, 0x7F, 0x81,
  0xFE, 0xFD, 0xF9, 0xFE, 0x07, 0xFB, 0xF7, 0xE7, 0xF8, 0x1F, 0xEF, 0xCF,
  0xDF, 0xE0, 0x7F, 0xBF, 0x3F, 0x7F, 0x01, 0xFE, 0xFC, 0xFF, 0xFC, 0x03,
  0xFB, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F,
  0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xDF, 0xFE,
  0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0x8F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x10, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0xFF, 0x9F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x80, 0x1F,
  0xFB, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xE0,
  0xFF, 0x3F, 0xFF, 0x81, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x3F,
  0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x00, 0xFF, 0x80, 0x7F,
  0xE1, 0xFF, 0x03, 0xFF, 0xF3, 0xFE, 0x0F, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x7F,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFD, 0xFF, 0x03, 0xFF, 0xF1, 0xFE, 0x01, 0xFF,
  0x83, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0,
  0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x10, 0x7F, 0xE0, 0x00, 0x30, 0x7F, 0xF0, 0x00, 0x78, 0x3F, 0xFC,
  0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xC3,
  0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x3F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x80,
  0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0x1F,
  0xF0, 0x00, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x82, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x0F, 0xFC, 0x1F, 0x00, 0x3F, 0xF8,
  0x7F, 0xC3, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x08, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0x3F, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x07, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xCC, 0x3F, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xE0, 0x07, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xE7, 0xFF,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xE0,
  0x07, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0xFC, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x10, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xFC, 0xFF, 0xCF, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF, 0xCF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0x87, 0xFF,
  0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF,
  0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xE0,
  0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF,
  0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x07,
  0xFE, 0x03, 0xFC, 0x3F, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF,
  0xFF, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xFE, 0x1F, 0xF8, 0x03, 0xFC, 0xFF, 0xFC, 0x07, 0xFB,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0x80,
  0x3F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFD,
  0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xCF,
  0xFE, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFE,
  0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xC7, 0xF8, 0x3F, 0xFF, 0xCF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0x00,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xCF,
  0xF8, 0x07, 0xFF, 0x1F, 0xF0, 0x00, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x08, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF9, 0xFB, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x02, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xF3,
  0xFC, 0x1F, 0xFF, 0x8F, 0xF0, 0x3F, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x01,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF,
  0xFF, 0x03, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xC0, 0xFF, 0x3F, 0xC1, 0xFE,
  0x07, 0xF9, 0xFE, 0x0F, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x83,
  0xF8, 0x7F, 0x8F, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xF1, 0xFE, 0x1F, 0xE3,
  0xEF, 0x8F, 0xF0, 0xFF, 0x1F, 0x7C, 0x7F, 0x83, 0xF8, 0xFB, 0xE3, 0xF8,
  0x1F, 0xC7, 0xDF, 0x1F, 0xC0, 0xFE, 0x7C, 0xFC, 0xFE, 0x07, 0xF3, 0xE3,
  0xE7, 0xF0, 0x3F, 0xDF, 0x1F, 0x7F, 0x80, 0xFE, 0xF8, 0xFB, 0xF8, 0x07,
  0xF7, 0xC7, 0xDF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0x81, 0xFF, 0xFC, 0x00, 0x3F, 0x3F, 0xFF, 0xE0, 0x07, 0xF7,
  0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFC, 0xFC, 0x00,
  0xFF, 0xFF, 0xCF, 0xC0, 0x07, 0xFF, 0xF8, 0x3C, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoMono_Bold66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 10, 47, 40, 15, -47 },
  { 60, 20, 18, 40, 9, -50 },
  { 105, 36, 47, 40, 1, -47 },
  { 317, 33, 61, 40, 4, -54 },
  { 569, 37, 49, 40, 1, -48 },
  { 796, 38, 49, 40, 2, -48 },
  { 1029, 7, 18, 40, 15, -50 },
  { 1045, 18, 67, 40, 11, -52 },
  { 1196, 18, 67, 40, 10, -52 },
  { 1347, 33, 33, 40, 5, -47 },
  { 1484, 32, 34, 40, 3, -39 },
  { 1620, 11, 21, 40, 12, -8 },
  { 1649, 27, 7, 40, 9, -24 },
  { 1673, 12, 12, 40, 14, -11 },
  { 1691, 26, 51, 40, 7, -47 },
  { 1857, 30, 49, 40, 5, -48 },
  { 2041, 20, 47, 40, 6, -47 },
  { 2159, 33, 48, 40, 2, -48 },
  { 2357, 32, 49, 40, 3, -48 },
  { 2553, 34, 47, 40, 2, -47 },
  { 2753, 31, 48, 40, 4, -47 },
  { 2939, 32, 48, 40, 3, -47 },
  { 3131, 33, 47, 40, 2, -47 },
  { 3325, 31, 49, 40, 4, -48 },
  { 3515, 32, 48, 40, 3, -48 },
  { 3707, 13, 39, 40, 14, -38 },
  { 3771, 14, 51, 40, 14, -38 },
  { 3861, 29, 31, 40, 5, -36 },
  { 3974, 31, 21, 40, 5, -30 },
  { 4056, 29, 31, 40, 5, -36 },
  { 4169, 31, 48, 40, 5, -48 },
  { 4355, 37, 46, 40, 1, -46 },
  { 4568, 39, 47, 40, 1, -47 },
  { 4798, 34, 47, 40, 4, -47 },
  { 4998, 34, 49, 40, 3, -48 },
  { 5207, 33, 47, 40, 4, -47 },
  { 5401, 31, 47, 40, 5, -47 },
  { 5584, 32, 47, 40, 5, -47 },
  { 5772, 33, 49, 40, 3, -48 },
  { 5975, 31, 47, 40, 4, -47 },
  { 6158, 27, 47, 40, 6, -47 },
  { 6317, 31, 48, 40, 4, -47 },
  { 6503, 37, 47, 40, 4, -47 },
  { 6721, 31, 47, 40, 5, -47 },
  { 6904, 32, 47, 40, 4, -47 },
  { 7092, 31, 47, 40, 4, -47 },
  { 7275, 34, 49, 40, 3, -48 },
  { 7484, 33, 47, 40, 5, -47 },
  { 7678, 36, 56, 40, 3, -48 },
  { 7930, 35, 47, 40, 4, -47 },
  { 8136, 35, 49, 40, 3, -48 },
  { 8351, 38, 47, 40, 1, -47 },
  { 8575, 32, 48, 40, 4, -47 },
  { 8767, 38, 47, 40, 1, -47 },
  { 8991, 38, 47, 40, 1, -47 },
  { 9215, 38, 47, 40, 1, -47 },
  { 9439, 38, 47, 40, 1, -47 },
  { 9663, 34, 47, 40, 3, -47 },
  { 9863, 14, 65, 40, 13, -54 },
  { 9977, 26, 51, 40, 8, -47 },
  { 10143, 14, 65, 40, 13, -54 },
  { 10257, 27, 25, 40, 7, -47 },
  { 10342, 29, 7, 40, 5, 0 },
  { 10368, 16, 9, 40, 13, -48 },
  { 10386, 31, 37, 40, 4, -36 },
  { 10530, 31, 51, 40, 5, -50 },
  { 10728, 31, 37, 40, 4, -36 },
  { 10872, 31, 51, 40, 4, -50 },
  { 11070, 32, 37, 40, 4, -36 },
  { 11218, 33, 51, 40, 4, -51 },
  { 11429, 31, 50, 40, 4, -36 },
  { 11623, 31, 50, 40, 5, -50 },
  { 11817, 28, 49, 40, 7, -49 },
  { 11989, 21, 63, 40, 7, -49 },
  { 12155, 34, 50, 40, 5, -50 },
  { 12368, 30, 50, 40, 6, -50 },
  { 12556, 35, 36, 40, 2, -36 },
  { 12714, 31, 36, 40, 5, -36 },
  { 12854, 33, 37, 40, 3, -36 },
  { 13007, 31, 49, 40, 5, -36 },
  { 13197, 31, 49, 40, 4, -36 },
  { 13387, 27, 36, 40, 9, -36 },
  { 13509, 32, 37, 40, 4, -36 },
  { 13657, 32, 44, 40, 4, -43 },
  { 13833, 30, 36, 40, 5, -35 },
  { 13968, 35, 35, 40, 2, -35 },
  { 14122, 37, 35, 40, 1, -35 },
  { 14284, 35, 35, 40, 3, -35 },
  { 14438, 38, 49, 40, 2, -35 },
  { 14671, 33, 35, 40, 4, -35 },
  { 14816, 21, 63, 40, 10, -51 },
  { 14982, 6, 60, 40, 17, -47 },
  { 15027, 21, 63, 40, 11, -51 },
  { 15193, 36, 15, 40, 1, -27 },
};

const GFXfont RobotoMono_Bold66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold66pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_BOLD66PT7B_H_
