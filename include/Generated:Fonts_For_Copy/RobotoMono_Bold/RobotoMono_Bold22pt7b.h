#ifndef _ROBOTOMONO_BOLD22PT7B_H_
#define _ROBOTOMONO_BOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xCF, 0x9F, 0x3E, 0x7C, 0xD9,
  0x80, 0x06, 0x60, 0x66, 0x04, 0x60, 0xCC, 0x0C, 0xC7, 0xFF, 0x7F, 0xF0,
  0xCC, 0x18, 0x81, 0x98, 0xFF, 0xFF, 0xFF, 0x19, 0x81, 0x18, 0x33, 0x03,
  0x30, 0x06, 0x00, 0xC0, 0x3C, 0x1F, 0xE7, 0xFE, 0xE1, 0xDC, 0x3B, 0x80,
  0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC1, 0xFC, 0x3B, 0xCF, 0x7F,
  0xC3, 0xF0, 0x18, 0x03, 0x00, 0x38, 0x03, 0xE0, 0x33, 0x11, 0x99, 0x8C,
  0xCC, 0x3E, 0xC0, 0xE4, 0x00, 0x60, 0x02, 0x00, 0x33, 0x03, 0x7C, 0x1B,
  0x31, 0x99, 0x84, 0xCC, 0x07, 0xE0, 0x1E, 0x0E, 0x03, 0xF0, 0x3F, 0x87,
  0x38, 0x73, 0x87, 0x30, 0x3F, 0x03, 0xC0, 0x3C, 0x77, 0xE7, 0xE7, 0x7E,
  0x7E, 0xE3, 0xEF, 0x3C, 0x7F, 0xE3, 0xFF, 0xFF, 0xF0, 0x08, 0x73, 0x1C,
  0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x38, 0x61, 0xC3, 0x0E,
  0x1C, 0x20, 0x43, 0x83, 0x0E, 0x18, 0x71, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x31, 0xC7, 0x18, 0x63, 0x1C, 0xE1, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x46,
  0x2E, 0xDD, 0xFF, 0xC3, 0x80, 0xF0, 0x33, 0x0E, 0x70, 0x86, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x77, 0x77, 0x6E, 0xC0, 0xFF, 0xFF, 0xC0, 0x6F, 0xFE,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x00, 0x1E, 0x1F, 0xCF, 0xFB,
  0x8E, 0xE1, 0xF8, 0x7E, 0x3F, 0xBF, 0xFD, 0xFC, 0x7E, 0x1F, 0x87, 0xE3,
  0xBC, 0xE7, 0xF0, 0xF8, 0x02, 0x1D, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x0F, 0xF1, 0xFF, 0x70, 0xEE,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x3F, 0xFF, 0xFF, 0x1F, 0x0F, 0xF1, 0xFF, 0x70, 0xE0, 0x0E, 0x03,
  0x80, 0x70, 0x7C, 0x0F, 0x80, 0x38, 0x03, 0x80, 0x7E, 0x0F, 0xE3, 0x9F,
  0xF1, 0xF8, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x3F, 0x0E, 0xE1,
  0x9C, 0x73, 0x9C, 0x73, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0, 0x1C,
  0x3F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xE3, 0xFE, 0x61,
  0xC0, 0x1C, 0x03, 0x80, 0x7E, 0x1E, 0xE3, 0x9F, 0xF0, 0xF8, 0x03, 0x03,
  0xE0, 0xFC, 0x1C, 0x07, 0x00, 0xE0, 0x3B, 0xE7, 0xFE, 0xF1, 0xDC, 0x1F,
  0x83, 0xF0, 0x77, 0x0E, 0xE3, 0x8F, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xE7,
  0x1C, 0xE3, 0x9C, 0xF1, 0xFC, 0x3F, 0x8E, 0x3B, 0x87, 0x70, 0x7E, 0x0E,
  0xE3, 0x9F, 0xF1, 0xFC, 0x1E, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x1D, 0xC1,
  0xB8, 0x3F, 0x0F, 0x7B, 0xCF, 0xF8, 0x7F, 0x00, 0xE0, 0x38, 0x1F, 0x0F,
  0xC1, 0xE0, 0x6F, 0xFE, 0x00, 0x00, 0x06, 0xFF, 0xE0, 0x6F, 0xF7, 0x00,
  0x00, 0x00, 0x66, 0x66, 0xEE, 0xC0, 0x00, 0x81, 0xC3, 0xEF, 0xEF, 0x87,
  0x03, 0xF0, 0x7F, 0x0F, 0x80, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x70, 0x3F, 0x0F, 0xE0, 0xF8, 0x1C, 0x7F, 0xFC,
  0xF8, 0x60, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0x87, 0x01, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x0F,
  0xC0, 0xC3, 0x0C, 0x0C, 0xCF, 0x26, 0xED, 0x36, 0x4D, 0x32, 0x79, 0x12,
  0xD8, 0x92, 0x6D, 0x9B, 0xF8, 0xCD, 0x87, 0x00, 0x1F, 0xC0, 0x3E, 0x00,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xE0, 0x77, 0x03,
  0x98, 0x1C, 0xE1, 0xC7, 0x0F, 0xF8, 0x7F, 0xE7, 0xFF, 0x38, 0x39, 0xC0,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1,
  0xEF, 0xFC, 0xFF, 0xCE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x1E, 0xFF,
  0xEF, 0xF8, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0x7E, 0x0F, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x7E, 0x0E, 0xE3, 0xCF, 0xF0, 0xFC,
  0xFC, 0x1F, 0xE3, 0xFE, 0x70, 0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1D, 0xCF, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0x7E, 0x0F, 0xC0, 0x38, 0x07,
  0x00, 0xE3, 0xFC, 0x7F, 0x83, 0xF0, 0x7F, 0x0E, 0xF3, 0xCF, 0xF8, 0xFC,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF,
  0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE3, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x7E, 0x0E, 0xE3, 0x9F,
  0xF1, 0xF8, 0xE0, 0x77, 0x07, 0x38, 0x79, 0xC7, 0x8E, 0x38, 0x73, 0x83,
  0xBC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3C, 0xE1, 0xC7, 0x8E, 0x1C, 0x70,
  0xF3, 0x83, 0xDC, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFE, 0x3F, 0xE7, 0xFD, 0xFF, 0xBF, 0xF7, 0xFB, 0xFF, 0x77, 0xEE,
  0xFD, 0xDF, 0x93, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE,
  0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x67, 0xEE, 0xFC, 0xDF,
  0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0x1F, 0x07, 0xF1, 0xFF,
  0x38, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0E, 0xE3, 0x8F, 0xF0, 0xF8, 0xFC, 0x1F, 0xF3, 0xFF, 0x70, 0xEE,
  0x1D, 0xC3, 0xF8, 0x77, 0x1E, 0xFF, 0x9F, 0xE3, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x0F, 0x03, 0xF8, 0x7F, 0xC7, 0x1E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF0, 0xE7,
  0x9C, 0x3F, 0xC1, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x20, 0xFE, 0x0F, 0xFC,
  0xFF, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8,
  0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0x0F, 0x03, 0xFC,
  0x7F, 0xE7, 0x0E, 0xE0, 0xE7, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x3E,
  0x00, 0xEE, 0x0F, 0xE0, 0xE7, 0x0E, 0x7F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x77, 0x0E, 0xE3, 0x8F, 0xF0, 0xFC, 0xF0, 0x3B, 0x83,
  0xDC, 0x1C, 0xE0, 0xE3, 0x8F, 0x1C, 0x70, 0xE3, 0x87, 0x9C, 0x1D, 0xC0,
  0xEE, 0x07, 0x70, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0xE7,
  0x3F, 0x39, 0xD9, 0xCE, 0xCE, 0x77, 0x73, 0x3B, 0x99, 0xDF, 0xCF, 0xBE,
  0x7D, 0xF1, 0xEF, 0x8F, 0x7C, 0x7B, 0xC3, 0xDE, 0x1E, 0x70, 0xE3, 0x87,
  0x1C, 0xF0, 0x7B, 0xC3, 0x8E, 0x3C, 0x71, 0xC1, 0xDE, 0x0E, 0xE0, 0x3F,
  0x01, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0xF0, 0x3B, 0xC3, 0xCE, 0x1C, 0x79,
  0xE1, 0xDE, 0x0F, 0xF0, 0x3B, 0x83, 0xDE, 0x1C, 0x71, 0xE3, 0x8E, 0x0E,
  0x70, 0x77, 0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xFF, 0xFC, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x30,
  0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0xFF, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0xFC,
  0x0C, 0x0E, 0x07, 0x87, 0xC3, 0x71, 0x99, 0x8C, 0xC7, 0xE1, 0x80, 0xFF,
  0xFF, 0xC0, 0xF0, 0xE1, 0xC0, 0x1F, 0x07, 0xF1, 0xCF, 0x78, 0xE0, 0x1C,
  0x7F, 0x9F, 0xF7, 0x8E, 0xE1, 0xDE, 0x79, 0xFF, 0x1F, 0x70, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3B, 0x8F, 0xFB, 0xFE, 0xE3, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFE, 0xDF, 0x00, 0x0F, 0x07, 0xF1, 0xFF,
  0x38, 0xFE, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0x70, 0xEE, 0x38, 0xFF, 0x0F,
  0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x39, 0xCF, 0xFB, 0xFF,
  0x71, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xDC, 0x7B, 0xFF, 0x3E,
  0xE0, 0x0F, 0x07, 0xF9, 0xFF, 0x38, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x4F, 0x18, 0xFF, 0x8F, 0xC0, 0x03, 0xE0, 0xFC, 0x3C, 0x87, 0x01,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0xB8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xEF, 0x3D, 0xFF, 0x8F, 0x70, 0x0E,
  0x43, 0x9F, 0xF1, 0xFC, 0x0C, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3B, 0xCF, 0xFB, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xC0, 0x0E, 0x07, 0x80, 0xC0, 0x00, 0xFE, 0x3F, 0x8F,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFF,
  0x0E, 0x1C, 0x38, 0x07, 0xEF, 0xDF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1D, 0xFF, 0xEF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC3, 0xB8, 0xE7, 0x38, 0xEE, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F,
  0xF1, 0xCE, 0x39, 0xE7, 0x1E, 0xE1, 0xE0, 0xFE, 0x3F, 0x8F, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0xCD, 0xDB, 0xFF, 0xFF, 0xF7, 0x3E, 0xE7,
  0xDC, 0xFB, 0x9F, 0x73, 0xEE, 0x7D, 0xCF, 0xB9, 0xF7, 0x30, 0xCF, 0x37,
  0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0x0F, 0x07, 0xF1, 0xFF, 0x38, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0xCE, 0x3F, 0xEF, 0xFB, 0x8F, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEF, 0xFB, 0xFC, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x1C, 0xE7, 0xFD, 0xFF, 0xB8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xF0, 0xEE, 0x3D, 0xFF, 0x9F, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0xE7, 0xF7, 0xFF, 0xFE, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x00, 0x1F, 0x07, 0xF9, 0xC7, 0xB8, 0x77, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0xEE, 0x1D, 0xFF, 0x1F, 0xC0, 0x1C, 0x03, 0x83, 0xFF, 0x7F,
  0xEF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x10,
  0xFE, 0x0F, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFF, 0xFD, 0xF7, 0xE0, 0xFC, 0x1D, 0xC3, 0xB8, 0xE7,
  0x1C, 0x63, 0x0E, 0xE1, 0xDC, 0x1B, 0x03, 0xE0, 0x3C, 0x07, 0x00, 0xE7,
  0x3F, 0x39, 0xD9, 0xCC, 0xCE, 0x67, 0x77, 0x3A, 0xB9, 0xF7, 0xC7, 0xBC,
  0x3D, 0xE1, 0xCF, 0x0E, 0x38, 0x71, 0xC0, 0xE0, 0xF7, 0x0E, 0x39, 0xC3,
  0xB8, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x3F, 0x83, 0x9C, 0x71, 0xEF,
  0x0F, 0xE0, 0x7E, 0x0F, 0x70, 0xE7, 0x0E, 0x71, 0xC3, 0x9C, 0x39, 0xC1,
  0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x7C, 0x07,
  0x80, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x78, 0x1E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF0, 0x06, 0x1C, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x19, 0xF3, 0x83, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x38,
  0x30, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x38, 0x7C, 0x79, 0xE3, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0x87, 0x0C, 0x00, 0x38, 0x07, 0xE3, 0x7F, 0xFC, 0x3F, 0x01, 0xE0,
};

const GFXglyph RobotoMono_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 7, 6, 13, 3, -17 },
  { 13, 12, 16, 13, 0, -16 },
  { 37, 11, 20, 13, 1, -18 },
  { 65, 13, 16, 13, 0, -16 },
  { 91, 12, 16, 13, 1, -16 },
  { 115, 2, 6, 13, 5, -17 },
  { 117, 6, 22, 13, 4, -17 },
  { 134, 6, 22, 13, 3, -17 },
  { 151, 11, 11, 13, 2, -16 },
  { 167, 11, 11, 13, 1, -13 },
  { 183, 4, 7, 13, 4, -3 },
  { 187, 9, 2, 13, 3, -8 },
  { 190, 4, 4, 13, 5, -4 },
  { 192, 9, 17, 13, 2, -16 },
  { 212, 10, 16, 13, 2, -16 },
  { 232, 7, 16, 13, 2, -16 },
  { 246, 11, 16, 13, 1, -16 },
  { 268, 11, 16, 13, 1, -16 },
  { 290, 11, 16, 13, 1, -16 },
  { 312, 11, 16, 13, 1, -16 },
  { 334, 11, 16, 13, 1, -16 },
  { 356, 11, 16, 13, 1, -16 },
  { 378, 11, 16, 13, 1, -16 },
  { 400, 11, 16, 13, 1, -16 },
  { 422, 4, 13, 13, 5, -13 },
  { 429, 4, 17, 13, 5, -13 },
  { 438, 9, 10, 13, 2, -12 },
  { 450, 10, 7, 13, 2, -10 },
  { 459, 9, 10, 13, 2, -12 },
  { 471, 10, 16, 13, 2, -16 },
  { 491, 13, 15, 13, 0, -15 },
  { 516, 13, 16, 13, 0, -16 },
  { 542, 12, 16, 13, 1, -16 },
  { 566, 11, 16, 13, 1, -16 },
  { 588, 11, 16, 13, 1, -16 },
  { 610, 10, 16, 13, 2, -16 },
  { 630, 10, 16, 13, 2, -16 },
  { 650, 11, 16, 13, 1, -16 },
  { 672, 11, 16, 13, 1, -16 },
  { 694, 9, 16, 13, 2, -16 },
  { 712, 11, 16, 13, 1, -16 },
  { 734, 13, 16, 13, 1, -16 },
  { 760, 10, 16, 13, 2, -16 },
  { 780, 11, 16, 13, 1, -16 },
  { 802, 11, 16, 13, 1, -16 },
  { 824, 11, 16, 13, 1, -16 },
  { 846, 11, 16, 13, 2, -16 },
  { 868, 12, 19, 13, 1, -16 },
  { 897, 12, 16, 13, 1, -16 },
  { 921, 12, 16, 13, 1, -16 },
  { 945, 13, 16, 13, 0, -16 },
  { 971, 11, 16, 13, 1, -16 },
  { 993, 13, 16, 13, 0, -16 },
  { 1019, 13, 16, 13, 0, -16 },
  { 1045, 13, 16, 13, 0, -16 },
  { 1071, 13, 16, 13, 0, -16 },
  { 1097, 11, 16, 13, 1, -16 },
  { 1119, 5, 22, 13, 4, -18 },
  { 1133, 8, 17, 13, 3, -16 },
  { 1150, 5, 22, 13, 4, -18 },
  { 1164, 9, 9, 13, 2, -16 },
  { 1175, 9, 2, 13, 2, 0 },
  { 1178, 6, 3, 13, 4, -16 },
  { 1181, 11, 12, 13, 1, -12 },
  { 1198, 10, 17, 13, 2, -17 },
  { 1220, 11, 12, 13, 1, -12 },
  { 1237, 11, 17, 13, 1, -17 },
  { 1261, 11, 12, 13, 1, -12 },
  { 1278, 11, 17, 13, 1, -17 },
  { 1302, 11, 17, 13, 1, -12 },
  { 1326, 10, 17, 13, 2, -17 },
  { 1348, 10, 16, 13, 2, -16 },
  { 1368, 7, 21, 13, 2, -16 },
  { 1387, 11, 17, 13, 2, -17 },
  { 1411, 10, 17, 13, 2, -17 },
  { 1433, 11, 12, 13, 1, -12 },
  { 1450, 10, 12, 13, 2, -12 },
  { 1465, 11, 12, 13, 1, -12 },
  { 1482, 10, 16, 13, 2, -12 },
  { 1502, 11, 16, 13, 1, -12 },
  { 1524, 9, 12, 13, 3, -12 },
  { 1538, 11, 12, 13, 1, -12 },
  { 1555, 11, 14, 13, 1, -14 },
  { 1575, 10, 12, 13, 2, -12 },
  { 1590, 11, 12, 13, 1, -12 },
  { 1607, 13, 12, 13, 0, -12 },
  { 1627, 12, 12, 13, 1, -12 },
  { 1645, 12, 17, 13, 1, -12 },
  { 1671, 11, 12, 13, 1, -12 },
  { 1688, 7, 21, 13, 3, -17 },
  { 1707, 2, 20, 13, 6, -16 },
  { 1712, 7, 21, 13, 4, -17 },
  { 1731, 12, 5, 13, 0, -9 },
};

const GFXfont RobotoMono_Bold22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold22pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_BOLD22PT7B_H_
