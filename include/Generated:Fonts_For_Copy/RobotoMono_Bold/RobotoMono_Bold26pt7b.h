#ifndef _ROBOTOMONO_BOLD26PT7B_H_
#define _ROBOTOMONO_BOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0x00, 0x6F, 0xFE, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0x80, 0x06, 0x70, 0x39, 0xC0, 0xE6, 0x03, 0x18,
  0x0C, 0x63, 0xFF, 0xFF, 0xFF, 0xC7, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C,
  0x3F, 0xFE, 0xFF, 0xF8, 0xE6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x81, 0xCE,
  0x00, 0x07, 0x00, 0x70, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0x7F,
  0x07, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xFE,
  0x07, 0xE0, 0x7F, 0x07, 0xFF, 0xF7, 0xFE, 0x1F, 0xC0, 0x60, 0x06, 0x00,
  0x60, 0x18, 0x00, 0xFC, 0x01, 0x98, 0x07, 0x39, 0x8E, 0x73, 0x1C, 0xEC,
  0x1F, 0x98, 0x1F, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x19, 0xC0,
  0x67, 0xC0, 0xDD, 0xC3, 0x31, 0x86, 0x63, 0x00, 0xC6, 0x01, 0xFC, 0x01,
  0xF0, 0x07, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xEF, 0x03, 0x8E, 0x07, 0x1C,
  0x0E, 0x70, 0x1F, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xFC, 0x73, 0xFC, 0xEF,
  0x3D, 0xDE, 0x7F, 0xBC, 0x7E, 0x78, 0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xFE,
  0xF8, 0xFF, 0xED, 0xB0, 0x02, 0x0C, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x70,
  0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x83, 0x07, 0x0E,
  0x0E, 0x0E, 0x0C, 0x08, 0x81, 0x83, 0x83, 0x83, 0x87, 0x07, 0x0E, 0x1E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x0E,
  0x38, 0xF1, 0xC2, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x2F, 0x67,
  0xFF, 0xFC, 0x3E, 0x01, 0xE0, 0x1D, 0x80, 0xCE, 0x1E, 0x38, 0x61, 0xC0,
  0x04, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x77, 0x77, 0x7E, 0xEC, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0xF0, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0x0E, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE3, 0xFE, 0x7F, 0xFE, 0xFF, 0x8F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0E,
  0x7F, 0xE7, 0xFC, 0x1F, 0x80, 0x07, 0x1F, 0xFF, 0xFF, 0xE7, 0x87, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x01, 0xFE, 0x1F, 0xF8, 0xF1, 0xEF, 0x0F, 0x70, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x81, 0xFF, 0x1F, 0xFC, 0xF1,
  0xEF, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0x7E, 0x03, 0xFC,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0xC1, 0xFE, 0x0F, 0x7F, 0xF1, 0xFF, 0x07,
  0xF0, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0xEE, 0x07, 0x70, 0x73,
  0x87, 0x9C, 0x38, 0xE3, 0x87, 0x1C, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0x83, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xB8, 0x3D, 0xE1, 0xEF, 0xFE, 0x3F, 0xE0, 0xFE,
  0x00, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0x7F, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x0E, 0xFC, 0xFF, 0xF7, 0xFF, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3D,
  0xC1, 0xEF, 0x0E, 0x3F, 0xF1, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0xCF, 0x1E, 0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0xF8,
  0x3F, 0xC1, 0xEE, 0x0F, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0x07, 0x00, 0xFE,
  0x0F, 0xF8, 0xF1, 0xE7, 0x0F, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B,
  0xC7, 0xDF, 0xFE, 0x7F, 0xE1, 0xF7, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x1F,
  0xC0, 0xFC, 0x07, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x77,
  0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0xE7, 0x30, 0x00,
  0x20, 0x1C, 0x1F, 0x8F, 0xFF, 0xF1, 0xF0, 0x3E, 0x07, 0xF8, 0x3F, 0xE0,
  0xFC, 0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x03, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xC0, 0x78, 0x7F, 0x7F, 0x9F, 0xC3, 0xC0, 0x60, 0x00, 0x0F, 0x03, 0xFC,
  0x7F, 0xEF, 0x9F, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x7C,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x63, 0x3E, 0x6C,
  0xFC, 0xD9, 0x99, 0xB7, 0x33, 0x6C, 0x66, 0xD8, 0xCD, 0xB1, 0x93, 0x73,
  0x66, 0x7F, 0xCC, 0xE7, 0x1C, 0x00, 0x1C, 0x10, 0x1F, 0xE0, 0x1F, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F,
  0xFF, 0xC7, 0xFF, 0xB8, 0xFD, 0xC0, 0xEE, 0x07, 0xF0, 0x3B, 0x83, 0xDF,
  0xFC, 0xFF, 0xC7, 0xFF, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0x00, 0x07, 0x00, 0x7F, 0x83, 0xFF, 0x1E,
  0x3E, 0x70, 0x7B, 0xC0, 0xEF, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0x03, 0x9E, 0x1E, 0x7F, 0xF0,
  0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0x0F, 0xFC, 0xE7, 0xEE, 0x1E, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF,
  0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xF8, 0xF7, 0x87, 0xF8, 0x1F, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x7F, 0xE3, 0xFF, 0x03, 0xF8, 0x1D,
  0xC0, 0xEF, 0x07, 0x3F, 0xF9, 0xFF, 0xC3, 0xF8, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF8, 0x3D, 0xC1,
  0xEF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0xE0, 0x7F, 0x83, 0xCE, 0x1E, 0x38,
  0xF8, 0xE3, 0xC3, 0x9E, 0x0E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x3C, 0xF0, 0xE3, 0xE3, 0x87, 0x8E, 0x0F, 0x38, 0x3C, 0xE0, 0x7B,
  0x81, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xFB,
  0xFF, 0xFF, 0xFF, 0x7E, 0xF7, 0xEF, 0x7E, 0xE7, 0xEE, 0x7E, 0x67, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x8F, 0xF8, 0xFF, 0xCF, 0xFC, 0xFE, 0xEF, 0xEE, 0xFE, 0x6F, 0xE7,
  0xFE, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0x07,
  0x00, 0x7F, 0x83, 0xFF, 0x1E, 0x3C, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xBC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC0, 0xEF,
  0x07, 0x9E, 0x1E, 0x7F, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xC7, 0xFF,
  0x38, 0x7D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1E, 0xFF, 0xF7,
  0xFF, 0x3F, 0xF1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0x3C, 0x70, 0x7B,
  0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0x9E, 0x1E, 0x7F, 0xF0, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x60, 0xFF, 0xC7, 0xFF, 0x38, 0xFD, 0xC1,
  0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xDC, 0x1E, 0xFF, 0xF7, 0xFE, 0x3F, 0xE1,
  0xC7, 0x8E, 0x1C, 0x70, 0xF3, 0x83, 0xDC, 0x1E, 0xE0, 0x7F, 0x03, 0xC0,
  0x03, 0x80, 0x7F, 0x83, 0xFF, 0x9E, 0x1E, 0x70, 0x3D, 0xC0, 0xF7, 0x80,
  0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x3F, 0xC0,
  0xFF, 0x03, 0xDE, 0x0F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x7F, 0xC3, 0xF8, 0xF8,
  0x1E, 0xF0, 0x3D, 0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0xC7, 0x87, 0x0F, 0x1E,
  0x0E, 0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xF3, 0x8E, 0xE7,
  0x1D, 0xCF, 0x3B, 0x9E, 0x77, 0x3D, 0xEE, 0x7B, 0xDD, 0xF7, 0x3F, 0xEE,
  0x3F, 0xDC, 0x7D, 0xF8, 0xFB, 0xF1, 0xF7, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F,
  0x9E, 0x0E, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0x78, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFB, 0xFF, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFC, 0xF0, 0x1C,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0xFF,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFC, 0x1E, 0x07, 0x81, 0xF0, 0xFC, 0x33,
  0x1C, 0xE7, 0x3B, 0x87, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1,
  0xE3, 0xC7, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE1, 0xE0, 0x07, 0x00, 0x38,
  0x7F, 0xCF, 0xFE, 0x78, 0x77, 0x83, 0xBC, 0x1C, 0xFF, 0xE7, 0xFF, 0x9F,
  0xBC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8F,
  0xFC, 0xFF, 0xEF, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xF0, 0xFF, 0xFE, 0xFF, 0xEE, 0xFC, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC,
  0xF0, 0xE7, 0x07, 0xB8, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x83, 0xDE,
  0x1E, 0x7F, 0xE3, 0xFE, 0x07, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x3D, 0xE7, 0xFF, 0x7F, 0xFB, 0xC7, 0xDC, 0x1E,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEE, 0x0F, 0x78, 0x7B, 0xFF, 0xCF,
  0xFE, 0x3E, 0xF0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x83, 0xB8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x04, 0x7F, 0xF1, 0xFF,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x3E, 0x01, 0xE0, 0x0F, 0x03,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0F,
  0x39, 0xFD, 0xCF, 0xFE, 0xF0, 0xF7, 0x07, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7B, 0x83, 0xDE, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x01, 0xE4,
  0x0F, 0x39, 0xF3, 0xFF, 0x07, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE7, 0xCE, 0xFE, 0xFF, 0xEF, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x0E, 0x03, 0xC0, 0x38, 0x02, 0x00, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0x0F, 0x0F, 0x06, 0x00, 0x7F, 0x7F, 0x7F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x9F, 0xFE, 0xFC, 0x40, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x83, 0xDC, 0x3C, 0xE3, 0xC7, 0x3E, 0x3B, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x1E, 0x78, 0xE3, 0xE7, 0x0F, 0x38, 0x3D, 0xC0,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xEE, 0x73, 0xFF, 0xEF, 0xFF, 0xB9, 0xCF,
  0xE7, 0x3F, 0x9C, 0xFE, 0x73, 0xF9, 0xCF, 0xE7, 0x3F, 0x9C, 0xFE, 0x73,
  0xF9, 0xCF, 0xE7, 0x3F, 0x9C, 0xF0, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0x83, 0xDE, 0x1E, 0xFF, 0xE3, 0xFE,
  0x07, 0xE0, 0xE7, 0x8F, 0xFC, 0xFF, 0xEF, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0xFF, 0xEE, 0xF8, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x39, 0xFF, 0xDF, 0xFE,
  0xF0, 0xF7, 0x07, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0x83, 0xDE,
  0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xBC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0x87, 0xFE, 0xFF,
  0xFF, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x9F, 0x7F, 0xE3, 0xFC, 0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF,
  0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x3F, 0xC0, 0xE7, 0x07, 0x9E, 0x1C, 0x38,
  0x70, 0xE3, 0xC3, 0xCE, 0x07, 0x38, 0x1D, 0xE0, 0x77, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF3, 0x8E, 0xE7, 0x1D, 0xCE, 0x7B, 0x9C,
  0xE7, 0x3D, 0xCE, 0x7B, 0x9D, 0xB7, 0x1B, 0x6E, 0x3E, 0xDC, 0x7C, 0xF0,
  0xF9, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0x8F, 0x00, 0xF0, 0x3D, 0xE1, 0xE3,
  0xC7, 0x0F, 0x3C, 0x1F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x7F, 0x81, 0xCF, 0x0F, 0x3C, 0x78, 0x7B, 0xC0, 0xF0, 0xF0, 0x1F, 0xE0,
  0x79, 0xC0, 0xF3, 0xC3, 0xC3, 0x87, 0x87, 0x8E, 0x0F, 0x3C, 0x0E, 0x70,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0x00, 0x00, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x0F,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0xF8, 0xF0, 0x78,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x78, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xF0, 0xF8, 0xF8, 0x70, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC1, 0xE0, 0x80, 0x00, 0x3E, 0x0E,
  0xFE, 0x19, 0xDF, 0xF7, 0x0F, 0xE0, 0x0F, 0x80,
};

const GFXglyph RobotoMono_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 18, 16, 6, -18 },
  { 10, 7, 7, 16, 4, -20 },
  { 17, 14, 18, 16, 1, -18 },
  { 49, 12, 24, 16, 2, -21 },
  { 85, 15, 19, 16, 0, -19 },
  { 121, 15, 19, 16, 1, -19 },
  { 157, 3, 7, 16, 6, -20 },
  { 160, 7, 27, 16, 4, -21 },
  { 184, 7, 27, 16, 4, -21 },
  { 208, 13, 13, 16, 2, -18 },
  { 230, 13, 13, 16, 1, -15 },
  { 252, 4, 8, 16, 5, -3 },
  { 256, 10, 3, 16, 4, -10 },
  { 260, 5, 4, 16, 5, -4 },
  { 263, 10, 20, 16, 3, -18 },
  { 288, 12, 19, 16, 2, -19 },
  { 317, 8, 18, 16, 2, -18 },
  { 335, 13, 19, 16, 1, -19 },
  { 366, 13, 19, 16, 1, -19 },
  { 397, 13, 18, 16, 1, -18 },
  { 427, 13, 18, 16, 1, -18 },
  { 457, 13, 19, 16, 1, -19 },
  { 488, 13, 18, 16, 1, -18 },
  { 518, 13, 19, 16, 1, -19 },
  { 549, 13, 19, 16, 1, -19 },
  { 580, 4, 14, 16, 6, -14 },
  { 587, 5, 19, 16, 6, -14 },
  { 599, 11, 12, 16, 2, -14 },
  { 616, 12, 8, 16, 2, -12 },
  { 628, 11, 12, 16, 2, -14 },
  { 645, 12, 19, 16, 2, -19 },
  { 674, 15, 18, 16, 0, -18 },
  { 708, 16, 18, 16, 0, -18 },
  { 744, 13, 18, 16, 2, -18 },
  { 774, 14, 19, 16, 1, -19 },
  { 808, 12, 18, 16, 2, -18 },
  { 835, 12, 18, 16, 2, -18 },
  { 862, 12, 18, 16, 2, -18 },
  { 889, 13, 19, 16, 1, -19 },
  { 920, 12, 18, 16, 2, -18 },
  { 947, 11, 18, 16, 2, -18 },
  { 972, 13, 18, 16, 1, -18 },
  { 1002, 14, 18, 16, 2, -18 },
  { 1034, 12, 18, 16, 2, -18 },
  { 1061, 12, 18, 16, 2, -18 },
  { 1088, 12, 18, 16, 2, -18 },
  { 1115, 14, 19, 16, 1, -19 },
  { 1149, 13, 18, 16, 2, -18 },
  { 1179, 14, 22, 16, 1, -19 },
  { 1218, 13, 18, 16, 2, -18 },
  { 1248, 14, 19, 16, 1, -19 },
  { 1282, 15, 18, 16, 0, -18 },
  { 1316, 12, 18, 16, 2, -18 },
  { 1343, 15, 18, 16, 0, -18 },
  { 1377, 15, 18, 16, 0, -18 },
  { 1411, 16, 18, 16, 0, -18 },
  { 1447, 16, 18, 16, 0, -18 },
  { 1483, 14, 18, 16, 1, -18 },
  { 1515, 6, 25, 16, 5, -21 },
  { 1534, 10, 20, 16, 3, -18 },
  { 1559, 6, 25, 16, 5, -21 },
  { 1578, 10, 9, 16, 3, -18 },
  { 1590, 11, 3, 16, 2, 0 },
  { 1595, 6, 4, 16, 5, -19 },
  { 1598, 13, 14, 16, 1, -14 },
  { 1621, 12, 20, 16, 2, -20 },
  { 1651, 13, 14, 16, 1, -14 },
  { 1674, 13, 20, 16, 1, -20 },
  { 1707, 13, 14, 16, 1, -14 },
  { 1730, 13, 20, 16, 2, -20 },
  { 1763, 13, 19, 16, 1, -14 },
  { 1794, 12, 20, 16, 2, -20 },
  { 1824, 11, 19, 16, 3, -19 },
  { 1851, 8, 25, 16, 3, -19 },
  { 1876, 13, 20, 16, 2, -20 },
  { 1909, 11, 20, 16, 3, -20 },
  { 1937, 14, 14, 16, 1, -14 },
  { 1962, 12, 14, 16, 2, -14 },
  { 1983, 13, 14, 16, 1, -14 },
  { 2006, 12, 19, 16, 2, -14 },
  { 2035, 13, 19, 16, 1, -14 },
  { 2066, 10, 14, 16, 4, -14 },
  { 2084, 12, 14, 16, 2, -14 },
  { 2105, 12, 17, 16, 2, -17 },
  { 2131, 12, 14, 16, 2, -14 },
  { 2152, 14, 14, 16, 1, -14 },
  { 2177, 15, 14, 16, 0, -14 },
  { 2204, 14, 14, 16, 1, -14 },
  { 2229, 15, 20, 16, 1, -14 },
  { 2267, 13, 14, 16, 1, -14 },
  { 2290, 8, 25, 16, 4, -20 },
  { 2315, 2, 23, 16, 7, -18 },
  { 2321, 9, 25, 16, 4, -20 },
  { 2350, 15, 5, 16, 0, -10 },
};

const GFXfont RobotoMono_Bold26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Bold26pt7bBitmaps,
  (GFXglyph *)RobotoMono_Bold26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_BOLD26PT7B_H_
