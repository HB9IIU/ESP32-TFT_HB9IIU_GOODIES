#ifndef _ROBOTOCONDENSED_THIN57PT7B_H_
#define _ROBOTOCONDENSED_THIN57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin57pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0x80, 0x00, 0x00, 0x17, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC2, 0xC2, 0xC2, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x08, 0x00, 0x08, 0x02, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xC0, 0x10,
  0x04, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x20, 0x08, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x08, 0x00, 0x08, 0x02, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x10,
  0x04, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x00, 0xE0, 0x70, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x04, 0x00, 0x0C, 0x60,
  0x00, 0x62, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x80, 0x00, 0x6C, 0x00, 0x01,
  0x60, 0x00, 0x09, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x28, 0x00, 0x03, 0x40, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0x60,
  0x00, 0xE1, 0xC0, 0x0E, 0x07, 0x80, 0xE0, 0x0F, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x60, 0x04, 0x01, 0x80, 0xC0, 0x08, 0x02,
  0x01, 0x80, 0x10, 0x0C, 0x03, 0x00, 0x20, 0x10, 0x06, 0x00, 0x40, 0x60,
  0x0C, 0x00, 0x81, 0x80, 0x18, 0x03, 0x03, 0x00, 0x10, 0x06, 0x0C, 0x00,
  0x30, 0x08, 0x10, 0x00, 0x20, 0x30, 0x60, 0x00, 0x70, 0xC0, 0x80, 0x00,
  0x7F, 0x03, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x06, 0x07, 0xF0, 0x00, 0x08, 0x18, 0x30, 0x00, 0x30, 0x60, 0x20, 0x00,
  0x40, 0x80, 0x60, 0x01, 0x83, 0x00, 0x40, 0x02, 0x06, 0x00, 0xC0, 0x0C,
  0x08, 0x01, 0x80, 0x10, 0x10, 0x03, 0x00, 0x60, 0x20, 0x06, 0x01, 0x80,
  0x40, 0x0C, 0x02, 0x00, 0x80, 0x18, 0x0C, 0x01, 0x00, 0x30, 0x10, 0x03,
  0x00, 0x60, 0x20, 0x02, 0x00, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x30, 0x70, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x80, 0x08, 0x00,
  0x20, 0x02, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x20, 0x00, 0x80, 0x18,
  0x00, 0x20, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40,
  0x40, 0x00, 0x18, 0x30, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x18, 0x01, 0x0C, 0x03,
  0x00, 0x42, 0x00, 0x40, 0x11, 0x80, 0x18, 0x04, 0x40, 0x03, 0x01, 0x10,
  0x00, 0x60, 0xCC, 0x00, 0x08, 0x33, 0x00, 0x03, 0x08, 0xC0, 0x00, 0x66,
  0x30, 0x00, 0x0D, 0x8C, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x1C, 0x18, 0x00, 0x0D, 0x83, 0x00, 0x06, 0x60, 0x60, 0x03, 0x0C, 0x0E,
  0x03, 0x81, 0x81, 0xFF, 0x80, 0x20, 0x02, 0x00, 0x00, 0xFF, 0xFE, 0xAA,
  0x00, 0x40, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x20, 0x0C, 0x03, 0xF0, 0x30, 0x3C, 0xF0, 0xC7,
  0x80, 0x7B, 0x78, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00,
  0x0C, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x60, 0x20, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x18, 0xC6, 0x31, 0x8C, 0x46, 0x23, 0x10, 0xFF, 0xE0, 0xFD, 0x00,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0xC0,
  0x18, 0x03, 0x00, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0x86, 0x00,
  0x06, 0x20, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x34,
  0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00,
  0x00, 0x68, 0x00, 0x03, 0x60, 0x00, 0x13, 0x00, 0x00, 0x88, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x20, 0x03, 0x01, 0x80,
  0x30, 0x07, 0x03, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x20, 0x3C,
  0x1C, 0x8E, 0x1F, 0x03, 0x80, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00,
  0xE0, 0x30, 0x06, 0x00, 0x60, 0x10, 0x00, 0xC0, 0xC0, 0x01, 0x86, 0x00,
  0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xC0, 0xE0, 0x18, 0x01,
  0x81, 0x80, 0x06, 0x18, 0x00, 0x10, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x06, 0x80, 0x00,
  0x36, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x83, 0x80, 0x18, 0x0F,
  0x01, 0x80, 0x1F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x18,
  0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60,
  0x40, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80,
  0x40, 0x03, 0x00, 0x40, 0x03, 0x00, 0x40, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x40, 0x08, 0x00, 0x40, 0x18, 0x00, 0x40, 0x30, 0x00,
  0x40, 0x30, 0x00, 0x40, 0x60, 0x00, 0x40, 0x60, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x1F, 0xFF,
  0xE3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x3F, 0x80, 0x6F, 0xBE, 0x07, 0x80, 0x30, 0x60, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x40,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80,
  0xE0, 0x70, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x07, 0xF0, 0x10, 0xFB,
  0xE0, 0x8C, 0x03, 0x84, 0xC0, 0x06, 0x2C, 0x00, 0x11, 0xC0, 0x00, 0xCC,
  0x00, 0x02, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0x90, 0x00, 0x08, 0xC0, 0x00, 0xC3, 0x00, 0x04, 0x0C, 0x00, 0x60, 0x70,
  0x06, 0x00, 0xE0, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x70, 0x38, 0x03,
  0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00,
  0x04, 0x60, 0x00, 0x19, 0x00, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x06,
  0x40, 0x00, 0x19, 0x00, 0x00, 0x66, 0x00, 0x01, 0x18, 0x00, 0x04, 0x30,
  0x00, 0x30, 0xC0, 0x01, 0x81, 0x80, 0x0C, 0x03, 0x80, 0x60, 0x03, 0xDF,
  0x00, 0x07, 0xF8, 0x00, 0x70, 0x38, 0x06, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x80, 0x00, 0xC6, 0x00, 0x01, 0x90, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x40, 0x00, 0x19, 0x80, 0x00, 0x43,
  0x00, 0x03, 0x06, 0x00, 0x38, 0x0E, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0x81, 0xC0, 0x18, 0x03,
  0x01, 0x80, 0x0C, 0x18, 0x00, 0x30, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40,
  0x00, 0x32, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0, 0x00, 0x14,
  0x80, 0x01, 0xA6, 0x00, 0x0B, 0x18, 0x00, 0xD8, 0x60, 0x18, 0xC1, 0xE7,
  0x86, 0x03, 0xF0, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x70, 0x39, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x84, 0x21, 0x08, 0x46, 0x33, 0x18, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x06,
  0x07, 0x06, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x02,
  0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x01, 0xF0, 0x00, 0x43, 0x00, 0x0F, 0xF8, 0x00, 0x84,
  0x00, 0x30, 0x18, 0x01, 0x18, 0x00, 0xC0, 0x10, 0x03, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x40, 0x04, 0x00, 0x40, 0x05, 0x80, 0x18, 0x00, 0x80, 0x0B,
  0x00, 0x20, 0x01, 0x00, 0x16, 0x00, 0xC0, 0x02, 0x00, 0x28, 0x01, 0x80,
  0x0C, 0x00, 0x50, 0x02, 0x00, 0x18, 0x00, 0xA0, 0x04, 0x00, 0x30, 0x01,
  0x40, 0x18, 0x00, 0x60, 0x02, 0x80, 0x30, 0x00, 0xC0, 0x05, 0x00, 0x60,
  0x01, 0x80, 0x0A, 0x00, 0xC0, 0x02, 0x00, 0x14, 0x01, 0x00, 0x04, 0x00,
  0x68, 0x02, 0x00, 0x08, 0x00, 0xD0, 0x04, 0x00, 0x10, 0x01, 0x20, 0x0C,
  0x00, 0x60, 0x02, 0x40, 0x18, 0x00, 0xC0, 0x0C, 0x80, 0x30, 0x03, 0x80,
  0x19, 0x80, 0x20, 0x05, 0x00, 0x23, 0x00, 0x60, 0x1B, 0x00, 0xC6, 0x00,
  0xC0, 0x62, 0x03, 0x04, 0x00, 0xC1, 0x86, 0x0C, 0x0C, 0x00, 0xFE, 0x07,
  0xF0, 0x18, 0x00, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x08, 0x01, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x00, 0x80, 0x01, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60,
  0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0x00, 0x80,
  0x00, 0x10, 0x08, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xF8, 0x03, 0x00, 0xFC, 0x0C, 0x00,
  0x1C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x1C, 0x30, 0x07, 0xC0,
  0xFF, 0xFF, 0x03, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x13, 0x00,
  0x00, 0xCC, 0x00, 0x0E, 0x30, 0x03, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x03, 0x01, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x03, 0x40, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x03, 0x80, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x1F, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0xC0, 0xC0, 0x3F,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xE3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x10, 0x00, 0x03, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x78,
  0x01, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0x60, 0x00, 0xC6, 0x00,
  0x18, 0x30, 0x03, 0x01, 0xC0, 0xE0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xF0,
  0x00, 0x0C, 0xCC, 0x00, 0x06, 0xC2, 0x00, 0x03, 0x41, 0x80, 0x01, 0xC0,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x04, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x05, 0xF0, 0x00, 0x00, 0x05, 0xD0, 0x00, 0x00, 0x0D, 0xD8, 0x00,
  0x00, 0x09, 0xD8, 0x00, 0x00, 0x09, 0xC8, 0x00, 0x00, 0x19, 0xCC, 0x00,
  0x00, 0x11, 0xC4, 0x00, 0x00, 0x31, 0xC4, 0x00, 0x00, 0x31, 0xC6, 0x00,
  0x00, 0x21, 0xC2, 0x00, 0x00, 0x61, 0xC3, 0x00, 0x00, 0x41, 0xC3, 0x00,
  0x00, 0x41, 0xC1, 0x00, 0x00, 0xC1, 0xC1, 0x80, 0x00, 0x81, 0xC0, 0x80,
  0x00, 0x81, 0xC0, 0x80, 0x01, 0x81, 0xC0, 0xC0, 0x01, 0x01, 0xC0, 0x40,
  0x03, 0x01, 0xC0, 0x40, 0x03, 0x01, 0xC0, 0x60, 0x02, 0x01, 0xC0, 0x20,
  0x06, 0x01, 0xC0, 0x30, 0x04, 0x01, 0xC0, 0x30, 0x04, 0x01, 0xC0, 0x10,
  0x0C, 0x01, 0xC0, 0x18, 0x08, 0x01, 0xC0, 0x08, 0x08, 0x01, 0xC0, 0x08,
  0x18, 0x01, 0xC0, 0x0C, 0x10, 0x01, 0xC0, 0x04, 0x30, 0x01, 0xC0, 0x04,
  0x30, 0x01, 0xC0, 0x06, 0x20, 0x01, 0xC0, 0x02, 0x60, 0x01, 0xC0, 0x03,
  0x40, 0x01, 0xC0, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x07, 0x20, 0x00, 0x03, 0x98, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE1, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0x20, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x04,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x20, 0x00, 0xE0,
  0x18, 0x00, 0x70, 0x04, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x18, 0x03, 0x80, 0x04, 0x01, 0xC0, 0x03, 0x00,
  0xE0, 0x00, 0x80, 0x70, 0x00, 0x60, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C,
  0x0E, 0x00, 0x03, 0x07, 0x00, 0x00, 0x83, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x10, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x17, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x3C,
  0x01, 0xC0, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x08, 0x40, 0x00, 0x06, 0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x63, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x70, 0x00,
  0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0x00, 0x3E, 0x0C,
  0x00, 0x0E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00,
  0x0C, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8C, 0x01, 0xF8, 0x3F, 0xFF, 0x80,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x03, 0x80, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFE, 0x00,
  0xC0, 0x0F, 0x80, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x10,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0xC0, 0x07, 0x80, 0xFF, 0xFE, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xF0, 0x0C, 0x00, 0x38,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x07, 0x80, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0D, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC6, 0x00, 0x03,
  0x07, 0x00, 0x0C, 0x07, 0x80, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x08,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x30, 0x04, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x08, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x08, 0x01, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00,
  0x05, 0x00, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x66, 0x00, 0x01, 0x40,
  0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0x88, 0x00, 0x08,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x62, 0x00, 0x06, 0x18, 0x00,
  0x31, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08, 0x20,
  0x00, 0x81, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x60,
  0x60, 0x02, 0x02, 0x00, 0x30, 0x30, 0x01, 0x01, 0x00, 0x10, 0x08, 0x01,
  0x80, 0x80, 0x08, 0x04, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x10,
  0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x30, 0x04, 0x01, 0x00,
  0x20, 0x18, 0x03, 0x01, 0x80, 0x18, 0x08, 0x01, 0x80, 0xC0, 0x0C, 0x04,
  0x00, 0x40, 0x60, 0x06, 0x06, 0x00, 0x20, 0x20, 0x01, 0x03, 0x00, 0x18,
  0x10, 0x00, 0xC1, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x02, 0x0C, 0x00,
  0x30, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0xC2, 0x00, 0x04, 0x20,
  0x00, 0x63, 0x00, 0x03, 0x10, 0x00, 0x11, 0x80, 0x01, 0x98, 0x00, 0x08,
  0xC0, 0x00, 0x4C, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x03, 0x20, 0x00,
  0x12, 0x00, 0x00, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x58, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x20, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x30, 0x30, 0x00, 0x04, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x02,
  0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x40, 0x08, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x04, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x40, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x30, 0x04, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x18, 0x01, 0x80, 0x00, 0x80,
  0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0x80, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0A, 0x00,
  0x34, 0x00, 0x6C, 0x00, 0x88, 0x03, 0x10, 0x04, 0x30, 0x08, 0x20, 0x30,
  0x40, 0x40, 0xC0, 0x80, 0x83, 0x01, 0x04, 0x03, 0x08, 0x02, 0x30, 0x06,
  0x40, 0x0C, 0x80, 0x0B, 0x00, 0x1C, 0x00, 0x30, 0xFF, 0xFF, 0xF8, 0xC0,
  0xC0, 0xC0, 0xC0, 0x81, 0x81, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0E,
  0x03, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00, 0x64,
  0x00, 0x06, 0xC0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x01, 0xFF, 0xE0, 0xFC, 0x02, 0x18, 0x00,
  0x23, 0x00, 0x02, 0x60, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x0E, 0xC0,
  0x00, 0xA4, 0x00, 0x12, 0x60, 0x06, 0x23, 0x81, 0xC2, 0x1F, 0xF8, 0x30,
  0x10, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x0F, 0xF8, 0x27,
  0x01, 0x85, 0x80, 0x18, 0xA0, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x03, 0x40,
  0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01, 0xB0, 0x00, 0x37, 0x00,
  0x0C, 0xB0, 0x03, 0x13, 0x80, 0xC2, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x3F, 0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC2,
  0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40,
  0x00, 0x36, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x04, 0x18, 0x00, 0xC0,
  0xE0, 0x38, 0x03, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x3F, 0xE1, 0x0E, 0x03, 0x11, 0x80, 0x19, 0x30,
  0x00, 0xD3, 0x00, 0x07, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0x60, 0x00, 0x12, 0x00, 0x03, 0x30, 0x00, 0x31, 0x00, 0x05, 0x18,
  0x00, 0x90, 0xE0, 0x31, 0x03, 0xFE, 0x10, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC2, 0x00, 0x06,
  0x60, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x02, 0x1C, 0x00, 0x60, 0xF0, 0x1C,
  0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x10, 0x03, 0xF0, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC1, 0x0E, 0x07, 0x11, 0x80, 0x19, 0x30, 0x00, 0xD3, 0x00,
  0x07, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x01, 0x40,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00,
  0x32, 0x00, 0x03, 0x30, 0x00, 0x73, 0x00, 0x05, 0x18, 0x00, 0x90, 0xE0,
  0x31, 0x03, 0xFE, 0x10, 0x06, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x30, 0x00, 0x61,
  0x80, 0x0C, 0x0C, 0x01, 0xC0, 0x7C, 0xF0, 0x01, 0xFC, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0xFF, 0x08, 0x60, 0x62, 0x20, 0x0C, 0x90, 0x01,
  0xAC, 0x00, 0x2E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x7D,
  0x80, 0x00, 0x00, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x40, 0x00, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x33, 0x78, 0x78, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x68, 0x00, 0x32, 0x00, 0x18, 0x80, 0x0C,
  0x20, 0x06, 0x08, 0x03, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x30, 0x08,
  0x18, 0x02, 0x0C, 0x00, 0x86, 0x00, 0x23, 0x00, 0x09, 0xC0, 0x02, 0xD8,
  0x00, 0xE3, 0x00, 0x30, 0x40, 0x08, 0x18, 0x02, 0x03, 0x00, 0x80, 0x60,
  0x20, 0x08, 0x08, 0x03, 0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x03, 0x08,
  0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1F, 0xE0,
  0x0F, 0xF0, 0xC7, 0x03, 0x03, 0x81, 0xCC, 0xC0, 0x18, 0x60, 0x0C, 0xD8,
  0x00, 0xCC, 0x00, 0x6D, 0x00, 0x05, 0x80, 0x02, 0xF0, 0x00, 0x50, 0x00,
  0x3E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x00, 0x20, 0xFF, 0x08, 0x60, 0x62, 0x20, 0x0C, 0x90, 0x01,
  0xAC, 0x00, 0x2E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xC0, 0xE0, 0x18, 0x01, 0x81, 0x80, 0x06,
  0x18, 0x00, 0x10, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x1A, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x11, 0x00, 0x01, 0x8C, 0x00, 0x08, 0x30, 0x00,
  0xC0, 0xC0, 0x0C, 0x03, 0x81, 0xC0, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0x82, 0x70, 0x18, 0x58, 0x01, 0x8A, 0x00, 0x19, 0x80,
  0x01, 0xB0, 0x00, 0x34, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00,
  0x1B, 0x00, 0x03, 0x70, 0x00, 0xCB, 0x00, 0x31, 0x38, 0x0C, 0x21, 0xFF,
  0x04, 0x02, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0x0E,
  0x07, 0x11, 0x80, 0x19, 0x30, 0x00, 0xD3, 0x00, 0x07, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00, 0x12, 0x00, 0x03, 0x30,
  0x00, 0x31, 0x00, 0x05, 0x18, 0x00, 0xD0, 0xE0, 0x31, 0x03, 0xFE, 0x10,
  0x06, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x10, 0xFE, 0x30, 0x4C, 0x0B,
  0x01, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x70, 0x1C, 0x18, 0x00, 0xC6, 0x00,
  0x08, 0x80, 0x01, 0x90, 0x00, 0x16, 0x00, 0x02, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x63, 0x00, 0x18, 0x38, 0x0E,
  0x03, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xF0, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x80, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80,
  0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x14, 0xC0,
  0x06, 0x98, 0x01, 0x91, 0xC0, 0xE2, 0x0F, 0xF8, 0x40, 0x20, 0x00, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x0C, 0x80, 0x00, 0x66, 0x00, 0x02,
  0x30, 0x00, 0x30, 0x80, 0x01, 0x86, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x80,
  0x06, 0x06, 0x00, 0x20, 0x30, 0x03, 0x00, 0x80, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x00, 0x80, 0x60, 0x06, 0x02, 0x00, 0x30, 0x30, 0x00, 0x81,
  0x80, 0x06, 0x08, 0x00, 0x30, 0xC0, 0x00, 0x86, 0x00, 0x04, 0x20, 0x00,
  0x33, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xA0, 0x00,
  0x60, 0x00, 0xD8, 0x00, 0x70, 0x00, 0x4C, 0x00, 0x28, 0x00, 0x62, 0x00,
  0x16, 0x00, 0x31, 0x00, 0x1B, 0x00, 0x18, 0xC0, 0x0C, 0x80, 0x08, 0x60,
  0x04, 0x40, 0x0C, 0x10, 0x02, 0x30, 0x06, 0x08, 0x03, 0x18, 0x03, 0x06,
  0x01, 0x84, 0x01, 0x03, 0x00, 0x83, 0x01, 0x80, 0x80, 0x41, 0x80, 0xC0,
  0x40, 0x60, 0x40, 0x60, 0x30, 0x30, 0x20, 0x20, 0x18, 0x10, 0x18, 0x30,
  0x04, 0x18, 0x0C, 0x18, 0x02, 0x0C, 0x02, 0x0C, 0x01, 0x84, 0x01, 0x04,
  0x00, 0xC2, 0x00, 0xC6, 0x00, 0x23, 0x00, 0x63, 0x00, 0x11, 0x80, 0x11,
  0x80, 0x0C, 0x80, 0x08, 0x80, 0x06, 0x40, 0x06, 0x40, 0x01, 0x60, 0x01,
  0x60, 0x00, 0xA0, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x36, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x80,
  0x18, 0x0C, 0x03, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x01,
  0x08, 0x00, 0x19, 0x80, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x01, 0x08, 0x00, 0x30, 0xC0,
  0x02, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x00, 0x80, 0x10, 0x18, 0x01,
  0x81, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x0C, 0x80, 0x00, 0x66,
  0x00, 0x02, 0x30, 0x00, 0x30, 0x80, 0x01, 0x86, 0x00, 0x08, 0x30, 0x00,
  0xC0, 0x80, 0x06, 0x06, 0x00, 0x20, 0x30, 0x03, 0x00, 0x80, 0x18, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x60, 0x06, 0x02, 0x00, 0x30, 0x10,
  0x00, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x40, 0x00, 0x86, 0x00, 0x06,
  0x30, 0x00, 0x11, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x14, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x70, 0x03, 0x80, 0x30, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x10, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x78, 0x00, 0x13,
  0x03, 0x00, 0x0D, 0x80, 0x60, 0x03, 0x40, 0x0C, 0x00, 0xB0, 0x01, 0x80,
  0x6C, 0x00, 0x30, 0x13, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Thin57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 42, 11, 4, -41 },
  { 17, 8, 11, 15, 4, -43 },
  { 28, 26, 41, 28, 2, -41 },
  { 162, 21, 53, 28, 3, -47 },
  { 302, 31, 43, 37, 3, -42 },
  { 469, 26, 43, 31, 3, -42 },
  { 609, 2, 12, 9, 4, -43 },
  { 612, 10, 58, 16, 4, -45 },
  { 685, 11, 58, 16, 1, -45 },
  { 765, 22, 22, 24, 1, -41 },
  { 826, 24, 29, 28, 2, -33 },
  { 913, 5, 11, 11, 2, -4 },
  { 920, 11, 1, 15, 2, -19 },
  { 922, 3, 3, 12, 4, -2 },
  { 924, 16, 44, 20, 1, -41 },
  { 1012, 21, 43, 28, 3, -42 },
  { 1125, 11, 41, 28, 5, -41 },
  { 1182, 22, 42, 28, 3, -42 },
  { 1298, 21, 43, 28, 3, -42 },
  { 1411, 24, 41, 28, 2, -41 },
  { 1534, 20, 42, 28, 5, -41 },
  { 1639, 21, 42, 28, 4, -41 },
  { 1750, 22, 41, 28, 2, -41 },
  { 1863, 22, 43, 28, 3, -42 },
  { 1982, 21, 42, 28, 3, -42 },
  { 2093, 4, 30, 10, 3, -29 },
  { 2108, 5, 36, 10, 2, -29 },
  { 2131, 20, 23, 26, 2, -30 },
  { 2189, 20, 11, 28, 4, -24 },
  { 2217, 20, 23, 26, 3, -30 },
  { 2275, 17, 43, 22, 3, -42 },
  { 2367, 39, 52, 46, 3, -39 },
  { 2621, 28, 41, 30, 1, -41 },
  { 2765, 22, 41, 30, 5, -41 },
  { 2878, 25, 43, 32, 4, -42 },
  { 3013, 24, 41, 33, 5, -41 },
  { 3136, 21, 41, 29, 5, -41 },
  { 3244, 22, 41, 29, 5, -41 },
  { 3357, 24, 43, 34, 5, -42 },
  { 3486, 25, 41, 35, 5, -41 },
  { 3615, 2, 41, 14, 6, -41 },
  { 3626, 20, 42, 28, 3, -41 },
  { 3731, 25, 41, 32, 5, -41 },
  { 3860, 19, 41, 26, 5, -41 },
  { 3958, 32, 41, 43, 5, -41 },
  { 4122, 25, 41, 35, 5, -41 },
  { 4251, 25, 43, 33, 4, -42 },
  { 4386, 22, 41, 30, 5, -41 },
  { 4499, 25, 49, 33, 4, -42 },
  { 4653, 24, 41, 33, 5, -41 },
  { 4776, 24, 43, 30, 3, -42 },
  { 4905, 26, 41, 30, 2, -41 },
  { 5039, 23, 42, 33, 5, -41 },
  { 5160, 28, 41, 30, 1, -41 },
  { 5304, 41, 41, 45, 2, -41 },
  { 5515, 26, 41, 30, 2, -41 },
  { 5649, 28, 41, 30, 1, -41 },
  { 5793, 24, 41, 30, 3, -41 },
  { 5916, 7, 55, 12, 5, -46 },
  { 5965, 16, 44, 19, 2, -41 },
  { 6053, 7, 55, 12, 0, -46 },
  { 6102, 15, 20, 21, 3, -41 },
  { 6140, 21, 1, 21, 0, 0 },
  { 6143, 7, 7, 15, 4, -42 },
  { 6150, 20, 32, 27, 3, -31 },
  { 6230, 19, 44, 28, 5, -43 },
  { 6335, 20, 32, 26, 3, -31 },
  { 6415, 20, 44, 28, 3, -43 },
  { 6525, 20, 32, 26, 3, -31 },
  { 6605, 14, 44, 16, 2, -44 },
  { 6682, 20, 43, 28, 3, -31 },
  { 6790, 18, 43, 28, 5, -43 },
  { 6887, 3, 41, 11, 4, -41 },
  { 6903, 10, 53, 12, -3, -41 },
  { 6970, 18, 43, 24, 5, -43 },
  { 7067, 1, 43, 11, 5, -43 },
  { 7073, 36, 31, 44, 4, -31 },
  { 7213, 18, 31, 28, 5, -31 },
  { 7283, 21, 32, 28, 3, -31 },
  { 7367, 19, 43, 28, 5, -31 },
  { 7470, 20, 43, 28, 3, -31 },
  { 7578, 11, 31, 17, 5, -31 },
  { 7621, 19, 32, 25, 3, -31 },
  { 7697, 13, 39, 16, 1, -38 },
  { 7761, 19, 31, 28, 4, -30 },
  { 7835, 21, 30, 24, 2, -30 },
  { 7914, 33, 30, 38, 2, -30 },
  { 8038, 20, 30, 24, 2, -30 },
  { 8113, 21, 42, 24, 2, -30 },
  { 8224, 20, 30, 24, 3, -30 },
  { 8299, 14, 56, 17, 2, -44 },
  { 8397, 2, 49, 11, 5, -41 },
  { 8410, 13, 56, 17, 1, -44 },
  { 8501, 26, 9, 34, 4, -21 },
};

const GFXfont RobotoCondensed_Thin57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_THIN57PT7B_H_
