#ifndef _ROBOTOCONDENSED_THIN53PT7B_H_
#define _ROBOTOCONDENSED_THIN53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0xC7,
  0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x20, 0x10,
  0x00, 0x20, 0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30,
  0x00, 0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20,
  0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60, 0x7F, 0xFF, 0xFF, 0x00, 0x80, 0x40,
  0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0,
  0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80,
  0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x02, 0x01, 0x80,
  0x02, 0x01, 0x00, 0xFF, 0xFF, 0xFE, 0x02, 0x01, 0x00, 0x06, 0x01, 0x00,
  0x06, 0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x02, 0x00,
  0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x06, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x70, 0x18,
  0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x02, 0x60, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x28, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x24,
  0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18,
  0x0E, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x60, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x10, 0x10, 0x02, 0x01,
  0x80, 0x80, 0x10, 0x08, 0x04, 0x00, 0x80, 0x80, 0x20, 0x04, 0x0C, 0x01,
  0x00, 0x20, 0x40, 0x08, 0x03, 0x06, 0x00, 0x60, 0x18, 0x20, 0x01, 0x00,
  0x83, 0x00, 0x0C, 0x0C, 0x10, 0x00, 0x30, 0xC1, 0x80, 0x00, 0xFC, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x3F, 0x00, 0x01, 0x06, 0x0C, 0x00,
  0x18, 0x20, 0x20, 0x00, 0x83, 0x01, 0x80, 0x0C, 0x10, 0x04, 0x00, 0x40,
  0x80, 0x20, 0x04, 0x04, 0x01, 0x00, 0x20, 0x20, 0x0C, 0x02, 0x01, 0x00,
  0x60, 0x30, 0x08, 0x03, 0x01, 0x00, 0x40, 0x10, 0x18, 0x02, 0x00, 0x80,
  0x80, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x01, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x18, 0x02, 0x00, 0x18, 0x06, 0x00, 0x08, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x04, 0x10, 0x00, 0x06, 0x20, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x18, 0x60, 0x00, 0x10, 0x30, 0x00, 0x30, 0x10, 0x06, 0x60, 0x18, 0x04,
  0x40, 0x0C, 0x04, 0x40, 0x06, 0x04, 0xC0, 0x02, 0x04, 0x80, 0x03, 0x0C,
  0x80, 0x01, 0x8C, 0x80, 0x00, 0xC8, 0x80, 0x00, 0x58, 0xC0, 0x00, 0x70,
  0x40, 0x00, 0x30, 0x60, 0x00, 0x78, 0x60, 0x00, 0xC8, 0x30, 0x01, 0x8C,
  0x1C, 0x07, 0x06, 0x07, 0xFC, 0x02, 0x00, 0x40, 0x00, 0x55, 0x55, 0x5C,
  0x00, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x10, 0x18, 0x08, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x04, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x5C, 0x04, 0x0F, 0x3C, 0x21, 0xC0, 0x39, 0x70, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0xCC, 0x00, 0x04, 0x30,
  0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0x60, 0x30,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x11, 0x11, 0x13, 0x33, 0x66, 0x40, 0xFF,
  0xC0, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x18, 0x18, 0x04, 0x01, 0x81, 0x80, 0x18, 0x60, 0x01, 0x08, 0x00,
  0x33, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x02,
  0x60, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x02, 0x0C, 0x00, 0xC0, 0x80, 0x30,
  0x0C, 0x0C, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x40, 0xF0, 0xE4, 0xE1,
  0xE0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x00, 0x40, 0x00, 0x7F, 0xC0,
  0x0C, 0x06, 0x01, 0x80, 0x30, 0x30, 0x01, 0x82, 0x00, 0x08, 0x60, 0x00,
  0xC4, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0x82, 0x00, 0x0C,
  0x60, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00,
  0x43, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x30, 0x03, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x48, 0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40,
  0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04, 0x00,
  0x0C, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40, 0x03,
  0x00, 0x80, 0x04, 0x01, 0x00, 0x18, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x08, 0x03, 0x00, 0x10, 0x06, 0x00, 0x20, 0x18, 0x00, 0x40, 0x20, 0x00,
  0x80, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xFF, 0xE2, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0xFE, 0x01, 0x78, 0xF0, 0x38, 0x03, 0x04, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x02,
  0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x02, 0x60, 0x00, 0x44, 0x00, 0x18,
  0xC0, 0x02, 0x0C, 0x00, 0x80, 0xE0, 0x70, 0x07, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x1F, 0xC0, 0x47,
  0x8E, 0x04, 0xC0, 0x38, 0xD8, 0x00, 0x8F, 0x00, 0x0C, 0xE0, 0x00, 0x4C,
  0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00,
  0x34, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00,
  0x0C, 0x18, 0x00, 0x80, 0xC0, 0x18, 0x06, 0x07, 0x00, 0x3F, 0xC0, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0E,
  0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0x64,
  0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00, 0x42, 0x00, 0x0C, 0x10, 0x01,
  0x81, 0xC0, 0x30, 0x07, 0x1E, 0x00, 0x3F, 0xC0, 0x0E, 0x07, 0x01, 0x80,
  0x18, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x0C,
  0x30, 0x01, 0x81, 0xC0, 0x30, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x30, 0x38, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x40, 0x01,
  0x18, 0x00, 0x32, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xA0, 0x00, 0x36, 0x00, 0x0E,
  0x40, 0x01, 0x4C, 0x00, 0x48, 0xC0, 0x31, 0x0F, 0x3C, 0x20, 0x7E, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xA0, 0x77, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x33, 0x33, 0x26, 0x4C, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x02, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xE0, 0xE3, 0x00, 0x44, 0x00, 0xD8,
  0x00, 0xA0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x61, 0x80, 0x07, 0xC0, 0x02, 0x30,
  0x01, 0xE7, 0x00, 0x23, 0x00, 0x30, 0x18, 0x03, 0x20, 0x02, 0x00, 0x80,
  0x36, 0x00, 0x40, 0x08, 0x01, 0x60, 0x0C, 0x00, 0x80, 0x14, 0x00, 0x80,
  0x08, 0x01, 0x40, 0x18, 0x00, 0x80, 0x14, 0x01, 0x00, 0x08, 0x01, 0x40,
  0x10, 0x01, 0x80, 0x1C, 0x01, 0x00, 0x18, 0x01, 0xC0, 0x30, 0x01, 0x80,
  0x1C, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x30, 0x01, 0x00, 0x1C, 0x02, 0x00,
  0x10, 0x01, 0xC0, 0x20, 0x01, 0x00, 0x1C, 0x02, 0x00, 0x10, 0x03, 0xC0,
  0x20, 0x01, 0x00, 0x2C, 0x02, 0x00, 0x30, 0x02, 0x40, 0x30, 0x03, 0x00,
  0x64, 0x01, 0x00, 0x70, 0x04, 0x40, 0x10, 0x05, 0x80, 0xC6, 0x01, 0x80,
  0x88, 0x08, 0x60, 0x0C, 0x10, 0xC1, 0x82, 0x00, 0x7E, 0x07, 0xE0, 0x20,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x04, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x20, 0x10, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0x20,
  0x00, 0x40, 0x08, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0x20, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x10,
  0x18, 0x00, 0x06, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x0C, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x08,
  0x01, 0xE0, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00,
  0x18, 0x80, 0x03, 0x08, 0x01, 0xE0, 0xFF, 0xFE, 0x08, 0x00, 0x30, 0x80,
  0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00,
  0xC8, 0x00, 0x18, 0x80, 0x0F, 0x0F, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0x00, 0x18, 0x03, 0x00, 0x60, 0x03, 0x81, 0x80, 0x01, 0x06, 0x00,
  0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40, 0x00, 0x05, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD0, 0x00,
  0x01, 0x20, 0x00, 0x02, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x10, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x18, 0x00, 0x7F, 0xE0,
  0x00, 0x08, 0x00, 0xFF, 0xF8, 0x02, 0x00, 0x78, 0x08, 0x00, 0x38, 0x20,
  0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x00, 0x88, 0x00, 0x03, 0x20, 0x00,
  0x04, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x01,
  0x88, 0x00, 0x0C, 0x20, 0x00, 0xE0, 0x80, 0x3E, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFE, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x00,
  0x1C, 0x03, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01, 0x82, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x10, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xB0,
  0x00, 0x01, 0x20, 0x00, 0x02, 0x60, 0x00, 0x04, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x30, 0xE0, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x02,
  0x40, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x06, 0x08, 0x01, 0x80, 0xC0, 0x60,
  0x0F, 0xF8, 0x00, 0x10, 0x00, 0x80, 0x00, 0x19, 0x00, 0x00, 0x62, 0x00,
  0x01, 0x84, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x20, 0x00,
  0xC0, 0x40, 0x03, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x08, 0x06, 0x00, 0x10, 0x18, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x80, 0x00, 0x83, 0x00, 0x01, 0x0E, 0x00, 0x02, 0x34, 0x00, 0x04,
  0xCC, 0x00, 0x0B, 0x0C, 0x00, 0x1C, 0x08, 0x00, 0x30, 0x08, 0x00, 0x40,
  0x18, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x30, 0x04, 0x00,
  0x30, 0x08, 0x00, 0x30, 0x10, 0x00, 0x20, 0x20, 0x00, 0x60, 0x40, 0x00,
  0x60, 0x80, 0x00, 0x61, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x90, 0x00, 0x01, 0x80, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x0F,
  0xA0, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x00, 0xB9, 0x00, 0x00, 0x06, 0xE4,
  0x00, 0x00, 0x13, 0x98, 0x00, 0x00, 0x4E, 0x20, 0x00, 0x03, 0x38, 0xC0,
  0x00, 0x08, 0xE1, 0x00, 0x00, 0x23, 0x84, 0x00, 0x01, 0x8E, 0x18, 0x00,
  0x04, 0x38, 0x20, 0x00, 0x30, 0xE0, 0x80, 0x00, 0xC3, 0x83, 0x00, 0x02,
  0x0E, 0x04, 0x00, 0x18, 0x38, 0x10, 0x00, 0x40, 0xE0, 0x60, 0x01, 0x03,
  0x80, 0x80, 0x0C, 0x0E, 0x03, 0x00, 0x20, 0x38, 0x04, 0x00, 0x80, 0xE0,
  0x10, 0x06, 0x03, 0x80, 0x60, 0x10, 0x0E, 0x00, 0x80, 0xC0, 0x38, 0x02,
  0x03, 0x00, 0xE0, 0x0C, 0x08, 0x03, 0x80, 0x10, 0x60, 0x0E, 0x00, 0x41,
  0x00, 0x38, 0x00, 0x84, 0x00, 0xE0, 0x02, 0x30, 0x03, 0x80, 0x0C, 0x80,
  0x0E, 0x00, 0x12, 0x00, 0x38, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x84, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x10, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x60, 0x03, 0x00, 0x40, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x30, 0x01, 0x80, 0x60,
  0x01, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x02, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0x60, 0x03, 0x01, 0x00, 0x01,
  0x06, 0x00, 0x03, 0x18, 0x00, 0x03, 0x20, 0x00, 0x02, 0x40, 0x00, 0x05,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x60, 0x80, 0x00, 0x80, 0xC0, 0x06, 0x00, 0xE0, 0x38, 0x00,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0xFF, 0xFC, 0x08, 0x00, 0xF0, 0x80, 0x01,
  0x88, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28,
  0x00, 0x06, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x1F, 0x0F, 0xFF, 0xC0,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x1C, 0x07,
  0x00, 0x60, 0x03, 0x01, 0x00, 0x01, 0x06, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x20, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00, 0x02,
  0x40, 0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x80,
  0xC0, 0x06, 0x00, 0xE0, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFC, 0x02, 0x00, 0x3C, 0x08, 0x00,
  0x18, 0x20, 0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x00, 0x88, 0x00, 0x03,
  0x20, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20,
  0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00,
  0x0C, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x20, 0x00, 0x60,
  0x80, 0x0F, 0x03, 0xFF, 0xF0, 0x08, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x80,
  0x06, 0x02, 0x00, 0x08, 0x08, 0x00, 0x30, 0x20, 0x00, 0x40, 0x80, 0x01,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x80, 0x00, 0x62,
  0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x1C, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0x90, 0x00, 0x02,
  0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x70, 0x38, 0x07, 0x00, 0x3F,
  0xF8, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x13, 0x00, 0x01, 0x98, 0x00, 0x08, 0x70, 0x01, 0xC1, 0xE0, 0x38, 0x03,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x06, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x40, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x00,
  0x20, 0x00, 0x40, 0x08, 0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x30, 0x30, 0x00, 0x04, 0x08, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x90,
  0x00, 0x1E, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x80, 0x01, 0x20,
  0x00, 0x66, 0x00, 0x0C, 0x80, 0x01, 0x08, 0x00, 0x33, 0x00, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x30, 0x80, 0x02, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x40,
  0x02, 0x0C, 0x00, 0x61, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40,
  0x04, 0x08, 0x01, 0x81, 0x80, 0x30, 0x20, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0x10, 0x08, 0x02, 0x03, 0x00, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x20, 0x0C, 0x04, 0x01, 0x80,
  0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x08, 0x20, 0x01, 0x04,
  0x00, 0x21, 0x80, 0x04, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10,
  0x00, 0x62, 0x00, 0x0C, 0x40, 0x00, 0x88, 0x00, 0x13, 0x00, 0x02, 0x20,
  0x00, 0x4C, 0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00, 0x36, 0x00, 0x06, 0x80,
  0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x01, 0x80, 0x01, 0x81,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x81,
  0x00, 0x01, 0x81, 0x80, 0x03, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x10, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x40, 0x30, 0x00, 0x30, 0x04, 0x00, 0x08, 0x01, 0x80, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0xF8, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xF8, 0x01,
  0x00, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x64, 0x00, 0x88, 0x01, 0x18,
  0x06, 0x10, 0x08, 0x20, 0x10, 0x60, 0x60, 0x40, 0x80, 0x81, 0x01, 0x86,
  0x01, 0x08, 0x02, 0x10, 0x06, 0x60, 0x04, 0x80, 0x09, 0x00, 0x18, 0xFF,
  0xFF, 0xE0, 0xC0, 0xC0, 0x81, 0x81, 0x81, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x01, 0xC0, 0x60, 0xC0, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x2C, 0x00,
  0x0B, 0x00, 0x02, 0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0xFF, 0xE1, 0xF0, 0x08, 0xE0, 0x02, 0x60, 0x00, 0x90,
  0x00, 0x2C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0xA6, 0x00, 0xCC, 0xC0, 0x63,
  0x1F, 0xF0, 0xC0, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC7, 0xFC, 0x33, 0x01,
  0x8D, 0x00, 0x33, 0x80, 0x06, 0xE0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x02, 0xE0, 0x01, 0xBC, 0x00, 0xCD, 0xC0, 0x62, 0x1F, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xC0, 0x60, 0xC0, 0x0C, 0x20,
  0x01, 0x98, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0x88, 0x00,
  0x63, 0x00, 0x30, 0x70, 0x18, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x01,
  0x01, 0x07, 0xF8, 0x47, 0x01, 0x91, 0x00, 0x34, 0xC0, 0x07, 0x60, 0x00,
  0xD8, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00,
  0x50, 0x00, 0x16, 0x00, 0x05, 0x80, 0x03, 0x30, 0x00, 0xC4, 0x00, 0x50,
  0xC0, 0x64, 0x1F, 0xF1, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xC0,
  0x18, 0x0C, 0x04, 0x00, 0xC1, 0x00, 0x0C, 0x60, 0x00, 0x88, 0x00, 0x1B,
  0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x01, 0x03,
  0x00, 0xC0, 0x3F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x20, 0x0F, 0xC0, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x7F, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x01, 0xFE, 0x11, 0xC0, 0x64, 0x40, 0x0D, 0x30,
  0x01, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0xCC, 0x00,
  0x71, 0x00, 0x34, 0x70, 0x19, 0x07, 0xFC, 0x40, 0x30, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x80, 0x02, 0x30,
  0x01, 0x86, 0x00, 0xC0, 0xF0, 0xE0, 0x0F, 0xE0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x3F, 0xC6,
  0x30, 0x33, 0x20, 0x0D, 0xA0, 0x02, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x70, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x32, 0x38, 0x78, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x30,
  0x0C, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x20,
  0x03, 0x10, 0x00, 0xCC, 0x00, 0x34, 0x80, 0x0E, 0x30, 0x03, 0x06, 0x00,
  0xC0, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x03, 0x00, 0x80, 0xC0, 0x30, 0x30,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x10, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00,
  0x13, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x41, 0xFE, 0x01, 0xFE, 0x23, 0x81, 0x83,
  0x01, 0x91, 0x00, 0x63, 0x00, 0x69, 0x00, 0x13, 0x00, 0x15, 0x00, 0x0D,
  0x00, 0x0E, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x00, 0x61, 0xFE, 0x31, 0x81, 0x99, 0x00, 0x6D, 0x00, 0x17,
  0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0E, 0x07, 0x01, 0x80,
  0x18, 0x30, 0x00, 0x82, 0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x06, 0x40,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x66, 0x00, 0x04, 0x20, 0x00, 0xC3, 0x00, 0x08, 0x18, 0x01, 0x80, 0xE0,
  0x70, 0x03, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0xFF, 0x83, 0x30,
  0x18, 0x68, 0x01, 0x8E, 0x00, 0x19, 0xC0, 0x01, 0x30, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00,
  0x05, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0x9C, 0x00, 0x33, 0xC0, 0x0C, 0x6E, 0x03,
  0x0C, 0x7F, 0xC1, 0x80, 0x80, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFE, 0x11, 0xC0, 0x64,
  0x40, 0x0D, 0x30, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x01, 0x40,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x01, 0x60,
  0x00, 0xCC, 0x00, 0x31, 0x00, 0x14, 0x30, 0x19, 0x07, 0xFC, 0x40, 0x30,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x58, 0xFF, 0x30, 0x6C, 0x0D, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x0E, 0x03, 0x8C, 0x00, 0x44,
  0x00, 0x16, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xA0, 0x00, 0x98, 0x00,
  0xC7, 0x01, 0xC0, 0xFF, 0x80, 0x04, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xE0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x3F, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x05, 0x00, 0x06, 0x80, 0x03, 0x60, 0x03, 0x98, 0x03, 0x46, 0x03,
  0x21, 0xFE, 0x10, 0x18, 0x00, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00,
  0x0C, 0x18, 0x00, 0x80, 0x80, 0x08, 0x08, 0x01, 0x80, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x06, 0x02, 0x00, 0x60, 0x20, 0x02, 0x06, 0x00,
  0x30, 0x40, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x88, 0x00, 0x18, 0x80,
  0x00, 0x98, 0x00, 0x0D, 0x00, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x80, 0x06, 0x00, 0x09, 0x00,
  0x0E, 0x00, 0x33, 0x00, 0x14, 0x00, 0x66, 0x00, 0x68, 0x00, 0x84, 0x00,
  0xD8, 0x01, 0x08, 0x01, 0x30, 0x06, 0x18, 0x02, 0x20, 0x0C, 0x30, 0x0C,
  0x40, 0x10, 0x20, 0x18, 0xC0, 0x20, 0x40, 0x21, 0x80, 0xC0, 0xC0, 0x41,
  0x01, 0x81, 0x81, 0x82, 0x02, 0x01, 0x02, 0x06, 0x04, 0x02, 0x04, 0x04,
  0x18, 0x06, 0x18, 0x08, 0x30, 0x0C, 0x30, 0x18, 0x40, 0x08, 0x40, 0x30,
  0x80, 0x10, 0x80, 0x23, 0x00, 0x33, 0x00, 0x46, 0x00, 0x66, 0x00, 0xC8,
  0x00, 0x48, 0x01, 0x90, 0x00, 0x90, 0x01, 0x20, 0x01, 0x60, 0x02, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x06, 0x18,
  0x00, 0x81, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x01, 0x00, 0x20, 0x60, 0x06,
  0x08, 0x00, 0x43, 0x00, 0x0C, 0xC0, 0x00, 0xD0, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00, 0x62, 0x00, 0x18,
  0x60, 0x02, 0x06, 0x00, 0xC0, 0x40, 0x10, 0x0C, 0x06, 0x00, 0x81, 0x80,
  0x18, 0x20, 0x01, 0x8C, 0x00, 0x11, 0x00, 0x03, 0x60, 0x00, 0x30, 0x40,
  0x00, 0x14, 0x00, 0x03, 0x60, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x63,
  0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x0C, 0x18, 0x00, 0x80, 0x80, 0x08,
  0x08, 0x01, 0x80, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x06, 0x03,
  0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00, 0x10,
  0xC0, 0x01, 0x8C, 0x00, 0x08, 0x80, 0x00, 0x98, 0x00, 0x0D, 0x80, 0x00,
  0x50, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x07, 0x80, 0x38, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x07, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x08, 0x00, 0x0F, 0x00, 0x00,
  0x39, 0xC0, 0x01, 0x60, 0x60, 0x03, 0x40, 0x30, 0x03, 0xC0, 0x18, 0x02,
  0xC0, 0x0C, 0x02, 0x80, 0x06, 0x04, 0x80, 0x03, 0x9C, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_Thin53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 39, 10, 4, -38 },
  { 11, 7, 11, 14, 4, -40 },
  { 21, 24, 38, 26, 2, -38 },
  { 135, 20, 50, 26, 3, -44 },
  { 260, 29, 40, 34, 3, -39 },
  { 405, 24, 40, 28, 3, -39 },
  { 525, 2, 11, 9, 3, -40 },
  { 528, 9, 54, 14, 4, -42 },
  { 589, 10, 54, 15, 1, -42 },
  { 657, 21, 20, 22, 1, -38 },
  { 710, 22, 27, 26, 2, -31 },
  { 785, 4, 11, 10, 2, -4 },
  { 791, 10, 1, 14, 2, -18 },
  { 793, 3, 3, 11, 4, -2 },
  { 795, 15, 41, 18, 1, -38 },
  { 872, 19, 40, 26, 3, -39 },
  { 967, 10, 38, 26, 5, -38 },
  { 1015, 20, 39, 26, 3, -39 },
  { 1113, 20, 40, 26, 3, -39 },
  { 1213, 23, 38, 26, 2, -38 },
  { 1323, 19, 39, 26, 4, -38 },
  { 1416, 20, 39, 26, 3, -38 },
  { 1514, 21, 38, 26, 2, -38 },
  { 1614, 20, 40, 26, 3, -39 },
  { 1714, 19, 39, 26, 3, -39 },
  { 1807, 3, 28, 9, 3, -27 },
  { 1818, 4, 34, 9, 2, -27 },
  { 1835, 19, 21, 24, 2, -28 },
  { 1885, 18, 11, 26, 4, -23 },
  { 1910, 18, 21, 24, 3, -28 },
  { 1958, 15, 40, 21, 3, -39 },
  { 2033, 36, 48, 43, 3, -36 },
  { 2249, 26, 38, 28, 1, -38 },
  { 2373, 20, 38, 28, 5, -38 },
  { 2468, 23, 40, 30, 4, -39 },
  { 2583, 22, 38, 30, 5, -38 },
  { 2688, 19, 38, 27, 5, -38 },
  { 2779, 20, 38, 27, 5, -38 },
  { 2874, 23, 40, 32, 4, -39 },
  { 2989, 23, 38, 33, 5, -38 },
  { 3099, 1, 38, 13, 6, -38 },
  { 3104, 19, 39, 26, 2, -38 },
  { 3197, 23, 38, 29, 5, -38 },
  { 3307, 18, 38, 24, 5, -38 },
  { 3393, 30, 38, 40, 5, -38 },
  { 3536, 23, 38, 33, 5, -38 },
  { 3646, 23, 40, 31, 4, -39 },
  { 3761, 20, 38, 28, 5, -38 },
  { 3856, 23, 46, 31, 4, -39 },
  { 3989, 22, 38, 30, 5, -38 },
  { 4094, 22, 40, 28, 3, -39 },
  { 4204, 24, 38, 28, 2, -38 },
  { 4318, 21, 39, 31, 5, -38 },
  { 4421, 26, 38, 28, 1, -38 },
  { 4545, 38, 38, 42, 2, -38 },
  { 4726, 24, 38, 28, 2, -38 },
  { 4840, 26, 38, 28, 1, -38 },
  { 4964, 22, 38, 28, 3, -38 },
  { 5069, 7, 51, 11, 4, -43 },
  { 5114, 14, 41, 18, 2, -38 },
  { 5186, 7, 51, 11, 0, -43 },
  { 5231, 15, 19, 20, 2, -38 },
  { 5267, 19, 1, 20, 0, 0 },
  { 5270, 7, 7, 14, 4, -40 },
  { 5277, 18, 30, 25, 3, -29 },
  { 5345, 18, 41, 26, 4, -40 },
  { 5438, 18, 30, 24, 3, -29 },
  { 5506, 18, 41, 26, 3, -40 },
  { 5599, 19, 30, 24, 2, -29 },
  { 5671, 13, 41, 15, 2, -41 },
  { 5738, 18, 40, 26, 3, -29 },
  { 5828, 17, 40, 26, 4, -40 },
  { 5913, 2, 38, 10, 4, -38 },
  { 5923, 10, 49, 11, -3, -38 },
  { 5985, 18, 40, 22, 4, -40 },
  { 6075, 2, 40, 10, 4, -40 },
  { 6085, 33, 29, 41, 4, -29 },
  { 6205, 17, 29, 26, 4, -29 },
  { 6267, 20, 30, 26, 3, -29 },
  { 6342, 19, 40, 26, 4, -29 },
  { 6437, 18, 40, 26, 3, -29 },
  { 6527, 11, 29, 16, 4, -29 },
  { 6567, 17, 30, 23, 3, -29 },
  { 6631, 12, 37, 15, 1, -36 },
  { 6687, 17, 29, 26, 4, -28 },
  { 6749, 20, 28, 22, 1, -28 },
  { 6819, 31, 28, 35, 2, -28 },
  { 6928, 19, 28, 22, 2, -28 },
  { 6995, 20, 39, 22, 1, -28 },
  { 7093, 19, 28, 22, 2, -28 },
  { 7160, 13, 52, 16, 2, -41 },
  { 7245, 1, 45, 11, 5, -38 },
  { 7251, 12, 52, 16, 1, -41 },
  { 7329, 24, 9, 32, 4, -20 },
};

const GFXfont RobotoCondensed_Thin53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_THIN53PT7B_H_
