#ifndef _ROBOTOCONDENSED_THIN43PT7B_H_
#define _ROBOTOCONDENSED_THIN43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin43pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0x3C, 0x86, 0x18, 0x61,
  0x8E, 0x38, 0xE3, 0x8C, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80,
  0x08, 0x08, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x18, 0x10,
  0x01, 0x01, 0x03, 0xFF, 0xFF, 0x01, 0x03, 0x00, 0x10, 0x20, 0x01, 0x02,
  0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x06, 0x04, 0x0F, 0xFF, 0xFE, 0x04,
  0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00,
  0x80, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x10, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x7E, 0x03, 0x06, 0x0C, 0x02, 0x30,
  0x02, 0x40, 0x04, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x01, 0xA0, 0x02, 0x20, 0x0C,
  0x30, 0x70, 0x1F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x1E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0x40, 0x00,
  0x40, 0x40, 0x60, 0xC0, 0x40, 0x40, 0x80, 0x40, 0x80, 0x80, 0x40, 0x80,
  0x80, 0x41, 0x00, 0x40, 0x41, 0x00, 0x40, 0x42, 0x00, 0x60, 0x82, 0x00,
  0x31, 0x84, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x78, 0x00, 0x21, 0x8C, 0x00, 0x41, 0x06,
  0x00, 0x42, 0x02, 0x00, 0x82, 0x02, 0x00, 0x82, 0x03, 0x01, 0x02, 0x03,
  0x01, 0x02, 0x03, 0x02, 0x02, 0x03, 0x06, 0x02, 0x02, 0x00, 0x02, 0x02,
  0x00, 0x01, 0x06, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00,
  0x63, 0x00, 0x08, 0x18, 0x01, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80,
  0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81, 0x00, 0x08, 0x20,
  0x00, 0xC4, 0x00, 0x04, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xD0,
  0x00, 0x18, 0x80, 0x01, 0x0C, 0x02, 0x20, 0x60, 0x26, 0x02, 0x06, 0x40,
  0x10, 0x44, 0x01, 0x84, 0xC0, 0x08, 0x4C, 0x00, 0x4C, 0xC0, 0x02, 0x84,
  0x00, 0x38, 0x40, 0x01, 0x06, 0x00, 0x28, 0x30, 0x04, 0x41, 0xC1, 0x86,
  0x07, 0xE0, 0x20, 0xFF, 0x80, 0x01, 0x02, 0x04, 0x04, 0x08, 0x18, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x10, 0x10, 0x20, 0x60, 0x40, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x83, 0x38,
  0x9C, 0x07, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x60, 0x04, 0x20, 0x0C,
  0x10, 0x08, 0x18, 0x10, 0x0C, 0x30, 0x04, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x1F, 0xFF, 0xF0, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x24, 0x92, 0xD6, 0x80,
  0xFF, 0x80, 0xD8, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x07, 0xC0, 0x30, 0xE0, 0xC0, 0x61,
  0x00, 0x44, 0x00, 0xC8, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x09, 0x00, 0x31, 0x00, 0x43, 0x01,
  0x83, 0x06, 0x01, 0xF0, 0x00, 0x01, 0x0F, 0x39, 0xE1, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x07, 0xE0, 0x06, 0x1C, 0x04, 0x03, 0x04, 0x00, 0x86, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x0C, 0x18, 0x10, 0x04,
  0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x03, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x03,
  0x20, 0x02, 0x10, 0x04, 0x0C, 0x18, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x0C, 0x80,
  0x02, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08, 0x20, 0x04,
  0x08, 0x03, 0x02, 0x00, 0x80, 0x80, 0x60, 0x20, 0x10, 0x08, 0x08, 0x02,
  0x06, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08, 0x3F, 0xFF, 0xF0, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xFC, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x7E, 0x07, 0x07, 0x08, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0B, 0x00, 0x12, 0x00, 0x42, 0x01,
  0x83, 0x06, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x87, 0xE0, 0x9C, 0x30, 0xB0, 0x08, 0xE0, 0x04, 0xC0,
  0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20,
  0x0C, 0x30, 0x08, 0x1C, 0x30, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x03, 0xE0, 0x06,
  0x0C, 0x04, 0x03, 0x04, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x19, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00,
  0x20, 0x80, 0x20, 0x30, 0x60, 0x0F, 0xC0, 0x1C, 0x18, 0x18, 0x03, 0x18,
  0x00, 0x88, 0x00, 0x24, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xE0, 0x00, 0x90, 0x00, 0x4C, 0x00, 0x63, 0x00, 0x60, 0xE0,
  0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0C, 0x38, 0x10, 0x0C, 0x30, 0x04, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60,
  0x03, 0x20, 0x05, 0x10, 0x09, 0x0C, 0x31, 0x07, 0xC1, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x6C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x4B, 0x6B, 0x40, 0x00, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x0F, 0x80, 0x83, 0x08, 0x08, 0x80, 0x24,
  0x01, 0x40, 0x0E, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x31, 0x00, 0x3E, 0x00, 0x98, 0x03, 0x18, 0x04,
  0x80, 0x20, 0x20, 0x24, 0x02, 0x01, 0x01, 0xA0, 0x30, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x80, 0x30, 0x0C, 0x04, 0x01,
  0x80, 0x60, 0x20, 0x08, 0x03, 0x01, 0x00, 0x40, 0x18, 0x08, 0x02, 0x00,
  0xC0, 0x40, 0x10, 0x06, 0x02, 0x00, 0x80, 0x50, 0x10, 0x04, 0x02, 0x80,
  0x80, 0x60, 0x14, 0x04, 0x03, 0x01, 0xA0, 0x20, 0x28, 0x09, 0x00, 0x81,
  0x20, 0x8C, 0x06, 0x31, 0x8C, 0x20, 0x1E, 0x07, 0x81, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x44,
  0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00,
  0xC1, 0x00, 0x04, 0x0C, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x10, 0x0C,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x20, 0x10,
  0x01, 0x01, 0x00, 0x08, 0x0F, 0xFF, 0xE0, 0x40, 0x01, 0x06, 0x00, 0x08,
  0x20, 0x00, 0x61, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0x64, 0x00,
  0x01, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x60, 0xFF, 0xC0, 0x40, 0x18, 0x20,
  0x03, 0x10, 0x00, 0x88, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00,
  0x62, 0x00, 0xE1, 0xFF, 0xE0, 0x80, 0x1C, 0x40, 0x03, 0x20, 0x00, 0x90,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x64, 0x00, 0xE3, 0xFF,
  0xC0, 0x03, 0xF8, 0x01, 0xC1, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC2, 0x00,
  0x08, 0x80, 0x00, 0x90, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x08, 0x80, 0x02, 0x18, 0x00, 0x41, 0x80, 0x10, 0x1C, 0x0C,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x20, 0x0E, 0x08, 0x00, 0xC2, 0x00, 0x18,
  0x80, 0x03, 0x20, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x48, 0x00, 0x32, 0x00, 0x18, 0x80, 0x0C, 0x20, 0x0E, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x03, 0x03, 0x81, 0x00, 0x30,
  0x80, 0x06, 0x40, 0x00, 0x90, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x1F, 0xF8, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x50, 0x00, 0x16, 0x00, 0x04, 0x80, 0x03, 0x18, 0x01, 0x83, 0x83,
  0xC0, 0x3F, 0x80, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x09, 0x00, 0x12, 0x00, 0x62, 0x01, 0x83,
  0x06, 0x03, 0xF0, 0x00, 0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x22, 0x00,
  0x10, 0x80, 0x0C, 0x20, 0x06, 0x08, 0x01, 0x02, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x08, 0x18, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x21, 0x00, 0x08,
  0xC0, 0x02, 0x48, 0x00, 0xA3, 0x00, 0x38, 0x60, 0x0C, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x60, 0x20, 0x08, 0x08, 0x01, 0x02, 0x00, 0x20, 0x80, 0x0C,
  0x20, 0x01, 0x08, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x28,
  0x00, 0x04, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xC0, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xA0, 0x00, 0x05, 0xA0, 0x00, 0x05,
  0xA0, 0x00, 0x05, 0x90, 0x00, 0x09, 0x90, 0x00, 0x09, 0x98, 0x00, 0x09,
  0x88, 0x00, 0x11, 0x88, 0x00, 0x11, 0x84, 0x00, 0x31, 0x84, 0x00, 0x21,
  0x84, 0x00, 0x21, 0x82, 0x00, 0x41, 0x82, 0x00, 0x41, 0x82, 0x00, 0x41,
  0x81, 0x00, 0x81, 0x81, 0x00, 0x81, 0x81, 0x80, 0x81, 0x80, 0x81, 0x01,
  0x80, 0x81, 0x01, 0x80, 0x43, 0x01, 0x80, 0x42, 0x01, 0x80, 0x42, 0x01,
  0x80, 0x24, 0x01, 0x80, 0x24, 0x01, 0x80, 0x24, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xD0, 0x00, 0x1B, 0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x40,
  0x01, 0x84, 0x00, 0x30, 0xC0, 0x06, 0x08, 0x00, 0xC1, 0x80, 0x18, 0x10,
  0x03, 0x01, 0x00, 0x60, 0x20, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x04,
  0x06, 0x00, 0xC0, 0xC0, 0x08, 0x18, 0x00, 0x83, 0x00, 0x10, 0x60, 0x01,
  0x0C, 0x00, 0x31, 0x80, 0x02, 0x30, 0x00, 0x66, 0x00, 0x04, 0xC0, 0x00,
  0x58, 0x00, 0x0B, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x03, 0xF8, 0x01, 0xC1,
  0xC0, 0x60, 0x0C, 0x18, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x00, 0x90, 0x00,
  0x14, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x08, 0x80, 0x03,
  0x18, 0x00, 0x41, 0x80, 0x30, 0x1C, 0x1C, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x40, 0x0C, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x34, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x18, 0x7F, 0xF0,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC1, 0xC0, 0x60, 0x0C, 0x18,
  0x00, 0x46, 0x00, 0x0C, 0x80, 0x00, 0x90, 0x00, 0x14, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0x40, 0x00, 0x48, 0x00, 0x09, 0x80, 0x03, 0x18, 0x00, 0x41, 0x80,
  0x30, 0x1C, 0x1C, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0xFF, 0xE0, 0x20, 0x06,
  0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x22, 0x00, 0x10, 0x80, 0x18, 0x3F, 0xFC,
  0x08, 0x02, 0x02, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x10, 0x80, 0x04, 0x20, 0x00, 0x88, 0x00, 0x32, 0x00, 0x04, 0x80,
  0x01, 0xA0, 0x00, 0x28, 0x00, 0x0C, 0x03, 0xF8, 0x01, 0x81, 0xC0, 0x40,
  0x0C, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xA0, 0x00,
  0x14, 0x00, 0x03, 0x80, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x10, 0x00,
  0x41, 0x00, 0x10, 0x1C, 0x0C, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x6C,
  0x00, 0x63, 0x00, 0x60, 0xE0, 0xE0, 0x1F, 0xC0, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x66, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x80, 0x01, 0x86, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00,
  0x20, 0x10, 0x01, 0x00, 0x80, 0x08, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x03, 0x00, 0x30, 0x10, 0x00, 0x80, 0x80, 0x04, 0x0C,
  0x00, 0x30, 0x40, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x21, 0x00, 0x00,
  0x88, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x40, 0x01, 0x80, 0x02, 0x80, 0x03,
  0x00, 0x05, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x36, 0x00, 0x24,
  0x00, 0x44, 0x00, 0x48, 0x00, 0x88, 0x00, 0x90, 0x01, 0x10, 0x02, 0x20,
  0x06, 0x30, 0x04, 0x20, 0x08, 0x20, 0x08, 0x40, 0x10, 0x40, 0x10, 0x80,
  0x20, 0x80, 0x41, 0x00, 0x41, 0x00, 0x81, 0x01, 0x81, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x10, 0x08, 0x30,
  0x18, 0x20, 0x10, 0x40, 0x10, 0x40, 0x20, 0x80, 0x21, 0x80, 0x41, 0x00,
  0x42, 0x00, 0x42, 0x00, 0x84, 0x00, 0x8C, 0x00, 0x88, 0x01, 0x10, 0x01,
  0x30, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x80, 0x05, 0x80, 0x0D,
  0x00, 0x0A, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x32, 0x00, 0x02,
  0x30, 0x00, 0x41, 0x00, 0x04, 0x18, 0x00, 0x80, 0x80, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x02, 0x02, 0x00, 0x30, 0x40, 0x01, 0x04, 0x00, 0x18,
  0x80, 0x00, 0x98, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x50, 0x00, 0x09, 0x00, 0x00, 0x88, 0x00, 0x10, 0xC0, 0x03, 0x04, 0x00,
  0x20, 0x60, 0x06, 0x02, 0x00, 0x40, 0x10, 0x08, 0x01, 0x00, 0x80, 0x08,
  0x10, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00,
  0x10, 0xC0, 0x00, 0x12, 0x00, 0x01, 0x98, 0x00, 0x08, 0x40, 0x00, 0xC3,
  0x00, 0x04, 0x08, 0x00, 0x60, 0x60, 0x02, 0x01, 0x00, 0x30, 0x0C, 0x01,
  0x00, 0x20, 0x18, 0x01, 0x80, 0x80, 0x04, 0x04, 0x00, 0x30, 0x40, 0x00,
  0x82, 0x00, 0x04, 0x20, 0x00, 0x11, 0x00, 0x00, 0x90, 0x00, 0x02, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x87, 0xC0, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0xC0, 0x06, 0x00,
  0x60, 0x0A, 0x00, 0x90, 0x09, 0x01, 0x10, 0x10, 0x81, 0x08, 0x20, 0x82,
  0x04, 0x20, 0x44, 0x04, 0x40, 0x24, 0x02, 0x80, 0x20, 0xFF, 0xFF, 0xC1,
  0x82, 0x0C, 0x18, 0x20, 0x07, 0xE0, 0x30, 0x70, 0xC0, 0x33, 0x00, 0x24,
  0x00, 0x48, 0x00, 0xD0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x1F,
  0xF8, 0xE0, 0x32, 0x00, 0x68, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x74, 0x01, 0x26, 0x0C, 0x47, 0xE0, 0x80,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x8F, 0xC3, 0x60, 0xC7, 0x80, 0x4E, 0x00,
  0x58, 0x00, 0xB0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x2C, 0x00, 0x54, 0x01, 0x26, 0x0C, 0x43, 0xF0,
  0x07, 0xE0, 0x30, 0x70, 0xC0, 0x33, 0x00, 0x24, 0x00, 0x68, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x09,
  0x00, 0x23, 0x00, 0xC3, 0x87, 0x01, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x3F, 0x13, 0x86, 0x58, 0x05, 0x40, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0x40, 0x0D, 0x80,
  0x73, 0x83, 0x43, 0xF1, 0x07, 0xE0, 0x38, 0x70, 0xC0, 0x31, 0x00, 0x24,
  0x00, 0x68, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x61, 0x83, 0x00, 0xFC, 0x00,
  0x03, 0xC3, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x3F,
  0xE1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x0F, 0xC4, 0xC1, 0x96, 0x01, 0x50, 0x03, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x50, 0x03, 0x60, 0x1C, 0xE0, 0xD0, 0xFC, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x40, 0x0D, 0x80, 0x21, 0x83, 0x03, 0xF0,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x0F, 0x8C, 0xC3, 0x36, 0x02, 0xF0, 0x0F, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xF0, 0x00, 0x55, 0x55,
  0x55, 0x55, 0x55, 0x54, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30,
  0x40, 0x86, 0x78, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x2C, 0x01, 0xB0, 0x0C,
  0xC0, 0x63, 0x03, 0x0C, 0x18, 0x30, 0x40, 0xC2, 0x03, 0x10, 0x0C, 0x80,
  0x37, 0x00, 0xE4, 0x03, 0x08, 0x0C, 0x30, 0x30, 0x40, 0xC0, 0x83, 0x03,
  0x0C, 0x06, 0x30, 0x08, 0xC0, 0x13, 0x00, 0x6C, 0x00, 0xB0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x3F, 0x11, 0x86, 0x0C, 0x32, 0x40, 0x22,
  0x01, 0x50, 0x06, 0x80, 0x3A, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0xC3, 0xE3, 0x30,
  0xCD, 0x80, 0xBC, 0x03, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x40, 0x03, 0xE0, 0x0C, 0x18, 0x10, 0x0C, 0x20, 0x06, 0x60, 0x02,
  0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x03, 0x20, 0x02, 0x20, 0x06, 0x10, 0x0C, 0x0C, 0x18, 0x07, 0xE0,
  0x87, 0xE1, 0x30, 0x62, 0xC0, 0x25, 0x00, 0x2C, 0x00, 0x58, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x16,
  0x00, 0x2E, 0x00, 0x9B, 0x06, 0x31, 0xF8, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x0F, 0xC4, 0xE1, 0x96, 0x01, 0x50, 0x03, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x50, 0x03, 0x60,
  0x1C, 0xE0, 0xD0, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xC7, 0xE6, 0x34, 0x1C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x0F, 0xC0,
  0xE0, 0xC6, 0x00, 0x90, 0x03, 0x40, 0x05, 0x00, 0x14, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x60, 0x08, 0xE0,
  0xC0, 0xFE, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xF8,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x07, 0xC0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x05, 0x00, 0x14,
  0x00, 0xD0, 0x03, 0x20, 0x14, 0x61, 0x90, 0xFC, 0x40, 0x80, 0x01, 0x40,
  0x03, 0x40, 0x02, 0x40, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x10,
  0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04,
  0x10, 0x04, 0x20, 0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x03,
  0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x18, 0x03, 0x40, 0x1C, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x60, 0x24, 0x02, 0x20, 0x26, 0x06, 0x20, 0x42, 0x04, 0x20, 0x42,
  0x04, 0x30, 0x42, 0x04, 0x10, 0xC1, 0x0C, 0x10, 0x81, 0x08, 0x10, 0x81,
  0x08, 0x18, 0x81, 0x88, 0x09, 0x80, 0x98, 0x09, 0x00, 0x90, 0x09, 0x00,
  0x90, 0x09, 0x00, 0xD0, 0x06, 0x00, 0x50, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x40, 0x02, 0x20, 0x06, 0x30, 0x04, 0x10, 0x08,
  0x18, 0x08, 0x08, 0x10, 0x04, 0x30, 0x06, 0x20, 0x02, 0x40, 0x03, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20,
  0x0C, 0x10, 0x08, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x02,
  0x40, 0x03, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x02,
  0x20, 0x04, 0x20, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x08, 0x10, 0x04, 0x10, 0x04, 0x30, 0x04, 0x20, 0x02, 0x20,
  0x02, 0x60, 0x02, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x40, 0x60, 0x30, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x60, 0x30, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x00, 0x1E, 0x00, 0x32, 0x18, 0x02, 0x40, 0xC0, 0x24, 0x06, 0x02, 0xC0,
  0x30, 0x68, 0x01, 0x8C, 0x80, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_Thin43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 31, 8, 3, -31 },
  { 9, 6, 9, 11, 3, -32 },
  { 16, 20, 31, 21, 1, -31 },
  { 94, 15, 39, 21, 3, -35 },
  { 168, 24, 31, 28, 2, -31 },
  { 261, 20, 31, 23, 2, -31 },
  { 339, 1, 9, 7, 3, -32 },
  { 341, 8, 44, 12, 3, -34 },
  { 385, 8, 44, 12, 1, -34 },
  { 429, 16, 17, 18, 1, -31 },
  { 463, 17, 23, 21, 2, -26 },
  { 512, 3, 9, 8, 2, -3 },
  { 516, 9, 1, 12, 1, -14 },
  { 518, 3, 2, 9, 3, -2 },
  { 519, 12, 34, 15, 1, -31 },
  { 570, 15, 31, 21, 3, -31 },
  { 629, 8, 31, 21, 4, -31 },
  { 660, 17, 31, 21, 2, -31 },
  { 726, 16, 31, 21, 2, -31 },
  { 788, 18, 31, 21, 2, -31 },
  { 858, 15, 31, 21, 4, -31 },
  { 917, 16, 31, 21, 3, -31 },
  { 979, 16, 31, 21, 2, -31 },
  { 1041, 17, 31, 21, 2, -31 },
  { 1107, 16, 31, 21, 2, -31 },
  { 1169, 2, 22, 7, 3, -22 },
  { 1175, 3, 28, 7, 2, -22 },
  { 1186, 15, 16, 20, 2, -22 },
  { 1216, 15, 10, 21, 3, -19 },
  { 1235, 15, 16, 20, 2, -22 },
  { 1265, 13, 31, 17, 2, -31 },
  { 1316, 29, 40, 35, 3, -30 },
  { 1461, 21, 31, 23, 1, -31 },
  { 1543, 17, 31, 23, 4, -31 },
  { 1609, 19, 31, 24, 3, -31 },
  { 1683, 18, 31, 25, 4, -31 },
  { 1753, 16, 31, 22, 4, -31 },
  { 1815, 16, 31, 22, 4, -31 },
  { 1877, 18, 31, 26, 4, -31 },
  { 1947, 18, 31, 26, 4, -31 },
  { 2017, 1, 31, 10, 5, -31 },
  { 2021, 15, 31, 21, 2, -31 },
  { 2080, 18, 31, 24, 4, -31 },
  { 2150, 14, 31, 20, 4, -31 },
  { 2205, 24, 31, 32, 4, -31 },
  { 2298, 19, 31, 27, 4, -31 },
  { 2372, 19, 31, 25, 3, -31 },
  { 2446, 17, 31, 23, 4, -31 },
  { 2512, 19, 37, 25, 3, -31 },
  { 2600, 18, 31, 25, 4, -31 },
  { 2670, 19, 31, 22, 2, -31 },
  { 2744, 20, 31, 23, 1, -31 },
  { 2822, 17, 31, 25, 4, -31 },
  { 2888, 21, 31, 23, 1, -31 },
  { 2970, 31, 31, 34, 1, -31 },
  { 3091, 20, 31, 23, 1, -31 },
  { 3169, 21, 31, 23, 1, -31 },
  { 3251, 19, 31, 23, 2, -31 },
  { 3325, 5, 42, 9, 4, -35 },
  { 3352, 12, 34, 15, 1, -31 },
  { 3403, 5, 42, 9, 0, -35 },
  { 3430, 12, 15, 16, 2, -31 },
  { 3453, 16, 1, 16, 0, 0 },
  { 3455, 6, 6, 11, 3, -33 },
  { 3460, 15, 23, 20, 2, -23 },
  { 3504, 15, 32, 21, 3, -32 },
  { 3564, 15, 23, 19, 2, -23 },
  { 3608, 14, 32, 21, 3, -32 },
  { 3664, 15, 23, 19, 2, -23 },
  { 3708, 10, 32, 12, 2, -32 },
  { 3748, 14, 32, 21, 3, -23 },
  { 3804, 14, 32, 21, 3, -32 },
  { 3860, 2, 31, 8, 3, -31 },
  { 3868, 7, 40, 9, -2, -31 },
  { 3903, 14, 32, 18, 3, -32 },
  { 3959, 1, 32, 8, 4, -32 },
  { 3963, 27, 23, 33, 3, -23 },
  { 4041, 14, 23, 21, 3, -23 },
  { 4082, 16, 23, 21, 2, -23 },
  { 4128, 15, 32, 21, 3, -23 },
  { 4188, 14, 32, 21, 3, -23 },
  { 4244, 9, 23, 13, 3, -23 },
  { 4270, 14, 23, 19, 2, -23 },
  { 4311, 10, 29, 12, 1, -29 },
  { 4348, 14, 23, 21, 3, -23 },
  { 4389, 16, 23, 18, 1, -23 },
  { 4435, 24, 23, 28, 2, -23 },
  { 4504, 16, 23, 18, 1, -23 },
  { 4550, 16, 32, 18, 1, -23 },
  { 4614, 15, 23, 18, 2, -23 },
  { 4658, 10, 43, 13, 2, -34 },
  { 4712, 1, 37, 9, 4, -31 },
  { 4717, 11, 43, 13, 0, -34 },
  { 4777, 20, 7, 26, 3, -16 },
};

const GFXfont RobotoCondensed_Thin43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_THIN43PT7B_H_
