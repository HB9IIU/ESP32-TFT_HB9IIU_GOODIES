#ifndef _ROBOTOCONDENSED_THIN31PT7B_H_
#define _ROBOTOCONDENSED_THIN31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin31pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0xF0, 0x99, 0x99, 0x99, 0x02, 0x10,
  0x08, 0x40, 0x41, 0x01, 0x04, 0x04, 0x20, 0x10, 0x87, 0xFF, 0xC1, 0x08,
  0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84,
  0x3F, 0xFE, 0x10, 0x40, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x82,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x0F, 0x82, 0x0C, 0x80, 0x90, 0x0C, 0x01,
  0x80, 0x30, 0x01, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x1B, 0x06, 0x1F, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x38, 0x00, 0x44, 0x00, 0x82, 0x00, 0x82, 0x08,
  0x82, 0x10, 0x82, 0x10, 0x82, 0x20, 0x82, 0x20, 0x44, 0x40, 0x38, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x1E, 0x02, 0x21, 0x02, 0x21, 0x04, 0x41,
  0x04, 0x41, 0x08, 0x41, 0x10, 0x41, 0x10, 0x21, 0x00, 0x21, 0x00, 0x1E,
  0x0E, 0x00, 0xC4, 0x02, 0x08, 0x08, 0x20, 0x40, 0x80, 0x82, 0x02, 0x10,
  0x08, 0x80, 0x14, 0x00, 0x60, 0x01, 0x80, 0x09, 0x00, 0x42, 0x09, 0x08,
  0x28, 0x10, 0xA0, 0x22, 0x80, 0x52, 0x01, 0x48, 0x02, 0x20, 0x14, 0x60,
  0x88, 0x7C, 0x20, 0xFC, 0x04, 0x21, 0x04, 0x20, 0x82, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82,
  0x08, 0x10, 0x40, 0x81, 0x84, 0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x22, 0x10,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x04, 0x23, 0x9D, 0x60, 0x1C, 0x00,
  0xA0, 0x04, 0x80, 0x44, 0x04, 0x10, 0x60, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x24, 0xA5, 0x00, 0xFC, 0x30, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00,
  0x0C, 0xDC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x05,
  0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0xFF, 0xC0,
  0x1F, 0x04, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x3C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xA0, 0x26, 0x0C, 0x3E, 0x00, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x02, 0x80, 0x14, 0x01, 0x20, 0x11, 0x00, 0x88, 0x08, 0x40, 0x42, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x20, 0x21, 0x01, 0x1F, 0xFF, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0xD0, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0xBE, 0x30, 0x60, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x60, 0x87, 0xC0, 0x03,
  0x81, 0x80, 0x40, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x9F, 0x14,
  0x1B, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05,
  0x00, 0xA0, 0x22, 0x08, 0x3E, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x1F, 0x02, 0x08, 0x40, 0x48, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x40, 0x42, 0x08, 0x1F, 0x02, 0x08, 0x40, 0x48, 0x02,
  0x80, 0x28, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x60, 0xC1, 0xF0,
  0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x34, 0x06, 0x43, 0x47, 0x88, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x30, 0x78, 0x00, 0x30, 0x00, 0x00, 0x0B, 0x4C,
  0x00, 0x00, 0x00, 0x00, 0x09, 0x49, 0x40, 0x00, 0x20, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x30, 0x08, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x00, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x18,
  0x0C, 0x03, 0x00, 0x10, 0x30, 0x00, 0x41, 0x00, 0x02, 0x10, 0x00, 0x08,
  0x81, 0xE0, 0x48, 0x10, 0x81, 0x41, 0x02, 0x0C, 0x08, 0x10, 0x60, 0x81,
  0x03, 0x04, 0x08, 0x18, 0x20, 0x40, 0xC1, 0x02, 0x06, 0x08, 0x10, 0x30,
  0x40, 0x81, 0x82, 0x04, 0x0C, 0x10, 0x60, 0xA0, 0x83, 0x05, 0x04, 0x24,
  0x44, 0x1E, 0x1C, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x10, 0x04,
  0x20, 0x08, 0x40, 0x10, 0x40, 0x40, 0x80, 0x81, 0x01, 0x01, 0x04, 0x02,
  0x0F, 0xFC, 0x10, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x50, 0x00, 0x40, 0xFF, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x08, 0xFF, 0x08, 0x0C, 0x80, 0x28,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x4F,
  0xF8, 0x0F, 0xC0, 0x40, 0xC2, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x05, 0x00, 0x24, 0x00, 0x88, 0x04,
  0x10, 0x30, 0x3F, 0x00, 0xFF, 0x04, 0x06, 0x20, 0x09, 0x00, 0x48, 0x01,
  0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00,
  0x48, 0x0C, 0x7F, 0x80, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x0F, 0xC1, 0x81, 0x10, 0x05, 0x00,
  0x28, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x50,
  0x02, 0x80, 0x13, 0x03, 0x07, 0xE0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x05, 0x00, 0xA0,
  0x22, 0x08, 0x3E, 0x00, 0x80, 0x14, 0x01, 0x20, 0x11, 0x01, 0x08, 0x08,
  0x40, 0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0x80, 0x26, 0x01, 0x50, 0x0C,
  0x40, 0x41, 0x02, 0x04, 0x10, 0x20, 0x80, 0x84, 0x02, 0x20, 0x19, 0x00,
  0x48, 0x01, 0x40, 0x04, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3A, 0x00, 0x2D, 0x00, 0x16, 0x80, 0x0B, 0x20,
  0x09, 0x90, 0x04, 0xC4, 0x02, 0x62, 0x02, 0x31, 0x01, 0x18, 0x41, 0x0C,
  0x20, 0x86, 0x10, 0x43, 0x04, 0x41, 0x82, 0x20, 0xC1, 0x10, 0x60, 0x50,
  0x30, 0x28, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x40, 0x1A, 0x00, 0xC8, 0x06, 0x40, 0x31, 0x01, 0x84, 0x0C, 0x20, 0x60,
  0x83, 0x04, 0x18, 0x10, 0xC0, 0x46, 0x02, 0x30, 0x09, 0x80, 0x4C, 0x01,
  0x60, 0x0B, 0x00, 0x38, 0x00, 0xC0, 0x04, 0x0F, 0xC0, 0x40, 0x82, 0x01,
  0x10, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x05, 0x00, 0x14, 0x00, 0x88, 0x04, 0x10, 0x30, 0x3F, 0x00, 0xFF, 0x88,
  0x04, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x04, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0xC0, 0x40, 0x82, 0x01,
  0x10, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x05, 0x00, 0x14, 0x00, 0x88, 0x04, 0x10, 0x20, 0x3F, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0xFF, 0x84, 0x02, 0x20, 0x09, 0x00, 0x48,
  0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00,
  0x8F, 0xF8, 0x40, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02, 0x20, 0x09,
  0x00, 0x48, 0x01, 0x40, 0x04, 0x1F, 0x81, 0x03, 0x10, 0x05, 0x00, 0x28,
  0x01, 0x40, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x50, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04,
  0x80, 0x22, 0x06, 0x0F, 0xC0, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x14, 0x02, 0x60, 0x61, 0xF8, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00,
  0x24, 0x00, 0x88, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x20, 0x20,
  0x40, 0x80, 0x81, 0x00, 0x82, 0x01, 0x08, 0x02, 0x10, 0x02, 0x20, 0x04,
  0x80, 0x09, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80,
  0x10, 0x06, 0x00, 0xC0, 0x14, 0x03, 0x00, 0x50, 0x0A, 0x01, 0x40, 0x48,
  0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0x88, 0x11, 0x02, 0x20, 0x84, 0x10,
  0x82, 0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0x84, 0x11, 0x02, 0x10, 0x44,
  0x08, 0x81, 0x10, 0x22, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x20, 0x28, 0x05,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x05, 0x00, 0x22, 0x00, 0x88, 0x04, 0x10, 0x20, 0x40, 0x80, 0x84,
  0x01, 0x10, 0x04, 0x80, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x80, 0x12,
  0x00, 0x84, 0x02, 0x08, 0x10, 0x20, 0x40, 0x42, 0x01, 0x10, 0x02, 0x40,
  0x0A, 0x00, 0x10, 0x80, 0x05, 0x00, 0x09, 0x00, 0x22, 0x00, 0x42, 0x01,
  0x04, 0x02, 0x04, 0x08, 0x08, 0x10, 0x08, 0x40, 0x08, 0x80, 0x12, 0x00,
  0x14, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xF8, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xF0,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0xC0,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x06, 0x05, 0x02, 0x81, 0x21,
  0x10, 0x88, 0x42, 0x41, 0x20, 0x90, 0x20, 0xFF, 0xE0, 0x44, 0x21, 0x0F,
  0x86, 0x09, 0x00, 0xA0, 0x14, 0x02, 0x00, 0x40, 0x08, 0x01, 0x1F, 0xE4,
  0x05, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x50, 0x1A, 0x05, 0x3F, 0x20, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0xC5, 0x06, 0xC0, 0x58,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1C, 0x05, 0x41, 0x23, 0xC0, 0x1F, 0x18, 0x24, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x14, 0x05, 0x82, 0x1F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x47, 0xCB, 0x05, 0x40, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x06, 0x41, 0x47,
  0xC8, 0x0F, 0x83, 0x04, 0x20, 0x24, 0x02, 0x40, 0x28, 0x01, 0x80, 0x1F,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x06, 0x0F, 0x80, 0x0F, 0x10, 0x10, 0x20, 0x20, 0x20, 0xFE, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x1F, 0x2C, 0x15, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x1B, 0x05,
  0x1F, 0x20, 0x04, 0x01, 0x80, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x23, 0xC4, 0x84, 0xA0, 0x58, 0x0B,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x30, 0x05, 0x55, 0x55, 0x55, 0x54,
  0x08, 0xC0, 0x00, 0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x84, 0x2E, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x14, 0x04, 0x81, 0x10, 0x42, 0x10, 0x44, 0x09,
  0x01, 0x20, 0x2A, 0x06, 0x40, 0x84, 0x10, 0x42, 0x08, 0x40, 0x88, 0x09,
  0x00, 0xA0, 0x10, 0xFF, 0xFF, 0xFE, 0x8F, 0x07, 0xC9, 0x08, 0x82, 0xA0,
  0x50, 0x2C, 0x06, 0x01, 0xC0, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18,
  0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01,
  0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20,
  0x10, 0x8F, 0x12, 0x12, 0x81, 0x60, 0x2C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x11, 0x04, 0x1F,
  0x00, 0x9F, 0x14, 0x1B, 0x01, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x15, 0x04, 0x9F,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x1F, 0x2C, 0x15,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x50, 0x19, 0x05, 0x1F, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x8F, 0x62, 0x86, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x3E, 0x10, 0x68, 0x0A,
  0x01, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x18, 0x09, 0x06, 0x3E, 0x00, 0x20, 0x40, 0x81, 0x0F, 0xC4, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81,
  0xE0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xD0, 0x19, 0x05, 0x1F,
  0x20, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x80, 0x88, 0x21, 0x04,
  0x20, 0x82, 0x20, 0x44, 0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x40, 0x50, 0x30, 0x14, 0x0C, 0x09, 0x02, 0x82, 0x40, 0xA0,
  0x88, 0x48, 0x22, 0x12, 0x08, 0x84, 0x44, 0x22, 0x11, 0x04, 0x84, 0x41,
  0x21, 0x10, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x80, 0xC0, 0xA0, 0x30,
  0x10, 0x08, 0x04, 0x00, 0x40, 0x28, 0x08, 0x82, 0x10, 0x41, 0x10, 0x22,
  0x02, 0x80, 0x30, 0x04, 0x01, 0x40, 0x28, 0x08, 0x81, 0x08, 0x41, 0x10,
  0x12, 0x02, 0x80, 0x20, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x40,
  0x88, 0x21, 0x04, 0x10, 0x82, 0x20, 0x44, 0x04, 0x80, 0xA0, 0x14, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x18, 0x00,
  0x7F, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0xFF, 0xE0,
  0x03, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x3C, 0x05, 0x08, 0x14, 0x10, 0x60,
  0x22, 0x80, 0x70,
};

const GFXglyph RobotoCondensed_Thin31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 22, 6, 2, -22 },
  { 7, 4, 6, 8, 2, -23 },
  { 10, 14, 22, 15, 1, -22 },
  { 49, 11, 28, 15, 2, -25 },
  { 88, 16, 22, 20, 2, -22 },
  { 132, 14, 22, 17, 2, -22 },
  { 171, 1, 6, 5, 2, -23 },
  { 172, 6, 32, 8, 2, -25 },
  { 196, 5, 32, 9, 1, -25 },
  { 216, 13, 12, 13, 0, -22 },
  { 236, 13, 17, 15, 1, -19 },
  { 264, 3, 6, 6, 1, -2 },
  { 267, 6, 1, 8, 1, -11 },
  { 268, 2, 2, 7, 2, -2 },
  { 269, 8, 24, 11, 1, -22 },
  { 293, 11, 22, 15, 2, -22 },
  { 324, 6, 22, 15, 3, -22 },
  { 341, 11, 22, 15, 2, -22 },
  { 372, 11, 22, 15, 2, -22 },
  { 403, 13, 22, 15, 1, -22 },
  { 439, 10, 22, 15, 3, -22 },
  { 467, 11, 22, 15, 2, -22 },
  { 498, 12, 22, 15, 1, -22 },
  { 531, 12, 22, 15, 2, -22 },
  { 564, 11, 22, 15, 2, -22 },
  { 595, 2, 16, 5, 2, -16 },
  { 599, 3, 20, 5, 1, -16 },
  { 607, 11, 12, 14, 1, -16 },
  { 624, 11, 8, 15, 2, -14 },
  { 635, 11, 12, 14, 2, -16 },
  { 652, 10, 22, 12, 1, -22 },
  { 680, 21, 28, 25, 2, -21 },
  { 754, 15, 22, 16, 1, -22 },
  { 796, 12, 22, 16, 3, -22 },
  { 829, 14, 22, 18, 2, -22 },
  { 868, 13, 22, 18, 3, -22 },
  { 904, 11, 22, 16, 3, -22 },
  { 935, 11, 22, 16, 3, -22 },
  { 966, 13, 22, 19, 3, -22 },
  { 1002, 13, 22, 19, 3, -22 },
  { 1038, 1, 22, 7, 3, -22 },
  { 1041, 11, 22, 15, 1, -22 },
  { 1072, 13, 22, 17, 3, -22 },
  { 1108, 10, 22, 14, 3, -22 },
  { 1136, 17, 22, 23, 3, -22 },
  { 1183, 13, 22, 19, 3, -22 },
  { 1219, 14, 22, 18, 2, -22 },
  { 1258, 12, 22, 16, 3, -22 },
  { 1291, 14, 26, 18, 2, -22 },
  { 1337, 13, 22, 18, 3, -22 },
  { 1373, 13, 22, 16, 2, -22 },
  { 1409, 14, 22, 16, 1, -22 },
  { 1448, 12, 22, 18, 3, -22 },
  { 1481, 15, 22, 16, 1, -22 },
  { 1523, 22, 22, 24, 1, -22 },
  { 1584, 14, 22, 16, 1, -22 },
  { 1623, 15, 22, 16, 1, -22 },
  { 1665, 14, 22, 16, 1, -22 },
  { 1704, 3, 30, 6, 3, -25 },
  { 1716, 9, 24, 11, 1, -22 },
  { 1743, 4, 30, 6, 0, -25 },
  { 1758, 9, 11, 11, 1, -22 },
  { 1771, 11, 1, 11, 0, 0 },
  { 1773, 4, 4, 8, 2, -23 },
  { 1775, 11, 17, 15, 1, -17 },
  { 1799, 11, 23, 15, 2, -23 },
  { 1831, 10, 17, 14, 2, -17 },
  { 1853, 11, 23, 15, 2, -23 },
  { 1885, 12, 17, 14, 1, -17 },
  { 1911, 8, 23, 9, 1, -23 },
  { 1934, 11, 23, 15, 2, -17 },
  { 1966, 11, 23, 15, 2, -23 },
  { 1998, 2, 23, 6, 2, -23 },
  { 2004, 5, 29, 6, -1, -23 },
  { 2023, 11, 23, 13, 2, -23 },
  { 2055, 1, 23, 6, 3, -23 },
  { 2058, 20, 17, 24, 2, -17 },
  { 2101, 11, 17, 15, 2, -17 },
  { 2125, 11, 17, 15, 2, -17 },
  { 2149, 11, 23, 15, 2, -17 },
  { 2181, 11, 23, 15, 2, -17 },
  { 2213, 7, 17, 9, 2, -17 },
  { 2228, 10, 17, 14, 2, -17 },
  { 2250, 7, 21, 9, 1, -21 },
  { 2269, 11, 17, 15, 2, -17 },
  { 2293, 11, 17, 13, 1, -17 },
  { 2317, 18, 17, 20, 1, -17 },
  { 2356, 11, 17, 13, 1, -17 },
  { 2380, 11, 23, 13, 1, -17 },
  { 2412, 11, 17, 13, 1, -17 },
  { 2436, 8, 31, 9, 1, -24 },
  { 2467, 1, 26, 6, 3, -22 },
  { 2471, 8, 31, 9, 0, -24 },
  { 2502, 14, 5, 19, 2, -12 },
};

const GFXfont RobotoCondensed_Thin31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_THIN31PT7B_H_
