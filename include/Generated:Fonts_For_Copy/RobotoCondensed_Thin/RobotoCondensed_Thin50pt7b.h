#ifndef _ROBOTOCONDENSED_THIN50PT7B_H_
#define _ROBOTOCONDENSED_THIN50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin50pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x00, 0x3F, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40,
  0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x00,
  0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x01, 0x80, 0x02,
  0x03, 0x03, 0xFF, 0xFF, 0xF0, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40,
  0x20, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x04,
  0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0xC0,
  0x01, 0x01, 0x00, 0x06, 0x02, 0x01, 0xFF, 0xFF, 0xF0, 0x10, 0x08, 0x00,
  0x20, 0x10, 0x00, 0x40, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x06,
  0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0xFE, 0x00, 0xE0, 0xE0, 0x60, 0x0C, 0x30, 0x01, 0x08, 0x00,
  0x66, 0x00, 0x09, 0x00, 0x03, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x60,
  0x00, 0x88, 0x00, 0x61, 0x80, 0x30, 0x3C, 0x38, 0x03, 0xF8, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x1F, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x00, 0x40, 0x30, 0x20, 0x08, 0x04, 0x04, 0x01, 0x01,
  0x80, 0x80, 0x20, 0x20, 0x10, 0x04, 0x0C, 0x02, 0x00, 0x81, 0x00, 0x40,
  0x10, 0x40, 0x0C, 0x06, 0x08, 0x00, 0x80, 0x82, 0x00, 0x18, 0x30, 0xC0,
  0x01, 0x8C, 0x10, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x0F, 0x00, 0x01, 0x83, 0x38, 0x00, 0x20, 0x81,
  0x00, 0x0C, 0x30, 0x10, 0x01, 0x04, 0x02, 0x00, 0x40, 0x80, 0x60, 0x08,
  0x30, 0x0C, 0x02, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x10, 0x18, 0x06,
  0x06, 0x03, 0x00, 0xC0, 0x80, 0x20, 0x18, 0x30, 0x04, 0x02, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x08, 0x10, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0xC0, 0xC0, 0x02, 0x01, 0x00, 0x18,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x40, 0x10, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x31, 0x80, 0x00, 0x4C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xC8, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x00, 0x80, 0x80,
  0x26, 0x01, 0x00, 0x90, 0x06, 0x02, 0xC0, 0x0C, 0x0A, 0x00, 0x10, 0x68,
  0x00, 0x21, 0x20, 0x00, 0xC4, 0x80, 0x01, 0xB2, 0x00, 0x02, 0x8C, 0x00,
  0x06, 0x10, 0x00, 0x38, 0x60, 0x01, 0xB0, 0xC0, 0x0C, 0x41, 0x80, 0xE0,
  0x83, 0xFE, 0x03, 0x00, 0x80, 0x00, 0x55, 0xFF, 0xF0, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x20, 0x10, 0x0F, 0x82, 0x0F, 0x1C, 0x47, 0x00, 0x7F, 0x00, 0x03,
  0x80, 0x00, 0x50, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x00, 0x83, 0x00, 0x30,
  0x30, 0x0C, 0x02, 0x03, 0x00, 0x60, 0x40, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x33, 0x33, 0x33, 0x26, 0x4C, 0xFF, 0x80, 0x3C, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x87,
  0x01, 0x80, 0x60, 0x40, 0x08, 0x30, 0x01, 0x08, 0x00, 0x66, 0x00, 0x09,
  0x00, 0x02, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x03, 0x40,
  0x00, 0x98, 0x00, 0x22, 0x00, 0x18, 0xC0, 0x04, 0x10, 0x03, 0x06, 0x01,
  0x80, 0x61, 0xC0, 0x0F, 0xC0, 0x00, 0x40, 0xF0, 0xE4, 0xE1, 0xE0, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x03, 0xF0, 0x01, 0xC3, 0x80, 0x60, 0x18, 0x18, 0x01, 0x86,
  0x00, 0x10, 0x80, 0x03, 0x10, 0x00, 0x66, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0,
  0x04, 0x60, 0x01, 0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x0D, 0x80, 0x02, 0x20, 0x01, 0x06, 0x00, 0xC0, 0xE0, 0xC0, 0x0F,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x1A, 0x00,
  0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x21,
  0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x18, 0x10, 0x00,
  0x80, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x20, 0x06, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x30, 0x02, 0x01, 0x00, 0x10, 0x18, 0x00, 0x80, 0x80,
  0x04, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x1F, 0xFF, 0x8C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0xFC, 0x06, 0xC1, 0xC1, 0xC0, 0x18,
  0x60, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x26, 0x00, 0x18, 0x80, 0x04,
  0x30, 0x03, 0x06, 0x01, 0x80, 0xE1, 0xC0, 0x0F, 0xC0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x1F, 0x80, 0x8E, 0x38, 0x32, 0x00, 0xC6, 0x80, 0x08, 0xA0,
  0x01, 0x98, 0x00, 0x13, 0x00, 0x03, 0x60, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0B, 0x00,
  0x01, 0x60, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x98, 0x00, 0x21, 0x80,
  0x0C, 0x10, 0x03, 0x01, 0x80, 0xC0, 0x1C, 0x30, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0xC3, 0x80, 0x60, 0x18, 0x18, 0x01, 0x86, 0x00,
  0x18, 0x80, 0x01, 0x10, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00,
  0x0B, 0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0xC0, 0x03, 0x0C, 0x00,
  0x40, 0xC0, 0x30, 0x0E, 0x1C, 0x00, 0x7F, 0x00, 0x30, 0x38, 0x18, 0x01,
  0x86, 0x00, 0x18, 0x80, 0x01, 0xB0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xB0, 0x00, 0x12, 0x00, 0x06, 0x60, 0x01, 0x86, 0x00, 0x60, 0x38, 0x78,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0x8F, 0x01, 0x80, 0x60, 0xC0, 0x0C,
  0x60, 0x01, 0x10, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x1D, 0x80, 0x05,
  0x30, 0x02, 0x46, 0x01, 0x10, 0xE3, 0x8C, 0x1F, 0x83, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x5F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFC, 0x27, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x33, 0x32,
  0x26, 0x48, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x60, 0xC0, 0x21, 0x00, 0x66,
  0x00, 0x48, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0xC0, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x41, 0x00, 0x0F, 0x80, 0x08, 0xC0,
  0x0E, 0x30, 0x02, 0x20, 0x06, 0x02, 0x00, 0x88, 0x03, 0x00, 0xC0, 0x36,
  0x00, 0x80, 0x30, 0x0D, 0x00, 0x60, 0x08, 0x01, 0x40, 0x10, 0x02, 0x00,
  0x50, 0x04, 0x00, 0x80, 0x1C, 0x03, 0x00, 0x20, 0x07, 0x00, 0x80, 0x08,
  0x01, 0xC0, 0x20, 0x02, 0x00, 0x60, 0x08, 0x00, 0x80, 0x18, 0x06, 0x00,
  0x20, 0x06, 0x01, 0x80, 0x08, 0x01, 0x80, 0x60, 0x02, 0x00, 0xE0, 0x18,
  0x01, 0x80, 0x38, 0x06, 0x00, 0x60, 0x0B, 0x01, 0x80, 0x18, 0x02, 0xC0,
  0x20, 0x06, 0x00, 0xB0, 0x08, 0x03, 0x80, 0x44, 0x02, 0x01, 0xA0, 0x11,
  0x00, 0xC0, 0x48, 0x08, 0x60, 0x18, 0x61, 0x06, 0x18, 0x03, 0xF0, 0x7F,
  0x02, 0x00, 0x20, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x20, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x14, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x26, 0x00, 0x00, 0x62, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x43, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x81, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x80, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x40,
  0x03, 0x00, 0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x04, 0x00, 0x20, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x10,
  0x0F, 0xFF, 0xF8, 0x18, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x0C,
  0x30, 0x00, 0x04, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x10, 0x07, 0x82, 0x00, 0x18, 0x40, 0x01, 0x88, 0x00, 0x19,
  0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0xC4,
  0x00, 0x30, 0x80, 0x1C, 0x1F, 0xFF, 0x02, 0x00, 0x18, 0x40, 0x01, 0x88,
  0x00, 0x09, 0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x06, 0x80, 0x01, 0x90, 0x00, 0x62, 0x00, 0x38, 0x7F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x3C, 0x07, 0x00, 0x30, 0x60, 0x00,
  0xC2, 0x00, 0x02, 0x30, 0x00, 0x09, 0x00, 0x00, 0x58, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x80, 0x00, 0x44,
  0x00, 0x04, 0x10, 0x00, 0x60, 0x60, 0x06, 0x01, 0xC1, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0xF0, 0x08, 0x03, 0xC0, 0x80, 0x07, 0x08, 0x00, 0x18, 0x80,
  0x00, 0x88, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x08, 0x80, 0x01, 0x88,
  0x00, 0x70, 0x80, 0x3C, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xC8,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xC8, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1E, 0x0E, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x10, 0x80, 0x00, 0x66, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x80, 0x00, 0x12,
  0x00, 0x00, 0x44, 0x00, 0x03, 0x18, 0x00, 0x18, 0x38, 0x01, 0xC0, 0x38,
  0x3C, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x90, 0x00, 0x24, 0x00, 0x19, 0x80, 0x04,
  0x20, 0x03, 0x06, 0x01, 0x80, 0xE1, 0xC0, 0x0F, 0xC0, 0x80, 0x00, 0x24,
  0x00, 0x03, 0x20, 0x00, 0x31, 0x00, 0x03, 0x08, 0x00, 0x30, 0x40, 0x01,
  0x02, 0x00, 0x10, 0x10, 0x01, 0x80, 0x80, 0x18, 0x04, 0x01, 0x80, 0x20,
  0x18, 0x01, 0x00, 0x80, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x0C, 0x00,
  0x10, 0xC0, 0x00, 0x8E, 0x00, 0x04, 0x58, 0x00, 0x24, 0x40, 0x01, 0x43,
  0x00, 0x0C, 0x0C, 0x00, 0x60, 0x20, 0x02, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x80, 0x18, 0x04, 0x00, 0x40, 0x20, 0x03, 0x01, 0x00, 0x0C, 0x08, 0x00,
  0x30, 0x40, 0x00, 0x82, 0x00, 0x06, 0x10, 0x00, 0x18, 0x80, 0x00, 0x44,
  0x00, 0x03, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x30, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xA0, 0x00,
  0x00, 0xFA, 0x00, 0x00, 0x0B, 0xB0, 0x00, 0x00, 0xB9, 0x00, 0x00, 0x13,
  0x90, 0x00, 0x01, 0x38, 0x80, 0x00, 0x33, 0x88, 0x00, 0x02, 0x38, 0xC0,
  0x00, 0x23, 0x84, 0x00, 0x06, 0x38, 0x40, 0x00, 0x43, 0x86, 0x00, 0x04,
  0x38, 0x20, 0x00, 0xC3, 0x82, 0x00, 0x08, 0x38, 0x30, 0x00, 0x83, 0x81,
  0x00, 0x18, 0x38, 0x10, 0x01, 0x03, 0x80, 0x80, 0x30, 0x38, 0x08, 0x02,
  0x03, 0x80, 0xC0, 0x20, 0x38, 0x04, 0x06, 0x03, 0x80, 0x40, 0x40, 0x38,
  0x06, 0x04, 0x03, 0x80, 0x20, 0xC0, 0x38, 0x02, 0x08, 0x03, 0x80, 0x30,
  0x80, 0x38, 0x01, 0x18, 0x03, 0x80, 0x11, 0x00, 0x38, 0x00, 0xB0, 0x03,
  0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00,
  0x40, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x60, 0x00, 0x31, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x20, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0xC0, 0x06, 0x02, 0x00, 0x30, 0x18, 0x01, 0x80, 0x40, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x20, 0x18, 0x01, 0x80, 0xC0, 0x04, 0x06,
  0x00, 0x30, 0x30, 0x00, 0x81, 0x80, 0x02, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0x43, 0x00, 0x03, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x30,
  0x00, 0x05, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x10, 0x00, 0xFE, 0x00, 0x07, 0x07, 0x00, 0x38, 0x01, 0x80, 0xC0, 0x01,
  0x81, 0x00, 0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x03, 0x30, 0x00, 0x02,
  0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x44, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x1C, 0x00, 0xC0, 0x0E, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x10,
  0x03, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0xC8, 0x00, 0x0D, 0x00, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x14, 0x00, 0x02, 0x80,
  0x00, 0xD0, 0x00, 0x32, 0x00, 0x0C, 0x40, 0x0F, 0x0F, 0xFF, 0x81, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0x07, 0x00, 0x38, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x03, 0x30, 0x00, 0x02, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x8C, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x1C, 0x00,
  0xC0, 0x0E, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0xFF, 0xFC, 0x06, 0x00, 0x38, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00,
  0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30,
  0x00, 0x61, 0x80, 0x0E, 0x0F, 0xFF, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x10,
  0x18, 0x00, 0xC0, 0xC0, 0x02, 0x06, 0x00, 0x18, 0x30, 0x00, 0x41, 0x80,
  0x03, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x04,
  0xC0, 0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00,
  0xFE, 0x00, 0x1E, 0x0E, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x10, 0x80, 0x00, 0x66, 0x00, 0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x09,
  0x80, 0x00, 0x26, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x8C, 0x00, 0x06, 0x18, 0x00, 0x30, 0x30, 0x01, 0x80, 0x7C, 0x3C, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x34,
  0x00, 0x01, 0xA0, 0x00, 0x09, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x30, 0x00,
  0x60, 0xC0, 0x06, 0x03, 0xC1, 0xE0, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x0C,
  0x18, 0x00, 0x08, 0x18, 0x00, 0x08, 0x08, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x0C, 0x00, 0x10, 0x04, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0,
  0x01, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0x81, 0x80,
  0x00, 0x81, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x43, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x26, 0x00, 0x00, 0x24, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x28, 0x00, 0x06, 0x00, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x2C, 0x00,
  0x0A, 0x00, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x64, 0x00, 0x09, 0x00, 0x04,
  0x60, 0x01, 0x90, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x20, 0x01, 0x18,
  0x00, 0xC2, 0x00, 0x10, 0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x83, 0x00,
  0x20, 0x80, 0x08, 0x10, 0x02, 0x0C, 0x01, 0x81, 0x00, 0x20, 0x40, 0x18,
  0x10, 0x06, 0x04, 0x01, 0x01, 0x80, 0x40, 0x40, 0x10, 0x18, 0x04, 0x06,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x08, 0x0C, 0x02, 0x02, 0x00, 0xC0,
  0x80, 0x20, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x00, 0x41, 0x80, 0x10, 0x60,
  0x04, 0x18, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x06, 0x10, 0x01,
  0x84, 0x00, 0x63, 0x00, 0x08, 0x40, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x0C, 0x80,
  0x01, 0x60, 0x00, 0x58, 0x00, 0x14, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00,
  0x50, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x11, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x81, 0x00, 0x03, 0x03, 0x00, 0x04, 0x02, 0x00, 0x18, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x20, 0x00, 0x10, 0x80, 0x00, 0x13, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x04, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x61, 0x80, 0x00, 0x81, 0x00,
  0x03, 0x01, 0x00, 0x04, 0x03, 0x00, 0x18, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x80, 0x04, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x34, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x08, 0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C,
  0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x03,
  0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xFC, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0xFC, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xA0, 0x04, 0x80, 0x13, 0x00,
  0xC4, 0x02, 0x10, 0x08, 0x60, 0x60, 0x81, 0x02, 0x04, 0x0C, 0x30, 0x10,
  0x80, 0x42, 0x01, 0x98, 0x02, 0x40, 0x0B, 0x00, 0x30, 0xFF, 0xFF, 0xC0,
  0xC1, 0x02, 0x0C, 0x18, 0x30, 0x03, 0xF8, 0x03, 0x83, 0x81, 0x80, 0x30,
  0xC0, 0x04, 0x20, 0x00, 0x98, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x03, 0xFF, 0x83, 0xE0,
  0x23, 0x80, 0x08, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x2C, 0x00, 0x0B,
  0x00, 0x02, 0xC0, 0x01, 0x90, 0x00, 0x64, 0x00, 0x28, 0x80, 0x32, 0x3C,
  0x38, 0xC3, 0xF8, 0x30, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x3F, 0x04, 0x60, 0xE2, 0x40, 0x19,
  0x40, 0x04, 0xC0, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x60, 0x01, 0xB8, 0x00, 0x96, 0x00, 0xC9, 0xC1, 0xC4, 0x1F,
  0x80, 0x03, 0xF8, 0x03, 0x83, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20, 0x00,
  0x98, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x14, 0x00, 0x05, 0x00, 0x03, 0x60, 0x00,
  0x88, 0x00, 0x23, 0x00, 0x18, 0x60, 0x0C, 0x0F, 0x0E, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x7F, 0x08, 0xE0, 0xE4, 0xC0, 0x1A, 0x40, 0x05, 0x60, 0x01,
  0xA0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xB0, 0x00,
  0xC8, 0x00, 0xE6, 0x00, 0xD0, 0xC1, 0xC8, 0x3F, 0x80, 0x01, 0xF8, 0x01,
  0xC3, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20, 0x00, 0x98, 0x00, 0x34, 0x00,
  0x05, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x08, 0x70, 0x06, 0x07, 0x0F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x0F, 0xFE, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xE0, 0x8E, 0x0C, 0x4C,
  0x01, 0xA4, 0x00, 0x56, 0x00, 0x1A, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x0B, 0x00, 0x0C, 0x80, 0x0E, 0x60, 0x0D, 0x1C, 0x1C,
  0x83, 0xF8, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x20, 0x03, 0x0C, 0x01, 0x03, 0x87, 0x00, 0x7E, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x83, 0xF0, 0x86, 0x1C, 0x88, 0x06, 0x90, 0x02, 0xA0, 0x03, 0xA0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04, 0x1C, 0xF0, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x10, 0x80, 0x20, 0x80, 0x60, 0x80,
  0xC0, 0x81, 0x80, 0x83, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB4,
  0x00, 0xA2, 0x00, 0xC3, 0x00, 0x81, 0x80, 0x80, 0x80, 0x80, 0x40, 0x80,
  0x60, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x83, 0xF0, 0x07, 0xE1, 0x1C, 0x38, 0x38, 0x72, 0x60, 0x18, 0xC0,
  0x34, 0x80, 0x13, 0x00, 0x2A, 0x00, 0x24, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x83, 0xF0, 0x86, 0x1C, 0x88, 0x06,
  0x90, 0x02, 0xA0, 0x03, 0xA0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x03, 0xF0,
  0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x24,
  0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x40, 0x00, 0x98, 0x00, 0x63,
  0x00, 0x30, 0x60, 0x18, 0x0E, 0x1C, 0x00, 0xFC, 0x00, 0x83, 0xF0, 0x46,
  0x0E, 0x2C, 0x01, 0x94, 0x00, 0x6C, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x16, 0x00, 0x0B, 0x80, 0x09, 0x60, 0x0C,
  0x9C, 0x1C, 0x43, 0xF8, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xE0, 0x8E, 0x0E, 0x4C, 0x01, 0xA4, 0x00, 0x76, 0x00,
  0x1A, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0B, 0x00,
  0x0C, 0x80, 0x0E, 0x60, 0x0D, 0x0E, 0x1C, 0x83, 0xF8, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x83, 0xE3, 0x89, 0x82, 0xC0,
  0xA0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x0F, 0xE0, 0x38, 0x38, 0x60, 0x0C, 0x40, 0x06,
  0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x40, 0x02, 0x60, 0x06, 0x3C, 0x38, 0x0F, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0xFF, 0xE1, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x20, 0x03, 0x00, 0x3C, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x05, 0x30, 0x0D, 0x1C, 0x71, 0x0F, 0xC1, 0x40,
  0x00, 0x68, 0x00, 0x09, 0x80, 0x01, 0x10, 0x00, 0x62, 0x00, 0x08, 0x60,
  0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x18, 0x01, 0x01, 0x00, 0x60, 0x20,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x60, 0x08, 0x08, 0x01, 0x81, 0x00, 0x10,
  0x60, 0x02, 0x08, 0x00, 0x61, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00, 0x19,
  0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0xC0, 0x02, 0x00, 0x1A, 0x00, 0x30, 0x00, 0x90, 0x01, 0xC0, 0x04,
  0x80, 0x0A, 0x00, 0x66, 0x00, 0x50, 0x03, 0x10, 0x06, 0xC0, 0x10, 0x80,
  0x26, 0x00, 0x84, 0x01, 0x10, 0x0C, 0x30, 0x18, 0x80, 0x60, 0x80, 0x86,
  0x02, 0x04, 0x04, 0x10, 0x10, 0x20, 0x20, 0x81, 0x81, 0x83, 0x04, 0x0C,
  0x04, 0x10, 0x30, 0x40, 0x20, 0x80, 0x82, 0x01, 0x0C, 0x04, 0x30, 0x0C,
  0x60, 0x31, 0x80, 0x22, 0x00, 0x88, 0x01, 0x10, 0x04, 0x40, 0x09, 0x80,
  0x26, 0x00, 0x68, 0x01, 0xB0, 0x01, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x28,
  0x00, 0x70, 0x01, 0x40, 0x03, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x98, 0x00, 0x42, 0x00, 0x30, 0xC0, 0x18, 0x10, 0x04, 0x06,
  0x03, 0x00, 0xC0, 0x80, 0x10, 0x60, 0x06, 0x30, 0x00, 0x88, 0x00, 0x36,
  0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x16, 0x00, 0x0C, 0x80,
  0x06, 0x30, 0x01, 0x04, 0x00, 0xC1, 0x80, 0x20, 0x30, 0x10, 0x04, 0x0C,
  0x01, 0x82, 0x00, 0x21, 0x80, 0x04, 0xC0, 0x01, 0xA0, 0x00, 0x20, 0x40,
  0x00, 0x68, 0x00, 0x0D, 0x80, 0x01, 0x10, 0x00, 0x62, 0x00, 0x0C, 0x60,
  0x01, 0x04, 0x00, 0x60, 0x80, 0x0C, 0x18, 0x01, 0x01, 0x00, 0x60, 0x20,
  0x0C, 0x06, 0x01, 0x00, 0x40, 0x60, 0x08, 0x0C, 0x01, 0x81, 0x00, 0x10,
  0x60, 0x02, 0x0C, 0x00, 0x61, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x19,
  0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0xF0, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x78, 0x01, 0xC0, 0x30, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x70, 0x02, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xC6, 0x00, 0x14, 0x04, 0x00, 0x70, 0x08, 0x01, 0x80,
  0x10, 0x0E, 0x00, 0x20, 0x28, 0x00, 0x63, 0x00, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Thin50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 36, 9, 4, -36 },
  { 10, 6, 10, 13, 4, -38 },
  { 18, 23, 36, 24, 2, -36 },
  { 122, 18, 46, 24, 3, -41 },
  { 226, 27, 36, 33, 3, -36 },
  { 348, 22, 37, 27, 3, -36 },
  { 450, 2, 10, 8, 3, -38 },
  { 453, 10, 51, 14, 3, -40 },
  { 517, 9, 51, 14, 1, -40 },
  { 575, 19, 19, 21, 1, -36 },
  { 621, 21, 25, 25, 2, -29 },
  { 687, 4, 10, 9, 2, -4 },
  { 692, 9, 1, 13, 2, -17 },
  { 694, 2, 3, 11, 4, -3 },
  { 695, 14, 39, 17, 1, -36 },
  { 764, 18, 36, 24, 3, -36 },
  { 845, 10, 36, 24, 4, -36 },
  { 890, 19, 36, 24, 3, -36 },
  { 976, 18, 36, 24, 3, -36 },
  { 1057, 21, 36, 24, 2, -36 },
  { 1152, 18, 36, 24, 4, -36 },
  { 1233, 19, 36, 24, 3, -36 },
  { 1319, 19, 36, 24, 2, -36 },
  { 1405, 19, 36, 24, 3, -36 },
  { 1491, 18, 36, 24, 3, -36 },
  { 1572, 3, 26, 9, 3, -26 },
  { 1582, 4, 32, 9, 2, -26 },
  { 1598, 18, 20, 23, 2, -26 },
  { 1643, 17, 11, 25, 4, -22 },
  { 1667, 17, 19, 23, 3, -26 },
  { 1708, 15, 36, 19, 2, -36 },
  { 1776, 34, 45, 40, 3, -34 },
  { 1968, 24, 36, 26, 1, -36 },
  { 2076, 19, 36, 27, 5, -36 },
  { 2162, 21, 36, 28, 4, -36 },
  { 2257, 20, 36, 29, 5, -36 },
  { 2347, 18, 36, 25, 5, -36 },
  { 2428, 18, 36, 25, 5, -36 },
  { 2509, 22, 36, 30, 4, -36 },
  { 2608, 21, 36, 31, 5, -36 },
  { 2703, 2, 36, 12, 5, -36 },
  { 2712, 18, 36, 24, 2, -36 },
  { 2793, 21, 36, 28, 5, -36 },
  { 2888, 16, 36, 23, 5, -36 },
  { 2960, 28, 36, 37, 5, -36 },
  { 3086, 21, 36, 31, 5, -36 },
  { 3181, 23, 36, 29, 3, -36 },
  { 3285, 19, 36, 26, 5, -36 },
  { 3371, 23, 42, 29, 3, -36 },
  { 3492, 21, 36, 29, 4, -36 },
  { 3587, 22, 36, 26, 2, -36 },
  { 3686, 23, 36, 26, 2, -36 },
  { 3790, 21, 36, 29, 4, -36 },
  { 3885, 24, 36, 26, 1, -36 },
  { 3993, 36, 36, 39, 2, -36 },
  { 4155, 23, 36, 26, 2, -36 },
  { 4259, 24, 36, 26, 1, -36 },
  { 4367, 22, 36, 26, 2, -36 },
  { 4466, 6, 49, 10, 4, -41 },
  { 4503, 14, 39, 17, 2, -36 },
  { 4572, 6, 49, 10, 0, -41 },
  { 4609, 14, 18, 19, 2, -36 },
  { 4641, 18, 1, 19, 0, 0 },
  { 4644, 6, 6, 13, 4, -37 },
  { 4649, 18, 26, 23, 2, -26 },
  { 4708, 17, 38, 24, 4, -38 },
  { 4789, 18, 26, 22, 2, -26 },
  { 4848, 17, 38, 24, 3, -38 },
  { 4929, 18, 26, 23, 2, -26 },
  { 4988, 12, 39, 14, 2, -39 },
  { 5047, 17, 36, 24, 3, -26 },
  { 5124, 16, 38, 24, 4, -38 },
  { 5200, 2, 36, 10, 4, -36 },
  { 5209, 8, 46, 10, -2, -36 },
  { 5255, 16, 38, 21, 4, -38 },
  { 5331, 2, 38, 10, 4, -38 },
  { 5341, 31, 26, 39, 4, -26 },
  { 5442, 16, 26, 24, 4, -26 },
  { 5494, 18, 26, 24, 3, -26 },
  { 5553, 17, 36, 24, 4, -26 },
  { 5630, 17, 36, 24, 3, -26 },
  { 5707, 10, 26, 15, 4, -26 },
  { 5740, 16, 26, 22, 3, -26 },
  { 5792, 11, 34, 14, 1, -34 },
  { 5839, 16, 26, 24, 4, -26 },
  { 5891, 19, 26, 21, 1, -26 },
  { 5953, 29, 26, 33, 2, -26 },
  { 6048, 18, 26, 21, 2, -26 },
  { 6107, 19, 36, 21, 1, -26 },
  { 6193, 18, 26, 21, 2, -26 },
  { 6252, 12, 50, 15, 2, -39 },
  { 6327, 2, 43, 10, 4, -36 },
  { 6338, 13, 50, 15, 0, -39 },
  { 6420, 22, 8, 30, 4, -19 },
};

const GFXfont RobotoCondensed_Thin50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_THIN50PT7B_H_
