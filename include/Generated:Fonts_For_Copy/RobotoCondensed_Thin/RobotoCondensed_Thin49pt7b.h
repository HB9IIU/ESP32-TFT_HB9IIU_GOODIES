#ifndef _ROBOTOCONDENSED_THIN49PT7B_H_
#define _ROBOTOCONDENSED_THIN49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin49pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00,
  0x00, 0x7D, 0x80, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0x8E, 0x30, 0x00,
  0x40, 0x60, 0x01, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80,
  0x40, 0x02, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x80, 0x80,
  0x06, 0x02, 0x07, 0xFF, 0xFF, 0xC0, 0x40, 0x20, 0x01, 0x01, 0x80, 0x04,
  0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x03, 0x01, 0x00, 0x08, 0x04,
  0x00, 0x20, 0x10, 0x00, 0x80, 0xC0, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00,
  0x60, 0x20, 0x01, 0x80, 0x80, 0xFF, 0xFF, 0xF8, 0x10, 0x18, 0x00, 0x40,
  0x60, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40,
  0x02, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x03, 0xF0, 0x03,
  0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x98, 0x00, 0x24, 0x00,
  0x09, 0x00, 0x02, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x18, 0x80, 0x04, 0x38, 0x03, 0x03,
  0x83, 0x80, 0x3F, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x1E, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x80, 0x40, 0x10, 0x20, 0x18, 0x04, 0x08, 0x02, 0x03, 0x02,
  0x00, 0x80, 0x80, 0x80, 0x20, 0x60, 0x20, 0x08, 0x10, 0x08, 0x06, 0x08,
  0x02, 0x01, 0x02, 0x00, 0xC0, 0x41, 0x00, 0x18, 0x30, 0xC0, 0x03, 0x18,
  0x20, 0x00, 0x78, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0xF8, 0x00, 0x10, 0x63, 0x00, 0x08, 0x30,
  0x60, 0x02, 0x08, 0x08, 0x01, 0x06, 0x01, 0x00, 0xC1, 0x00, 0x40, 0x20,
  0x40, 0x10, 0x18, 0x10, 0x04, 0x04, 0x04, 0x01, 0x03, 0x01, 0x00, 0x40,
  0x80, 0x40, 0x10, 0x60, 0x18, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x18, 0xE0,
  0x00, 0xC0, 0xC0, 0x06, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x18, 0x01,
  0x00, 0x60, 0x04, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x30, 0x01, 0x00,
  0x80, 0x06, 0x04, 0x00, 0x08, 0x20, 0x00, 0x31, 0x00, 0x00, 0x48, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x36, 0x00, 0x00, 0x88, 0x00, 0x04,
  0x10, 0x00, 0x20, 0x60, 0x19, 0x80, 0xC0, 0x64, 0x01, 0x01, 0x30, 0x02,
  0x04, 0x80, 0x0C, 0x12, 0x00, 0x18, 0x48, 0x00, 0x23, 0x20, 0x00, 0x48,
  0x80, 0x01, 0xE2, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x68, 0x20,
  0x03, 0x30, 0xE0, 0x30, 0x60, 0xFF, 0x80, 0x80, 0x20, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x20, 0x10, 0x1F,
  0x82, 0x0E, 0x1C, 0x4F, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x50, 0x00,
  0x13, 0x00, 0x06, 0x30, 0x01, 0x82, 0x00, 0x20, 0x60, 0x0C, 0x06, 0x03,
  0x00, 0x60, 0x40, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x33, 0x33, 0x33, 0x26,
  0x4C, 0xFF, 0x80, 0xBC, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0x86, 0x01, 0x80, 0x40, 0xC0, 0x08, 0x20, 0x03, 0x18, 0x00,
  0x44, 0x00, 0x19, 0x00, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x02, 0x40, 0x01, 0x98, 0x00, 0x42, 0x00, 0x30, 0x40, 0x08, 0x18,
  0x04, 0x03, 0x86, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0xF0, 0xE5, 0xC1, 0xC0,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0xF0, 0x03, 0x06, 0x01, 0x00, 0x60, 0x80, 0x08, 0x60,
  0x03, 0x10, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x03,
  0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x64, 0x00,
  0x0B, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x38, 0x00,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x18, 0x80, 0x04, 0x38, 0x02, 0x03,
  0x87, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x09, 0x80, 0x00, 0xCC, 0x00, 0x04,
  0x60, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00,
  0x10, 0x30, 0x01, 0x81, 0x80, 0x08, 0x0C, 0x00, 0xC0, 0x60, 0x04, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x20, 0x06, 0x03, 0x00, 0x30, 0x10,
  0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xFF, 0xFF, 0xF8, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x3F, 0xFF, 0x98, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x1F, 0x81, 0xB0, 0xE0, 0xE0, 0x0C, 0x60, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14,
  0x00, 0x1A, 0x00, 0x09, 0x80, 0x04, 0x60, 0x06, 0x18, 0x06, 0x07, 0x0E,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x41, 0xF0, 0x31, 0x87, 0x0D, 0x80,
  0x62, 0xC0, 0x0C, 0xA0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0x98, 0x00, 0x62, 0x00,
  0x10, 0x40, 0x0C, 0x18, 0x06, 0x01, 0xC7, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xE1, 0xC0, 0x30, 0x0C, 0x08, 0x00, 0xC3, 0x00, 0x0C, 0x40, 0x00,
  0x88, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x0D, 0x80, 0x01,
  0x10, 0x00, 0x22, 0x00, 0x04, 0x60, 0x01, 0x04, 0x00, 0x60, 0x60, 0x18,
  0x07, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x18, 0x0C, 0x00, 0xC3, 0x00, 0x0C,
  0x40, 0x00, 0x90, 0x00, 0x1A, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x11,
  0x80, 0x06, 0x18, 0x01, 0x81, 0xE1, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x03, 0x8E, 0x01, 0x80, 0x60, 0xC0, 0x08, 0x60, 0x03, 0x10, 0x00, 0x4C,
  0x00, 0x1B, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x34, 0x00, 0x1D, 0x80, 0x0F, 0x20, 0x02, 0xC4, 0x03, 0x20,
  0xC3, 0x88, 0x1F, 0x82, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x5F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x27, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x33, 0x32, 0x22, 0x26, 0xC8, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x10, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x38, 0x60, 0xC0,
  0x61, 0x00, 0x66, 0x00, 0x48, 0x00, 0x90, 0x01, 0xE0, 0x03, 0xC0, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x84, 0x00, 0x3E, 0x00, 0x46, 0x00,
  0x73, 0x80, 0x22, 0x00, 0x60, 0x60, 0x1B, 0x00, 0x60, 0x10, 0x05, 0x80,
  0x20, 0x08, 0x02, 0x80, 0x20, 0x04, 0x01, 0x40, 0x10, 0x02, 0x00, 0xA0,
  0x18, 0x01, 0x00, 0x70, 0x08, 0x01, 0x80, 0x38, 0x04, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x40, 0x04, 0x00, 0xC0, 0x20, 0x02, 0x00,
  0x60, 0x10, 0x01, 0x00, 0x70, 0x08, 0x01, 0x80, 0x2C, 0x04, 0x00, 0xC0,
  0x16, 0x03, 0x00, 0x60, 0x19, 0x00, 0x80, 0x50, 0x08, 0x80, 0x40, 0x64,
  0x0C, 0x40, 0x10, 0x63, 0x0C, 0x30, 0x07, 0xE0, 0xFC, 0x08, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x02, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x0C, 0x00,
  0x20, 0x08, 0x00, 0x30, 0x08, 0x00, 0x10, 0x1F, 0xFF, 0xF0, 0x10, 0x00,
  0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x18, 0x03, 0x83, 0x00, 0x0C, 0x60,
  0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x36, 0x00, 0x02, 0xC0,
  0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x0D, 0x80,
  0x01, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x0E, 0x1F, 0xFF, 0x83, 0x00,
  0x1C, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x06, 0xC0, 0x01, 0x98, 0x00,
  0xE3, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x06, 0x00, 0x70,
  0x60, 0x00, 0x82, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x58, 0x00,
  0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x05, 0x80, 0x00, 0x24, 0x00, 0x01, 0x30, 0x00, 0x10, 0x80,
  0x00, 0x86, 0x00, 0x08, 0x18, 0x00, 0x80, 0x38, 0x38, 0x00, 0x7F, 0x00,
  0xFF, 0xF0, 0x06, 0x00, 0xF0, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80,
  0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x30,
  0xC0, 0x03, 0x06, 0x00, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF,
  0xCC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xF3, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x30, 0x30,
  0x00, 0xC3, 0x00, 0x03, 0x30, 0x00, 0x09, 0x00, 0x00, 0x68, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x80, 0x00, 0x16, 0x00, 0x00, 0x90, 0x00, 0x04, 0xC0, 0x00,
  0x23, 0x00, 0x03, 0x0C, 0x00, 0x60, 0x3C, 0x1E, 0x00, 0x3F, 0x80, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14, 0x00, 0x1A, 0x00,
  0x09, 0x80, 0x04, 0x40, 0x04, 0x10, 0x06, 0x07, 0x0E, 0x00, 0xFC, 0x00,
  0xC0, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x11, 0x80, 0x01, 0x0C, 0x00,
  0x18, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x08, 0x06,
  0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0,
  0x03, 0x04, 0x00, 0x18, 0x40, 0x00, 0xC7, 0x00, 0x06, 0x6C, 0x00, 0x36,
  0x20, 0x01, 0xE0, 0x80, 0x0E, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00, 0x81, 0x80,
  0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x43, 0x00, 0x01, 0x18, 0x00, 0x0C,
  0xC0, 0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xE0, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x05, 0xD0, 0x00, 0x00, 0x5D, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0x9C,
  0x80, 0x00, 0x09, 0xC8, 0x00, 0x01, 0x1C, 0xC0, 0x00, 0x11, 0xC4, 0x00,
  0x03, 0x1C, 0x40, 0x00, 0x21, 0xC2, 0x00, 0x02, 0x1C, 0x20, 0x00, 0x61,
  0xC3, 0x00, 0x04, 0x1C, 0x10, 0x00, 0x41, 0xC1, 0x00, 0x0C, 0x1C, 0x18,
  0x00, 0x81, 0xC0, 0x80, 0x08, 0x1C, 0x08, 0x01, 0x01, 0xC0, 0xC0, 0x10,
  0x1C, 0x04, 0x03, 0x01, 0xC0, 0x40, 0x20, 0x1C, 0x02, 0x02, 0x01, 0xC0,
  0x20, 0x60, 0x1C, 0x03, 0x04, 0x01, 0xC0, 0x10, 0x40, 0x1C, 0x01, 0x0C,
  0x01, 0xC0, 0x18, 0x80, 0x1C, 0x00, 0x98, 0x01, 0xC0, 0x09, 0x00, 0x1C,
  0x00, 0x50, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x02,
  0x00, 0x10, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xD0, 0x00, 0x07, 0x20, 0x00, 0x1C, 0xC0, 0x00, 0x71, 0x00, 0x01,
  0xC6, 0x00, 0x07, 0x08, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x40, 0x01, 0xC0,
  0x80, 0x07, 0x03, 0x00, 0x1C, 0x04, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x20,
  0x07, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x02, 0x01, 0xC0, 0x0C, 0x07,
  0x00, 0x10, 0x1C, 0x00, 0x60, 0x70, 0x00, 0x81, 0xC0, 0x01, 0x07, 0x00,
  0x06, 0x1C, 0x00, 0x08, 0x70, 0x00, 0x31, 0xC0, 0x00, 0x47, 0x00, 0x01,
  0x9C, 0x00, 0x02, 0x70, 0x00, 0x05, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x0E, 0x0E, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0x08, 0x30, 0x00, 0x10, 0x80, 0x00, 0x66, 0x00, 0x00, 0x90, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x05,
  0x00, 0x00, 0x14, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x08, 0x80,
  0x00, 0x61, 0x00, 0x01, 0x06, 0x00, 0x08, 0x0C, 0x00, 0xC0, 0x0E, 0x0E,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x18, 0x01, 0xC3, 0x00, 0x06, 0x60,
  0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x02, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00,
  0x3C, 0x7F, 0xFE, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0E, 0x0E, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x08, 0x30, 0x00, 0x10, 0x80, 0x00, 0x66, 0x00, 0x00, 0x90,
  0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x08,
  0x80, 0x00, 0x63, 0x00, 0x01, 0x06, 0x00, 0x08, 0x0C, 0x00, 0xC0, 0x0E,
  0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0xFF, 0xF8, 0x06,
  0x00, 0x70, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x60, 0x00,
  0x33, 0x00, 0x00, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x26, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x01,
  0x98, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x01, 0xC1, 0xFF,
  0xF8, 0x0C, 0x00, 0x80, 0x60, 0x06, 0x03, 0x00, 0x10, 0x18, 0x00, 0xC0,
  0xC0, 0x02, 0x06, 0x00, 0x08, 0x30, 0x00, 0x61, 0x80, 0x01, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x23, 0x00, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x36,
  0x00, 0x00, 0xB0, 0x00, 0x06, 0x01, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x00,
  0x30, 0x30, 0x00, 0x43, 0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x00, 0x68,
  0x00, 0x01, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xB0, 0x00, 0x0C,
  0x80, 0x00, 0x46, 0x00, 0x06, 0x1C, 0x00, 0xE0, 0x3C, 0x1C, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x40, 0x00, 0x16, 0x00, 0x03, 0x60, 0x00, 0x63, 0x00, 0x04, 0x18, 0x01,
  0xC0, 0xF0, 0x70, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18,
  0x18, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x20,
  0x04, 0x00, 0x20, 0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80,
  0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x46, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x24, 0x00, 0x1A, 0x00,
  0x0C, 0x80, 0x02, 0x40, 0x01, 0x98, 0x00, 0x44, 0x00, 0x23, 0x00, 0x08,
  0x80, 0x04, 0x20, 0x03, 0x10, 0x00, 0x84, 0x00, 0x42, 0x00, 0x30, 0x80,
  0x08, 0x60, 0x04, 0x18, 0x01, 0x04, 0x00, 0x81, 0x00, 0x60, 0x80, 0x10,
  0x20, 0x08, 0x10, 0x06, 0x04, 0x01, 0x03, 0x00, 0xC0, 0xC0, 0x20, 0x20,
  0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x18, 0x18, 0x04, 0x04, 0x01, 0x02, 0x00, 0xC1, 0x80, 0x20, 0x40, 0x08,
  0x20, 0x04, 0x08, 0x01, 0x04, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x08, 0x60,
  0x06, 0x30, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0x80, 0x06,
  0x20, 0x01, 0x10, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x09, 0x00, 0x06, 0x80,
  0x01, 0x20, 0x00, 0x50, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x66, 0x00, 0x01, 0x0C, 0x00, 0x0C,
  0x10, 0x00, 0x20, 0x60, 0x01, 0x80, 0x80, 0x0C, 0x03, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x08, 0x04, 0x00, 0x30, 0x30, 0x00, 0x40, 0x80, 0x01, 0x84,
  0x00, 0x02, 0x30, 0x00, 0x04, 0x80, 0x00, 0x16, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x12, 0x00, 0x00, 0x8C, 0x00, 0x02,
  0x10, 0x00, 0x10, 0x60, 0x00, 0xC0, 0x80, 0x02, 0x01, 0x00, 0x18, 0x06,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x30, 0x18, 0x00, 0x40, 0x40, 0x01, 0x83,
  0x00, 0x03, 0x08, 0x00, 0x04, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x04, 0x20,
  0x00, 0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00, 0x10, 0x08,
  0x00, 0x30, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02,
  0x00, 0xC0, 0x03, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x42, 0x00, 0x00, 0x46, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0x84, 0x02, 0x10, 0x18,
  0x60, 0x40, 0x81, 0x02, 0x0C, 0x0C, 0x20, 0x11, 0x80, 0x44, 0x01, 0x90,
  0x02, 0xC0, 0x08, 0xFF, 0xFF, 0xC0, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x03, 0xF0, 0x07, 0x0E, 0x06, 0x00, 0x86, 0x00, 0x22, 0x00, 0x1A, 0x00,
  0x0D, 0x00, 0x02, 0x80, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x3F, 0xF8, 0x78, 0x04, 0xC0, 0x02, 0xC0, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1A, 0x00, 0x1D, 0x00,
  0x1A, 0xC0, 0x19, 0x38, 0x38, 0x87, 0xF0, 0x40, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0xFE, 0x08, 0xC1, 0x85,
  0x80, 0x22, 0x80, 0x09, 0x80, 0x06, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x02, 0xC0, 0x03, 0x70, 0x01, 0x2C, 0x01, 0x13, 0x83,
  0x08, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0x87, 0x01, 0x80, 0x30, 0xC0, 0x04,
  0x20, 0x01, 0x98, 0x00, 0x24, 0x00, 0x09, 0x00, 0x03, 0x40, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x0D, 0x00, 0x02,
  0x60, 0x00, 0x88, 0x00, 0x23, 0x00, 0x10, 0x60, 0x0C, 0x0E, 0x0E, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0xFC, 0x11, 0xC1, 0x89, 0x80, 0x24, 0x80, 0x0A, 0xC0, 0x07,
  0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03, 0x60, 0x01,
  0x90, 0x01, 0x4C, 0x01, 0xA3, 0x83, 0x10, 0x7E, 0x00, 0x03, 0xF8, 0x03,
  0x83, 0x81, 0x80, 0x30, 0xC0, 0x04, 0x20, 0x01, 0x98, 0x00, 0x24, 0x00,
  0x09, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x08, 0x60, 0x04, 0x07, 0x0E, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x3F, 0x06,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0xFF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xE0, 0x8E, 0x0C, 0x4C, 0x01, 0x24,
  0x00, 0x54, 0x00, 0x3A, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14,
  0x00, 0x1B, 0x00, 0x0C, 0x80, 0x0A, 0x60, 0x0D, 0x1C, 0x18, 0x83, 0xF0,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x20, 0x03, 0x18, 0x03, 0x03, 0x07, 0x00, 0x7E, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x83, 0xF0, 0x86, 0x18,
  0x98, 0x04, 0x90, 0x06, 0xA0, 0x02, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x3C, 0x00, 0x0A, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x1C, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80,
  0x30, 0x80, 0x60, 0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x83, 0x00, 0x86,
  0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB4, 0x00, 0xE6, 0x00, 0xC3, 0x00, 0x81,
  0x00, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80,
  0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x83, 0xF0, 0x07, 0xC1, 0x1C, 0x30, 0x30, 0xE2, 0x60, 0x30,
  0x80, 0x65, 0x80, 0x32, 0x00, 0x4A, 0x00, 0x28, 0x00, 0x58, 0x00, 0x50,
  0x00, 0xB0, 0x00, 0xC0, 0x01, 0x60, 0x01, 0x80, 0x02, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x83, 0xF0, 0x86, 0x18, 0x98,
  0x04, 0x90, 0x06, 0xA0, 0x02, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x03,
  0xF0, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01, 0x10, 0x00,
  0x6C, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0x40, 0x01, 0x98, 0x00,
  0x43, 0x00, 0x30, 0x60, 0x18, 0x0E, 0x1C, 0x00, 0xFC, 0x00, 0x87, 0xF0,
  0x4E, 0x0C, 0x2C, 0x01, 0x14, 0x00, 0x4C, 0x00, 0x36, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x16, 0x00, 0x1B, 0x80, 0x09, 0x60,
  0x08, 0x9C, 0x38, 0x43, 0xF0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xE0, 0x8E, 0x1C, 0x4C, 0x01, 0x24, 0x00, 0x56,
  0x00, 0x3A, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14, 0x00, 0x1B,
  0x00, 0x0C, 0x80, 0x0A, 0x60, 0x0D, 0x1C, 0x18, 0x83, 0xF0, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x83, 0xE3, 0x09, 0x02,
  0x80, 0xA0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xE0, 0x38, 0x38, 0x60, 0x0C, 0x40,
  0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0xC0, 0x06, 0x60, 0x0C, 0x3C, 0x38, 0x0F, 0xE0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFE, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x38, 0x03, 0xE0, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0x40, 0x07, 0x60, 0x05, 0x20, 0x09, 0x3C, 0x71, 0x0F, 0xC1, 0xC0,
  0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x03, 0x0C, 0x00, 0x40, 0x80, 0x08, 0x10, 0x03, 0x03, 0x00, 0x40, 0x20,
  0x08, 0x04, 0x03, 0x00, 0xC0, 0x40, 0x08, 0x08, 0x01, 0x03, 0x00, 0x30,
  0x40, 0x02, 0x08, 0x00, 0x43, 0x00, 0x0C, 0x40, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x03, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x40, 0x06, 0x00, 0x24,
  0x00, 0x70, 0x02, 0x60, 0x09, 0x00, 0x66, 0x00, 0x90, 0x06, 0x20, 0x09,
  0x00, 0x42, 0x01, 0x98, 0x04, 0x30, 0x10, 0x80, 0x43, 0x01, 0x08, 0x0C,
  0x10, 0x10, 0xC0, 0x81, 0x03, 0x0C, 0x08, 0x18, 0x20, 0x40, 0x81, 0x82,
  0x04, 0x18, 0x08, 0x20, 0x61, 0x80, 0x86, 0x02, 0x10, 0x0C, 0x40, 0x21,
  0x00, 0xC4, 0x02, 0x30, 0x04, 0xC0, 0x33, 0x00, 0x48, 0x01, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x68, 0x01, 0x60, 0x03, 0x80, 0x1E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0xA0, 0x01,
  0x98, 0x00, 0x86, 0x00, 0xC1, 0x00, 0x40, 0xC0, 0x40, 0x20, 0x60, 0x18,
  0x20, 0x06, 0x30, 0x01, 0x10, 0x00, 0xD0, 0x00, 0x38, 0x00, 0x08, 0x00,
  0x0E, 0x00, 0x0D, 0x00, 0x04, 0xC0, 0x06, 0x20, 0x02, 0x08, 0x03, 0x06,
  0x03, 0x01, 0x01, 0x00, 0xC1, 0x80, 0x30, 0x80, 0x08, 0xC0, 0x06, 0xC0,
  0x01, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x48, 0x00, 0x09, 0x80, 0x03, 0x30,
  0x00, 0x62, 0x00, 0x08, 0x60, 0x03, 0x04, 0x00, 0x60, 0x80, 0x08, 0x18,
  0x03, 0x01, 0x00, 0x60, 0x20, 0x08, 0x06, 0x03, 0x00, 0x40, 0x60, 0x08,
  0x08, 0x01, 0x81, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x61, 0x00, 0x04,
  0x60, 0x00, 0x88, 0x00, 0x19, 0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x0E, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x06, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x07, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0x40, 0x00, 0x1F, 0x00, 0x01, 0xC6, 0x00, 0x34, 0x0C,
  0x00, 0xF0, 0x18, 0x02, 0x80, 0x30, 0x0A, 0x00, 0x60, 0x68, 0x00, 0xE3,
  0x00, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Thin49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 35, 9, 3, -35 },
  { 15, 6, 10, 13, 4, -37 },
  { 23, 22, 35, 24, 2, -35 },
  { 120, 18, 43, 24, 3, -39 },
  { 217, 26, 35, 32, 3, -35 },
  { 331, 22, 36, 26, 3, -35 },
  { 430, 2, 10, 8, 3, -37 },
  { 433, 9, 50, 13, 3, -39 },
  { 490, 9, 50, 14, 1, -39 },
  { 547, 19, 19, 21, 1, -35 },
  { 593, 20, 25, 24, 2, -29 },
  { 656, 4, 10, 9, 2, -4 },
  { 661, 9, 1, 13, 2, -16 },
  { 663, 2, 3, 11, 4, -3 },
  { 664, 14, 38, 17, 1, -35 },
  { 731, 18, 35, 24, 3, -35 },
  { 810, 10, 35, 24, 4, -35 },
  { 854, 18, 35, 24, 3, -35 },
  { 933, 18, 35, 24, 3, -35 },
  { 1012, 21, 35, 24, 2, -35 },
  { 1104, 17, 35, 24, 4, -35 },
  { 1179, 18, 35, 24, 3, -35 },
  { 1258, 19, 35, 24, 2, -35 },
  { 1342, 19, 35, 24, 2, -35 },
  { 1426, 18, 35, 24, 3, -35 },
  { 1505, 3, 26, 9, 3, -26 },
  { 1515, 4, 32, 8, 2, -26 },
  { 1531, 17, 20, 22, 2, -26 },
  { 1574, 17, 10, 24, 3, -21 },
  { 1596, 17, 20, 22, 3, -26 },
  { 1639, 15, 35, 19, 2, -35 },
  { 1705, 33, 45, 39, 3, -34 },
  { 1891, 24, 35, 26, 1, -35 },
  { 1996, 19, 35, 26, 4, -35 },
  { 2080, 21, 35, 28, 4, -35 },
  { 2172, 21, 35, 28, 4, -35 },
  { 2264, 18, 35, 25, 4, -35 },
  { 2343, 19, 35, 25, 4, -35 },
  { 2427, 21, 35, 29, 4, -35 },
  { 2519, 22, 35, 30, 4, -35 },
  { 2616, 2, 35, 12, 5, -35 },
  { 2625, 17, 35, 24, 2, -35 },
  { 2700, 21, 35, 27, 4, -35 },
  { 2792, 17, 35, 22, 4, -35 },
  { 2867, 28, 35, 37, 4, -35 },
  { 2990, 22, 35, 30, 4, -35 },
  { 3087, 22, 35, 29, 3, -35 },
  { 3184, 19, 35, 26, 4, -35 },
  { 3268, 22, 41, 29, 3, -35 },
  { 3381, 21, 35, 28, 4, -35 },
  { 3473, 21, 35, 25, 2, -35 },
  { 3565, 22, 35, 26, 2, -35 },
  { 3662, 20, 35, 29, 4, -35 },
  { 3750, 24, 35, 26, 1, -35 },
  { 3855, 35, 35, 39, 2, -35 },
  { 4009, 22, 35, 26, 2, -35 },
  { 4106, 24, 35, 26, 1, -35 },
  { 4211, 21, 35, 26, 2, -35 },
  { 4303, 6, 47, 10, 4, -40 },
  { 4339, 13, 38, 17, 2, -35 },
  { 4401, 6, 47, 10, 0, -40 },
  { 4437, 14, 17, 18, 2, -35 },
  { 4467, 18, 1, 18, 0, 0 },
  { 4470, 7, 6, 13, 3, -36 },
  { 4476, 17, 26, 23, 2, -26 },
  { 4532, 17, 37, 24, 4, -37 },
  { 4611, 18, 26, 22, 2, -26 },
  { 4670, 17, 37, 24, 3, -37 },
  { 4749, 18, 26, 22, 2, -26 },
  { 4808, 12, 38, 14, 2, -38 },
  { 4865, 17, 36, 24, 3, -26 },
  { 4942, 16, 37, 24, 4, -37 },
  { 5016, 2, 36, 10, 4, -36 },
  { 5025, 8, 46, 10, -2, -36 },
  { 5071, 16, 37, 21, 4, -37 },
  { 5145, 1, 37, 10, 4, -37 },
  { 5150, 31, 26, 38, 4, -26 },
  { 5251, 16, 26, 24, 4, -26 },
  { 5303, 18, 26, 24, 3, -26 },
  { 5362, 17, 36, 24, 4, -26 },
  { 5439, 17, 36, 24, 3, -26 },
  { 5516, 10, 26, 15, 4, -26 },
  { 5549, 16, 26, 22, 3, -26 },
  { 5601, 11, 33, 14, 1, -33 },
  { 5647, 16, 26, 24, 4, -26 },
  { 5699, 19, 26, 21, 1, -26 },
  { 5761, 28, 26, 32, 2, -26 },
  { 5852, 17, 26, 21, 2, -26 },
  { 5908, 19, 36, 21, 1, -26 },
  { 5994, 17, 26, 21, 2, -26 },
  { 6050, 12, 49, 14, 2, -38 },
  { 6124, 2, 41, 10, 4, -35 },
  { 6135, 12, 49, 14, 0, -38 },
  { 6209, 22, 8, 30, 4, -19 },
};

const GFXfont RobotoCondensed_Thin49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_THIN49PT7B_H_
