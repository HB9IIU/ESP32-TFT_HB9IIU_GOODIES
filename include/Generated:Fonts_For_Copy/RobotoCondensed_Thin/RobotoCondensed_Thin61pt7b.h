#ifndef _ROBOTOCONDENSED_THIN61PT7B_H_
#define _ROBOTOCONDENSED_THIN61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin61pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x90, 0x00, 0x00, 0x00, 0x1F, 0xA0, 0x41, 0x41, 0x41, 0x41, 0x41, 0x41,
  0x41, 0x41, 0xC1, 0xC1, 0xC1, 0xC1, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x10, 0x06, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x08, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40, 0x18,
  0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x30, 0x00, 0x08, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x20, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0x03, 0xC0, 0x30, 0x03, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x20, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x0D,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0xE3, 0x00, 0x03, 0x07, 0x00,
  0x18, 0x0F, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x30, 0x01, 0x00, 0x80, 0x08, 0x01, 0x80, 0xC0,
  0x04, 0x00, 0x80, 0x60, 0x02, 0x00, 0xC0, 0x30, 0x01, 0x00, 0xC0, 0x18,
  0x00, 0x80, 0x60, 0x0C, 0x00, 0x40, 0x60, 0x02, 0x00, 0x20, 0x30, 0x01,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x18, 0x10, 0x00, 0x60, 0x18, 0x18, 0x00,
  0x18, 0x0C, 0x08, 0x00, 0x06, 0x1C, 0x0C, 0x00, 0x01, 0xFC, 0x04, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x80,
  0xFE, 0x00, 0x00, 0xC0, 0xC3, 0x80, 0x00, 0xC0, 0xC0, 0x60, 0x00, 0x40,
  0x40, 0x10, 0x00, 0x60, 0x60, 0x0C, 0x00, 0x20, 0x20, 0x06, 0x00, 0x30,
  0x10, 0x01, 0x00, 0x10, 0x18, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x40, 0x08,
  0x06, 0x00, 0x20, 0x0C, 0x03, 0x00, 0x10, 0x0C, 0x01, 0x80, 0x08, 0x06,
  0x00, 0x40, 0x04, 0x06, 0x00, 0x20, 0x06, 0x01, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x40, 0x04, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x04, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x80, 0xC0, 0x04, 0x18, 0x06, 0x00, 0x43, 0x00, 0x20, 0x04, 0x20, 0x03,
  0x00, 0x46, 0x00, 0x18, 0x0C, 0x60, 0x00, 0xC0, 0xC4, 0x00, 0x04, 0x0C,
  0x40, 0x00, 0x60, 0x8C, 0x00, 0x03, 0x18, 0xC0, 0x00, 0x19, 0x84, 0x00,
  0x00, 0xB0, 0x40, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x90, 0x30, 0x00, 0x19, 0x81, 0xC0, 0x06, 0x0C, 0x0E,
  0x01, 0xC0, 0x60, 0x3F, 0xF8, 0x02, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0,
  0x10, 0x04, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x07, 0xF8, 0x18, 0x1E, 0x1E,
  0x18, 0xF0, 0x03, 0xDB, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01,
  0x81, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x33, 0x33,
  0x33, 0x33, 0x66, 0xC8, 0xFF, 0xFF, 0xFF, 0x2F, 0xF0, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x78, 0x03, 0x00, 0x70,
  0x18, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x11, 0x00, 0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x64, 0x00,
  0x01, 0x90, 0x00, 0x06, 0x60, 0x00, 0x10, 0x80, 0x00, 0xC3, 0x00, 0x03,
  0x04, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x30, 0x07, 0x00, 0x70, 0x78, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x10, 0x0F, 0x03, 0x90, 0xE1, 0x78,
  0x1E, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x18, 0x00,
  0x70, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x0E, 0x07, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x03,
  0x03, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x13, 0x00, 0x00, 0x26, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x04, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x1E,
  0x07, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04,
  0x00, 0x06, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xFF, 0xF8, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x21, 0xFC, 0x00, 0x9F, 0xFC,
  0x03, 0xC0, 0x1C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x24, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x18, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0xC0, 0x1C, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x3F, 0x80, 0xC3, 0xFF, 0x83, 0x18,
  0x07, 0x0C, 0xC0, 0x06, 0x24, 0x00, 0x0C, 0xA0, 0x00, 0x13, 0x80, 0x00,
  0x6C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00,
  0xD8, 0x00, 0x02, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x06,
  0x00, 0x18, 0x0E, 0x00, 0xC0, 0x1E, 0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0x81, 0xC0, 0x0E, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0x01, 0xC0, 0x0C, 0x00,
  0x70, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x07, 0x01, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x07,
  0x01, 0xC0, 0x07, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x90, 0x00, 0x0F, 0x30, 0x00,
  0x16, 0x30, 0x00, 0x6C, 0x30, 0x01, 0x90, 0x30, 0x0E, 0x20, 0x3F, 0xF0,
  0x40, 0x1F, 0x81, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x5F, 0xA0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xF8, 0x11, 0xCE, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x31, 0x8C, 0x63, 0x19, 0x8C, 0x46, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFE, 0x01, 0xC0,
  0xE0, 0xE0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0xFC, 0x00, 0x18,
  0xC0, 0x00, 0xFF, 0x80, 0x04, 0x60, 0x01, 0xC0, 0xE0, 0x02, 0x20, 0x01,
  0xC0, 0x18, 0x01, 0xB0, 0x00, 0xC0, 0x08, 0x00, 0xD8, 0x00, 0xC0, 0x04,
  0x00, 0x6C, 0x00, 0x40, 0x02, 0x00, 0x34, 0x00, 0x60, 0x01, 0x00, 0x0E,
  0x00, 0x20, 0x00, 0x80, 0x07, 0x00, 0x30, 0x00, 0x40, 0x03, 0x80, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x08, 0x00, 0x30, 0x00, 0xE0, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x60,
  0x00, 0xC0, 0x07, 0x00, 0x30, 0x00, 0x40, 0x03, 0x80, 0x18, 0x00, 0x20,
  0x01, 0x40, 0x0C, 0x00, 0x30, 0x00, 0xB0, 0x06, 0x00, 0x18, 0x00, 0xD8,
  0x03, 0x00, 0x0C, 0x00, 0x6C, 0x01, 0x80, 0x0E, 0x00, 0x26, 0x00, 0x40,
  0x05, 0x00, 0x31, 0x00, 0x30, 0x06, 0xC0, 0x10, 0x80, 0x08, 0x06, 0x20,
  0x18, 0x60, 0x06, 0x06, 0x18, 0x38, 0x30, 0x01, 0xFE, 0x07, 0xF8, 0x08,
  0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x01, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x02, 0x00,
  0x07, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00,
  0x06, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x06,
  0x40, 0x00, 0x0C, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00, 0x01, 0x84,
  0x00, 0x0E, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x20, 0x00, 0x78, 0x40,
  0x00, 0x38, 0x80, 0x00, 0x19, 0x00, 0x00, 0x12, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x40, 0x00, 0x18,
  0x80, 0x00, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x0E, 0x00, 0x02, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x20,
  0x00, 0x70, 0x10, 0x00, 0x0E, 0x08, 0x00, 0x03, 0x84, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x40, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xE1, 0x00, 0x00, 0xE0, 0x80, 0x01,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC8, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x2C, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0x86, 0x00,
  0x18, 0x18, 0x01, 0xC0, 0x70, 0x38, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x03, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x38, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x02, 0x00,
  0x03, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x02,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x08, 0x18,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x87, 0x80, 0x00, 0x23, 0x30, 0x00, 0x09,
  0x84, 0x00, 0x02, 0xC1, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x08, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x20, 0x00,
  0xC0, 0x08, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x20,
  0x00, 0x18, 0x08, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18,
  0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x68, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xA0, 0x00, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x00, 0xB9, 0x00, 0x00,
  0x00, 0x6E, 0x60, 0x00, 0x00, 0x1B, 0x98, 0x00, 0x00, 0x04, 0xE2, 0x00,
  0x00, 0x03, 0x38, 0xC0, 0x00, 0x00, 0x8E, 0x30, 0x00, 0x00, 0x63, 0x84,
  0x00, 0x00, 0x18, 0xE1, 0x80, 0x00, 0x04, 0x38, 0x20, 0x00, 0x03, 0x0E,
  0x0C, 0x00, 0x00, 0xC3, 0x83, 0x00, 0x00, 0x20, 0xE0, 0x40, 0x00, 0x18,
  0x38, 0x18, 0x00, 0x04, 0x0E, 0x06, 0x00, 0x03, 0x03, 0x80, 0x80, 0x00,
  0xC0, 0xE0, 0x30, 0x00, 0x20, 0x38, 0x04, 0x00, 0x18, 0x0E, 0x01, 0x00,
  0x06, 0x03, 0x80, 0x60, 0x01, 0x00, 0xE0, 0x08, 0x00, 0xC0, 0x38, 0x03,
  0x00, 0x20, 0x0E, 0x00, 0xC0, 0x08, 0x03, 0x80, 0x10, 0x06, 0x00, 0xE0,
  0x06, 0x01, 0x00, 0x38, 0x00, 0x80, 0xC0, 0x0E, 0x00, 0x20, 0x30, 0x03,
  0x80, 0x0C, 0x08, 0x00, 0xE0, 0x01, 0x06, 0x00, 0x38, 0x00, 0x61, 0x80,
  0x0E, 0x00, 0x18, 0x40, 0x03, 0x80, 0x02, 0x30, 0x00, 0xE0, 0x00, 0xC8,
  0x00, 0x38, 0x00, 0x36, 0x00, 0x0E, 0x00, 0x05, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x08, 0x00, 0x18, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x36, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x30, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x82, 0x00, 0x03, 0x84, 0x00, 0x01, 0x88, 0x00, 0x01, 0x90,
  0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x01, 0x90, 0x00, 0x06,
  0x20, 0x00, 0x38, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x10, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x26, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x80, 0x7C, 0x07, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x60, 0x02, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x60, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x40, 0x00, 0x07, 0x00,
  0x00, 0x26, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x09, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x90, 0x00, 0x06, 0x20, 0x00, 0x19, 0x80, 0x00, 0x43,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x00, 0x03,
  0x0C, 0x00, 0x08, 0x18, 0x00, 0x20, 0x40, 0x01, 0x81, 0x80, 0x02, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0x80, 0x06, 0x06, 0x00,
  0x10, 0x0C, 0x00, 0x40, 0x20, 0x03, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x06, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x40, 0x02, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08,
  0xC0, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x30, 0x00, 0x04, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x10, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0xFF,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x06, 0x60, 0x06, 0x20,
  0x04, 0x20, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x18, 0x18, 0x08,
  0x10, 0x08, 0x30, 0x0C, 0x30, 0x04, 0x20, 0x04, 0x60, 0x06, 0x60, 0x02,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x19,
  0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xE0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x05,
  0xB0, 0x00, 0x6C, 0xC0, 0x0E, 0x67, 0x81, 0xC3, 0x0F, 0xFC, 0x18, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x0F, 0xF8, 0x11, 0xC0, 0x70, 0x98, 0x01, 0xC5, 0x80,
  0x07, 0x28, 0x00, 0x19, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1A,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x27, 0x00, 0x03, 0x2C, 0x00, 0x31, 0x30, 0x03, 0x88, 0xE0, 0x38,
  0x41, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x01,
  0xC0, 0xF0, 0x38, 0x01, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00,
  0x4C, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0x58, 0x00, 0x06, 0x40, 0x00, 0x33, 0x00, 0x03, 0x0C, 0x00,
  0x18, 0x70, 0x01, 0x80, 0xE0, 0x78, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x1F, 0xF8, 0x61, 0xC0, 0xE3, 0x18, 0x01, 0x99, 0x80, 0x06, 0xD8,
  0x00, 0x1E, 0xC0, 0x00, 0x74, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x68, 0x00, 0x03, 0x60, 0x00, 0x3B,
  0x00, 0x01, 0xCC, 0x00, 0x1E, 0x30, 0x01, 0xB0, 0xE0, 0x79, 0x83, 0xFF,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x3C,
  0x03, 0x00, 0x38, 0x18, 0x00, 0x70, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x40, 0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x60, 0xC0, 0x03, 0x01, 0xE0, 0x78, 0x01, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0xC3, 0x81, 0xC6, 0x30, 0x03, 0x33, 0x00, 0x0D, 0xB0, 0x00, 0x3D, 0x80,
  0x00, 0xE8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x98,
  0x00, 0x3C, 0x60, 0x03, 0x61, 0xC0, 0xF3, 0x07, 0xFE, 0x18, 0x02, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x61, 0xC0, 0x03, 0x07, 0x00, 0x70,
  0x0F, 0xBF, 0x00, 0x1F, 0xC0, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x81, 0xFE, 0x08, 0x70, 0x38, 0x8C, 0x00,
  0xC9, 0x80, 0x0C, 0x90, 0x00, 0x6B, 0x00, 0x06, 0xA0, 0x00, 0x2E, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x7D, 0x80, 0x00, 0x00, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x3F, 0x87, 0xC0, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0xE8, 0x00, 0x1C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00,
  0xC0, 0x80, 0x18, 0x08, 0x03, 0x00, 0x80, 0x60, 0x08, 0x0C, 0x00, 0x81,
  0x80, 0x08, 0x30, 0x00, 0x86, 0x00, 0x08, 0x60, 0x00, 0x8E, 0x00, 0x09,
  0xB0, 0x00, 0xB1, 0x80, 0x0E, 0x18, 0x00, 0x80, 0xC0, 0x08, 0x06, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x0C,
  0x08, 0x00, 0x60, 0x80, 0x03, 0x08, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00,
  0x0C, 0x80, 0x00, 0x68, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07,
  0xF8, 0x01, 0xFF, 0x08, 0x70, 0x38, 0x1C, 0x0E, 0x23, 0x00, 0x70, 0xC0,
  0x0C, 0x98, 0x00, 0xC6, 0x00, 0x12, 0xC0, 0x01, 0xB0, 0x00, 0x6A, 0x00,
  0x06, 0x80, 0x00, 0xB8, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x1F, 0xE0,
  0x87, 0x03, 0x88, 0xC0, 0x0C, 0x98, 0x00, 0xC9, 0x00, 0x06, 0xB0, 0x00,
  0x6A, 0x00, 0x02, 0xE0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x1E, 0x07, 0x00, 0x70, 0x03, 0x01, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x09, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x01,
  0xA0, 0x00, 0x03, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x80, 0x06, 0x03, 0x80, 0x18, 0x03,
  0xC0, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x1F,
  0xF0, 0x23, 0x80, 0xE1, 0x30, 0x03, 0x8B, 0x00, 0x0E, 0x50, 0x00, 0x33,
  0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x14, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4E, 0x00, 0x06,
  0x58, 0x00, 0x62, 0x60, 0x07, 0x11, 0xC0, 0x70, 0x83, 0xFE, 0x04, 0x01,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0xC3, 0x81, 0xC6, 0x30, 0x03, 0x33, 0x00, 0x0D, 0xB0, 0x00, 0x3D, 0x80,
  0x00, 0xE8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x98,
  0x00, 0x3C, 0x60, 0x03, 0x61, 0xC0, 0xF3, 0x07, 0xFE, 0x18, 0x03, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x3F, 0x86, 0x08, 0xC0,
  0x98, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x1C, 0x07, 0x83, 0x80, 0x0C, 0x20, 0x00, 0x66, 0x00, 0x06, 0x40,
  0x00, 0x24, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x06, 0x38,
  0x00, 0xC1, 0xE0, 0x38, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x40, 0x00, 0x76, 0x00, 0x0F, 0x60, 0x01, 0xB3,
  0x00, 0x33, 0x1C, 0x0E, 0x30, 0xFF, 0xC3, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x90, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x42, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x40,
  0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x10, 0x08, 0x00, 0x40, 0x30, 0x03,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x01, 0x80, 0x18, 0x04, 0x00,
  0x20, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x04, 0x08, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x00, 0x00, 0x84, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x12, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xE0, 0x01, 0x98,
  0x00, 0x48, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x20, 0x03, 0x30, 0x03, 0x0C, 0x00, 0x84, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x0C, 0x10, 0x04, 0x18, 0x02, 0x06, 0x01, 0x02,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x08,
  0x04, 0x04, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30,
  0x40, 0x18, 0x30, 0x04, 0x10, 0x02, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x18, 0x80, 0x04, 0x60, 0x02, 0x20, 0x01, 0x10,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x02,
  0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x19, 0x80, 0x00, 0x43,
  0x00, 0x03, 0x04, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x60, 0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0x61, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x23,
  0x00, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x80, 0x60,
  0x04, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x31, 0x80, 0x00, 0x46, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60, 0x00, 0x18,
  0x80, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x60,
  0x00, 0x81, 0x80, 0x06, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x40, 0x30, 0x03,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x20, 0x06, 0x01, 0x80, 0x08, 0x06, 0x00,
  0x30, 0x10, 0x00, 0xC0, 0xC0, 0x01, 0x03, 0x00, 0x06, 0x08, 0x00, 0x18,
  0x60, 0x00, 0x21, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x04, 0xC0,
  0x00, 0x1A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x05, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x05, 0x80, 0xC0, 0x01, 0xA0, 0x0C, 0x00, 0x3C, 0x00, 0xC0, 0x07, 0x80,
  0x0C, 0x00, 0xA0, 0x00, 0xC0, 0x34, 0x00, 0x0C, 0x0C, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Thin61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 44, 11, 4, -43 },
  { 18, 8, 12, 16, 4, -46 },
  { 30, 28, 43, 30, 2, -43 },
  { 181, 22, 57, 29, 4, -50 },
  { 338, 33, 45, 40, 3, -44 },
  { 524, 28, 45, 33, 3, -44 },
  { 682, 2, 12, 10, 4, -46 },
  { 685, 11, 62, 17, 4, -48 },
  { 771, 11, 62, 17, 1, -48 },
  { 857, 24, 24, 26, 1, -43 },
  { 929, 26, 31, 30, 2, -35 },
  { 1030, 4, 12, 11, 3, -5 },
  { 1036, 12, 2, 16, 2, -21 },
  { 1039, 4, 4, 13, 4, -3 },
  { 1041, 17, 47, 21, 2, -43 },
  { 1141, 22, 45, 29, 4, -44 },
  { 1265, 12, 43, 29, 5, -43 },
  { 1330, 24, 44, 29, 3, -44 },
  { 1462, 23, 45, 29, 3, -44 },
  { 1592, 25, 43, 29, 3, -43 },
  { 1727, 22, 44, 29, 5, -43 },
  { 1848, 22, 44, 29, 4, -43 },
  { 1969, 24, 43, 29, 2, -43 },
  { 2098, 24, 45, 29, 3, -44 },
  { 2233, 23, 44, 29, 3, -44 },
  { 2360, 3, 32, 11, 4, -31 },
  { 2372, 5, 38, 10, 2, -31 },
  { 2396, 21, 24, 28, 3, -32 },
  { 2459, 21, 14, 30, 4, -27 },
  { 2496, 22, 24, 28, 3, -32 },
  { 2562, 18, 45, 24, 3, -44 },
  { 2664, 41, 56, 49, 4, -42 },
  { 2951, 30, 43, 32, 1, -43 },
  { 3113, 23, 43, 32, 6, -43 },
  { 3237, 27, 45, 35, 4, -44 },
  { 3389, 25, 43, 35, 6, -43 },
  { 3524, 22, 43, 31, 6, -43 },
  { 3643, 22, 43, 31, 6, -43 },
  { 3762, 27, 45, 37, 5, -44 },
  { 3914, 26, 43, 37, 6, -43 },
  { 4054, 1, 43, 15, 7, -43 },
  { 4060, 21, 44, 30, 3, -43 },
  { 4176, 26, 43, 34, 6, -43 },
  { 4316, 20, 43, 28, 6, -43 },
  { 4424, 34, 43, 46, 6, -43 },
  { 4607, 26, 43, 38, 6, -43 },
  { 4747, 28, 45, 36, 4, -44 },
  { 4905, 23, 43, 32, 6, -43 },
  { 5029, 28, 52, 36, 4, -44 },
  { 5211, 26, 43, 35, 5, -43 },
  { 5351, 26, 45, 32, 3, -44 },
  { 5498, 28, 43, 32, 2, -43 },
  { 5649, 25, 44, 36, 5, -43 },
  { 5787, 30, 43, 32, 1, -43 },
  { 5949, 44, 43, 48, 2, -43 },
  { 6186, 28, 43, 32, 2, -43 },
  { 6337, 30, 43, 32, 1, -43 },
  { 6499, 26, 43, 32, 3, -43 },
  { 6639, 7, 59, 12, 5, -50 },
  { 6691, 17, 47, 21, 2, -43 },
  { 6791, 8, 59, 12, 0, -50 },
  { 6850, 16, 22, 23, 3, -43 },
  { 6894, 21, 2, 23, 1, 0 },
  { 6900, 8, 8, 16, 4, -46 },
  { 6908, 21, 34, 29, 3, -33 },
  { 6998, 21, 47, 30, 5, -46 },
  { 7122, 21, 34, 27, 3, -33 },
  { 7212, 21, 47, 30, 4, -46 },
  { 7336, 22, 34, 28, 3, -33 },
  { 7430, 15, 47, 18, 2, -47 },
  { 7519, 21, 45, 30, 4, -33 },
  { 7638, 20, 46, 29, 5, -46 },
  { 7753, 3, 44, 12, 4, -44 },
  { 7770, 11, 56, 12, -3, -44 },
  { 7847, 20, 46, 26, 5, -46 },
  { 7962, 2, 46, 12, 5, -46 },
  { 7974, 38, 33, 47, 5, -33 },
  { 8131, 20, 33, 29, 5, -33 },
  { 8214, 23, 34, 30, 3, -33 },
  { 8312, 21, 45, 30, 5, -33 },
  { 8431, 21, 45, 30, 4, -33 },
  { 8550, 12, 33, 18, 5, -33 },
  { 8600, 20, 34, 27, 3, -33 },
  { 8685, 14, 42, 18, 1, -41 },
  { 8759, 20, 33, 29, 5, -32 },
  { 8842, 22, 32, 26, 2, -32 },
  { 8930, 34, 32, 40, 3, -32 },
  { 9066, 22, 32, 26, 2, -32 },
  { 9154, 22, 44, 26, 2, -32 },
  { 9275, 21, 32, 26, 3, -32 },
  { 9359, 15, 61, 18, 2, -48 },
  { 9474, 2, 51, 12, 5, -43 },
  { 9487, 14, 61, 18, 1, -48 },
  { 9594, 27, 10, 37, 5, -23 },
};

const GFXfont RobotoCondensed_Thin61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_THIN61PT7B_H_
