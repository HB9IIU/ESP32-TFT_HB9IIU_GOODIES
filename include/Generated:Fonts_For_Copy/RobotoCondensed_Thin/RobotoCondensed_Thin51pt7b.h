#ifndef _ROBOTOCONDENSED_THIN51PT7B_H_
#define _ROBOTOCONDENSED_THIN51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin51pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x00, 0x3F, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40,
  0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02,
  0x01, 0x03, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x40,
  0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40,
  0x01, 0x00, 0x80, 0x02, 0x03, 0x01, 0xFF, 0xFF, 0xF8, 0x18, 0x08, 0x00,
  0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x07, 0xF0, 0x03, 0x83, 0x80, 0xC0, 0x18, 0x30, 0x01, 0x84,
  0x00, 0x11, 0x80, 0x03, 0x30, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x02, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0D, 0x00,
  0x01, 0x20, 0x00, 0x26, 0x00, 0x0C, 0x60, 0x03, 0x06, 0x00, 0xC0, 0x78,
  0x70, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x81, 0x00, 0x40, 0x10,
  0x20, 0x08, 0x06, 0x04, 0x01, 0x00, 0x80, 0x80, 0x20, 0x30, 0x10, 0x04,
  0x04, 0x02, 0x00, 0x81, 0x00, 0x40, 0x10, 0x60, 0x0C, 0x02, 0x08, 0x00,
  0x80, 0xC3, 0x00, 0x18, 0x30, 0x40, 0x01, 0xCC, 0x18, 0x00, 0x1F, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x0F, 0x80,
  0x00, 0x83, 0x18, 0x00, 0x20, 0xC1, 0x80, 0x0C, 0x10, 0x10, 0x01, 0x06,
  0x01, 0x00, 0x60, 0x80, 0x20, 0x08, 0x10, 0x04, 0x03, 0x02, 0x00, 0x80,
  0x40, 0x40, 0x10, 0x10, 0x08, 0x02, 0x02, 0x01, 0x00, 0x40, 0x80, 0x20,
  0x08, 0x30, 0x06, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x70, 0x00,
  0x30, 0x30, 0x00, 0x40, 0x30, 0x01, 0x80, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0x40, 0x40, 0x00, 0x81, 0x00, 0x01, 0x84, 0x00, 0x01, 0x90,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x33, 0x00,
  0x00, 0xC2, 0x00, 0x01, 0x06, 0x00, 0xC4, 0x06, 0x01, 0x98, 0x06, 0x02,
  0x20, 0x04, 0x04, 0xC0, 0x0C, 0x09, 0x00, 0x0C, 0x12, 0x00, 0x0C, 0x64,
  0x00, 0x08, 0x88, 0x00, 0x0B, 0x10, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x20,
  0x00, 0x70, 0x60, 0x00, 0x90, 0x60, 0x06, 0x30, 0x60, 0x18, 0x30, 0x7F,
  0xC0, 0x20, 0x08, 0x00, 0x00, 0x55, 0x5F, 0xF0, 0x00, 0x80, 0x80, 0x80,
  0xC0, 0x40, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04,
  0x02, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x10, 0x10, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0E,
  0x06, 0x07, 0x78, 0x63, 0xC0, 0xF6, 0xE0, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xB0, 0x00, 0x19, 0x80, 0x03, 0x08, 0x00, 0x20, 0xC0, 0x06, 0x06,
  0x00, 0xC0, 0x30, 0x18, 0x01, 0x01, 0x80, 0x18, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x33, 0x33, 0x33, 0x26, 0x4C,
  0xFF, 0xC0, 0x5F, 0x00, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xE3, 0x80, 0x30,
  0x18, 0x08, 0x01, 0x83, 0x00, 0x10, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00,
  0x06, 0x40, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x28, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x0C, 0xC0, 0x01, 0x08, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x03,
  0x01, 0x80, 0xC0, 0x1C, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x3C, 0x39,
  0x9C, 0x3E, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0xF0,
  0x01, 0xC3, 0x80, 0x60, 0x18, 0x18, 0x01, 0x82, 0x00, 0x18, 0x80, 0x03,
  0x10, 0x00, 0x26, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x1A, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xF8, 0x01, 0xE3, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0x82, 0x00, 0x08,
  0xC0, 0x01, 0x10, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x90,
  0x00, 0x13, 0x00, 0x06, 0x30, 0x01, 0x83, 0x00, 0x60, 0x3C, 0x38, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x40, 0x00, 0x0D, 0x00, 0x00, 0x24, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40,
  0x00, 0x21, 0x00, 0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00,
  0x81, 0x00, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x06, 0x01,
  0x00, 0x10, 0x04, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x01, 0x00,
  0xC0, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x40, 0x01, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xC4, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0xFC,
  0x06, 0xE1, 0xC1, 0xC0, 0x18, 0x60, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0xD0, 0x00,
  0x36, 0x00, 0x08, 0x80, 0x06, 0x30, 0x01, 0x06, 0x00, 0xC0, 0xE1, 0xC0,
  0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x1F, 0x80, 0x8E, 0x1C, 0x33,
  0x00, 0xC6, 0x80, 0x0C, 0xE0, 0x00, 0x9C, 0x00, 0x1B, 0x00, 0x01, 0x60,
  0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x04, 0xC0,
  0x00, 0x88, 0x00, 0x31, 0x80, 0x04, 0x18, 0x01, 0x81, 0x80, 0x60, 0x1C,
  0x38, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF8,
  0x01, 0xC3, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x01,
  0x90, 0x00, 0x12, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x0C, 0xC0, 0x01, 0x0C, 0x00, 0x60, 0xC0, 0x18,
  0x0F, 0x1C, 0x00, 0x7F, 0x00, 0x30, 0x38, 0x18, 0x01, 0x86, 0x00, 0x08,
  0x80, 0x01, 0xB0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x12,
  0x00, 0x06, 0x60, 0x00, 0x87, 0x00, 0x60, 0x38, 0x38, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x98,
  0x00, 0x24, 0x00, 0x0B, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x05, 0x30, 0x03, 0x46,
  0x01, 0x90, 0xE1, 0xC4, 0x0F, 0x81, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x5D, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5F, 0x80, 0x27, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x33, 0x32, 0x64,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x0C, 0x38, 0x10,
  0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x10, 0x60, 0x01, 0xE0, 0x02, 0x18, 0x00, 0xE7, 0x00, 0x63,
  0x00, 0x30, 0x30, 0x04, 0x40, 0x0C, 0x02, 0x00, 0x98, 0x03, 0x00, 0x40,
  0x13, 0x00, 0x40, 0x08, 0x03, 0x40, 0x18, 0x01, 0x00, 0x68, 0x02, 0x00,
  0x20, 0x0D, 0x00, 0x40, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x1C, 0x02,
  0x00, 0x30, 0x03, 0x80, 0x40, 0x06, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x1C,
  0x01, 0x00, 0x10, 0x03, 0x80, 0x20, 0x02, 0x00, 0x70, 0x04, 0x00, 0x40,
  0x0A, 0x00, 0x80, 0x08, 0x01, 0x60, 0x10, 0x01, 0x00, 0x2C, 0x02, 0x00,
  0x60, 0x05, 0x80, 0x40, 0x0C, 0x01, 0x10, 0x08, 0x03, 0x80, 0x22, 0x01,
  0x80, 0x50, 0x0C, 0x40, 0x10, 0x11, 0x03, 0x0C, 0x03, 0x06, 0x30, 0xC0,
  0x80, 0x3F, 0x03, 0xF0, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x88, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x06,
  0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x00,
  0x30, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x03, 0x00, 0x20,
  0x00, 0x80, 0x30, 0x00, 0x40, 0x18, 0x00, 0x30, 0x0F, 0xFF, 0xF8, 0x0C,
  0x00, 0x04, 0x06, 0x00, 0x03, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x30, 0xFF, 0xF0,
  0x10, 0x03, 0x82, 0x00, 0x1C, 0x40, 0x00, 0x88, 0x00, 0x19, 0x00, 0x01,
  0x20, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x03,
  0x40, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x18,
  0x80, 0x1C, 0x1F, 0xFF, 0x82, 0x00, 0x1C, 0x40, 0x00, 0xC8, 0x00, 0x0D,
  0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x72, 0x00, 0x38, 0x7F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x1C, 0x1E, 0x00, 0xC0, 0x0C, 0x04, 0x00, 0x18, 0x30,
  0x00, 0x31, 0x80, 0x00, 0x44, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xB0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x66, 0x00,
  0x01, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x78, 0x78,
  0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0xE0, 0x20, 0x01, 0xC1, 0x00,
  0x03, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x06,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x01,
  0x90, 0x00, 0x18, 0x80, 0x01, 0x84, 0x00, 0x18, 0x20, 0x0F, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xC8, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0xFF, 0xF2, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0E, 0x0F, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x80, 0x00, 0x26, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x40,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x60, 0x00, 0x04, 0x80, 0x00, 0x13,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x18, 0x00, 0x1C, 0x38, 0x00, 0xC0, 0x3C,
  0x1E, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xD0, 0x00, 0x34,
  0x00, 0x09, 0x80, 0x06, 0x30, 0x03, 0x06, 0x01, 0x80, 0xE1, 0xC0, 0x0F,
  0xC0, 0x80, 0x00, 0x32, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x20, 0x00, 0x20,
  0x80, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x03, 0x00, 0x80,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x20, 0x18, 0x00, 0x80, 0xC0,
  0x02, 0x06, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02,
  0x2C, 0x00, 0x09, 0x18, 0x00, 0x2C, 0x20, 0x00, 0xE0, 0xC0, 0x03, 0x01,
  0x80, 0x08, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0x30,
  0x08, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80, 0x03, 0x02, 0x00, 0x06, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x20, 0x00, 0x06, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xF0, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xA0,
  0x00, 0x00, 0x5B, 0x00, 0x00, 0x0D, 0x90, 0x00, 0x00, 0x99, 0x00, 0x00,
  0x09, 0x98, 0x00, 0x01, 0x98, 0x80, 0x00, 0x11, 0x88, 0x00, 0x01, 0x18,
  0xC0, 0x00, 0x31, 0x84, 0x00, 0x02, 0x18, 0x40, 0x00, 0x21, 0x82, 0x00,
  0x06, 0x18, 0x20, 0x00, 0x41, 0x83, 0x00, 0x0C, 0x18, 0x10, 0x00, 0x81,
  0x81, 0x00, 0x08, 0x18, 0x18, 0x01, 0x81, 0x80, 0x80, 0x10, 0x18, 0x08,
  0x01, 0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0x60, 0x60,
  0x18, 0x02, 0x04, 0x01, 0x80, 0x20, 0x40, 0x18, 0x03, 0x0C, 0x01, 0x80,
  0x10, 0x80, 0x18, 0x01, 0x08, 0x01, 0x80, 0x19, 0x80, 0x18, 0x00, 0x90,
  0x01, 0x80, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x68,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00, 0x62, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x20, 0x00, 0x60, 0xC0, 0x01,
  0x81, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x10, 0x01, 0x80,
  0x60, 0x06, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x01, 0x80, 0x08,
  0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0x60, 0x01, 0x81, 0x80, 0x02, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x00, 0xC6, 0x00,
  0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x16, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x07, 0x87, 0x80,
  0x18, 0x01, 0x80, 0x40, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x01, 0x88,
  0x00, 0x01, 0x30, 0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x40, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x44, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0x08, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0F, 0x0F, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xF8, 0x10, 0x03, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0x48,
  0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x0E, 0x40,
  0x0F, 0x0F, 0xFF, 0x81, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x87, 0x80, 0x18, 0x01,
  0x80, 0x40, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x01, 0x88, 0x00, 0x01,
  0x30, 0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x44, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x08, 0x00, 0x0C,
  0x08, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0F, 0x0F, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0xFF, 0xF8, 0x04, 0x00,
  0x70, 0x20, 0x00, 0xC1, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x32,
  0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00,
  0x0D, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x0C, 0x80, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x1C,
  0x0F, 0xFF, 0x80, 0x40, 0x04, 0x02, 0x00, 0x30, 0x10, 0x00, 0x80, 0x80,
  0x06, 0x04, 0x00, 0x10, 0x20, 0x00, 0xC1, 0x00, 0x02, 0x08, 0x00, 0x18,
  0x40, 0x00, 0x42, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x80, 0x00, 0x24, 0x00,
  0x01, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x1E, 0x0F,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x98, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x12, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01,
  0x40, 0x00, 0x05, 0x80, 0x00, 0x12, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x18,
  0x00, 0x30, 0x38, 0x01, 0xC0, 0x7C, 0x3C, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00,
  0x0D, 0x80, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x60, 0xE0, 0x06, 0x01,
  0xE1, 0xE0, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x90,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x18, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x06,
  0x02, 0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00,
  0x80, 0x10, 0x00, 0x40, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x18, 0x00, 0x60, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x34,
  0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00,
  0x02, 0x60, 0x00, 0x90, 0x00, 0x66, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01,
  0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x30, 0x01, 0x0C, 0x00, 0x43,
  0x00, 0x30, 0x40, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40,
  0x08, 0x18, 0x02, 0x06, 0x00, 0x81, 0x80, 0x60, 0x20, 0x18, 0x08, 0x04,
  0x02, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01, 0x00,
  0xC0, 0xC0, 0x10, 0x30, 0x0C, 0x08, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x82, 0x00, 0x61, 0x80, 0x08, 0x20, 0x06, 0x10,
  0x00, 0x86, 0x00, 0x21, 0x00, 0x08, 0x60, 0x02, 0x30, 0x00, 0xC4, 0x00,
  0x23, 0x00, 0x04, 0x40, 0x03, 0x20, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x04,
  0xC0, 0x01, 0x20, 0x00, 0x68, 0x00, 0x16, 0x00, 0x02, 0x80, 0x01, 0xC0,
  0x00, 0x28, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x21, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x03, 0x00, 0x06, 0x02, 0x00, 0x18,
  0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x04, 0x01, 0x00, 0x0C, 0x06, 0x00,
  0x08, 0x18, 0x00, 0x08, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x11, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x28, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x20, 0x80, 0x00, 0xC1,
  0x80, 0x03, 0x01, 0x00, 0x04, 0x03, 0x00, 0x18, 0x03, 0x00, 0x20, 0x02,
  0x00, 0xC0, 0x06, 0x03, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x20, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x14, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x20, 0x18, 0x00,
  0x30, 0x04, 0x00, 0x10, 0x03, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x60,
  0x0C, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x02, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x28,
  0x01, 0xA0, 0x04, 0x80, 0x11, 0x00, 0xC4, 0x02, 0x18, 0x08, 0x20, 0x60,
  0x81, 0x03, 0x04, 0x04, 0x30, 0x10, 0x80, 0x62, 0x00, 0x98, 0x02, 0x40,
  0x0D, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0xC1, 0x06, 0x0C, 0x10, 0x60, 0xC0,
  0x03, 0xF8, 0x03, 0x83, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20, 0x00, 0x98,
  0x00, 0x26, 0x00, 0x0D, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x03, 0xFF, 0xC3, 0xC0, 0x31, 0x80, 0x0C, 0xC0, 0x03,
  0x60, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0,
  0x00, 0x34, 0x00, 0x1D, 0x80, 0x0B, 0x30, 0x0C, 0xC7, 0x0E, 0x10, 0xFE,
  0x04, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x0F, 0xC0, 0x8E, 0x1C, 0x26, 0x01, 0x8A, 0x00, 0x33, 0x80,
  0x04, 0xC0, 0x01, 0xB0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0x4A, 0x00, 0x32, 0xC0, 0x18, 0x8E, 0x1C,
  0x20, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0x0E, 0x0C, 0x01, 0x84, 0x00, 0x64,
  0x00, 0x1A, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x04, 0x40, 0x06, 0x30, 0x06, 0x07, 0x0E, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x0F, 0xC3, 0x0E, 0x1C, 0xC6, 0x01, 0xB2, 0x00, 0x3D, 0x80,
  0x07, 0x40, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00,
  0x03, 0x40, 0x00, 0xD8, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x1B, 0x0E, 0x1C,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xE1, 0xC0, 0x30, 0x0C, 0x08, 0x00,
  0xC3, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x02,
  0x0C, 0x01, 0x80, 0xE0, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC1,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x0F, 0xFE, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x07, 0xF0, 0xC3, 0x87, 0x31, 0x80, 0x6C, 0x80, 0x0F, 0x60, 0x01, 0xD0,
  0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0,
  0x00, 0x36, 0x00, 0x1C, 0xC0, 0x07, 0x18, 0x06, 0xC3, 0x87, 0x30, 0x7F,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x20, 0x01, 0x8C, 0x00, 0x41, 0x80, 0x30, 0x38, 0x78, 0x03, 0xF0, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x3E, 0x08, 0x61, 0xC4, 0x40, 0x32, 0x40, 0x0D, 0x60, 0x02, 0xA0, 0x01,
  0x70, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x3C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x02, 0x06, 0x04, 0x1C, 0xF0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x68, 0x00, 0x64, 0x00, 0x62,
  0x00, 0x61, 0x00, 0x60, 0x80, 0x60, 0x40, 0x60, 0x20, 0x60, 0x10, 0x20,
  0x08, 0x20, 0x04, 0x20, 0x02, 0x30, 0x01, 0x38, 0x00, 0xB2, 0x00, 0x71,
  0x80, 0x30, 0x40, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x03, 0x02, 0x00, 0x81,
  0x00, 0x60, 0x80, 0x18, 0x40, 0x04, 0x20, 0x01, 0x10, 0x00, 0xC8, 0x00,
  0x34, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x83, 0xF0, 0x03, 0xE0, 0x86, 0x1C, 0x0E, 0x38, 0x88, 0x06, 0x10,
  0x0C, 0x90, 0x02, 0x20, 0x06, 0xA0, 0x03, 0x40, 0x02, 0xA0, 0x01, 0xC0,
  0x02, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x81, 0xF0, 0x43, 0x0E, 0x22, 0x01, 0x92, 0x00, 0x6B, 0x00, 0x15,
  0x00, 0x0B, 0x80, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x03,
  0xF8, 0x01, 0xC3, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0x82, 0x00, 0x08, 0xC0,
  0x01, 0x90, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x50, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x24, 0x00,
  0x04, 0xC0, 0x01, 0x88, 0x00, 0x21, 0x80, 0x0C, 0x18, 0x03, 0x01, 0xE3,
  0x80, 0x0F, 0xC0, 0x00, 0x83, 0xF0, 0x23, 0x87, 0x09, 0x00, 0x62, 0x80,
  0x0C, 0xE0, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00,
  0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x12, 0x80, 0x0C, 0xB0, 0x06,
  0x23, 0x87, 0x08, 0x3F, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0xC3, 0x87, 0x31, 0x80, 0x6C, 0xC0,
  0x0F, 0x60, 0x01, 0xD0, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x40, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x1C, 0xC0, 0x07, 0x18, 0x06,
  0xC3, 0x87, 0x30, 0x3F, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x83, 0xE3, 0x89, 0x82, 0x40, 0xA0, 0x28, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x0F, 0xE0, 0x3C, 0x38, 0x60, 0x04, 0x40, 0x02, 0xC0, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0x40, 0x03, 0x60, 0x06, 0x1E, 0x3C, 0x07, 0xF0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFE, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1D, 0x00, 0x0E,
  0xC0, 0x0F, 0x30, 0x0D, 0x8E, 0x3C, 0xC1, 0xF8, 0x00, 0x40, 0x00, 0x28,
  0x00, 0x0D, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x0C, 0x60, 0x01, 0x0C,
  0x00, 0x20, 0x80, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x20, 0x20, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x81, 0x80, 0x30, 0x20, 0x02,
  0x04, 0x00, 0x41, 0x80, 0x0C, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x03,
  0x20, 0x00, 0x24, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x0A, 0x00, 0x18, 0x00, 0xD0, 0x01, 0xC0,
  0x06, 0x80, 0x0A, 0x00, 0x26, 0x00, 0x58, 0x01, 0x10, 0x02, 0xC0, 0x18,
  0x80, 0x32, 0x00, 0xC4, 0x01, 0x10, 0x04, 0x30, 0x08, 0xC0, 0x20, 0x80,
  0xC2, 0x03, 0x04, 0x06, 0x10, 0x18, 0x20, 0x20, 0x80, 0x81, 0x81, 0x06,
  0x04, 0x04, 0x18, 0x10, 0x60, 0x20, 0x80, 0x83, 0x01, 0x04, 0x06, 0x10,
  0x0C, 0x20, 0x30, 0x80, 0x63, 0x00, 0x8C, 0x01, 0x10, 0x04, 0x60, 0x08,
  0x80, 0x32, 0x00, 0x64, 0x00, 0x90, 0x03, 0x60, 0x04, 0x80, 0x0A, 0x00,
  0x2C, 0x00, 0x50, 0x01, 0xE0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x98, 0x00, 0x62, 0x00, 0x30, 0xC0,
  0x08, 0x10, 0x06, 0x06, 0x01, 0x00, 0xC0, 0xC0, 0x10, 0x20, 0x06, 0x10,
  0x00, 0x8C, 0x00, 0x32, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x04, 0x80, 0x02, 0x30, 0x01, 0x84, 0x00, 0x41, 0x80, 0x30,
  0x20, 0x08, 0x04, 0x04, 0x01, 0x83, 0x00, 0x20, 0x80, 0x0C, 0x60, 0x01,
  0x90, 0x00, 0x2C, 0x00, 0x0C, 0x40, 0x00, 0x28, 0x00, 0x0D, 0x80, 0x01,
  0x90, 0x00, 0x22, 0x00, 0x04, 0x60, 0x01, 0x84, 0x00, 0x20, 0x80, 0x04,
  0x18, 0x01, 0x81, 0x00, 0x20, 0x20, 0x04, 0x06, 0x01, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x01, 0x81, 0x80, 0x10, 0x20, 0x02, 0x04, 0x00, 0x61, 0x80,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x19, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00,
  0x07, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03,
  0x00, 0xF0, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x78, 0x01, 0xC0, 0x18, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x10, 0x00, 0x1F, 0x00, 0x00, 0x63, 0x80,
  0x0D, 0x81, 0x80, 0x1E, 0x01, 0x80, 0x28, 0x01, 0x80, 0x50, 0x01, 0x81,
  0xA0, 0x01, 0xC6, 0x00, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Thin51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 36, 9, 4, -36 },
  { 10, 6, 10, 13, 4, -38 },
  { 18, 23, 36, 25, 2, -36 },
  { 122, 19, 46, 25, 3, -41 },
  { 232, 27, 36, 33, 3, -36 },
  { 354, 23, 37, 27, 3, -36 },
  { 461, 2, 10, 8, 3, -38 },
  { 464, 9, 52, 14, 4, -40 },
  { 523, 9, 52, 14, 1, -40 },
  { 582, 20, 20, 21, 1, -36 },
  { 632, 21, 27, 25, 2, -30 },
  { 703, 4, 10, 10, 2, -4 },
  { 708, 10, 1, 14, 2, -17 },
  { 710, 3, 3, 11, 4, -3 },
  { 712, 15, 39, 18, 1, -36 },
  { 786, 19, 36, 25, 3, -36 },
  { 872, 11, 36, 25, 4, -36 },
  { 922, 19, 36, 25, 3, -36 },
  { 1008, 19, 36, 25, 3, -36 },
  { 1094, 22, 36, 25, 2, -36 },
  { 1193, 18, 36, 25, 4, -36 },
  { 1274, 19, 36, 25, 3, -36 },
  { 1360, 20, 36, 25, 2, -36 },
  { 1450, 19, 36, 25, 3, -36 },
  { 1536, 18, 36, 25, 3, -36 },
  { 1617, 3, 27, 9, 3, -27 },
  { 1628, 4, 33, 9, 2, -27 },
  { 1645, 18, 20, 23, 2, -27 },
  { 1690, 17, 11, 25, 4, -22 },
  { 1714, 18, 20, 23, 3, -27 },
  { 1759, 16, 36, 20, 2, -36 },
  { 1831, 35, 46, 41, 3, -35 },
  { 2033, 25, 36, 27, 1, -36 },
  { 2146, 19, 36, 27, 5, -36 },
  { 2232, 22, 36, 29, 4, -36 },
  { 2331, 21, 36, 29, 5, -36 },
  { 2426, 18, 36, 26, 5, -36 },
  { 2507, 19, 36, 26, 5, -36 },
  { 2593, 22, 36, 31, 4, -36 },
  { 2692, 22, 36, 31, 5, -36 },
  { 2791, 2, 36, 12, 5, -36 },
  { 2800, 18, 36, 25, 2, -36 },
  { 2881, 22, 36, 28, 5, -36 },
  { 2980, 17, 36, 23, 5, -36 },
  { 3057, 28, 36, 38, 5, -36 },
  { 3183, 22, 36, 32, 5, -36 },
  { 3282, 23, 36, 30, 3, -36 },
  { 3386, 19, 36, 27, 5, -36 },
  { 3472, 23, 43, 30, 3, -36 },
  { 3596, 21, 36, 29, 5, -36 },
  { 3691, 22, 36, 27, 2, -36 },
  { 3790, 23, 36, 27, 2, -36 },
  { 3894, 21, 36, 30, 4, -36 },
  { 3989, 25, 36, 27, 1, -36 },
  { 4102, 36, 36, 40, 2, -36 },
  { 4264, 23, 36, 27, 2, -36 },
  { 4368, 25, 36, 27, 1, -36 },
  { 4481, 22, 36, 27, 2, -36 },
  { 4580, 6, 49, 10, 4, -41 },
  { 4617, 14, 39, 17, 2, -36 },
  { 4686, 6, 49, 10, 0, -41 },
  { 4723, 14, 18, 19, 2, -36 },
  { 4755, 18, 1, 19, 0, 0 },
  { 4758, 6, 7, 14, 4, -39 },
  { 4764, 18, 27, 24, 2, -27 },
  { 4825, 18, 38, 25, 4, -38 },
  { 4911, 17, 27, 23, 3, -27 },
  { 4969, 18, 38, 25, 3, -38 },
  { 5055, 19, 27, 23, 2, -27 },
  { 5120, 13, 39, 15, 2, -39 },
  { 5184, 18, 37, 25, 3, -27 },
  { 5268, 17, 38, 25, 4, -38 },
  { 5349, 2, 37, 10, 4, -37 },
  { 5359, 8, 47, 10, -2, -37 },
  { 5406, 17, 38, 22, 4, -38 },
  { 5487, 2, 38, 10, 4, -38 },
  { 5497, 32, 27, 40, 4, -27 },
  { 5605, 17, 27, 25, 4, -27 },
  { 5663, 19, 27, 25, 3, -27 },
  { 5728, 18, 37, 25, 4, -27 },
  { 5812, 18, 37, 25, 3, -27 },
  { 5896, 10, 27, 15, 4, -27 },
  { 5930, 16, 27, 23, 3, -27 },
  { 5984, 12, 34, 15, 1, -34 },
  { 6035, 17, 27, 25, 4, -27 },
  { 6093, 19, 27, 22, 1, -27 },
  { 6158, 29, 27, 34, 2, -27 },
  { 6256, 18, 27, 22, 2, -27 },
  { 6317, 19, 37, 22, 1, -27 },
  { 6405, 18, 27, 22, 2, -27 },
  { 6466, 13, 51, 15, 2, -40 },
  { 6549, 2, 43, 10, 4, -36 },
  { 6560, 13, 51, 15, 0, -40 },
  { 6643, 23, 8, 31, 4, -19 },
};

const GFXfont RobotoCondensed_Thin51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_THIN51PT7B_H_
