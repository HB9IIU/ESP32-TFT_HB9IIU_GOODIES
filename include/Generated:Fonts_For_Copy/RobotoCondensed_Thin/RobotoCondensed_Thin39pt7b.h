#ifndef _ROBOTOCONDENSED_THIN39PT7B_H_
#define _ROBOTOCONDENSED_THIN39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin39pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x0A, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02,
  0x00, 0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x7F, 0xFF, 0xC0, 0x81, 0x00,
  0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x83, 0xFF, 0xFE, 0x04, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00,
  0x82, 0x00, 0x40, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x7C, 0x03, 0x06, 0x0C, 0x02, 0x10, 0x06, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x80, 0x03, 0x00, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00, 0x44, 0x01,
  0x06, 0x0C, 0x03, 0xF0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x1C, 0x00, 0x01, 0x18, 0x00, 0x10, 0x40, 0x01, 0x81, 0x00, 0x08, 0x08,
  0x10, 0x40, 0x40, 0x82, 0x02, 0x08, 0x10, 0x10, 0x40, 0x80, 0x84, 0x06,
  0x04, 0x20, 0x10, 0x42, 0x00, 0x46, 0x10, 0x01, 0xC1, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x3C, 0x00, 0x42, 0x30, 0x04, 0x20, 0x80,
  0x21, 0x02, 0x02, 0x10, 0x10, 0x10, 0x80, 0x81, 0x04, 0x04, 0x08, 0x20,
  0x20, 0x81, 0x01, 0x0C, 0x04, 0x08, 0x00, 0x20, 0x80, 0x00, 0x8C, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x03, 0x18, 0x01, 0x02, 0x00, 0x40, 0x40, 0x10,
  0x10, 0x08, 0x04, 0x03, 0x01, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x10,
  0x00, 0x88, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x90, 0x00,
  0xC4, 0x00, 0x20, 0x80, 0x90, 0x10, 0x24, 0x02, 0x0A, 0x00, 0x84, 0x80,
  0x11, 0x20, 0x02, 0x48, 0x00, 0xE1, 0x00, 0x18, 0x40, 0x06, 0x08, 0x02,
  0x43, 0x03, 0x18, 0x3F, 0x02, 0xFF, 0x02, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x81, 0x01, 0x01, 0x80, 0x81, 0x01, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40,
  0x82, 0x08, 0x10, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x10, 0x20, 0xDC, 0x4E, 0x07, 0xE0, 0x03, 0x00, 0x05, 0x00, 0x13,
  0x00, 0x43, 0x01, 0x82, 0x02, 0x02, 0x08, 0x06, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x6D, 0xB4, 0xB4, 0xFF, 0xF0, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x00, 0x07, 0xC0, 0x10, 0x40, 0x40, 0x41, 0x00, 0x46, 0x00, 0x88,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x0A,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x10, 0x04, 0x20,
  0x08, 0x20, 0x20, 0x60, 0x80, 0x3E, 0x00, 0x01, 0x0F, 0x31, 0xC1, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07,
  0xC0, 0x30, 0x60, 0x80, 0x43, 0x00, 0x44, 0x00, 0x88, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x30, 0x60, 0xC0, 0x61, 0x00, 0x44,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x60, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x20,
  0x02, 0x40, 0x04, 0x40, 0x10, 0x60, 0xC0, 0x3E, 0x00, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x50, 0x00, 0x50, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10, 0x01,
  0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x10,
  0x10, 0x30, 0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0x80, 0x10, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x3F, 0xFC, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0xFC,
  0x14, 0x18, 0x60, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x02, 0x60,
  0x08, 0x80, 0x41, 0x82, 0x01, 0xF0, 0x00, 0xF0, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x1F, 0x82, 0x41, 0x85, 0x00, 0x94, 0x01, 0xB0, 0x01, 0x60, 0x02,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x28, 0x00, 0xD0,
  0x01, 0x30, 0x02, 0x20, 0x08, 0x20, 0x30, 0x30, 0xC0, 0x3E, 0x00, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x63, 0x00, 0x64,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x80,
  0x31, 0x00, 0x41, 0x83, 0x00, 0xF8, 0x06, 0x0C, 0x10, 0x04, 0x40, 0x04,
  0x80, 0x0A, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x03, 0x40, 0x04, 0x40, 0x10, 0x60, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x61,
  0x83, 0x01, 0x08, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0xD8,
  0x03, 0x20, 0x14, 0x61, 0x90, 0xF8, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x07, 0x80, 0x6C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x20, 0x4C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x09, 0x24, 0x94, 0x80, 0x00, 0x08, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x00, 0x1F,
  0x06, 0x19, 0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x00, 0x10,
  0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x10, 0x18, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x02, 0x30, 0x07, 0x80, 0x44, 0x03, 0x08, 0x08,
  0x80, 0xC0, 0x80, 0xA0, 0x10, 0x10, 0x14, 0x04, 0x02, 0x02, 0x80, 0x80,
  0x40, 0x50, 0x20, 0x18, 0x0A, 0x04, 0x02, 0x01, 0xC0, 0x80, 0x40, 0x30,
  0x10, 0x08, 0x06, 0x02, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x18, 0x08, 0x04,
  0x05, 0x01, 0x00, 0x80, 0x90, 0x20, 0x30, 0x12, 0x04, 0x06, 0x04, 0x40,
  0x81, 0x40, 0x88, 0x08, 0x44, 0x21, 0x00, 0xF0, 0x78, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02,
  0x08, 0x00, 0x41, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x40, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x18, 0x02, 0x02, 0x00, 0x40, 0x40,
  0x04, 0x0F, 0xFF, 0x82, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x30, 0xFF,
  0x81, 0x00, 0xC2, 0x00, 0x44, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x06, 0x1F,
  0xF8, 0x20, 0x0C, 0x40, 0x04, 0x80, 0x0D, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x40, 0x02, 0x80, 0x0D, 0x00, 0x12,
  0x00, 0xC7, 0xFE, 0x00, 0x07, 0xF0, 0x0C, 0x0C, 0x0C, 0x01, 0x84, 0x00,
  0x44, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x14, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x20, 0x02, 0x18, 0x03, 0x06,
  0x02, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x80, 0x60, 0x80, 0x18, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x60, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF,
  0xC8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03,
  0xFF, 0xC8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x00, 0x84, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0xC0, 0x01, 0x20, 0x00, 0x88, 0x01, 0x83, 0x03, 0x80,
  0x7F, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x13, 0x01, 0x8C, 0x18, 0x1F, 0x00,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10, 0x80, 0x30, 0x80, 0x60,
  0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x82, 0x00, 0x86, 0x00, 0x84, 0x00,
  0x88, 0x00, 0x9C, 0x00, 0xA4, 0x00, 0xC2, 0x00, 0x81, 0x00, 0x81, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x08,
  0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0x70, 0x00, 0x05, 0xA0, 0x00, 0x26, 0x80, 0x00, 0x9A, 0x00,
  0x02, 0x64, 0x00, 0x11, 0x90, 0x00, 0x46, 0x40, 0x01, 0x18, 0x80, 0x08,
  0x62, 0x00, 0x21, 0x84, 0x00, 0x86, 0x10, 0x04, 0x18, 0x40, 0x10, 0x60,
  0x80, 0xC1, 0x82, 0x02, 0x06, 0x08, 0x08, 0x18, 0x10, 0x40, 0x60, 0x41,
  0x01, 0x81, 0x04, 0x06, 0x02, 0x20, 0x18, 0x08, 0x80, 0x60, 0x12, 0x01,
  0x80, 0x50, 0x06, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x0C, 0x80, 0x06,
  0x40, 0x03, 0x10, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0x61, 0x80, 0x30, 0x40,
  0x18, 0x10, 0x0C, 0x08, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0x40, 0xC0,
  0x10, 0x60, 0x08, 0x30, 0x02, 0x18, 0x01, 0x0C, 0x00, 0x46, 0x00, 0x33,
  0x00, 0x09, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0x70, 0x00, 0x30, 0x07,
  0xF0, 0x0C, 0x0C, 0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x16, 0x00, 0x0A,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x04,
  0x80, 0x02, 0x60, 0x02, 0x18, 0x03, 0x07, 0x06, 0x00, 0xFE, 0x00, 0xFF,
  0xC1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x28, 0x00, 0xD0,
  0x01, 0x20, 0x0C, 0x7F, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x00, 0x07, 0xF0, 0x0C, 0x0C, 0x0C, 0x01, 0x8C, 0x00,
  0x44, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x04, 0x80, 0x02, 0x60, 0x02, 0x18, 0x03, 0x07,
  0x06, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0xFF, 0xE0, 0x40, 0x0C, 0x20, 0x01, 0x10, 0x00, 0xC8,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x61, 0xFF,
  0xC0, 0x80, 0x20, 0x40, 0x10, 0x20, 0x04, 0x10, 0x02, 0x08, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x11, 0x00, 0x0C, 0x80, 0x02, 0x40, 0x01, 0xA0, 0x00,
  0x50, 0x00, 0x30, 0x07, 0xF0, 0x0C, 0x06, 0x0C, 0x01, 0x8C, 0x00, 0x44,
  0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x28, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x04, 0x80, 0x02, 0x40, 0x03, 0x10, 0x03, 0x06, 0x03,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x02, 0x30, 0x06, 0x18, 0x1C,
  0x07, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x64,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x10, 0x01, 0x02,
  0x00, 0x20, 0x40, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x03,
  0x01, 0x00, 0x20, 0x20, 0x04, 0x08, 0x00, 0x81, 0x00, 0x08, 0x20, 0x01,
  0x0C, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x09, 0x00, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x00,
  0x14, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x03, 0x40,
  0x05, 0x00, 0x22, 0x00, 0x90, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88,
  0x02, 0x20, 0x08, 0x80, 0x43, 0x01, 0x08, 0x04, 0x10, 0x10, 0x40, 0x41,
  0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0xC1, 0x02, 0x04, 0x08, 0x08, 0x20,
  0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10,
  0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A,
  0x00, 0x30, 0x00, 0xA0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x40,
  0x00, 0xD8, 0x00, 0x22, 0x00, 0x18, 0x40, 0x04, 0x10, 0x02, 0x02, 0x00,
  0x80, 0xC0, 0x40, 0x10, 0x30, 0x02, 0x08, 0x00, 0x84, 0x00, 0x11, 0x00,
  0x04, 0x80, 0x00, 0xA0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x01,
  0x30, 0x00, 0xC4, 0x00, 0x20, 0x80, 0x10, 0x20, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x20, 0x40, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x01, 0x80, 0x00, 0x48, 0x00, 0x09, 0x00, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x00,
  0x80, 0x80, 0x10, 0x20, 0x01, 0x04, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00,
  0x48, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xF0, 0xFC, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x48, 0x12, 0x04, 0x82, 0x10,
  0x84, 0x21, 0x10, 0x24, 0x09, 0x02, 0x80, 0x60, 0x10, 0xFF, 0xFC, 0xC2,
  0x08, 0x61, 0x00, 0x0F, 0xC1, 0x81, 0x18, 0x04, 0x80, 0x1C, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x7F, 0xCC, 0x02, 0xC0, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xD0, 0x0A, 0xC1, 0x91,
  0xF0, 0x80, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x8F, 0xC2, 0x41, 0x8A, 0x01, 0x30, 0x06, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0B, 0x00, 0x4E,
  0x01, 0x2C, 0x18, 0x8F, 0xC0, 0x0F, 0xC0, 0x40, 0x82, 0x01, 0x10, 0x02,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x02, 0x40, 0x09, 0x00,
  0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x0F, 0xC4, 0x40, 0x92,
  0x01, 0x50, 0x03, 0x40, 0x0D, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x01,
  0x40, 0x05, 0x00, 0x32, 0x01, 0x44, 0x09, 0x0F, 0xC4, 0x0F, 0xC0, 0x60,
  0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x86, 0x0C, 0x07, 0xC0, 0x03, 0xC1,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0xFF, 0x84, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x00, 0x0F,
  0xC4, 0x40, 0x92, 0x01, 0x50, 0x03, 0x40, 0x0D, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x32, 0x01, 0x44, 0x09, 0x0F, 0xC4,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x22, 0x01, 0x86, 0x0C,
  0x07, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x87, 0xC4, 0xC3, 0x2C, 0x05, 0x40, 0x2C, 0x01, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0xF0, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x18, 0x27, 0x80, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x34, 0x01, 0x20, 0x11, 0x01,
  0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x80, 0x98, 0x04, 0xC0, 0x2A, 0x01,
  0x88, 0x08, 0x20, 0x41, 0x82, 0x04, 0x10, 0x10, 0x80, 0xC4, 0x02, 0x20,
  0x09, 0x00, 0x28, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x87, 0xC0, 0xF8,
  0x4C, 0x30, 0x83, 0x28, 0x04, 0x80, 0x94, 0x02, 0x80, 0x2C, 0x01, 0x40,
  0x16, 0x00, 0x40, 0x0A, 0x00, 0x20, 0x05, 0x00, 0x10, 0x02, 0x80, 0x08,
  0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01, 0x00, 0x38, 0x00,
  0x80, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x20, 0x07, 0x00, 0x10, 0x03, 0x80,
  0x08, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01, 0x00, 0x38,
  0x00, 0x80, 0x18, 0x87, 0xC4, 0xC3, 0x2C, 0x05, 0x40, 0x2C, 0x01, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x07, 0xC0, 0x30, 0x60, 0xC0, 0x63, 0x00, 0x44, 0x00, 0x48,
  0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x20, 0x02, 0x40, 0x04, 0xC0, 0x10,
  0xC0, 0x60, 0xC1, 0x80, 0x7C, 0x00, 0x8F, 0xC2, 0x41, 0x8A, 0x01, 0x30,
  0x06, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0B,
  0x00, 0x4E, 0x01, 0x2C, 0x18, 0x8F, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0xC4, 0x40,
  0x92, 0x01, 0x50, 0x03, 0x40, 0x0D, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50,
  0x01, 0x40, 0x05, 0x00, 0x32, 0x01, 0x44, 0x09, 0x0F, 0xC4, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x8F, 0x90, 0xA0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x81, 0x83,
  0x10, 0x04, 0x80, 0x28, 0x01, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x90, 0x04, 0x60, 0xC0, 0xFC, 0x00, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x07, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x03, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1A, 0x00, 0xD0, 0x0A, 0x60, 0x91, 0xF8,
  0x80, 0x80, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x42, 0x00, 0x84, 0x01,
  0x08, 0x04, 0x18, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x41, 0x00,
  0x84, 0x01, 0x08, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x05, 0x00, 0x0A,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x20, 0x06, 0x00, 0xC0, 0x38, 0x03,
  0x00, 0x90, 0x14, 0x02, 0x40, 0x50, 0x09, 0x01, 0x20, 0x64, 0x04, 0x81,
  0x18, 0x22, 0x04, 0x20, 0x8C, 0x10, 0x82, 0x10, 0xC2, 0x18, 0x42, 0x0C,
  0x41, 0x08, 0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x20, 0x24, 0x06, 0x80,
  0x90, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x40, 0x0D, 0x80, 0x22, 0x01, 0x04, 0x04, 0x10, 0x20,
  0x20, 0x80, 0xC4, 0x01, 0x30, 0x02, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x04, 0x80, 0x11, 0x00, 0x84, 0x06, 0x08, 0x10, 0x30, 0xC0, 0x42, 0x00,
  0x90, 0x02, 0x40, 0x04, 0x80, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x62,
  0x00, 0x84, 0x01, 0x08, 0x06, 0x08, 0x08, 0x10, 0x10, 0x20, 0x60, 0x20,
  0x80, 0x41, 0x00, 0x82, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x07, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x81,
  0x81, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x18, 0x18, 0x10, 0x06, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x03, 0x03, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x30, 0x00, 0x3C, 0x00, 0xB1, 0x80, 0x50, 0x60, 0x30, 0x08, 0x18, 0x02,
  0x14, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Thin39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 28, 7, 3, -28 },
  { 8, 5, 8, 10, 3, -29 },
  { 13, 18, 28, 19, 1, -28 },
  { 76, 15, 36, 19, 2, -32 },
  { 144, 21, 28, 25, 2, -28 },
  { 218, 18, 28, 21, 2, -28 },
  { 281, 1, 8, 7, 3, -29 },
  { 282, 7, 40, 11, 3, -31 },
  { 317, 7, 40, 11, 1, -31 },
  { 352, 15, 15, 16, 1, -28 },
  { 381, 16, 21, 19, 2, -23 },
  { 423, 3, 8, 7, 2, -3 },
  { 426, 8, 1, 11, 1, -13 },
  { 427, 2, 2, 8, 3, -2 },
  { 428, 11, 30, 13, 1, -28 },
  { 470, 15, 28, 19, 2, -28 },
  { 523, 8, 28, 19, 3, -28 },
  { 551, 15, 28, 19, 2, -28 },
  { 604, 15, 28, 19, 2, -28 },
  { 657, 16, 28, 19, 2, -28 },
  { 713, 14, 28, 19, 3, -28 },
  { 762, 15, 28, 19, 2, -28 },
  { 815, 15, 28, 19, 2, -28 },
  { 868, 15, 28, 19, 2, -28 },
  { 921, 14, 28, 19, 2, -28 },
  { 970, 3, 20, 7, 2, -20 },
  { 978, 3, 25, 7, 2, -20 },
  { 988, 13, 15, 18, 2, -20 },
  { 1013, 13, 9, 19, 3, -17 },
  { 1028, 14, 15, 18, 2, -20 },
  { 1055, 11, 28, 15, 2, -28 },
  { 1094, 27, 36, 31, 2, -27 },
  { 1216, 19, 28, 21, 1, -28 },
  { 1283, 15, 28, 21, 4, -28 },
  { 1336, 17, 28, 22, 3, -28 },
  { 1396, 16, 28, 22, 4, -28 },
  { 1452, 14, 28, 20, 4, -28 },
  { 1501, 14, 28, 20, 4, -28 },
  { 1550, 17, 28, 23, 3, -28 },
  { 1610, 16, 28, 24, 4, -28 },
  { 1666, 1, 28, 9, 4, -28 },
  { 1670, 13, 28, 19, 2, -28 },
  { 1716, 16, 28, 22, 4, -28 },
  { 1772, 13, 28, 18, 4, -28 },
  { 1818, 22, 28, 29, 4, -28 },
  { 1895, 17, 28, 24, 4, -28 },
  { 1955, 17, 28, 23, 3, -28 },
  { 2015, 15, 28, 21, 4, -28 },
  { 2068, 17, 33, 23, 3, -28 },
  { 2139, 17, 28, 22, 3, -28 },
  { 2199, 17, 28, 20, 2, -28 },
  { 2259, 18, 28, 20, 1, -28 },
  { 2322, 16, 28, 23, 3, -28 },
  { 2378, 19, 28, 21, 1, -28 },
  { 2445, 28, 28, 31, 1, -28 },
  { 2543, 18, 28, 21, 1, -28 },
  { 2606, 19, 28, 20, 1, -28 },
  { 2673, 17, 28, 21, 2, -28 },
  { 2733, 5, 38, 8, 3, -32 },
  { 2757, 11, 30, 13, 1, -28 },
  { 2799, 5, 38, 8, 0, -32 },
  { 2823, 10, 14, 14, 2, -28 },
  { 2841, 14, 1, 14, 0, 0 },
  { 2843, 5, 5, 10, 3, -29 },
  { 2847, 13, 21, 18, 2, -21 },
  { 2882, 14, 29, 19, 3, -29 },
  { 2933, 14, 21, 18, 2, -21 },
  { 2970, 14, 29, 19, 2, -29 },
  { 3021, 14, 21, 18, 2, -21 },
  { 3058, 10, 29, 11, 1, -29 },
  { 3095, 14, 29, 19, 2, -21 },
  { 3146, 13, 29, 19, 3, -29 },
  { 3194, 2, 28, 8, 3, -28 },
  { 3201, 7, 36, 8, -2, -28 },
  { 3233, 13, 29, 16, 3, -29 },
  { 3281, 1, 29, 8, 3, -29 },
  { 3285, 25, 21, 30, 3, -21 },
  { 3351, 13, 21, 19, 3, -21 },
  { 3386, 15, 21, 19, 2, -21 },
  { 3426, 14, 29, 19, 3, -21 },
  { 3477, 14, 29, 19, 2, -21 },
  { 3528, 8, 21, 12, 3, -21 },
  { 3549, 13, 21, 17, 2, -21 },
  { 3584, 9, 26, 11, 1, -26 },
  { 3614, 13, 21, 19, 3, -21 },
  { 3649, 15, 21, 17, 1, -21 },
  { 3689, 22, 21, 26, 2, -21 },
  { 3747, 14, 21, 17, 1, -21 },
  { 3784, 15, 29, 16, 1, -21 },
  { 3839, 13, 21, 17, 2, -21 },
  { 3874, 9, 38, 11, 2, -30 },
  { 3917, 2, 33, 8, 3, -28 },
  { 3926, 10, 38, 11, 0, -30 },
  { 3974, 17, 6, 24, 3, -14 },
};

const GFXfont RobotoCondensed_Thin39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_THIN39PT7B_H_
