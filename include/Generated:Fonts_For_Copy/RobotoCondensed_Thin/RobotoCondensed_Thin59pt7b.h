#ifndef _ROBOTOCONDENSED_THIN59PT7B_H_
#define _ROBOTOCONDENSED_THIN59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin59pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x00, 0x00, 0xFD, 0x00, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x40, 0x18, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x60, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00, 0x20, 0x0C,
  0x00, 0x04, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x04, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xC0, 0x30, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x40, 0x10, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00, 0x20, 0x08, 0x00,
  0x04, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x80, 0x30, 0x00, 0x10, 0x04, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x10, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x18,
  0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x08, 0x00, 0x0C,
  0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01,
  0xC0, 0x70, 0x0E, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0x80, 0x00, 0x22, 0x00, 0x00, 0xC8, 0x00, 0x03,
  0x20, 0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x14, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x32,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x30, 0x30, 0x01, 0x80, 0x70,
  0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x80, 0xC0, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x40, 0x08, 0x18, 0x00, 0x40, 0x18, 0x10,
  0x00, 0x60, 0x18, 0x30, 0x00, 0x30, 0x30, 0x20, 0x00, 0x18, 0x60, 0x60,
  0x00, 0x0F, 0xC0, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x03, 0x03,
  0xF8, 0x00, 0x02, 0x06, 0x1C, 0x00, 0x06, 0x0C, 0x04, 0x00, 0x0C, 0x08,
  0x06, 0x00, 0x0C, 0x18, 0x02, 0x00, 0x18, 0x18, 0x03, 0x00, 0x10, 0x10,
  0x03, 0x00, 0x30, 0x10, 0x01, 0x00, 0x20, 0x10, 0x01, 0x00, 0x60, 0x10,
  0x01, 0x00, 0x40, 0x10, 0x01, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x80, 0x10,
  0x03, 0x01, 0x80, 0x18, 0x03, 0x01, 0x00, 0x18, 0x02, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0x40, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0x80, 0x00, 0x30, 0x30, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x08, 0x18, 0x00, 0x03, 0x01, 0x80, 0x10, 0xC0, 0x18, 0x02,
  0x10, 0x03, 0x00, 0x46, 0x00, 0x30, 0x08, 0x80, 0x03, 0x01, 0x10, 0x00,
  0x30, 0x66, 0x00, 0x06, 0x0C, 0xC0, 0x00, 0x61, 0x18, 0x00, 0x06, 0x63,
  0x00, 0x00, 0x68, 0x20, 0x00, 0x0F, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x1C, 0x0C, 0x00, 0x06, 0xC1, 0x80, 0x01, 0x98, 0x1C, 0x00, 0xE1, 0x81,
  0xE0, 0x70, 0x18, 0x0F, 0xFC, 0x01, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF,
  0xFA, 0x00, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0xE0, 0x10, 0x0E, 0xF0, 0x20, 0xF0, 0x3C, 0x47, 0x80, 0x0F, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x33, 0x33, 0x33,
  0x32, 0x66, 0xC8, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xE0, 0x01, 0xC1, 0xC0, 0x18,
  0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x01, 0x8C, 0x00, 0x04,
  0x40, 0x00, 0x32, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x28, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x90, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x02, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x03, 0x00, 0x18,
  0x0C, 0x01, 0x80, 0x38, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x0F, 0x03, 0xB1, 0xE3, 0x70, 0x3C, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1C, 0x0E, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x30, 0x00,
  0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00,
  0x70, 0x1C, 0x03, 0x00, 0x38, 0x18, 0x00, 0x20, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00, 0x24, 0x00, 0x00,
  0x90, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x09,
  0x80, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x1C,
  0x07, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x28, 0x00, 0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x20, 0x00,
  0x06, 0x10, 0x00, 0x06, 0x08, 0x00, 0x02, 0x04, 0x00, 0x03, 0x02, 0x00,
  0x01, 0x01, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x20,
  0x00, 0xC0, 0x10, 0x00, 0x40, 0x08, 0x00, 0x60, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x40, 0x18, 0x00,
  0x20, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x06, 0x00,
  0x02, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xF0, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x61, 0xF8, 0x03, 0x3F, 0xF8, 0x1E, 0x00, 0xE0, 0xE0, 0x01, 0x86,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x00,
  0xB0, 0x00, 0x0C, 0x80, 0x00, 0x66, 0x00, 0x02, 0x10, 0x00, 0x30, 0xC0,
  0x01, 0x03, 0x00, 0x18, 0x0E, 0x03, 0x80, 0x1F, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x1F, 0x80, 0xC3, 0xFF, 0x04, 0x70, 0x0E, 0x26,
  0x00, 0x31, 0x60, 0x00, 0xCA, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00,
  0x03, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x18, 0x07, 0x03, 0x80,
  0x0F, 0xF0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00,
  0x1C, 0x0F, 0x00, 0x60, 0x07, 0x01, 0x80, 0x07, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x32, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x02, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x20, 0x00, 0x60, 0x60, 0x01,
  0x80, 0x70, 0x06, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xC0, 0xF0,
  0x06, 0x00, 0x30, 0x18, 0x00, 0x30, 0x60, 0x00, 0x31, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x24, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x88, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x60, 0x1E, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x38, 0x03, 0x00, 0x30,
  0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x04, 0x60,
  0x00, 0x19, 0x00, 0x00, 0x64, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0xCC, 0x00, 0x0F, 0x10, 0x00, 0x6C, 0x60, 0x03,
  0x30, 0xE0, 0x18, 0xC1, 0xF7, 0xC2, 0x01, 0xFC, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x5F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x11, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x8C, 0x63, 0x11, 0x8C, 0xC6, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x09, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x1F, 0x00,
  0x04, 0x30, 0x00, 0x7F, 0xC0, 0x06, 0x30, 0x00, 0xC0, 0x60, 0x06, 0x20,
  0x01, 0x80, 0x20, 0x02, 0x60, 0x03, 0x00, 0x20, 0x02, 0x60, 0x06, 0x00,
  0x20, 0x02, 0x40, 0x06, 0x00, 0x20, 0x02, 0x40, 0x04, 0x00, 0x20, 0x03,
  0xC0, 0x0C, 0x00, 0x20, 0x03, 0xC0, 0x08, 0x00, 0x20, 0x03, 0xC0, 0x08,
  0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x10, 0x00, 0x60, 0x03, 0x80, 0x10, 0x00, 0x60, 0x03, 0x80,
  0x10, 0x00, 0x60, 0x03, 0x80, 0x10, 0x00, 0x60, 0x03, 0x80, 0x10, 0x00,
  0x40, 0x02, 0x80, 0x10, 0x00, 0x40, 0x02, 0x80, 0x10, 0x00, 0x40, 0x02,
  0x80, 0x10, 0x00, 0xC0, 0x06, 0x80, 0x10, 0x00, 0xC0, 0x06, 0xC0, 0x10,
  0x00, 0xC0, 0x04, 0xC0, 0x10, 0x01, 0xC0, 0x0C, 0xC0, 0x18, 0x01, 0x60,
  0x08, 0xC0, 0x08, 0x03, 0x60, 0x18, 0x40, 0x0C, 0x06, 0x20, 0x30, 0x60,
  0x06, 0x1C, 0x38, 0x60, 0x60, 0x03, 0xF8, 0x1F, 0xC0, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x08, 0x02, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x20, 0x02, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x10, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x01, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xC0, 0xFF,
  0xFC, 0x01, 0x80, 0x7F, 0x03, 0x00, 0x07, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x04, 0xC0, 0x00,
  0x09, 0x80, 0x00, 0x13, 0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x98, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x30, 0x00, 0x0E, 0x60, 0x00, 0x38, 0xC0, 0x0F, 0xC1, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x04, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x26, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x84, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFC, 0x00, 0x60, 0x0F, 0xC0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x02, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x01,
  0xC1, 0x80, 0x01, 0xC0, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02,
  0x40, 0x00, 0x66, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0E, 0x07,
  0x00, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC6,
  0xC0, 0x00, 0x33, 0x18, 0x00, 0x0D, 0x86, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xD0, 0x00, 0x00, 0x02, 0xF6, 0x00, 0x00, 0x01, 0xBD, 0x80, 0x00,
  0x00, 0x6F, 0x20, 0x00, 0x00, 0x13, 0xCC, 0x00, 0x00, 0x0C, 0xF3, 0x00,
  0x00, 0x03, 0x3C, 0x40, 0x00, 0x00, 0x8F, 0x18, 0x00, 0x00, 0x63, 0xC2,
  0x00, 0x00, 0x10, 0xF0, 0x80, 0x00, 0x04, 0x3C, 0x30, 0x00, 0x03, 0x0F,
  0x04, 0x00, 0x00, 0x83, 0xC1, 0x80, 0x00, 0x60, 0xF0, 0x60, 0x00, 0x18,
  0x3C, 0x08, 0x00, 0x04, 0x0F, 0x03, 0x00, 0x03, 0x03, 0xC0, 0x40, 0x00,
  0x80, 0xF0, 0x10, 0x00, 0x20, 0x3C, 0x06, 0x00, 0x18, 0x0F, 0x00, 0x80,
  0x04, 0x03, 0xC0, 0x20, 0x03, 0x00, 0xF0, 0x0C, 0x00, 0xC0, 0x3C, 0x01,
  0x00, 0x20, 0x0F, 0x00, 0x60, 0x18, 0x03, 0xC0, 0x18, 0x06, 0x00, 0xF0,
  0x02, 0x01, 0x00, 0x3C, 0x00, 0xC0, 0xC0, 0x0F, 0x00, 0x10, 0x20, 0x03,
  0xC0, 0x04, 0x08, 0x00, 0xF0, 0x01, 0x86, 0x00, 0x3C, 0x00, 0x21, 0x00,
  0x0F, 0x00, 0x0C, 0xC0, 0x03, 0xC0, 0x03, 0x30, 0x00, 0xF0, 0x00, 0x48,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x10, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x70, 0x30, 0x00, 0x1C, 0x04, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x20, 0x01,
  0xC0, 0x0C, 0x00, 0x70, 0x01, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x0C,
  0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x08, 0x07, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x41, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x02, 0x1C, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x17, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x1F, 0x83, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x1C,
  0x00, 0x78, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0xFF,
  0xFE, 0x00, 0x60, 0x07, 0xE0, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x1F, 0x01, 0xFF,
  0xFE, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x10, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x1C, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x20, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x02,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x02, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x10, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10,
  0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x34, 0x00, 0x00, 0xE0, 0x00,
  0x0D, 0x00, 0x00, 0x28, 0x00, 0x03, 0x60, 0x00, 0x1A, 0x00, 0x00, 0x98,
  0x00, 0x04, 0x80, 0x00, 0x66, 0x00, 0x01, 0x30, 0x00, 0x18, 0x80, 0x00,
  0xC4, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x0C, 0x00, 0x08, 0x60,
  0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x30, 0x40, 0x01, 0x82, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x80, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80,
  0x04, 0x0C, 0x00, 0x60, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0,
  0x40, 0x06, 0x03, 0x00, 0x20, 0x18, 0x01, 0x00, 0xC0, 0x08, 0x06, 0x00,
  0x40, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x40, 0x0C, 0x02, 0x00, 0x60, 0x10, 0x03, 0x00, 0x80, 0x18, 0x0C,
  0x00, 0x40, 0x60, 0x02, 0x03, 0x00, 0x10, 0x18, 0x00, 0x80, 0x80, 0x06,
  0x06, 0x00, 0x30, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x40,
  0x01, 0x06, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x40, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x10, 0x80, 0x01, 0x8C, 0x00,
  0x04, 0x60, 0x00, 0x22, 0x00, 0x01, 0x98, 0x00, 0x08, 0x80, 0x00, 0x66,
  0x00, 0x03, 0x60, 0x00, 0x09, 0x00, 0x00, 0xD8, 0x00, 0x02, 0xC0, 0x00,
  0x14, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x10, 0x00, 0x04, 0x03, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x04, 0x00, 0x40, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x04, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x40, 0x04, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x04, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x20, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFE, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x02, 0xC0, 0x06, 0x40, 0x06, 0x40, 0x04, 0x60, 0x0C,
  0x20, 0x0C, 0x20, 0x08, 0x30, 0x18, 0x10, 0x18, 0x10, 0x10, 0x18, 0x30,
  0x08, 0x30, 0x08, 0x20, 0x0C, 0x60, 0x04, 0x60, 0x06, 0x40, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x02, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0E, 0x03, 0x81, 0x80, 0x0C,
  0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x03, 0x40, 0x00,
  0x34, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0x0F, 0xFF, 0xF1, 0xC0, 0x03, 0x30,
  0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x40, 0x01, 0xB6, 0x00, 0x33, 0x38, 0x0E, 0x30, 0xFF, 0x81, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x7F, 0xE0,
  0x8E, 0x07, 0x09, 0x80, 0x18, 0xB0, 0x00, 0xCE, 0x00, 0x04, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x04, 0xA0, 0x00, 0xCB, 0x00, 0x18, 0x8E, 0x07,
  0x08, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0x80, 0xE0, 0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00,
  0xC8, 0x00, 0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40, 0x00, 0x12,
  0x00, 0x00, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00,
  0x60, 0x38, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x81, 0xFF, 0x0C, 0x38, 0x0E,
  0x63, 0x80, 0x1B, 0x18, 0x00, 0x79, 0x80, 0x01, 0xC8, 0x00, 0x0E, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03,
  0x40, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x1A,
  0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x0C, 0x80, 0x00, 0x66, 0x00, 0x07, 0x18, 0x00, 0x78, 0x60, 0x06, 0xC1,
  0x80, 0xE6, 0x07, 0xFC, 0x30, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x01, 0xC0, 0xE0, 0x38, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x03,
  0x06, 0x00, 0x30, 0x1C, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0xF0, 0xC3, 0x80, 0xE6, 0x38, 0x01, 0xB1, 0x80,
  0x07, 0x98, 0x00, 0x1C, 0x80, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00,
  0x68, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x60,
  0x00, 0x71, 0x80, 0x07, 0x8E, 0x00, 0x6C, 0x38, 0x0E, 0x60, 0x7F, 0xC3,
  0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x60,
  0x70, 0x06, 0x01, 0xF3, 0xE0, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x02, 0x01, 0x07, 0xFC, 0x21, 0xC1, 0xC4, 0x60, 0x0C, 0x98, 0x00,
  0xD6, 0x00, 0x1A, 0x80, 0x01, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x7D, 0x80, 0x00, 0x00, 0x36, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0xC0, 0x70,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0xDE, 0x1E, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x18, 0x80, 0x06, 0x10, 0x01, 0x82,
  0x00, 0x60, 0x40, 0x18, 0x08, 0x06, 0x01, 0x01, 0x80, 0x20, 0x60, 0x04,
  0x0C, 0x00, 0x83, 0x00, 0x10, 0xC0, 0x02, 0x30, 0x00, 0x4F, 0x00, 0x0B,
  0x30, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x04, 0x06, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x02, 0x00, 0xC0, 0x40, 0x0C, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x20,
  0x01, 0x84, 0x00, 0x18, 0x80, 0x01, 0x10, 0x00, 0x32, 0x00, 0x03, 0x40,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x04, 0x03, 0x07, 0xFC, 0x01, 0xFE, 0x0C, 0x30,
  0x38, 0x1C, 0x0E, 0x31, 0x80, 0x30, 0xC0, 0x0C, 0xCC, 0x00, 0x46, 0x00,
  0x33, 0x60, 0x01, 0xB0, 0x00, 0x6D, 0x00, 0x02, 0x80, 0x01, 0xBC, 0x00,
  0x0E, 0x00, 0x02, 0xE0, 0x00, 0x30, 0x00, 0x0B, 0x80, 0x00, 0xC0, 0x00,
  0x2C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x10,
  0x7F, 0xC2, 0x1C, 0x1C, 0x46, 0x00, 0xC9, 0x80, 0x0D, 0x60, 0x01, 0xA8,
  0x00, 0x17, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x3C, 0x03, 0x00, 0x38,
  0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x09, 0x80, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x08, 0x80, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x80,
  0x70, 0x3C, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x7F,
  0xE0, 0x8E, 0x07, 0x09, 0x80, 0x18, 0xB0, 0x00, 0xCE, 0x00, 0x04, 0xC0,
  0x00, 0x6C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xA0, 0x00, 0xCB, 0x80, 0x18, 0x8E,
  0x07, 0x08, 0x7F, 0xE0, 0x80, 0x60, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0xC3, 0x80, 0xE6, 0x38, 0x01, 0xB1, 0x80, 0x07, 0x98,
  0x00, 0x1C, 0x80, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x60, 0x00, 0x71,
  0x80, 0x07, 0x86, 0x00, 0x6C, 0x38, 0x0E, 0x60, 0x7F, 0xC3, 0x00, 0x20,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x08, 0x3E, 0x8E, 0x09, 0x80,
  0x90, 0x0A, 0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xC0, 0x70,
  0x1C, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0x90, 0x00, 0x1A, 0x00,
  0x03, 0x40, 0x00, 0x68, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00,
  0x36, 0x00, 0x0C, 0x60, 0x03, 0x87, 0x01, 0xE0, 0x3F, 0xF0, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xEF, 0xFF, 0x81, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7E, 0x00,
  0x20, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1D, 0x00, 0x03, 0xB0, 0x00, 0xF3, 0x00, 0x36, 0x30, 0x1C,
  0xC3, 0xFE, 0x18, 0x04, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0x80, 0x00, 0x26, 0x00, 0x03, 0x30, 0x00, 0x18, 0x80, 0x00, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x02, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x80, 0x80, 0x08, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x20, 0x06,
  0x03, 0x00, 0x30, 0x18, 0x00, 0x80, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x00, 0x82, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0x88, 0x00, 0x06,
  0x40, 0x00, 0x36, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x38, 0x00, 0x36,
  0x00, 0x0E, 0x00, 0x0D, 0x80, 0x02, 0x80, 0x02, 0x20, 0x01, 0xA0, 0x01,
  0x8C, 0x00, 0x6C, 0x00, 0x63, 0x00, 0x13, 0x00, 0x18, 0xC0, 0x04, 0xC0,
  0x04, 0x10, 0x03, 0x10, 0x03, 0x06, 0x00, 0xC6, 0x00, 0xC1, 0x80, 0x21,
  0x80, 0x30, 0x60, 0x18, 0x20, 0x08, 0x08, 0x06, 0x0C, 0x06, 0x03, 0x01,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0xC0, 0x60, 0x30, 0x30, 0x10, 0x10, 0x04,
  0x0C, 0x06, 0x0C, 0x01, 0x82, 0x01, 0x83, 0x00, 0x60, 0x80, 0x20, 0xC0,
  0x18, 0x60, 0x08, 0x20, 0x02, 0x18, 0x03, 0x18, 0x00, 0xC4, 0x00, 0xC6,
  0x00, 0x33, 0x00, 0x11, 0x80, 0x0C, 0xC0, 0x04, 0x40, 0x01, 0x20, 0x01,
  0xB0, 0x00, 0x48, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x60,
  0x00, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x60,
  0x02, 0x02, 0x00, 0x18, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x0D,
  0x80, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00,
  0x06, 0xC0, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x30, 0x60, 0x01, 0x01,
  0x00, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x06, 0x04,
  0x00, 0x10, 0x60, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x90, 0x00, 0x04,
  0x60, 0x00, 0x31, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x30,
  0x00, 0x60, 0x40, 0x01, 0x81, 0x80, 0x04, 0x02, 0x00, 0x30, 0x08, 0x00,
  0xC0, 0x30, 0x02, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x06, 0x01, 0x00,
  0x08, 0x0C, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x80, 0x01, 0x06, 0x00, 0x04,
  0x18, 0x00, 0x18, 0x40, 0x00, 0x23, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x20,
  0x00, 0x05, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x01, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0x70, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x04, 0xC0, 0xC0, 0x01, 0x90, 0x0C, 0x00, 0x36, 0x00, 0xC0, 0x06, 0x80,
  0x0C, 0x00, 0x90, 0x00, 0xC0, 0x36, 0x00, 0x0C, 0x0C, 0xC0, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Thin59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 43, 11, 4, -42 },
  { 18, 8, 12, 15, 4, -44 },
  { 30, 27, 42, 29, 2, -42 },
  { 172, 22, 54, 29, 3, -48 },
  { 321, 32, 44, 38, 3, -43 },
  { 497, 27, 44, 32, 3, -43 },
  { 646, 2, 12, 10, 4, -44 },
  { 649, 11, 61, 16, 4, -47 },
  { 733, 11, 61, 16, 1, -47 },
  { 817, 23, 23, 25, 1, -42 },
  { 884, 25, 31, 29, 2, -35 },
  { 981, 4, 12, 11, 3, -5 },
  { 987, 11, 1, 16, 2, -20 },
  { 989, 4, 4, 13, 4, -3 },
  { 991, 16, 46, 20, 2, -42 },
  { 1083, 21, 44, 29, 4, -43 },
  { 1199, 12, 42, 29, 5, -42 },
  { 1262, 23, 43, 29, 3, -43 },
  { 1386, 22, 44, 29, 3, -43 },
  { 1507, 25, 42, 29, 2, -42 },
  { 1639, 21, 43, 29, 5, -42 },
  { 1752, 21, 43, 29, 4, -42 },
  { 1865, 23, 42, 29, 2, -42 },
  { 1986, 23, 44, 29, 3, -43 },
  { 2113, 22, 43, 29, 3, -43 },
  { 2232, 3, 32, 10, 4, -31 },
  { 2244, 5, 38, 10, 2, -31 },
  { 2268, 20, 23, 27, 3, -31 },
  { 2326, 21, 13, 29, 4, -26 },
  { 2361, 21, 23, 27, 3, -31 },
  { 2422, 17, 44, 23, 3, -43 },
  { 2516, 40, 54, 47, 4, -41 },
  { 2786, 29, 42, 31, 1, -42 },
  { 2939, 23, 42, 31, 5, -42 },
  { 3060, 26, 44, 34, 4, -43 },
  { 3203, 25, 42, 34, 5, -42 },
  { 3335, 22, 42, 30, 5, -42 },
  { 3451, 22, 42, 30, 5, -42 },
  { 3567, 26, 44, 35, 5, -43 },
  { 3710, 26, 42, 36, 5, -42 },
  { 3847, 2, 42, 14, 6, -42 },
  { 3858, 20, 43, 29, 3, -42 },
  { 3966, 26, 42, 33, 5, -42 },
  { 4103, 20, 42, 27, 5, -42 },
  { 4208, 34, 42, 44, 5, -42 },
  { 4387, 26, 42, 37, 5, -42 },
  { 4524, 27, 44, 34, 4, -43 },
  { 4673, 23, 42, 31, 5, -42 },
  { 4794, 27, 51, 34, 4, -43 },
  { 4967, 25, 42, 34, 5, -42 },
  { 5099, 25, 44, 31, 3, -43 },
  { 5237, 27, 42, 31, 2, -42 },
  { 5379, 24, 43, 34, 5, -42 },
  { 5508, 29, 42, 31, 1, -42 },
  { 5661, 42, 42, 46, 2, -42 },
  { 5882, 27, 42, 31, 2, -42 },
  { 6024, 29, 42, 31, 1, -42 },
  { 6177, 25, 42, 31, 3, -42 },
  { 6309, 7, 57, 12, 5, -48 },
  { 6359, 16, 46, 20, 2, -42 },
  { 6451, 7, 57, 12, 0, -48 },
  { 6501, 16, 21, 22, 3, -42 },
  { 6543, 20, 1, 22, 1, 0 },
  { 6546, 8, 8, 16, 4, -45 },
  { 6554, 20, 33, 28, 3, -32 },
  { 6637, 20, 45, 29, 5, -44 },
  { 6750, 21, 33, 27, 3, -32 },
  { 6837, 21, 45, 29, 3, -44 },
  { 6956, 21, 33, 27, 3, -32 },
  { 7043, 15, 45, 17, 2, -45 },
  { 7128, 21, 44, 29, 3, -32 },
  { 7244, 19, 44, 28, 5, -44 },
  { 7349, 3, 42, 12, 4, -42 },
  { 7365, 10, 54, 12, -3, -42 },
  { 7433, 19, 44, 25, 5, -44 },
  { 7538, 2, 44, 12, 5, -44 },
  { 7549, 38, 32, 46, 4, -32 },
  { 7701, 19, 32, 29, 5, -32 },
  { 7777, 22, 33, 29, 3, -32 },
  { 7868, 20, 44, 29, 5, -32 },
  { 7978, 21, 44, 29, 3, -32 },
  { 8094, 12, 32, 18, 5, -32 },
  { 8142, 19, 33, 26, 3, -32 },
  { 8221, 14, 41, 17, 1, -40 },
  { 8293, 19, 32, 29, 5, -31 },
  { 8369, 21, 31, 25, 2, -31 },
  { 8451, 34, 31, 39, 2, -31 },
  { 8583, 21, 31, 25, 2, -31 },
  { 8665, 22, 43, 25, 2, -31 },
  { 8784, 20, 31, 25, 3, -31 },
  { 8862, 15, 59, 17, 2, -46 },
  { 8973, 2, 50, 12, 5, -42 },
  { 8986, 14, 59, 17, 1, -46 },
  { 9090, 27, 10, 36, 4, -23 },
};

const GFXfont RobotoCondensed_Thin59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_THIN59PT7B_H_
