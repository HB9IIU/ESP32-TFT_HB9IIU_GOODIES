#ifndef _ROBOTOCONDENSED_THIN38PT7B_H_
#define _ROBOTOCONDENSED_THIN38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin38pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0x28, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x04,
  0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x10, 0x7F, 0xFF, 0xC0, 0x81, 0x00,
  0x20, 0x80, 0x08, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x04, 0x10, 0x01, 0x04, 0x0F, 0xFF, 0xF8, 0x20, 0x40, 0x08, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01,
  0x02, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x01, 0xF0, 0x18, 0x30, 0x80,
  0x62, 0x00, 0x90, 0x03, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14,
  0x00, 0xC8, 0x02, 0x18, 0x30, 0x1F, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x1C, 0x00, 0x03, 0x10, 0x00, 0x10, 0x40, 0x01, 0x02, 0x02, 0x08, 0x08,
  0x10, 0x40, 0x41, 0x02, 0x02, 0x08, 0x10, 0x10, 0x80, 0x80, 0x84, 0x04,
  0x08, 0x40, 0x10, 0x46, 0x00, 0xC4, 0x20, 0x01, 0xC2, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x0F, 0x00, 0x08, 0xC4, 0x00, 0x84, 0x10, 0x04, 0x40, 0x80,
  0x42, 0x02, 0x02, 0x10, 0x10, 0x20, 0x80, 0x82, 0x04, 0x04, 0x10, 0x20,
  0x41, 0x01, 0x02, 0x00, 0x04, 0x10, 0x00, 0x31, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x04, 0x30, 0x04, 0x08, 0x02, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08, 0x40, 0x02, 0x40, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x50, 0x00, 0x44, 0x00, 0x43, 0x02, 0x40, 0x81, 0x20,
  0x20, 0xA0, 0x08, 0x50, 0x06, 0x28, 0x01, 0x24, 0x00, 0x53, 0x00, 0x10,
  0x80, 0x1C, 0x60, 0x1A, 0x18, 0x10, 0x83, 0xF0, 0x20, 0x55, 0x57, 0x02,
  0x08, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x10, 0x20, 0x41, 0x04, 0x08, 0x20, 0x00, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x02, 0x04, 0x37, 0x13, 0x83, 0xF0, 0x03,
  0x00, 0x1E, 0x00, 0x48, 0x02, 0x10, 0x18, 0x20, 0x40, 0xC2, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x55, 0x5A, 0xFF, 0xF0, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x00, 0x07, 0xC0,
  0x61, 0x83, 0x01, 0x08, 0x06, 0x40, 0x09, 0x00, 0x24, 0x00, 0x50, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00,
  0x24, 0x00, 0x88, 0x06, 0x30, 0x10, 0x61, 0x80, 0x7C, 0x00, 0x03, 0x0D,
  0x31, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x0F, 0xC0, 0x30, 0xC0, 0x80, 0x42, 0x00, 0xC4, 0x00, 0x98, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0x60, 0xC2, 0x01, 0x10, 0x02, 0x40,
  0x09, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x1F, 0x00, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x02, 0x20, 0x08,
  0x60, 0xC0, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0x50,
  0x00, 0x90, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10,
  0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x10, 0x10, 0x30, 0x10, 0x20, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F, 0xF8,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0xF8, 0x1C, 0x18, 0x40, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x02, 0x80, 0x0A, 0x00,
  0x24, 0x00, 0x90, 0x06, 0x20, 0x10, 0x40, 0x80, 0xFC, 0x00, 0x00, 0xF0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x1F, 0x05, 0x83, 0x2C, 0x06, 0xA0, 0x0B, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00,
  0x14, 0x00, 0xC8, 0x02, 0x30, 0x10, 0x60, 0xC0, 0x7C, 0x00, 0xFF, 0xFC,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x00, 0x07, 0xC0,
  0x30, 0x60, 0x80, 0x62, 0x00, 0x44, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x21, 0x00, 0x81, 0x82, 0x00, 0xF8,
  0x06, 0x0C, 0x10, 0x04, 0x40, 0x0D, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xA0, 0x01, 0x20, 0x02, 0x60, 0x08, 0x60, 0x60, 0x3F,
  0x00, 0x0F, 0x80, 0x61, 0x82, 0x01, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x28,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05,
  0x00, 0x34, 0x01, 0xC8, 0x05, 0x10, 0x64, 0x3E, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x06, 0x01, 0xE0,
  0x00, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x60, 0x22, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x22, 0x24, 0x40, 0x00, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x10, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x20, 0x0F, 0x00, 0x88, 0x04,
  0x30, 0x14, 0x02, 0x04, 0x05, 0x01, 0x01, 0x01, 0x40, 0x40, 0x40, 0x50,
  0x20, 0x10, 0x14, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x40, 0x10, 0x18, 0x10, 0x04, 0x06, 0x04, 0x01, 0x01, 0x81, 0x00,
  0x80, 0x50, 0x40, 0x20, 0x24, 0x08, 0x14, 0x09, 0x02, 0x05, 0x04, 0x40,
  0x42, 0x63, 0x18, 0x0F, 0x0F, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x10, 0x02, 0x04, 0x00,
  0x81, 0xFF, 0xE0, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x09,
  0x00, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x04, 0xFF, 0xC1, 0x00,
  0x62, 0x00, 0x64, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x03, 0x1F, 0xFC, 0x20,
  0x06, 0x40, 0x06, 0x80, 0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x33, 0xFF, 0x80,
  0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x60, 0x02, 0x40, 0x02, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x02, 0x60, 0x02,
  0x30, 0x04, 0x18, 0x18, 0x07, 0xE0, 0xFF, 0xC0, 0x80, 0x30, 0x80, 0x08,
  0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF,
  0xE8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x1F, 0xFF, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x0C, 0x01, 0x84, 0x00, 0x44,
  0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x02, 0x40, 0x01, 0x10, 0x03, 0x06, 0x07, 0x00, 0xFE,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x48, 0x02, 0x40, 0x21, 0x82, 0x03, 0xE0, 0x80,
  0x02, 0x40, 0x03, 0x20, 0x03, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x02,
  0x01, 0x01, 0x01, 0x80, 0x81, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x08, 0xC0, 0x04, 0x90, 0x02, 0x8C, 0x01, 0xC2, 0x00, 0xC0, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0xC2, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x02, 0x40, 0x01, 0xA0, 0x00, 0x40, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xFE, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3A, 0x00,
  0x00, 0xE8, 0x00, 0x05, 0xA0, 0x00, 0x16, 0x40, 0x00, 0x99, 0x00, 0x02,
  0x62, 0x00, 0x09, 0x88, 0x00, 0x46, 0x20, 0x01, 0x18, 0x40, 0x04, 0x61,
  0x00, 0x21, 0x84, 0x00, 0x86, 0x08, 0x02, 0x18, 0x20, 0x10, 0x60, 0x40,
  0x41, 0x81, 0x02, 0x06, 0x04, 0x08, 0x18, 0x08, 0x20, 0x60, 0x21, 0x01,
  0x80, 0x84, 0x06, 0x01, 0x10, 0x18, 0x04, 0x80, 0x60, 0x12, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x40, 0xC0, 0x00, 0xE0, 0x00,
  0x68, 0x00, 0x36, 0x00, 0x19, 0x00, 0x0C, 0x40, 0x06, 0x20, 0x03, 0x08,
  0x01, 0x84, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x30, 0x20, 0x18, 0x08, 0x0C,
  0x04, 0x06, 0x01, 0x03, 0x00, 0xC1, 0x80, 0x20, 0xC0, 0x08, 0x60, 0x04,
  0x30, 0x01, 0x18, 0x00, 0x8C, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x05, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x07, 0xE0, 0x0C, 0x0C, 0x08, 0x01,
  0x08, 0x00, 0x44, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x20, 0x04, 0x0C,
  0x0C, 0x01, 0xF8, 0x00, 0xFF, 0xE1, 0x00, 0x32, 0x00, 0x24, 0x00, 0x28,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x50, 0x01, 0xA0, 0x06, 0x7F, 0xF0, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x0C, 0x0C, 0x08,
  0x01, 0x08, 0x00, 0x44, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x20, 0x04,
  0x0C, 0x0C, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0xFF, 0xE0, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0xFF, 0xE0, 0x80, 0x60, 0x80,
  0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80,
  0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x07, 0xE0, 0x18,
  0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x02, 0x20, 0x06, 0x18,
  0x1C, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01,
  0x40, 0x02, 0x60, 0x02, 0x20, 0x04, 0x18, 0x18, 0x07, 0xE0, 0x80, 0x00,
  0x60, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x42,
  0x00, 0x10, 0x80, 0x04, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x20,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x40, 0x10, 0x20, 0x04, 0x08,
  0x01, 0x02, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x80,
  0x06, 0x00, 0x24, 0x00, 0x60, 0x02, 0x40, 0x06, 0x00, 0x24, 0x00, 0xA0,
  0x02, 0x40, 0x09, 0x00, 0x62, 0x00, 0x90, 0x04, 0x20, 0x09, 0x00, 0x42,
  0x01, 0x10, 0x04, 0x20, 0x10, 0x80, 0x43, 0x01, 0x08, 0x08, 0x10, 0x10,
  0x80, 0x81, 0x02, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18,
  0x08, 0x20, 0x41, 0x00, 0x84, 0x04, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84,
  0x02, 0x10, 0x04, 0x40, 0x22, 0x00, 0x48, 0x03, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x30, 0x01, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x98, 0x00, 0x62, 0x00, 0x10, 0x40, 0x08, 0x10, 0x02, 0x02, 0x01, 0x00,
  0xC0, 0xC0, 0x10, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x03, 0x30,
  0x00, 0x84, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08, 0x04, 0x06, 0x01, 0x81,
  0x00, 0x20, 0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x2C, 0x00, 0x08, 0x80,
  0x00, 0x50, 0x00, 0x24, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x04, 0x00,
  0x81, 0x00, 0x20, 0x20, 0x10, 0x08, 0x04, 0x01, 0x02, 0x00, 0x40, 0x80,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0xF8, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0x0C, 0x03,
  0x00, 0xC0, 0x48, 0x12, 0x08, 0x82, 0x10, 0x84, 0x41, 0x10, 0x24, 0x0A,
  0x03, 0x80, 0x40, 0xFF, 0xFC, 0x82, 0x08, 0x41, 0x00, 0x0F, 0xC1, 0x83,
  0x18, 0x04, 0x80, 0x28, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x7F, 0xCC, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1E, 0x01, 0x58, 0x32, 0x3E, 0x10, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x7C, 0x2C, 0x19,
  0xC0, 0x6C, 0x01, 0x40, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x16, 0x00,
  0xB0, 0x0D, 0x60, 0xC8, 0xF8, 0x00, 0x0F, 0xC1, 0x83, 0x18, 0x04, 0x80,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x40, 0x0B, 0x00, 0x8C,
  0x08, 0x1F, 0x80, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x7C, 0x4C, 0x1A, 0x40, 0x34, 0x00,
  0xA0, 0x05, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x06, 0x20,
  0x50, 0xFC, 0x80, 0x0F, 0xC0, 0x83, 0x08, 0x04, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x46, 0x0C, 0x1F, 0x80,
  0x03, 0xC1, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x3F,
  0xE1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x00, 0x0F, 0x89, 0x83, 0x48, 0x06, 0x80, 0x14, 0x00, 0xA0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x09, 0x00, 0xC4, 0x0A, 0x1F, 0x90, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x09, 0x00, 0x84, 0x0C, 0x1F, 0x80, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x78, 0x98, 0x6A, 0x02, 0xA0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xF0, 0x02, 0xAA, 0xAA, 0xAA,
  0xAA, 0xA8, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x13, 0xC0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x02,
  0x80, 0x68, 0x0C, 0x81, 0x88, 0x10, 0x82, 0x08, 0x40, 0x88, 0x09, 0x00,
  0xA8, 0x0C, 0xC0, 0x84, 0x08, 0x20, 0x81, 0x08, 0x10, 0x80, 0x88, 0x04,
  0x80, 0x68, 0x02, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xF8, 0x8F, 0x80, 0xF8,
  0x90, 0x63, 0x04, 0xA0, 0x24, 0x02, 0xC0, 0x14, 0x02, 0xC0, 0x18, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01,
  0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01,
  0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01,
  0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x01, 0x87, 0x89, 0x86,
  0xA0, 0x2A, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x07, 0xC0, 0x60, 0xC2, 0x01, 0x10, 0x02, 0x40, 0x0D,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x03, 0x40, 0x08, 0x80, 0x41, 0x83,
  0x01, 0xF0, 0x8F, 0x85, 0x83, 0x38, 0x0D, 0x80, 0x28, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x16, 0x01, 0xAC, 0x19, 0x1F, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x0F, 0x89, 0x83, 0x48, 0x06, 0x80, 0x14, 0x00, 0xA0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00,
  0x28, 0x01, 0x40, 0x09, 0x00, 0xC4, 0x1A, 0x1F, 0x90, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x8F, 0x90,
  0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x82, 0x06, 0x40, 0x28, 0x01,
  0x80, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x14, 0x03, 0x20, 0x61, 0xF8,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x08, 0x07, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x34, 0x03, 0x20, 0xD1, 0xF1, 0x80, 0x05, 0x00, 0x14,
  0x00, 0x90, 0x02, 0x60, 0x08, 0x80, 0x42, 0x01, 0x0C, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x14, 0x03, 0x80, 0xA0, 0x24, 0x05, 0x01, 0x20, 0x68, 0x09, 0x02,
  0x20, 0x4C, 0x11, 0x04, 0x20, 0x88, 0x21, 0x08, 0x41, 0x08, 0x41, 0x08,
  0x62, 0x08, 0x81, 0x10, 0x44, 0x09, 0x01, 0x20, 0x48, 0x09, 0x03, 0x40,
  0x50, 0x0C, 0x02, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00,
  0x40, 0x09, 0x80, 0x62, 0x01, 0x04, 0x08, 0x10, 0x20, 0x21, 0x00, 0xCC,
  0x01, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x20, 0x04, 0x80, 0x21,
  0x00, 0x86, 0x04, 0x08, 0x20, 0x10, 0x80, 0x44, 0x00, 0xB0, 0x03, 0x80,
  0x05, 0x00, 0x14, 0x00, 0x90, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01, 0x04,
  0x04, 0x10, 0x20, 0x40, 0x80, 0x82, 0x02, 0x18, 0x08, 0x40, 0x11, 0x00,
  0x4C, 0x01, 0x20, 0x02, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x1C, 0x00,
  0xFF, 0xF0, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x00, 0xC0, 0x40,
  0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x03, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x30, 0x03, 0x03, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x30,
  0x00, 0x3C, 0x00, 0xA1, 0x80, 0x70, 0x60, 0x30, 0x18, 0x28, 0x06, 0x34,
  0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Thin38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 27, 7, 3, -27 },
  { 8, 5, 8, 10, 3, -29 },
  { 13, 18, 27, 18, 1, -27 },
  { 74, 14, 33, 18, 2, -30 },
  { 132, 21, 27, 25, 2, -27 },
  { 203, 17, 27, 20, 2, -27 },
  { 261, 2, 8, 6, 2, -29 },
  { 263, 7, 39, 10, 3, -30 },
  { 298, 7, 39, 11, 1, -30 },
  { 333, 14, 15, 16, 1, -27 },
  { 360, 16, 19, 19, 1, -22 },
  { 398, 2, 8, 7, 2, -3 },
  { 400, 8, 1, 10, 1, -13 },
  { 401, 2, 2, 8, 3, -2 },
  { 402, 11, 29, 13, 1, -27 },
  { 442, 14, 27, 18, 2, -27 },
  { 490, 8, 27, 18, 3, -27 },
  { 517, 15, 27, 18, 2, -27 },
  { 568, 14, 27, 18, 2, -27 },
  { 616, 16, 27, 18, 2, -27 },
  { 670, 14, 27, 18, 3, -27 },
  { 718, 14, 27, 18, 2, -27 },
  { 766, 14, 27, 18, 2, -27 },
  { 814, 15, 27, 18, 2, -27 },
  { 865, 14, 27, 18, 2, -27 },
  { 913, 3, 20, 7, 2, -20 },
  { 921, 4, 25, 7, 1, -20 },
  { 934, 13, 15, 17, 2, -20 },
  { 959, 13, 9, 19, 3, -17 },
  { 974, 13, 15, 17, 2, -20 },
  { 999, 11, 27, 15, 2, -27 },
  { 1037, 26, 34, 31, 2, -26 },
  { 1148, 18, 27, 20, 1, -27 },
  { 1209, 15, 27, 20, 3, -27 },
  { 1260, 16, 27, 22, 3, -27 },
  { 1314, 16, 27, 22, 3, -27 },
  { 1368, 14, 27, 19, 3, -27 },
  { 1416, 15, 27, 19, 3, -27 },
  { 1467, 17, 27, 23, 3, -27 },
  { 1525, 17, 27, 23, 3, -27 },
  { 1583, 1, 27, 9, 4, -27 },
  { 1587, 13, 27, 18, 2, -27 },
  { 1631, 17, 27, 21, 3, -27 },
  { 1689, 13, 27, 17, 3, -27 },
  { 1733, 22, 27, 28, 3, -27 },
  { 1808, 17, 27, 24, 3, -27 },
  { 1866, 17, 27, 22, 3, -27 },
  { 1924, 15, 27, 20, 3, -27 },
  { 1975, 17, 32, 22, 3, -27 },
  { 2043, 16, 27, 22, 3, -27 },
  { 2097, 16, 27, 20, 2, -27 },
  { 2151, 18, 27, 20, 1, -27 },
  { 2212, 16, 27, 22, 3, -27 },
  { 2266, 18, 27, 20, 1, -27 },
  { 2327, 28, 27, 30, 1, -27 },
  { 2422, 18, 27, 20, 1, -27 },
  { 2483, 18, 27, 20, 1, -27 },
  { 2544, 16, 27, 20, 2, -27 },
  { 2598, 5, 37, 8, 3, -31 },
  { 2622, 11, 29, 13, 1, -27 },
  { 2662, 5, 37, 8, 0, -31 },
  { 2686, 10, 13, 14, 2, -27 },
  { 2703, 14, 1, 14, 0, 0 },
  { 2705, 5, 5, 10, 3, -29 },
  { 2709, 13, 20, 18, 2, -20 },
  { 2742, 13, 29, 18, 3, -29 },
  { 2790, 13, 20, 17, 2, -20 },
  { 2823, 13, 29, 18, 2, -29 },
  { 2871, 13, 20, 17, 2, -20 },
  { 2904, 10, 29, 11, 1, -29 },
  { 2941, 13, 28, 18, 2, -20 },
  { 2987, 12, 29, 18, 3, -29 },
  { 3031, 2, 27, 7, 3, -27 },
  { 3038, 7, 35, 8, -2, -27 },
  { 3069, 12, 29, 16, 3, -29 },
  { 3113, 1, 29, 7, 3, -29 },
  { 3117, 24, 20, 30, 3, -20 },
  { 3177, 12, 20, 18, 3, -20 },
  { 3207, 14, 20, 18, 2, -20 },
  { 3242, 13, 28, 18, 3, -20 },
  { 3288, 13, 28, 18, 2, -20 },
  { 3334, 8, 20, 12, 3, -20 },
  { 3354, 12, 20, 17, 2, -20 },
  { 3384, 8, 26, 11, 1, -26 },
  { 3410, 12, 20, 18, 3, -20 },
  { 3440, 14, 20, 16, 1, -20 },
  { 3475, 21, 20, 25, 2, -20 },
  { 3528, 14, 20, 16, 1, -20 },
  { 3563, 14, 28, 16, 1, -20 },
  { 3612, 13, 20, 16, 2, -20 },
  { 3645, 10, 38, 11, 1, -30 },
  { 3693, 1, 32, 8, 3, -27 },
  { 3697, 10, 38, 11, 0, -30 },
  { 3745, 17, 6, 23, 3, -14 },
};

const GFXfont RobotoCondensed_Thin38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_THIN38PT7B_H_
