#ifndef _ROBOTOCONDENSED_THIN28PT7B_H_
#define _ROBOTOCONDENSED_THIN28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x10, 0x99, 0x99, 0x99, 0x04, 0x20, 0x21, 0x01, 0x08,
  0x08, 0x80, 0x84, 0x3F, 0xFC, 0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x04,
  0x20, 0x21, 0x01, 0x08, 0x08, 0x43, 0xFF, 0xC2, 0x10, 0x11, 0x01, 0x08,
  0x08, 0x40, 0x42, 0x00, 0x04, 0x01, 0x00, 0x40, 0x78, 0x61, 0x10, 0x28,
  0x06, 0x01, 0x80, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x90, 0x23, 0xF0, 0x10, 0x04, 0x01,
  0x00, 0x70, 0x01, 0x10, 0x02, 0x10, 0x04, 0x21, 0x08, 0x42, 0x10, 0x88,
  0x21, 0x10, 0x44, 0x40, 0x71, 0x00, 0x02, 0x00, 0x08, 0x00, 0x11, 0xC0,
  0x44, 0x40, 0x90, 0x42, 0x20, 0x84, 0x41, 0x10, 0x82, 0x01, 0x04, 0x01,
  0x10, 0x01, 0xC0, 0x1E, 0x02, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x22, 0x02, 0x40, 0x18, 0x01, 0x00, 0x28, 0x04, 0x41, 0x82, 0x18, 0x22,
  0x81, 0x28, 0x0A, 0x80, 0x48, 0x0C, 0x41, 0x23, 0xE1, 0xFC, 0x08, 0x84,
  0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x04, 0x21,
  0x04, 0x20, 0x84, 0x10, 0x84, 0x10, 0x42, 0x10, 0x42, 0x10, 0x82, 0x10,
  0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x22, 0x21, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x06, 0x4E, 0x3E, 0x01, 0x80, 0x48, 0x09, 0x02, 0x10,
  0x81, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x55, 0x60, 0xF8, 0xC0, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x90, 0x22, 0x10, 0x78, 0x0C, 0xDC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3E, 0x10, 0x48, 0x0A, 0x02,
  0x80, 0xA0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x03, 0xFF, 0x0F, 0x06, 0x10, 0x81,
  0x20, 0x24, 0x02, 0x80, 0x40, 0x08, 0x02, 0x00, 0x81, 0xE0, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x08, 0x83, 0x0F, 0x80,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88,
  0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x40, 0x84, 0x08, 0xFF, 0xF0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x3F, 0xD0, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x78, 0x61, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x18,
  0x06, 0x01, 0x40, 0x50, 0x22, 0x08, 0x7C, 0x07, 0x06, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x78, 0xA1, 0xB0, 0x28, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x50, 0x22, 0x10, 0x78, 0xFF, 0xE0, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00,
  0x1F, 0x04, 0x11, 0x01, 0x20, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x20,
  0x83, 0xE0, 0xC2, 0x20, 0x24, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28,
  0x04, 0x81, 0x0F, 0xC0, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x24, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x28, 0x0D, 0x01, 0x90, 0x51, 0xF2, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x0C, 0x0E, 0x00, 0x80, 0x04, 0x40, 0x00,
  0x00, 0x55, 0x60, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x0C, 0x18, 0x10,
  0x30, 0x20, 0x00, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x20, 0x04, 0x08, 0x00, 0x42,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x3C, 0x14, 0x08, 0x41, 0x82, 0x08, 0x30,
  0x41, 0x06, 0x10, 0x20, 0xC2, 0x04, 0x18, 0x40, 0x83, 0x08, 0x20, 0x61,
  0x04, 0x0C, 0x20, 0x82, 0x84, 0x10, 0x50, 0x85, 0x12, 0x0F, 0x1C, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x40, 0x07,
  0xE0, 0x00, 0x02, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x40,
  0x22, 0x02, 0x10, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x42, 0x02, 0x1F,
  0xF1, 0x00, 0x48, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x03, 0x00, 0x10, 0xFE,
  0x20, 0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x81, 0x3F, 0x88,
  0x1A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B, 0xF8,
  0x1F, 0x82, 0x04, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x02, 0x20, 0x41, 0xF8, 0xFE, 0x10, 0x32, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x06, 0x7F, 0x00, 0xFF, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x0F, 0x83, 0x06, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01,
  0x40, 0x12, 0x01, 0x10, 0x30, 0xFC, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80,
  0x50, 0x22, 0x18, 0x78, 0x80, 0x28, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08,
  0x40, 0x84, 0x08, 0x80, 0x90, 0x0B, 0x00, 0xC8, 0x08, 0x80, 0x84, 0x08,
  0x20, 0x81, 0x08, 0x10, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xF0, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x74, 0x01, 0x68, 0x02, 0xD0, 0x09,
  0x90, 0x13, 0x20, 0x26, 0x20, 0x8C, 0x41, 0x18, 0x82, 0x30, 0x88, 0x61,
  0x10, 0xC2, 0x21, 0x82, 0x83, 0x05, 0x06, 0x0C, 0x0C, 0x08, 0x10, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x01, 0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x88,
  0x18, 0x41, 0x84, 0x18, 0x21, 0x81, 0x18, 0x11, 0x80, 0x98, 0x09, 0x80,
  0x58, 0x03, 0x80, 0x38, 0x01, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x20, 0x41, 0xF8, 0xFF,
  0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0B, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x1F, 0x82, 0x04, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x02, 0x20, 0x41, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0xFF, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02,
  0x80, 0x28, 0x04, 0xFF, 0x88, 0x10, 0x80, 0x88, 0x08, 0x80, 0x48, 0x04,
  0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x0F, 0x83, 0x06, 0x40, 0x14, 0x01,
  0x40, 0x14, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xE0, 0x01, 0xC0, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x30, 0x20, 0xFC,
  0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02,
  0x20, 0x40, 0xF8, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x10, 0x80, 0x84, 0x04, 0x20, 0x20, 0x82, 0x04, 0x10, 0x20, 0x81, 0x08,
  0x04, 0x40, 0x22, 0x01, 0x20, 0x05, 0x00, 0x28, 0x01, 0x80, 0x04, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x06, 0x02, 0x40, 0x90,
  0x24, 0x09, 0x02, 0x40, 0x90, 0x22, 0x09, 0x04, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x10, 0x80, 0x12, 0x00, 0x88, 0x08, 0x40, 0x41, 0x04, 0x08, 0x40,
  0x22, 0x01, 0x20, 0x05, 0x00, 0x10, 0x01, 0x80, 0x0A, 0x00, 0x88, 0x04,
  0x40, 0x41, 0x04, 0x08, 0x20, 0x22, 0x01, 0x10, 0x05, 0x00, 0x10, 0x80,
  0x0C, 0x00, 0x90, 0x04, 0x80, 0x42, 0x02, 0x10, 0x20, 0x41, 0x02, 0x10,
  0x08, 0x80, 0x48, 0x01, 0x40, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x7F, 0xF0, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x0F, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xF0, 0x08, 0x18, 0x18, 0x24, 0x24, 0x24, 0x42, 0x42,
  0x42, 0x81, 0xFF, 0xC0, 0x84, 0x22, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x7F, 0x60, 0x50, 0x18, 0x06, 0x01, 0x80, 0xD0, 0x53,
  0xE4, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xE2, 0x86, 0xC0,
  0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0B, 0x86, 0x9E, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x60, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x05, 0x01, 0x40, 0x48, 0x21, 0xF0, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xFA, 0x83, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x33, 0xE8, 0x1F,
  0x08, 0x24, 0x05, 0x01, 0x80, 0x60, 0x1F, 0xFE, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x11, 0xF8, 0x0E, 0x20, 0x81, 0x02, 0x04, 0x3F,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x00, 0x3E, 0xA0, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0A, 0x0C, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x28, 0x23,
  0xE0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0x42, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x87, 0xFF, 0xF0, 0x10, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x1E, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x02, 0x82, 0x42, 0x22, 0x12, 0x0A, 0x06, 0x82, 0x21, 0x08, 0x84,
  0x41, 0x20, 0x50, 0x28, 0x08, 0xFF, 0xFF, 0xF8, 0x9E, 0x1F, 0x28, 0x48,
  0x2C, 0x0C, 0x0A, 0x03, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06,
  0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80,
  0x80, 0x60, 0x20, 0x18, 0x08, 0x04, 0x9E, 0x50, 0xB0, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x3E,
  0x10, 0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x90, 0x43, 0xE0, 0x9E, 0x28, 0x6C, 0x0A, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xB8, 0x69,
  0xE2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x3E, 0xA0, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A,
  0x0C, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x9E, 0x8C, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3F, 0x10, 0x24,
  0x09, 0x00, 0x40, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x01,
  0x40, 0x50, 0x23, 0xF0, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x0C, 0xFA,
  0x80, 0x60, 0x18, 0x09, 0x02, 0x40, 0x90, 0x42, 0x10, 0x84, 0x21, 0x04,
  0x81, 0x20, 0x48, 0x0C, 0x03, 0x00, 0x80, 0x80, 0x81, 0x81, 0x81, 0x41,
  0x81, 0x41, 0x42, 0x42, 0x42, 0x42, 0x42, 0x22, 0x42, 0x22, 0x24, 0x24,
  0x24, 0x24, 0x24, 0x14, 0x24, 0x14, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x08, 0x80, 0x50, 0x22, 0x10, 0x84, 0x12, 0x04, 0x80, 0xC0, 0x20, 0x0C,
  0x04, 0x82, 0x20, 0x84, 0x40, 0x90, 0x28, 0x04, 0x80, 0x60, 0x18, 0x05,
  0x02, 0x40, 0x90, 0x22, 0x10, 0x84, 0x21, 0x04, 0x81, 0x20, 0x48, 0x0C,
  0x03, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x00, 0x7F,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x0F, 0xFC, 0x06, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x18, 0x18, 0x10, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x10, 0x30, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x80, 0xC3, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x86, 0x00, 0x38,
  0x0A, 0x20, 0x60, 0x85, 0x02, 0x28, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_Thin28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 20, 5, 2, -20 },
  { 4, 4, 6, 7, 2, -21 },
  { 7, 13, 20, 14, 1, -20 },
  { 40, 10, 26, 14, 2, -23 },
  { 73, 15, 20, 18, 2, -20 },
  { 111, 12, 20, 15, 2, -20 },
  { 141, 1, 6, 5, 2, -21 },
  { 142, 5, 28, 8, 2, -22 },
  { 160, 5, 28, 8, 1, -22 },
  { 178, 11, 11, 12, 0, -20 },
  { 194, 12, 15, 14, 1, -17 },
  { 217, 2, 6, 5, 1, -2 },
  { 219, 5, 1, 8, 1, -10 },
  { 220, 2, 1, 6, 2, -1 },
  { 221, 8, 22, 10, 1, -20 },
  { 243, 10, 20, 14, 2, -20 },
  { 268, 6, 20, 14, 2, -20 },
  { 283, 10, 20, 14, 2, -20 },
  { 308, 11, 20, 14, 1, -20 },
  { 336, 12, 20, 14, 1, -20 },
  { 366, 10, 20, 14, 2, -20 },
  { 391, 10, 20, 14, 2, -20 },
  { 416, 11, 20, 14, 1, -20 },
  { 444, 11, 20, 14, 1, -20 },
  { 472, 11, 20, 14, 1, -20 },
  { 500, 1, 14, 5, 2, -14 },
  { 502, 2, 18, 5, 1, -14 },
  { 507, 10, 11, 13, 1, -15 },
  { 521, 10, 7, 14, 2, -13 },
  { 530, 9, 11, 13, 2, -15 },
  { 543, 9, 20, 11, 1, -20 },
  { 566, 19, 25, 23, 2, -19 },
  { 626, 13, 20, 15, 1, -20 },
  { 659, 10, 20, 15, 3, -20 },
  { 684, 12, 20, 16, 2, -20 },
  { 714, 11, 20, 16, 3, -20 },
  { 742, 10, 20, 14, 3, -20 },
  { 767, 10, 20, 14, 3, -20 },
  { 792, 12, 20, 17, 2, -20 },
  { 822, 12, 20, 17, 3, -20 },
  { 852, 1, 20, 7, 3, -20 },
  { 855, 10, 20, 14, 1, -20 },
  { 880, 12, 20, 16, 3, -20 },
  { 910, 9, 20, 13, 3, -20 },
  { 933, 15, 20, 21, 3, -20 },
  { 971, 12, 20, 17, 3, -20 },
  { 1001, 12, 20, 16, 2, -20 },
  { 1031, 10, 20, 15, 3, -20 },
  { 1056, 12, 24, 16, 2, -20 },
  { 1092, 12, 20, 16, 2, -20 },
  { 1122, 12, 20, 15, 1, -20 },
  { 1152, 13, 20, 15, 1, -20 },
  { 1185, 12, 20, 16, 2, -20 },
  { 1215, 13, 20, 15, 1, -20 },
  { 1248, 20, 20, 22, 1, -20 },
  { 1298, 13, 20, 15, 1, -20 },
  { 1331, 13, 20, 15, 1, -20 },
  { 1364, 12, 20, 15, 1, -20 },
  { 1394, 4, 27, 6, 2, -23 },
  { 1408, 8, 22, 10, 1, -20 },
  { 1430, 4, 27, 6, 0, -23 },
  { 1444, 8, 10, 10, 1, -20 },
  { 1454, 10, 1, 10, 0, 0 },
  { 1456, 4, 4, 7, 2, -21 },
  { 1458, 10, 15, 13, 1, -15 },
  { 1477, 10, 21, 14, 2, -21 },
  { 1504, 10, 15, 13, 1, -15 },
  { 1523, 9, 21, 14, 2, -21 },
  { 1547, 10, 15, 13, 1, -15 },
  { 1566, 7, 21, 8, 1, -21 },
  { 1585, 9, 21, 14, 2, -15 },
  { 1609, 9, 21, 14, 2, -21 },
  { 1633, 1, 20, 5, 2, -20 },
  { 1636, 4, 26, 6, -1, -20 },
  { 1649, 9, 21, 12, 2, -21 },
  { 1673, 1, 21, 5, 2, -21 },
  { 1676, 18, 15, 22, 2, -15 },
  { 1710, 9, 15, 14, 2, -15 },
  { 1727, 10, 15, 14, 2, -15 },
  { 1746, 10, 21, 14, 2, -15 },
  { 1773, 9, 21, 14, 2, -15 },
  { 1797, 6, 15, 8, 2, -15 },
  { 1809, 10, 15, 12, 1, -15 },
  { 1828, 6, 19, 8, 1, -19 },
  { 1843, 9, 15, 14, 2, -15 },
  { 1860, 10, 15, 12, 1, -15 },
  { 1879, 16, 15, 19, 1, -15 },
  { 1909, 10, 15, 12, 1, -15 },
  { 1928, 10, 21, 12, 1, -15 },
  { 1955, 10, 15, 12, 1, -15 },
  { 1974, 7, 28, 8, 1, -22 },
  { 1999, 1, 24, 6, 2, -20 },
  { 2002, 7, 28, 8, 0, -22 },
  { 2027, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_Thin28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_THIN28PT7B_H_
