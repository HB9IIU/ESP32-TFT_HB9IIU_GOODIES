#ifndef _ROBOTOCONDENSED_THIN69PT7B_H_
#define _ROBOTOCONDENSED_THIN69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin69pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xE8, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x01, 0x80, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x80, 0x08, 0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0x70, 0x03, 0x00, 0x1C, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x02,
  0x00, 0x30, 0x06, 0x00, 0x10, 0x01, 0x80, 0x30, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x06, 0x00, 0x18, 0x00, 0x40, 0x30, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x02, 0x00, 0x30, 0x18, 0x00, 0x18, 0x03, 0x01, 0x80,
  0x00, 0xE0, 0x18, 0x0C, 0x00, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x0F, 0xF8,
  0x06, 0x00, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xF0, 0x00,
  0x00, 0xC0, 0x3F, 0xE0, 0x00, 0x06, 0x03, 0x03, 0x80, 0x00, 0x60, 0x30,
  0x0C, 0x00, 0x03, 0x01, 0x00, 0x30, 0x00, 0x30, 0x18, 0x00, 0x80, 0x01,
  0x80, 0xC0, 0x06, 0x00, 0x18, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x20, 0x06, 0x00, 0x18, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x10, 0x00, 0x80, 0x06, 0x01, 0x80, 0x04, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x04, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xE0,
  0x03, 0x0C, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0C, 0x60, 0x00, 0xC0,
  0x18, 0xC0, 0x01, 0xC0, 0x33, 0x00, 0x01, 0x80, 0x66, 0x00, 0x01, 0x80,
  0xCC, 0x00, 0x01, 0x83, 0x18, 0x00, 0x03, 0x86, 0x30, 0x00, 0x03, 0x0C,
  0x60, 0x00, 0x03, 0x30, 0xC0, 0x00, 0x03, 0x61, 0x80, 0x00, 0x07, 0x83,
  0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x36, 0x06,
  0x00, 0x00, 0xCE, 0x0E, 0x00, 0x03, 0x0C, 0x0E, 0x00, 0x1C, 0x0C, 0x07,
  0x80, 0xF0, 0x0C, 0x07, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xA0, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0xE0, 0x18, 0x0F, 0x9F,
  0x03, 0x0F, 0x80, 0x7C, 0x67, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0xC0, 0x10, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x39, 0x8C, 0xCE, 0x20, 0xFF, 0xFF, 0xFF,
  0xF0, 0x6F, 0xF6, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x04, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x60,
  0x0E, 0x00, 0x60, 0x03, 0xC0, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1E, 0xC1, 0xE3, 0x1E, 0x0F, 0xE0, 0x3C,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x30, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x70, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x70, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0xFE, 0x00, 0x63, 0xFF, 0xC0,
  0x6E, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x70, 0x00, 0x38, 0x20, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02,
  0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x80, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x0F, 0xE0, 0x06, 0x0F, 0xFE, 0x01, 0x0F, 0x01, 0xE0, 0x47,
  0x00, 0x1C, 0x13, 0x00, 0x03, 0x8D, 0x80, 0x00, 0x63, 0x40, 0x00, 0x0C,
  0xF0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x00,
  0x70, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x1C, 0x00,
  0x0C, 0x01, 0xC0, 0x03, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x30, 0x00, 0x07, 0x07, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x90,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x40, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0xD8, 0x00, 0x01, 0xE6, 0x00, 0x00, 0xB3, 0x80, 0x00, 0xD8, 0xC0,
  0x00, 0xCC, 0x30, 0x00, 0xC6, 0x0E, 0x01, 0xC3, 0x03, 0xFF, 0x81, 0x80,
  0x7F, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF6, 0x33,
  0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x18, 0xC6, 0x31, 0x98, 0xC6,
  0x73, 0x31, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xF8, 0x03, 0xC0, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x06, 0x18, 0x00,
  0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x00, 0xB0,
  0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x7E, 0x00, 0x02, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x06, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x07, 0x00, 0x18, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x11, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x33, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x66, 0x00, 0x18, 0x00, 0x30, 0x00, 0xD8, 0x00, 0x60, 0x00,
  0x40, 0x01, 0xB0, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x60, 0x01, 0x80, 0x01,
  0x00, 0x06, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x0D, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x1A, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x78, 0x00, 0x40, 0x00, 0x60, 0x00, 0xF0, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x07, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x1E, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x58, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xB0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x20, 0x03, 0x00, 0x03, 0x00, 0x06, 0x40, 0x06, 0x00, 0x0E, 0x00, 0x08,
  0xC0, 0x04, 0x00, 0x1C, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x6C, 0x00, 0x63,
  0x00, 0x18, 0x00, 0xD8, 0x01, 0x86, 0x00, 0x30, 0x03, 0x10, 0x06, 0x06,
  0x00, 0x30, 0x0C, 0x30, 0x1C, 0x0C, 0x00, 0x30, 0x70, 0x30, 0x70, 0x18,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x04, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x30,
  0x00, 0x1E, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x07,
  0x83, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x01, 0xF0,
  0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x30, 0xD8, 0x00, 0x00, 0xC6, 0x30, 0x00, 0x03, 0x38, 0xE0,
  0x00, 0x0C, 0xC1, 0x80, 0x00, 0x36, 0x03, 0x00, 0x00, 0xF0, 0x06, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x00,
  0x01, 0xFB, 0x00, 0x00, 0x00, 0x02, 0xF6, 0x00, 0x00, 0x00, 0x0D, 0xE6,
  0x00, 0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00, 0x00, 0x27, 0x98, 0x00, 0x00,
  0x00, 0xCF, 0x18, 0x00, 0x00, 0x01, 0x9E, 0x30, 0x00, 0x00, 0x06, 0x3C,
  0x20, 0x00, 0x00, 0x0C, 0x78, 0x60, 0x00, 0x00, 0x10, 0xF0, 0xC0, 0x00,
  0x00, 0x61, 0xE0, 0x80, 0x00, 0x00, 0xC3, 0xC1, 0x80, 0x00, 0x01, 0x07,
  0x83, 0x00, 0x00, 0x06, 0x0F, 0x03, 0x00, 0x00, 0x0C, 0x1E, 0x06, 0x00,
  0x00, 0x30, 0x3C, 0x04, 0x00, 0x00, 0x60, 0x78, 0x0C, 0x00, 0x00, 0xC0,
  0xF0, 0x18, 0x00, 0x03, 0x01, 0xE0, 0x10, 0x00, 0x06, 0x03, 0xC0, 0x30,
  0x00, 0x08, 0x07, 0x80, 0x60, 0x00, 0x30, 0x0F, 0x00, 0x60, 0x00, 0x60,
  0x1E, 0x00, 0xC0, 0x00, 0x80, 0x3C, 0x01, 0x80, 0x03, 0x00, 0x78, 0x01,
  0x80, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x01, 0xE0, 0x02, 0x00, 0x30,
  0x03, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x80, 0x0C, 0x01, 0x80, 0x0F, 0x00,
  0x08, 0x03, 0x00, 0x1E, 0x00, 0x18, 0x04, 0x00, 0x3C, 0x00, 0x30, 0x18,
  0x00, 0x78, 0x00, 0x30, 0x30, 0x00, 0xF0, 0x00, 0x60, 0xC0, 0x01, 0xE0,
  0x00, 0x41, 0x80, 0x03, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x80, 0x01, 0x8C,
  0x00, 0x0F, 0x00, 0x01, 0x18, 0x00, 0x1E, 0x00, 0x03, 0x20, 0x00, 0x3C,
  0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x60,
  0x07, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x18, 0x00,
  0x07, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x10, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x21, 0x80,
  0x00, 0x20, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x08,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x04, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x20, 0x06, 0x00,
  0x18, 0x02, 0x00, 0x18, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x80, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x30, 0x20, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x06, 0x40, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0xFF, 0xFF, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x58, 0x00, 0x1B, 0x00,
  0x03, 0x20, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x08, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x03, 0x02, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x80,
  0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x08, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x02, 0xC0, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0x80, 0xF0, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0x80, 0x03, 0x1C, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x40,
  0x00, 0x07, 0x60, 0x00, 0x0F, 0x60, 0x00, 0x1B, 0x30, 0x00, 0x33, 0x38,
  0x00, 0xE3, 0x1E, 0x03, 0xC3, 0x07, 0xFF, 0x03, 0x01, 0xF8, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3E, 0x00, 0xC1,
  0xFF, 0xC0, 0xC7, 0x80, 0xF0, 0xCE, 0x00, 0x38, 0xDC, 0x00, 0x18, 0xD8,
  0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xD8,
  0x00, 0x18, 0xCC, 0x00, 0x38, 0xC7, 0x80, 0xE0, 0xC1, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x3C, 0x01,
  0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x18, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x03, 0x80, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x7C,
  0x03, 0x03, 0xFF, 0x83, 0x07, 0x00, 0xE3, 0x0C, 0x00, 0x33, 0x18, 0x00,
  0x1B, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x03, 0x30, 0x00, 0x07, 0x38, 0x00,
  0x0F, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x33, 0x07, 0x00, 0xE3, 0x03, 0xFF,
  0xC3, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x01, 0x81, 0xC0, 0x03, 0x80, 0x78, 0x07, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x83, 0x07, 0x00, 0xE3, 0x0C, 0x00, 0x33, 0x18, 0x00, 0x1B, 0x30,
  0x00, 0x0F, 0x30, 0x00, 0x0F, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x07, 0x30, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x18,
  0x00, 0x1B, 0x0C, 0x00, 0x33, 0x07, 0x00, 0xE3, 0x03, 0xFF, 0xC3, 0x00,
  0x7E, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x70, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x0F, 0x80, 0xC0, 0xFF, 0xC1, 0x83, 0x81, 0xE3, 0x0C, 0x00, 0xE6,
  0x30, 0x00, 0xCC, 0xC0, 0x00, 0xDB, 0x00, 0x01, 0xB6, 0x00, 0x03, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x5F,
  0xB0, 0x00, 0x00, 0x00, 0x1B, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x60, 0x0E, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0xFE, 0x0F, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x01,
  0xC6, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x60, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x30, 0xE0, 0x00, 0x61,
  0x80, 0x00, 0xC7, 0x80, 0x01, 0x9B, 0x80, 0x03, 0x63, 0x00, 0x07, 0x83,
  0x00, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x0C, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0xC3, 0xC0, 0xE0, 0x1C, 0x07, 0x0C, 0x70, 0x03, 0x03, 0x00, 0x18, 0xCE,
  0x00, 0x18, 0x60, 0x00, 0xCC, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xD8, 0x00,
  0x0D, 0x80, 0x00, 0x6D, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x70, 0x00, 0x02, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0x01, 0x81, 0xFF, 0x83, 0x07, 0x03, 0xC6, 0x18, 0x01,
  0xCC, 0x60, 0x01, 0x99, 0x80, 0x01, 0xB6, 0x00, 0x03, 0x6C, 0x00, 0x06,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x13, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0x80, 0xF0, 0xCE, 0x00, 0x38, 0xD8,
  0x00, 0x18, 0xD8, 0x00, 0x0C, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xF0,
  0x00, 0x0C, 0xD8, 0x00, 0x18, 0xCE, 0x00, 0x38, 0xC7, 0x80, 0xE0, 0xC1,
  0xFF, 0xC0, 0xC0, 0x3E, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x83, 0x07, 0x01, 0xE3, 0x0C, 0x00, 0x73, 0x18, 0x00, 0x1B, 0x38,
  0x00, 0x0F, 0x30, 0x00, 0x0F, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x03, 0x30, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x18,
  0x00, 0x1B, 0x0C, 0x00, 0x3B, 0x07, 0x00, 0xE3, 0x03, 0xFF, 0xC3, 0x00,
  0x7C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x3F, 0x07, 0xFC, 0x38, 0x31, 0x80,
  0xCC, 0x03, 0x20, 0x0D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x01, 0xE0, 0x1C, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x31,
  0x80, 0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x60, 0x00, 0x19, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x07, 0x80,
  0x78, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x0F, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0x98, 0x00, 0x0F, 0x38, 0x00, 0x36, 0x38,
  0x00, 0xCC, 0x3C, 0x0F, 0x18, 0x3F, 0xF8, 0x30, 0x0F, 0x80, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x20, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0D, 0x80, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0x40, 0x00, 0x66,
  0x00, 0x02, 0xC0, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x01, 0x8C, 0x00, 0x1B,
  0x00, 0x03, 0x18, 0x00, 0x33, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0x60, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x03, 0x18, 0x00, 0x60, 0xC0, 0x04,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x06,
  0x03, 0x00, 0x60, 0x40, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x08, 0x03, 0x01,
  0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0xC0,
  0xC0, 0x08, 0x18, 0x00, 0xC1, 0x00, 0x18, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x43, 0x00, 0x06,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01, 0x88, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00,
  0x78, 0x00, 0x0D, 0x00, 0x00, 0xF0, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x83, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x98, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01,
  0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0xE0, 0x70, 0x00, 0x19,
  0x80, 0x70, 0x00, 0x36, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x30, 0x00, 0xD0,
  0x00, 0x70, 0x03, 0x60, 0x00, 0x30, 0x06, 0xC0, 0x00, 0x30, 0x39, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Thin69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 50, 13, 5, -49 },
  { 20, 9, 14, 18, 5, -52 },
  { 36, 32, 49, 34, 2, -49 },
  { 232, 25, 63, 33, 4, -56 },
  { 429, 37, 51, 45, 4, -50 },
  { 665, 31, 51, 37, 4, -50 },
  { 863, 2, 14, 11, 5, -52 },
  { 867, 12, 71, 19, 5, -55 },
  { 974, 13, 71, 19, 1, -55 },
  { 1090, 27, 27, 29, 1, -49 },
  { 1182, 28, 36, 34, 3, -41 },
  { 1308, 5, 14, 13, 3, -5 },
  { 1317, 14, 2, 19, 2, -24 },
  { 1321, 4, 4, 15, 5, -3 },
  { 1323, 19, 53, 24, 2, -49 },
  { 1449, 25, 51, 33, 4, -50 },
  { 1609, 14, 49, 33, 6, -49 },
  { 1695, 26, 50, 33, 4, -50 },
  { 1858, 25, 51, 33, 4, -50 },
  { 2018, 29, 49, 33, 3, -49 },
  { 2196, 24, 50, 33, 6, -49 },
  { 2346, 26, 50, 33, 4, -49 },
  { 2509, 27, 49, 33, 3, -49 },
  { 2675, 27, 51, 33, 3, -50 },
  { 2848, 25, 50, 33, 4, -50 },
  { 3005, 4, 36, 12, 4, -35 },
  { 3023, 5, 44, 12, 3, -35 },
  { 3051, 24, 27, 31, 3, -36 },
  { 3132, 24, 16, 34, 5, -30 },
  { 3180, 24, 27, 31, 4, -36 },
  { 3261, 21, 51, 27, 3, -50 },
  { 3395, 47, 63, 56, 4, -48 },
  { 3766, 33, 49, 36, 2, -49 },
  { 3969, 27, 49, 37, 6, -49 },
  { 4135, 30, 51, 39, 5, -50 },
  { 4327, 29, 49, 40, 6, -49 },
  { 4505, 26, 49, 35, 6, -49 },
  { 4665, 26, 49, 35, 6, -49 },
  { 4825, 30, 51, 41, 6, -50 },
  { 5017, 30, 49, 42, 6, -49 },
  { 5201, 2, 49, 17, 7, -49 },
  { 5214, 24, 50, 33, 3, -49 },
  { 5364, 30, 49, 38, 6, -49 },
  { 5548, 23, 49, 32, 6, -49 },
  { 5689, 39, 49, 52, 6, -49 },
  { 5928, 30, 49, 43, 6, -49 },
  { 6112, 31, 51, 40, 5, -50 },
  { 6310, 27, 49, 37, 6, -49 },
  { 6476, 31, 59, 40, 5, -50 },
  { 6705, 29, 49, 39, 6, -49 },
  { 6883, 30, 51, 36, 3, -50 },
  { 7075, 32, 49, 36, 2, -49 },
  { 7271, 28, 50, 40, 6, -49 },
  { 7446, 33, 49, 36, 2, -49 },
  { 7649, 50, 49, 54, 2, -49 },
  { 7956, 32, 49, 36, 2, -49 },
  { 8152, 33, 49, 36, 2, -49 },
  { 8355, 30, 49, 36, 3, -49 },
  { 8539, 8, 67, 14, 6, -56 },
  { 8606, 19, 53, 23, 2, -49 },
  { 8732, 9, 67, 14, 0, -56 },
  { 8808, 19, 25, 26, 3, -49 },
  { 8868, 24, 2, 26, 1, 0 },
  { 8874, 9, 9, 18, 5, -52 },
  { 8885, 24, 38, 32, 3, -37 },
  { 8999, 24, 53, 33, 5, -52 },
  { 9158, 25, 38, 31, 3, -37 },
  { 9277, 24, 53, 33, 4, -52 },
  { 9436, 25, 38, 31, 3, -37 },
  { 9555, 17, 53, 20, 3, -53 },
  { 9668, 24, 51, 33, 4, -37 },
  { 9821, 23, 52, 33, 5, -52 },
  { 9971, 3, 50, 13, 5, -50 },
  { 9990, 12, 64, 14, -3, -50 },
  { 10086, 23, 52, 29, 5, -52 },
  { 10236, 2, 52, 13, 6, -52 },
  { 10249, 44, 37, 54, 5, -37 },
  { 10453, 23, 37, 33, 5, -37 },
  { 10560, 25, 38, 33, 4, -37 },
  { 10679, 24, 51, 33, 5, -37 },
  { 10832, 24, 51, 33, 4, -37 },
  { 10985, 14, 37, 21, 5, -37 },
  { 11050, 22, 38, 30, 4, -37 },
  { 11155, 15, 47, 20, 2, -46 },
  { 11244, 23, 37, 33, 5, -36 },
  { 11351, 25, 36, 29, 2, -36 },
  { 11464, 39, 36, 46, 3, -36 },
  { 11640, 25, 36, 29, 2, -36 },
  { 11753, 26, 50, 29, 2, -36 },
  { 11916, 24, 36, 29, 3, -36 },
  { 12024, 17, 69, 20, 3, -54 },
  { 12171, 2, 58, 14, 6, -49 },
  { 12186, 16, 69, 20, 1, -54 },
  { 12324, 31, 11, 42, 5, -26 },
};

const GFXfont RobotoCondensed_Thin69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_THIN69PT7B_H_
