#ifndef _ROBOTOCONDENSED_THIN17PT7B_H_
#define _ROBOTOCONDENSED_THIN17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB8, 0x00, 0x48, 0x93, 0xE2, 0x44, 0x92, 0x24, 0x7C,
  0x91, 0x20, 0x00, 0x00, 0x07, 0xA1, 0x86, 0x08, 0x18, 0x18, 0x10, 0x61,
  0x85, 0xA1, 0x04, 0x60, 0x48, 0x24, 0x92, 0x89, 0x43, 0x40, 0x2C, 0x29,
  0x14, 0x92, 0x41, 0x20, 0x60, 0x38, 0x48, 0x48, 0x48, 0x50, 0x20, 0x50,
  0x90, 0x8A, 0x86, 0x84, 0x7A, 0xE0, 0x05, 0x29, 0x24, 0x92, 0x48, 0x91,
  0x00, 0x08, 0x92, 0x49, 0x24, 0x92, 0x4A, 0x00, 0x10, 0x22, 0x4B, 0xE1,
  0x05, 0x11, 0x00, 0x00, 0x20, 0x43, 0xE1, 0x02, 0x04, 0x00, 0xE0, 0x40,
  0x80, 0x00, 0x42, 0x21, 0x08, 0x84, 0x22, 0x10, 0x80, 0x00, 0x7A, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x3D, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x7A, 0x18, 0x41, 0x04, 0x20, 0x84, 0x20, 0x84, 0x3E, 0x7A, 0x18,
  0x41, 0x04, 0x60, 0x41, 0x06, 0x18, 0x5E, 0x08, 0x30, 0x61, 0x42, 0x89,
  0x12, 0x44, 0xFC, 0x10, 0x20, 0x00, 0x79, 0x04, 0x10, 0x78, 0x10, 0x41,
  0x06, 0x14, 0x4E, 0x31, 0x04, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x5E,
  0x7C, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x00, 0x7A, 0x18, 0x61,
  0x85, 0xE4, 0x61, 0x86, 0x18, 0x5E, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x5F,
  0x04, 0x10, 0x9C, 0x80, 0x80, 0x80, 0xE0, 0x0C, 0xC4, 0x20, 0x40, 0xC0,
  0xC0, 0x78, 0x07, 0x80, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x74, 0x42,
  0x10, 0x88, 0x84, 0x00, 0x00, 0x40, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x72,
  0x88, 0x19, 0x11, 0x91, 0x19, 0x11, 0x91, 0x19, 0x11, 0x91, 0x28, 0xEC,
  0x80, 0x04, 0x00, 0x20, 0x01, 0xF0, 0x08, 0x0A, 0x05, 0x02, 0x82, 0x41,
  0x10, 0x88, 0x7C, 0x41, 0x20, 0x90, 0x40, 0x00, 0xFA, 0x18, 0x61, 0x87,
  0xE8, 0xA1, 0x86, 0x18, 0x5E, 0x3C, 0x42, 0x81, 0x81, 0x80, 0x80, 0x80,
  0x80, 0x81, 0x81, 0x42, 0x3C, 0x79, 0x0A, 0x14, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0A, 0x13, 0xC0, 0x7A, 0x08, 0x20, 0x83, 0xC8, 0x20, 0x82, 0x08,
  0x1E, 0x7A, 0x08, 0x20, 0x83, 0xC8, 0x20, 0x82, 0x08, 0x00, 0x3E, 0x41,
  0x81, 0x80, 0x80, 0x80, 0x86, 0x81, 0x81, 0x81, 0x41, 0x3E, 0x03, 0x06,
  0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x7F, 0xE0, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x06, 0x18, 0x9C, 0x05, 0x12, 0x24, 0x8A,
  0x18, 0x28, 0x48, 0x91, 0x12, 0x10, 0x10, 0x04, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x20, 0xE0, 0x00, 0xC0, 0x60, 0x70, 0x3C, 0x1E, 0x16, 0x8B, 0x49,
  0x94, 0xCA, 0x66, 0x21, 0x00, 0x81, 0x06, 0x0E, 0x1A, 0x34, 0x64, 0xC5,
  0x8B, 0x0E, 0x18, 0x10, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x42, 0x3C, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x08,
  0x00, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x02, 0x01, 0xF9, 0x0A, 0x14, 0x28, 0x50, 0xBA, 0x48, 0x89, 0x0A,
  0x10, 0x10, 0x7D, 0x06, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x03, 0x06, 0x0B,
  0xE0, 0x7C, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x81, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x00,
  0x20, 0x90, 0x48, 0x22, 0x21, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x06, 0x01,
  0x00, 0x04, 0x18, 0x41, 0x86, 0x28, 0xA2, 0x8A, 0x24, 0x92, 0x51, 0x25,
  0x14, 0x51, 0x45, 0x0C, 0x20, 0x82, 0x08, 0x83, 0x05, 0x11, 0x42, 0x82,
  0x04, 0x14, 0x44, 0x8A, 0x0C, 0x10, 0x81, 0x20, 0x90, 0x84, 0x42, 0x40,
  0xA0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7E, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x40, 0x82, 0x03, 0xE0, 0xAA, 0xAA, 0xAA, 0xAA, 0x80,
  0x08, 0x88, 0x44, 0x42, 0x22, 0x11, 0x00, 0x55, 0x55, 0x55, 0x55, 0x40,
  0x46, 0x69, 0x90, 0x78, 0x90, 0x7A, 0x10, 0x41, 0x76, 0x18, 0x63, 0x74,
  0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0xF8, 0x7A, 0x18,
  0x60, 0x82, 0x08, 0x61, 0x78, 0x04, 0x10, 0x41, 0x7E, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x7C, 0x7A, 0x18, 0x7F, 0x82, 0x08, 0x20, 0x78, 0x24, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C,
  0x10, 0x5E, 0x82, 0x08, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84,
  0x9F, 0xF0, 0x20, 0x12, 0x49, 0x24, 0x92, 0x50, 0x82, 0x08, 0x20, 0x8A,
  0x29, 0x28, 0xE2, 0x49, 0x22, 0x84, 0xFF, 0xF8, 0xB9, 0xD8, 0xC6, 0x10,
  0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x00, 0xBB, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x7E, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x7C, 0x10, 0x41, 0xAC, 0x88, 0x88, 0x88, 0x80, 0x7C, 0x20,
  0x83, 0x04, 0x31, 0x78, 0x02, 0x62, 0x22, 0x22, 0x22, 0x20, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x7C, 0x02, 0x85, 0x12, 0x22, 0x45, 0x0A, 0x08,
  0x10, 0x08, 0xC4, 0x65, 0x32, 0x95, 0x4A, 0x99, 0x8C, 0x46, 0x00, 0x00,
  0x8A, 0x25, 0x08, 0x21, 0x45, 0x22, 0x84, 0x02, 0x85, 0x12, 0x22, 0x45,
  0x0A, 0x08, 0x10, 0x20, 0x41, 0x00, 0x78, 0x21, 0x04, 0x21, 0x04, 0x20,
  0x78, 0x12, 0x44, 0x44, 0x44, 0x80, 0x44, 0x44, 0x42, 0x10, 0xFF, 0xFC,
  0x04, 0x22, 0x22, 0x22, 0x10, 0x22, 0x22, 0x24, 0x80, 0x71, 0x89, 0x86,
};

const GFXglyph RobotoCondensed_Thin17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 3, 1, -12 },
  { 3, 2, 3, 4, 1, -13 },
  { 4, 7, 12, 8, 1, -12 },
  { 15, 6, 16, 8, 1, -14 },
  { 27, 9, 12, 11, 1, -12 },
  { 41, 8, 12, 9, 1, -12 },
  { 53, 1, 3, 3, 1, -13 },
  { 54, 3, 17, 5, 1, -13 },
  { 61, 3, 17, 5, 0, -13 },
  { 68, 7, 7, 7, 0, -12 },
  { 75, 7, 8, 8, 1, -9 },
  { 82, 1, 3, 3, 1, -1 },
  { 83, 3, 1, 5, 1, -6 },
  { 84, 1, 1, 4, 1, -1 },
  { 85, 5, 13, 6, 0, -12 },
  { 94, 6, 12, 8, 1, -12 },
  { 103, 4, 12, 8, 1, -12 },
  { 109, 6, 12, 8, 1, -12 },
  { 118, 6, 12, 8, 1, -12 },
  { 127, 7, 12, 8, 1, -12 },
  { 138, 6, 12, 8, 1, -12 },
  { 147, 6, 12, 8, 1, -12 },
  { 156, 6, 12, 8, 1, -12 },
  { 165, 6, 12, 8, 1, -12 },
  { 174, 6, 12, 8, 1, -12 },
  { 183, 1, 9, 3, 1, -9 },
  { 185, 1, 11, 3, 1, -9 },
  { 187, 6, 7, 8, 1, -9 },
  { 193, 6, 3, 8, 1, -7 },
  { 196, 6, 7, 8, 1, -9 },
  { 202, 5, 12, 7, 1, -12 },
  { 210, 12, 16, 14, 1, -12 },
  { 234, 9, 12, 9, 0, -12 },
  { 248, 6, 12, 9, 2, -12 },
  { 257, 8, 12, 10, 1, -12 },
  { 269, 7, 12, 10, 2, -12 },
  { 280, 6, 12, 9, 2, -12 },
  { 289, 6, 12, 9, 2, -12 },
  { 298, 8, 12, 10, 1, -12 },
  { 310, 7, 12, 10, 2, -12 },
  { 321, 1, 12, 4, 2, -12 },
  { 323, 6, 12, 8, 1, -12 },
  { 332, 7, 12, 9, 2, -12 },
  { 343, 5, 12, 8, 2, -12 },
  { 351, 9, 12, 13, 2, -12 },
  { 365, 7, 12, 11, 2, -12 },
  { 376, 8, 12, 10, 1, -12 },
  { 388, 6, 12, 9, 2, -12 },
  { 397, 8, 14, 10, 1, -12 },
  { 411, 7, 12, 10, 2, -12 },
  { 422, 7, 12, 9, 1, -12 },
  { 433, 7, 12, 9, 1, -12 },
  { 444, 7, 12, 10, 1, -12 },
  { 455, 9, 12, 9, 0, -12 },
  { 469, 12, 12, 13, 1, -12 },
  { 487, 7, 12, 9, 1, -12 },
  { 498, 9, 12, 9, 0, -12 },
  { 512, 7, 12, 9, 1, -12 },
  { 523, 2, 17, 3, 1, -14 },
  { 528, 4, 13, 6, 1, -12 },
  { 535, 2, 17, 3, 0, -14 },
  { 540, 4, 6, 6, 1, -12 },
  { 543, 6, 1, 6, 0, 0 },
  { 544, 2, 2, 5, 1, -13 },
  { 545, 6, 9, 8, 1, -9 },
  { 552, 6, 13, 8, 1, -13 },
  { 562, 6, 9, 8, 1, -9 },
  { 569, 6, 13, 8, 1, -13 },
  { 579, 6, 9, 8, 1, -9 },
  { 586, 4, 13, 5, 1, -13 },
  { 593, 6, 12, 8, 1, -9 },
  { 602, 6, 13, 8, 1, -13 },
  { 612, 1, 12, 3, 1, -12 },
  { 614, 3, 15, 3, -1, -12 },
  { 620, 6, 13, 7, 1, -13 },
  { 630, 1, 13, 3, 1, -13 },
  { 632, 11, 9, 13, 1, -9 },
  { 645, 6, 9, 8, 1, -9 },
  { 652, 6, 9, 8, 1, -9 },
  { 659, 6, 12, 8, 1, -9 },
  { 668, 6, 12, 8, 1, -9 },
  { 677, 4, 9, 5, 1, -9 },
  { 682, 5, 9, 8, 1, -9 },
  { 688, 4, 11, 5, 0, -11 },
  { 694, 6, 9, 8, 1, -9 },
  { 701, 7, 9, 7, 0, -9 },
  { 709, 9, 9, 11, 1, -9 },
  { 720, 6, 9, 7, 1, -9 },
  { 727, 7, 12, 7, 0, -9 },
  { 738, 6, 9, 7, 1, -9 },
  { 745, 4, 17, 5, 1, -13 },
  { 754, 1, 14, 3, 1, -12 },
  { 756, 4, 17, 5, 0, -13 },
  { 765, 8, 3, 10, 1, -7 },
};

const GFXfont RobotoCondensed_Thin17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_THIN17PT7B_H_
