#ifndef _ROBOTOCONDENSED_THIN62PT7B_H_
#define _ROBOTOCONDENSED_THIN62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin62pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x41, 0xA0, 0xD0, 0x68, 0x34, 0x1A,
  0x0D, 0x06, 0x83, 0x41, 0x20, 0x90, 0x58, 0x20, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x60, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x18, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x30, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x18, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x01,
  0xC0, 0x30, 0x03, 0x81, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x19,
  0x80, 0x00, 0x26, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x58, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8E, 0x00, 0x0C,
  0x1C, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x04, 0x01, 0x00, 0x10,
  0x01, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x20, 0x0C, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x10,
  0x01, 0x01, 0x80, 0x04, 0x00, 0x40, 0x60, 0x01, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x0C, 0x0C, 0x00, 0x08, 0x02, 0x06, 0x00, 0x03, 0x01, 0x81, 0x00,
  0x00, 0x71, 0xC0, 0xC0, 0x00, 0x0F, 0xE0, 0x20, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x30, 0x38, 0x60, 0x00,
  0x0C, 0x08, 0x0C, 0x00, 0x06, 0x06, 0x01, 0x80, 0x01, 0x81, 0x00, 0x20,
  0x00, 0xC0, 0xC0, 0x08, 0x00, 0x20, 0x30, 0x03, 0x00, 0x18, 0x08, 0x00,
  0xC0, 0x04, 0x02, 0x00, 0x30, 0x03, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x20,
  0x03, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x0C, 0x06, 0x00, 0x30, 0x02, 0x00, 0x80, 0x04, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x10, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x30, 0x03, 0x10, 0x06, 0x00, 0x66, 0x00, 0x60, 0x0C, 0x80, 0x06,
  0x01, 0xB0, 0x00, 0x60, 0x36, 0x00, 0x0C, 0x04, 0x80, 0x00, 0xC1, 0x90,
  0x00, 0x0C, 0x32, 0x00, 0x00, 0x84, 0x40, 0x00, 0x19, 0x88, 0x00, 0x01,
  0xB1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x1B, 0x0E, 0x00, 0x06, 0x30, 0xE0, 0x03, 0x83, 0x0F, 0x00, 0xE0,
  0x60, 0x7F, 0xF0, 0x06, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x40,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x18,
  0x03, 0xF8, 0x18, 0x1E, 0x1E, 0x18, 0x78, 0x03, 0xDB, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x43,
  0x00, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x33, 0x33, 0x33, 0x33, 0x66, 0xC8, 0xFF, 0xFF, 0xFF,
  0x27, 0x70, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x70, 0x38, 0x03, 0x80, 0x70, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x83, 0x00, 0x03, 0x08, 0x00, 0x04, 0x60, 0x00, 0x19, 0x80, 0x00, 0x64,
  0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x62, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xF6, 0x1E, 0x33, 0x81, 0xF0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0x0E, 0x00,
  0xE0, 0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x20,
  0x00, 0x08, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00, 0x00, 0x64, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0E, 0x07, 0x80, 0x30, 0x03,
  0x80, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x20, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x38, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x08, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0x20, 0x00, 0x08, 0x08, 0x00,
  0x06, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x08,
  0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x20, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x20, 0x06,
  0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x20,
  0x18, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x1F, 0xFF, 0xFC, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x21, 0xFC, 0x00,
  0x9F, 0xFC, 0x02, 0xC0, 0x1C, 0x0C, 0x00, 0x38, 0x60, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x80, 0x70, 0x3C, 0x00,
  0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x3F, 0x00, 0xC3, 0xFF, 0x81, 0x8E, 0x01, 0x83, 0x30, 0x01, 0x86,
  0xC0, 0x01, 0x8F, 0x00, 0x01, 0x94, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x1C, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x81, 0xE0,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0x81, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x07, 0x81, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFE, 0x00, 0x0E, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x07, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x00, 0x00, 0x12, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x98, 0x00, 0x07, 0x30, 0x00, 0x1E, 0x30, 0x00, 0x6C,
  0x30, 0x01, 0x98, 0x30, 0x0E, 0x30, 0x3F, 0xF0, 0x60, 0x1F, 0x80, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x5F, 0xA0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xBF, 0x00, 0x11, 0xCE, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x31, 0x8C, 0x63, 0x18, 0xC4, 0x63, 0x31, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x01,
  0xFF, 0x00, 0xE0, 0xE0, 0x60, 0x0C, 0x30, 0x01, 0x98, 0x00, 0x64, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x41, 0x00, 0x03, 0xFE, 0x00, 0x18,
  0xC0, 0x01, 0x80, 0xC0, 0x06, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x88, 0x00,
  0x60, 0x06, 0x00, 0x26, 0x00, 0x30, 0x01, 0x80, 0x0D, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x40, 0x06, 0x00, 0x18, 0x00, 0xD0, 0x01, 0x80, 0x06, 0x00,
  0x3C, 0x00, 0x40, 0x01, 0x80, 0x0F, 0x00, 0x30, 0x00, 0x60, 0x03, 0xC0,
  0x0C, 0x00, 0x18, 0x00, 0xF0, 0x03, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x80,
  0x01, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x40, 0x03, 0x80, 0x18, 0x00, 0x10,
  0x00, 0xE0, 0x06, 0x00, 0x04, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x30, 0x00, 0xB0, 0x06,
  0x00, 0x0C, 0x00, 0x2C, 0x01, 0x80, 0x03, 0x00, 0x1B, 0x00, 0x60, 0x01,
  0xC0, 0x06, 0xC0, 0x08, 0x00, 0x70, 0x01, 0x30, 0x02, 0x00, 0x1C, 0x00,
  0xCC, 0x00, 0xC0, 0x0D, 0x00, 0x21, 0x00, 0x30, 0x06, 0x40, 0x18, 0x60,
  0x06, 0x03, 0x18, 0x0C, 0x18, 0x00, 0xC1, 0x83, 0x06, 0x06, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x30, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x80, 0x01, 0xC0, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80,
  0x00, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0xE0, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x38, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0xF0,
  0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x20, 0x00, 0x78, 0x10,
  0x00, 0x0E, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0x62, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x31, 0x00, 0x00, 0x30, 0x80, 0x00, 0x70, 0x40, 0x00,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC8, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x19, 0x00, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x60, 0x07, 0x00, 0xF0, 0x78, 0x00, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x03, 0x20, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x02,
  0x00, 0x03, 0x80, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x08, 0x00, 0x30,
  0x02, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x08, 0x01,
  0x80, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x20, 0x30, 0x00, 0x08,
  0x18, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x87, 0x80, 0x00, 0x21, 0xB0, 0x00,
  0x08, 0xCC, 0x00, 0x02, 0x61, 0x80, 0x00, 0xB0, 0x30, 0x00, 0x38, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x20,
  0x00, 0xC0, 0x08, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0,
  0x20, 0x00, 0x30, 0x08, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xD0, 0x00, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x00, 0x17,
  0x60, 0x00, 0x00, 0x06, 0xE4, 0x00, 0x00, 0x00, 0xDC, 0xC0, 0x00, 0x00,
  0x13, 0x98, 0x00, 0x00, 0x06, 0x71, 0x00, 0x00, 0x00, 0x8E, 0x30, 0x00,
  0x00, 0x31, 0xC2, 0x00, 0x00, 0x06, 0x38, 0x40, 0x00, 0x00, 0x87, 0x0C,
  0x00, 0x00, 0x30, 0xE0, 0x80, 0x00, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x83,
  0x83, 0x00, 0x00, 0x30, 0x70, 0x20, 0x00, 0x06, 0x0E, 0x06, 0x00, 0x00,
  0x81, 0xC0, 0xC0, 0x00, 0x30, 0x38, 0x08, 0x00, 0x04, 0x07, 0x01, 0x80,
  0x01, 0x80, 0xE0, 0x10, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x04, 0x03, 0x80,
  0x60, 0x01, 0x80, 0x70, 0x04, 0x00, 0x30, 0x0E, 0x00, 0xC0, 0x04, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x01, 0x00, 0x20, 0x07, 0x00, 0x30, 0x0C,
  0x00, 0xE0, 0x02, 0x01, 0x80, 0x1C, 0x00, 0x40, 0x20, 0x03, 0x80, 0x0C,
  0x0C, 0x00, 0x70, 0x00, 0x81, 0x80, 0x0E, 0x00, 0x18, 0x20, 0x01, 0xC0,
  0x03, 0x0C, 0x00, 0x38, 0x00, 0x21, 0x80, 0x07, 0x00, 0x06, 0x20, 0x00,
  0xE0, 0x00, 0xCC, 0x00, 0x1C, 0x00, 0x09, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xD0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x0E, 0x08, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x02, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x70, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x01,
  0x80, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x00, 0x1C, 0x00, 0x30, 0x03,
  0x80, 0x03, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x40, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x21, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x08, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x38, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x38, 0x80, 0x00, 0x70, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x1C, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x20, 0x00, 0x3C, 0x10, 0x00, 0x07, 0x08, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x40,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02,
  0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x90, 0x00, 0x01, 0x88, 0x00, 0x01,
  0x84, 0x00, 0x01, 0xC2, 0x00, 0x01, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x40, 0x10, 0x00, 0x30, 0x08, 0x00,
  0x08, 0x04, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x18, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03, 0x08,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x62, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0x38,
  0x00, 0x38, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x07, 0x00, 0x7C, 0x07,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x10, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x02, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x08, 0x00, 0x60, 0x00, 0x30,
  0x01, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x10, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x90, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0A, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x30, 0x00, 0x06,
  0xC0, 0x00, 0x10, 0x80, 0x00, 0x22, 0x00, 0x01, 0x86, 0x00, 0x01, 0x10,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x80, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00,
  0x02, 0x04, 0x00, 0x04, 0x10, 0x00, 0x30, 0x20, 0x00, 0x20, 0x80, 0x01,
  0x81, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60,
  0x60, 0x00, 0x80, 0x80, 0x02, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x10, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x02, 0x00,
  0x60, 0x08, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x40, 0x02, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x03, 0x01,
  0x80, 0x06, 0x06, 0x00, 0x08, 0x08, 0x00, 0x10, 0x30, 0x00, 0x60, 0xC0,
  0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x06, 0x08, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x03, 0x08, 0x00, 0x04,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x98,
  0x00, 0x02, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x26, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xA0, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x78, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x20, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x68, 0x00, 0x26, 0x00, 0x13, 0x00,
  0x18, 0x80, 0x08, 0x60, 0x04, 0x30, 0x06, 0x08, 0x02, 0x06, 0x01, 0x03,
  0x01, 0x80, 0x80, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x08, 0x20, 0x06, 0x30,
  0x03, 0x18, 0x00, 0x88, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x3C, 0x07, 0x00, 0x18, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x18, 0x00, 0x06, 0x40, 0x00,
  0x19, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xE0, 0x01, 0x8E, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0x00, 0x01, 0xE6, 0x00,
  0x0D, 0x8C, 0x00, 0xE6, 0x1C, 0x0F, 0x08, 0x3F, 0xF0, 0x30, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x0F, 0xFC, 0x11, 0xC0, 0x70, 0x98, 0x00, 0xC5, 0x80, 0x03,
  0x28, 0x00, 0x09, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x0A, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xB8, 0x00, 0x19, 0x60, 0x00, 0xC9, 0x80, 0x0C, 0x47,
  0x01, 0xC2, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC,
  0x00, 0x70, 0x3C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC2,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x09, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x02,
  0x20, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x03, 0x00, 0x18, 0x07,
  0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x1F, 0xF8, 0x21,
  0xC0, 0xF1, 0x18, 0x01, 0xC9, 0x80, 0x02, 0x48, 0x00, 0x0A, 0xC0, 0x00,
  0x76, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x28, 0x00, 0x01, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xC8, 0x00,
  0x0E, 0x60, 0x00, 0xD1, 0x80, 0x0C, 0x87, 0x01, 0xC4, 0x0F, 0xF8, 0x20,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x78, 0x3C, 0x03, 0x00,
  0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x98, 0x00, 0x02,
  0x60, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x01, 0x83, 0x80, 0x0C, 0x07, 0x80, 0xE0, 0x07, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC3, 0x81, 0xE6, 0x30,
  0x03, 0xB3, 0x00, 0x05, 0x90, 0x00, 0x3D, 0x80, 0x00, 0xE8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0,
  0x00, 0x06, 0x80, 0x00, 0x36, 0x00, 0x01, 0x90, 0x00, 0x1C, 0xC0, 0x01,
  0xE3, 0x00, 0x1B, 0x0E, 0x03, 0x98, 0x1F, 0xF0, 0xC0, 0x18, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x11, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0xC0,
  0x1C, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0xC1, 0xFF, 0x0C, 0x30, 0x38, 0xC6,
  0x00, 0xCC, 0xC0, 0x06, 0xD8, 0x00, 0x6F, 0x00, 0x02, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x10, 0xDF, 0x00, 0x00, 0x00, 0x0D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0xC0,
  0x1C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x18, 0xFE, 0x1F, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01,
  0x8C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC3,
  0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0D, 0xB0, 0x00, 0xF1, 0x00, 0x0E,
  0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x06, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0xFE, 0x00,
  0xFF, 0x82, 0x1C, 0x0E, 0x03, 0x81, 0xC4, 0x60, 0x06, 0x1C, 0x01, 0x89,
  0x80, 0x04, 0x30, 0x01, 0x92, 0x00, 0x0C, 0xC0, 0x01, 0xAC, 0x00, 0x0B,
  0x00, 0x03, 0x50, 0x00, 0x1C, 0x00, 0x02, 0xE0, 0x00, 0x38, 0x00, 0x05,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x10, 0x0C, 0x1F, 0xF0, 0xC3, 0x03, 0x8C, 0x60, 0x0C,
  0xCC, 0x00, 0x6D, 0x80, 0x06, 0xF0, 0x00, 0x2E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x38, 0x07,
  0x00, 0x38, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x38, 0x07, 0x03, 0x80, 0x0F, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x1F, 0xF8, 0x23, 0x80, 0xE1,
  0x30, 0x01, 0x8B, 0x00, 0x06, 0x50, 0x00, 0x13, 0x80, 0x00, 0xD8, 0x00,
  0x02, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x70, 0x00, 0x12, 0xC0,
  0x01, 0x93, 0x00, 0x18, 0x8F, 0x03, 0x84, 0x1F, 0xF0, 0x20, 0x08, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x43, 0x81, 0xE2, 0x30, 0x03, 0x93, 0x00, 0x07, 0x90, 0x00, 0x1D,
  0x80, 0x00, 0xEC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0x90, 0x00, 0x1C, 0xC0, 0x01, 0xE3, 0x00, 0x1B, 0x0E, 0x07, 0x98, 0x1F,
  0xF0, 0xC0, 0x18, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x2C, 0x3F, 0xC7, 0x0C, 0xC0, 0xD8, 0x0D, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0x80, 0xE0, 0x70,
  0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x11, 0x80, 0x00, 0xC8, 0x00, 0x06,
  0x40, 0x00, 0x32, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x24, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x01,
  0x87, 0x00, 0x18, 0x0E, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x07, 0xFF, 0xBF, 0xFC, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xC0, 0x08, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x07, 0x60, 0x00, 0xF3, 0x00, 0x0F,
  0x38, 0x03, 0xB1, 0xC0, 0xF3, 0x07, 0xFC, 0x30, 0x08, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x32, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x8C, 0x00, 0x03, 0x08, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30,
  0x20, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x00, 0x80, 0x06, 0x01,
  0x80, 0x08, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x80, 0x0C,
  0x03, 0x00, 0x08, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x20,
  0x60, 0x00, 0x60, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x86, 0x00, 0x01, 0x88,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0x60, 0x00,
  0x70, 0x00, 0x66, 0x00, 0x1A, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0x98,
  0x00, 0x4C, 0x00, 0x23, 0x00, 0x09, 0x80, 0x0C, 0x20, 0x03, 0x10, 0x01,
  0x86, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x08, 0x60, 0x04, 0x18, 0x03, 0x0C,
  0x01, 0x81, 0x00, 0x60, 0x80, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x06, 0x01,
  0x03, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x08, 0x0C, 0x06, 0x06, 0x01,
  0x81, 0x00, 0xC0, 0xC0, 0x30, 0x20, 0x18, 0x18, 0x06, 0x0C, 0x01, 0x06,
  0x00, 0x41, 0x80, 0x30, 0xC0, 0x0C, 0x20, 0x06, 0x18, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x02, 0x30, 0x01, 0x98, 0x00, 0x64,
  0x00, 0x33, 0x00, 0x0D, 0x80, 0x02, 0x60, 0x01, 0xB0, 0x00, 0x48, 0x00,
  0x14, 0x00, 0x0F, 0x00, 0x02, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x30, 0x01, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x02, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x00, 0xCC, 0x00, 0x01, 0x30,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00,
  0x04, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x86, 0x00, 0x06, 0x08, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x04,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98,
  0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x84, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x08, 0x10, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0x80, 0x40, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x08, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x41, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0x70, 0x30, 0x00, 0x26, 0x01, 0x80,
  0x02, 0xC0, 0x0C, 0x00, 0x2C, 0x00, 0x60, 0x06, 0x80, 0x03, 0x00, 0x48,
  0x00, 0x18, 0x0C, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Thin62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 45, 12, 4, -44 },
  { 18, 9, 12, 16, 4, -47 },
  { 32, 29, 44, 30, 2, -44 },
  { 192, 22, 58, 30, 4, -51 },
  { 352, 34, 46, 40, 3, -45 },
  { 548, 27, 46, 33, 4, -45 },
  { 704, 2, 13, 10, 4, -47 },
  { 708, 12, 63, 17, 4, -49 },
  { 803, 12, 63, 17, 1, -49 },
  { 898, 24, 24, 26, 1, -44 },
  { 970, 26, 31, 31, 2, -36 },
  { 1071, 4, 12, 12, 3, -5 },
  { 1077, 12, 2, 17, 2, -21 },
  { 1080, 4, 4, 13, 4, -3 },
  { 1082, 17, 48, 21, 2, -44 },
  { 1184, 22, 46, 30, 4, -45 },
  { 1311, 13, 44, 30, 5, -44 },
  { 1383, 23, 45, 30, 4, -45 },
  { 1513, 23, 46, 30, 3, -45 },
  { 1646, 26, 44, 30, 3, -44 },
  { 1789, 22, 45, 30, 5, -44 },
  { 1913, 23, 45, 30, 4, -44 },
  { 2043, 24, 44, 30, 3, -44 },
  { 2175, 24, 46, 30, 3, -45 },
  { 2313, 23, 45, 30, 3, -45 },
  { 2443, 3, 33, 11, 4, -32 },
  { 2456, 5, 39, 11, 2, -32 },
  { 2481, 21, 24, 28, 3, -32 },
  { 2544, 22, 15, 30, 4, -28 },
  { 2586, 21, 24, 28, 4, -32 },
  { 2649, 18, 46, 24, 3, -45 },
  { 2753, 42, 57, 50, 4, -43 },
  { 3053, 30, 44, 33, 1, -44 },
  { 3218, 24, 44, 33, 6, -44 },
  { 3350, 27, 46, 35, 4, -45 },
  { 3506, 25, 44, 36, 6, -44 },
  { 3644, 22, 44, 31, 6, -44 },
  { 3765, 23, 44, 31, 6, -44 },
  { 3892, 27, 46, 37, 5, -45 },
  { 4048, 26, 44, 38, 6, -44 },
  { 4191, 1, 44, 15, 7, -44 },
  { 4197, 22, 45, 30, 3, -44 },
  { 4321, 26, 44, 34, 6, -44 },
  { 4464, 20, 44, 28, 6, -44 },
  { 4574, 35, 44, 46, 6, -44 },
  { 4767, 27, 44, 38, 6, -44 },
  { 4916, 28, 46, 36, 4, -45 },
  { 5077, 24, 44, 33, 6, -44 },
  { 5209, 28, 53, 36, 4, -45 },
  { 5395, 25, 44, 35, 6, -44 },
  { 5533, 27, 46, 32, 3, -45 },
  { 5689, 29, 44, 33, 2, -44 },
  { 5849, 26, 45, 36, 5, -44 },
  { 5996, 30, 44, 33, 1, -44 },
  { 6161, 45, 44, 49, 2, -44 },
  { 6409, 29, 44, 33, 2, -44 },
  { 6569, 30, 44, 33, 1, -44 },
  { 6734, 27, 44, 33, 3, -44 },
  { 6883, 8, 59, 13, 5, -50 },
  { 6942, 17, 48, 21, 2, -44 },
  { 7044, 8, 59, 13, 0, -50 },
  { 7103, 17, 22, 23, 3, -44 },
  { 7150, 21, 2, 23, 1, 0 },
  { 7156, 8, 8, 16, 4, -46 },
  { 7164, 22, 35, 29, 3, -34 },
  { 7261, 21, 48, 30, 5, -47 },
  { 7387, 22, 35, 28, 3, -34 },
  { 7484, 21, 48, 30, 4, -47 },
  { 7610, 22, 35, 28, 3, -34 },
  { 7707, 16, 48, 18, 2, -48 },
  { 7803, 21, 47, 30, 4, -34 },
  { 7927, 20, 47, 30, 5, -47 },
  { 8045, 3, 45, 12, 5, -45 },
  { 8062, 11, 58, 13, -3, -45 },
  { 8142, 20, 47, 26, 5, -47 },
  { 8260, 2, 47, 12, 5, -47 },
  { 8272, 39, 34, 48, 5, -34 },
  { 8438, 20, 34, 30, 5, -34 },
  { 8523, 22, 35, 30, 4, -34 },
  { 8620, 21, 47, 30, 5, -34 },
  { 8744, 21, 47, 30, 4, -34 },
  { 8868, 12, 34, 19, 5, -34 },
  { 8919, 21, 35, 27, 3, -34 },
  { 9011, 13, 43, 18, 2, -42 },
  { 9081, 20, 34, 30, 5, -33 },
  { 9166, 23, 33, 26, 2, -33 },
  { 9261, 35, 33, 41, 3, -33 },
  { 9406, 22, 33, 26, 2, -33 },
  { 9497, 23, 46, 26, 2, -33 },
  { 9630, 22, 33, 26, 3, -33 },
  { 9721, 16, 61, 18, 2, -48 },
  { 9843, 2, 52, 12, 5, -44 },
  { 9856, 15, 61, 18, 1, -48 },
  { 9971, 28, 10, 37, 5, -23 },
};

const GFXfont RobotoCondensed_Thin62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_THIN62PT7B_H_
