#ifndef _ROBOTOCONDENSED_THIN8PT7B_H_
#define _ROBOTOCONDENSED_THIN8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin8pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0xC0, 0x05, 0x66, 0x62, 0x0E, 0x63, 0x78, 0xC5, 0xB8, 0x41,
  0x8C, 0x66, 0x4A, 0xAF, 0x00, 0x7E, 0x15, 0x56, 0x19, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x00, 0x15, 0x80, 0x76, 0xDA, 0xC0, 0x78, 0x74, 0x94, 0x80,
  0x64, 0x8B, 0xC0, 0x02, 0x62, 0x60, 0xED, 0x70, 0x51, 0xDA, 0xC0, 0xE4,
  0x94, 0x80, 0x76, 0xFB, 0xC0, 0x76, 0xD6, 0xC0, 0x00, 0x00, 0x18, 0x80,
  0xC0, 0x45, 0x00, 0x54, 0x80, 0x00, 0x39, 0x1A, 0x69, 0xB6, 0xD4, 0x08,
  0x22, 0x65, 0x98, 0xD6, 0x6A, 0x80, 0xF2, 0x49, 0xC0, 0xD6, 0xDA, 0x80,
  0xF2, 0x48, 0x80, 0xF2, 0x48, 0x00, 0xF2, 0x7B, 0xC0, 0x16, 0xFA, 0x00,
  0x78, 0x04, 0x9B, 0xC0, 0x1A, 0x4C, 0x40, 0x2A, 0x80, 0x09, 0x9B, 0xF4,
  0x16, 0xFA, 0x40, 0xF6, 0xDB, 0xC0, 0xD6, 0xE8, 0x00, 0xF6, 0xDB, 0xC8,
  0xD6, 0xEA, 0x00, 0x68, 0xC3, 0x9F, 0xF2, 0x22, 0x20, 0x16, 0xDB, 0xC0,
  0x09, 0x96, 0x60, 0x82, 0x5B, 0x55, 0x49, 0x20, 0x85, 0x24, 0x61, 0x89,
  0x64, 0x20, 0x72, 0x24, 0x46, 0xFE, 0xA5, 0x40, 0xFE, 0x48, 0x00, 0x40,
  0x00, 0x6E, 0xE0, 0x2F, 0xF0, 0xD2, 0x60, 0x0E, 0xDB, 0xC0, 0xFE, 0x60,
  0x15, 0x40, 0xF6, 0xF2, 0xC0, 0x2F, 0xC0, 0x18, 0x1F, 0x2A, 0x90, 0x78,
  0xBD, 0x6A, 0x10, 0xFC, 0xF6, 0xF0, 0xFF, 0x80, 0xF6, 0xF2, 0x00, 0xE0,
  0xC8, 0xB0, 0x2A, 0x00, 0x3F, 0x95, 0x20, 0x2D, 0x54, 0x80, 0x29, 0x00,
  0x95, 0x25, 0x00, 0x69, 0x20, 0x54, 0x14, 0x7C, 0x15, 0x16, 0x40,
};

const GFXglyph RobotoCondensed_Thin8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 1, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 8, 4, 0, -7 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 1, 0, -6 },
  { 17, 1, 8, 2, 1, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -6 },
  { 22, 4, 4, 4, 0, -5 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 2, 6, 3, 0, -6 },
  { 29, 3, 6, 4, 0, -6 },
  { 32, 1, 6, 4, 1, -6 },
  { 33, 3, 6, 4, 0, -6 },
  { 36, 3, 6, 4, 0, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 2, 6, 4, 1, -6 },
  { 44, 3, 6, 4, 0, -6 },
  { 47, 3, 6, 4, 0, -6 },
  { 50, 3, 6, 4, 0, -6 },
  { 53, 3, 6, 4, 0, -6 },
  { 56, 1, 4, 1, 0, -4 },
  { 57, 1, 5, 1, 0, -4 },
  { 58, 3, 3, 4, 0, -4 },
  { 60, 2, 2, 4, 1, -4 },
  { 61, 3, 3, 4, 0, -4 },
  { 63, 3, 6, 3, 0, -6 },
  { 66, 6, 8, 6, 0, -6 },
  { 72, 4, 6, 4, 0, -6 },
  { 75, 3, 6, 4, 1, -6 },
  { 78, 3, 6, 5, 1, -6 },
  { 81, 3, 6, 5, 1, -6 },
  { 84, 3, 6, 4, 1, -6 },
  { 87, 3, 6, 4, 1, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 1, 6, 2, 0, -6 },
  { 97, 3, 6, 4, 0, -6 },
  { 100, 3, 6, 4, 1, -6 },
  { 103, 2, 6, 4, 1, -6 },
  { 105, 4, 6, 6, 1, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 3, 6, 4, 1, -6 },
  { 117, 3, 7, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 4, 6, 4, 0, -6 },
  { 126, 4, 6, 4, 0, -6 },
  { 129, 3, 6, 5, 1, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 6, 6, 6, 0, -6 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 1, 8, 2, 1, -7 },
  { 150, 2, 6, 3, 0, -6 },
  { 152, 1, 8, 2, 0, -7 },
  { 153, 3, 3, 3, 0, -6 },
  { 155, 3, 1, 3, 0, 0 },
  { 156, 1, 1, 2, 1, -6 },
  { 157, 3, 4, 4, 0, -4 },
  { 159, 2, 6, 4, 1, -6 },
  { 161, 3, 4, 4, 0, -4 },
  { 163, 3, 6, 4, 0, -6 },
  { 166, 3, 4, 4, 0, -4 },
  { 168, 2, 6, 2, 0, -6 },
  { 170, 3, 6, 4, 0, -4 },
  { 173, 2, 6, 4, 1, -6 },
  { 175, 1, 6, 2, 0, -6 },
  { 176, 1, 8, 2, 0, -6 },
  { 177, 2, 6, 3, 1, -6 },
  { 179, 1, 6, 2, 0, -6 },
  { 180, 5, 4, 6, 1, -4 },
  { 183, 2, 4, 4, 1, -4 },
  { 184, 3, 4, 4, 0, -4 },
  { 186, 2, 6, 4, 1, -4 },
  { 188, 3, 6, 4, 0, -4 },
  { 191, 1, 4, 2, 1, -4 },
  { 192, 3, 4, 4, 0, -4 },
  { 194, 2, 5, 2, 0, -5 },
  { 196, 2, 4, 4, 1, -4 },
  { 197, 3, 4, 3, 0, -4 },
  { 199, 5, 4, 5, 0, -4 },
  { 202, 3, 4, 3, 0, -4 },
  { 204, 3, 6, 3, 0, -4 },
  { 207, 3, 4, 3, 0, -4 },
  { 209, 2, 8, 2, 0, -6 },
  { 211, 1, 7, 2, 0, -6 },
  { 212, 2, 8, 2, 0, -6 },
  { 214, 3, 1, 5, 1, -3 },
};

const GFXfont RobotoCondensed_Thin8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_THIN8PT7B_H_
