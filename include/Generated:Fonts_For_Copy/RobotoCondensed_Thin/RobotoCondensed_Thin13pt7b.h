#ifndef _ROBOTOCONDENSED_THIN13PT7B_H_
#define _ROBOTOCONDENSED_THIN13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin13pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0x80, 0x74, 0x00, 0x93, 0x8A, 0x28, 0xA7, 0x92, 0x00, 0x03,
  0xA3, 0x08, 0x30, 0x41, 0x8B, 0x80, 0xE1, 0x52, 0xA7, 0x81, 0x05, 0xCC,
  0xA9, 0x0E, 0x72, 0x49, 0x18, 0x42, 0x89, 0xA2, 0xF0, 0x40, 0x1A, 0xAA,
  0xA9, 0x00, 0x09, 0x12, 0x49, 0x25, 0x20, 0x01, 0x1C, 0x64, 0x00, 0x01,
  0x1C, 0x42, 0x00, 0xC0, 0x40, 0x80, 0x11, 0x22, 0x24, 0x44, 0x80, 0x74,
  0xA3, 0x18, 0xC6, 0x32, 0x70, 0x64, 0x92, 0x49, 0x20, 0xF4, 0x82, 0x21,
  0x11, 0x08, 0xF0, 0x74, 0x42, 0x13, 0x00, 0x31, 0x70, 0x11, 0x8C, 0xA5,
  0x4B, 0xC2, 0x10, 0x74, 0x21, 0xE0, 0x84, 0x31, 0x70, 0x64, 0x21, 0xE8,
  0xC6, 0x31, 0x70, 0x70, 0x84, 0x22, 0x11, 0x08, 0x00, 0x74, 0x63, 0x17,
  0x4A, 0x31, 0xF0, 0xF9, 0x99, 0x9F, 0x11, 0x60, 0x80, 0x01, 0x00, 0x16,
  0x84, 0x30, 0x66, 0x86, 0x16, 0x80, 0xE4, 0x94, 0x80, 0x40, 0x3E, 0x20,
  0xA0, 0x33, 0x9A, 0x0D, 0x26, 0x93, 0x49, 0xBF, 0x40, 0x10, 0x07, 0x80,
  0x10, 0x60, 0xA1, 0x44, 0x8E, 0x91, 0x42, 0x80, 0xF4, 0x63, 0x1F, 0x46,
  0x31, 0xF8, 0x7A, 0x18, 0x20, 0x82, 0x08, 0x21, 0x78, 0xF2, 0x28, 0x61,
  0x86, 0x18, 0x62, 0xF0, 0xF4, 0x21, 0x0E, 0x42, 0x10, 0xF0, 0xF4, 0x21,
  0x0F, 0x42, 0x10, 0x80, 0x7A, 0x18, 0x60, 0x8A, 0x18, 0x61, 0x78, 0x86,
  0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xFF, 0x80, 0x01, 0x11, 0x11, 0x19,
  0xE0, 0x8A, 0x49, 0x28, 0xC2, 0x89, 0x22, 0x80, 0x84, 0x21, 0x08, 0x42,
  0x10, 0xF0, 0x81, 0x83, 0xC3, 0xC5, 0xA5, 0xA5, 0xA9, 0x99, 0x91, 0x82,
  0x1C, 0x69, 0x96, 0x58, 0xE3, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x78, 0xFC, 0x63, 0x1F, 0xC2, 0x10, 0x80, 0x7A, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x78, 0x20, 0x00, 0xFA, 0x28, 0x62, 0xEA, 0x48, 0xA2, 0x00, 0x7C,
  0x21, 0x07, 0x04, 0x31, 0x70, 0x78, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x04, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x81, 0x09, 0x12, 0x24, 0x85, 0x0A,
  0x18, 0x10, 0x00, 0x61, 0x14, 0xC9, 0x2A, 0x52, 0x94, 0xA3, 0x28, 0x84,
  0x21, 0x00, 0x01, 0x12, 0x8C, 0x10, 0xA2, 0x91, 0x00, 0x00, 0x89, 0x21,
  0x43, 0x02, 0x04, 0x08, 0x10, 0x78, 0x44, 0x42, 0x21, 0x10, 0x70, 0xAA,
  0xAA, 0xAA, 0x80, 0x04, 0x44, 0x22, 0x21, 0x10, 0x55, 0x55, 0x55, 0x40,
  0x5A, 0xD0, 0x70, 0x80, 0xF1, 0x1F, 0x99, 0xE0, 0x04, 0x21, 0xE8, 0xC6,
  0x31, 0x8B, 0x80, 0xF8, 0x88, 0x88, 0xF0, 0x01, 0x1F, 0x99, 0x99, 0x9F,
  0xF9, 0xF8, 0x88, 0xF0, 0x24, 0x44, 0x44, 0x44, 0x44, 0xF9, 0x99, 0x99,
  0xF1, 0x1F, 0x08, 0x8F, 0x99, 0x99, 0x90, 0x8F, 0x80, 0x20, 0x02, 0x49,
  0x24, 0x90, 0x08, 0x89, 0xAC, 0xCA, 0x90, 0x7F, 0x80, 0x77, 0x89, 0x89,
  0x89, 0x89, 0x89, 0x00, 0x79, 0x99, 0x99, 0x00, 0xF4, 0x63, 0x18, 0xC7,
  0xC0, 0x74, 0x63, 0x18, 0xC7, 0xD0, 0x80, 0x00, 0xF9, 0x99, 0x99, 0xF1,
  0x10, 0x52, 0x49, 0x00, 0xF9, 0x86, 0x11, 0xF0, 0x49, 0x24, 0x92, 0x00,
  0x09, 0x99, 0x99, 0xF0, 0x04, 0x52, 0xA5, 0x10, 0x80, 0x13, 0x26, 0xCD,
  0x6A, 0xC8, 0x90, 0x00, 0x0A, 0x88, 0x43, 0x24, 0x20, 0x02, 0x52, 0xA5,
  0x10, 0x84, 0x20, 0x00, 0x72, 0x24, 0x48, 0x60, 0x09, 0x25, 0x20, 0x89,
  0x24, 0xFF, 0xE0, 0x09, 0x24, 0x88, 0x49, 0x28, 0xE4, 0x70,
};

const GFXglyph RobotoCondensed_Thin13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 2, 1, -9 },
  { 3, 2, 3, 3, 1, -10 },
  { 4, 6, 9, 6, 0, -9 },
  { 11, 5, 11, 6, 1, -10 },
  { 18, 7, 9, 8, 1, -9 },
  { 26, 6, 9, 7, 1, -9 },
  { 33, 1, 3, 2, 1, -10 },
  { 34, 2, 13, 4, 1, -10 },
  { 38, 3, 13, 4, 0, -10 },
  { 43, 5, 5, 5, 0, -9 },
  { 47, 5, 6, 6, 1, -7 },
  { 51, 1, 3, 2, 1, -1 },
  { 52, 3, 1, 4, 0, -5 },
  { 53, 1, 1, 3, 1, -1 },
  { 54, 4, 10, 4, 0, -9 },
  { 59, 5, 9, 6, 1, -9 },
  { 65, 3, 9, 6, 1, -9 },
  { 69, 5, 9, 6, 1, -9 },
  { 75, 5, 9, 6, 1, -9 },
  { 81, 5, 9, 6, 1, -9 },
  { 87, 5, 9, 6, 1, -9 },
  { 93, 5, 9, 6, 1, -9 },
  { 99, 5, 9, 6, 1, -9 },
  { 105, 5, 9, 6, 1, -9 },
  { 111, 4, 9, 6, 1, -9 },
  { 116, 1, 7, 2, 1, -7 },
  { 117, 1, 9, 2, 1, -7 },
  { 119, 4, 5, 6, 1, -7 },
  { 122, 4, 2, 6, 1, -5 },
  { 123, 4, 5, 6, 1, -7 },
  { 126, 3, 9, 5, 1, -9 },
  { 130, 9, 12, 10, 1, -9 },
  { 144, 7, 9, 7, 0, -9 },
  { 152, 5, 9, 7, 1, -9 },
  { 158, 6, 9, 7, 1, -9 },
  { 165, 6, 9, 7, 1, -9 },
  { 172, 5, 9, 7, 1, -9 },
  { 178, 5, 9, 7, 1, -9 },
  { 184, 6, 9, 8, 1, -9 },
  { 191, 6, 9, 8, 1, -9 },
  { 198, 1, 9, 3, 1, -9 },
  { 200, 4, 9, 6, 1, -9 },
  { 205, 6, 9, 7, 1, -9 },
  { 212, 5, 9, 6, 1, -9 },
  { 218, 8, 9, 10, 1, -9 },
  { 227, 6, 9, 8, 1, -9 },
  { 234, 6, 9, 8, 1, -9 },
  { 241, 5, 9, 7, 1, -9 },
  { 247, 6, 11, 8, 1, -9 },
  { 256, 6, 9, 7, 1, -9 },
  { 263, 5, 9, 7, 1, -9 },
  { 269, 6, 9, 7, 0, -9 },
  { 276, 5, 9, 8, 1, -9 },
  { 282, 7, 9, 7, 0, -9 },
  { 290, 10, 9, 10, 0, -9 },
  { 302, 6, 9, 7, 0, -9 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 5, 9, 7, 1, -9 },
  { 323, 2, 13, 3, 1, -11 },
  { 327, 4, 10, 4, 0, -9 },
  { 332, 2, 13, 3, 0, -11 },
  { 336, 3, 5, 5, 1, -9 },
  { 338, 5, 1, 5, 0, 0 },
  { 339, 2, 2, 3, 1, -10 },
  { 340, 4, 7, 6, 1, -7 },
  { 344, 5, 10, 6, 1, -10 },
  { 351, 4, 7, 6, 1, -7 },
  { 355, 4, 10, 6, 1, -10 },
  { 360, 4, 7, 6, 1, -7 },
  { 364, 4, 10, 4, 0, -10 },
  { 369, 4, 10, 6, 1, -7 },
  { 374, 4, 10, 6, 1, -10 },
  { 379, 1, 10, 3, 1, -10 },
  { 381, 3, 13, 3, -1, -10 },
  { 386, 4, 10, 5, 1, -10 },
  { 391, 1, 10, 3, 1, -10 },
  { 393, 8, 7, 10, 1, -7 },
  { 400, 4, 7, 6, 1, -7 },
  { 404, 5, 7, 6, 1, -7 },
  { 409, 5, 10, 6, 1, -7 },
  { 416, 4, 10, 6, 1, -7 },
  { 421, 3, 7, 4, 1, -7 },
  { 424, 4, 7, 6, 1, -7 },
  { 428, 3, 9, 4, 0, -9 },
  { 432, 4, 7, 6, 1, -7 },
  { 436, 5, 7, 6, 0, -7 },
  { 441, 7, 7, 9, 1, -7 },
  { 448, 5, 7, 6, 0, -7 },
  { 453, 5, 10, 6, 0, -7 },
  { 460, 4, 7, 6, 1, -7 },
  { 464, 3, 13, 4, 1, -10 },
  { 469, 1, 11, 3, 1, -9 },
  { 471, 3, 13, 4, 0, -10 },
  { 476, 6, 2, 8, 1, -5 },
};

const GFXfont RobotoCondensed_Thin13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_THIN13PT7B_H_
