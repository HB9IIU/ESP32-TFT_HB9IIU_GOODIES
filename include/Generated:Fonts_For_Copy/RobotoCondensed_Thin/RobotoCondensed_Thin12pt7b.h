#ifndef _ROBOTOCONDENSED_THIN12PT7B_H_
#define _ROBOTOCONDENSED_THIN12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin12pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0x00, 0x00, 0x00, 0xA3, 0x8A, 0x28, 0xA5, 0x14, 0x40, 0x0F,
  0x98, 0x86, 0x11, 0x9F, 0x00, 0xC2, 0xAB, 0x34, 0x20, 0xF5, 0x55, 0x0C,
  0x64, 0xA8, 0x8C, 0x56, 0x72, 0xE8, 0x00, 0x5A, 0xAA, 0xA9, 0x40, 0x15,
  0x55, 0x55, 0x00, 0x21, 0x1C, 0xA4, 0x00, 0x01, 0x1C, 0x42, 0x00, 0x00,
  0x40, 0x00, 0x11, 0x22, 0x24, 0x44, 0x88, 0xE9, 0x99, 0x99, 0x99, 0xE0,
  0x55, 0x55, 0x00, 0xE9, 0x11, 0x22, 0x48, 0xE0, 0xE1, 0x11, 0x21, 0x19,
  0xF0, 0x00, 0x42, 0x8A, 0x49, 0x27, 0x82, 0x00, 0x68, 0x8F, 0x11, 0x11,
  0xF0, 0x48, 0x8F, 0x99, 0x99, 0xF0, 0x78, 0x42, 0x21, 0x08, 0x84, 0x00,
  0xE9, 0x99, 0xE9, 0x99, 0xF0, 0xE9, 0x99, 0x9F, 0x11, 0x60, 0x00, 0x00,
  0x2C, 0xC2, 0x66, 0xC3, 0x2C, 0xE4, 0x92, 0x80, 0x00, 0x3C, 0x42, 0x91,
  0xA1, 0xA5, 0xA5, 0xA9, 0xBE, 0x80, 0x80, 0x70, 0x20, 0xC3, 0x0A, 0x49,
  0xE4, 0x61, 0x80, 0xF4, 0x63, 0x1F, 0x42, 0x31, 0x70, 0x74, 0x61, 0x08,
  0x42, 0x11, 0x70, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x74, 0x21, 0x0E,
  0x42, 0x10, 0x70, 0x74, 0x21, 0x0E, 0x42, 0x10, 0x00, 0x7C, 0x21, 0x08,
  0xC2, 0x31, 0x78, 0x04, 0x63, 0x1F, 0xC6, 0x31, 0x00, 0xFF, 0x80, 0x11,
  0x11, 0x11, 0x11, 0xE0, 0x0C, 0xA9, 0x88, 0x52, 0x52, 0x08, 0x08, 0x88,
  0x88, 0x88, 0x60, 0x83, 0x06, 0x1E, 0x3C, 0x75, 0x6A, 0xD9, 0x10, 0x84,
  0x73, 0x5A, 0xCE, 0x71, 0x08, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xF4,
  0x63, 0x1F, 0x42, 0x10, 0x00, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x02,
  0xF4, 0x63, 0x1F, 0x42, 0x51, 0x00, 0xF4, 0x61, 0x07, 0x04, 0x31, 0xF0,
  0x78, 0x41, 0x04, 0x10, 0x41, 0x04, 0x00, 0x04, 0x63, 0x18, 0xC6, 0x31,
  0x70, 0x82, 0x14, 0x52, 0x48, 0xA3, 0x04, 0x00, 0x08, 0x44, 0x53, 0x2A,
  0x95, 0x52, 0x99, 0x4C, 0x44, 0x20, 0x00, 0x05, 0x22, 0x8C, 0x10, 0xC4,
  0x92, 0x04, 0x05, 0x14, 0x8A, 0x30, 0x41, 0x04, 0x00, 0x68, 0x84, 0x42,
  0x22, 0x10, 0x70, 0x7F, 0xE0, 0x08, 0x44, 0x42, 0x22, 0x11, 0x55, 0x55,
  0x55, 0x5A, 0x90, 0x60, 0x80, 0xE1, 0x1D, 0x99, 0xF0, 0x08, 0xF9, 0x99,
  0x99, 0xF0, 0xE9, 0x88, 0x89, 0xE0, 0x01, 0xF9, 0x99, 0x99, 0xE0, 0xE9,
  0xF8, 0x88, 0xE0, 0x09, 0x24, 0x92, 0x40, 0xE9, 0x99, 0x99, 0xF1, 0xF0,
  0x08, 0xF9, 0x99, 0x99, 0x00, 0x0F, 0x80, 0x00, 0x02, 0x49, 0x24, 0x80,
  0x08, 0x8A, 0xCC, 0xAA, 0x10, 0x7F, 0x00, 0x7F, 0x26, 0x4C, 0x99, 0x32,
  0x40, 0x00, 0x79, 0x99, 0x99, 0x00, 0xE9, 0x99, 0x99, 0xE0, 0xF9, 0x99,
  0x99, 0xF8, 0x00, 0xE9, 0x99, 0x99, 0xF1, 0x00, 0xAA, 0xA0, 0xE8, 0x86,
  0x11, 0xE0, 0x49, 0x24, 0x92, 0x09, 0x99, 0x99, 0xE0, 0x8C, 0x54, 0xA5,
  0x10, 0x80, 0x02, 0x9B, 0x6D, 0xC9, 0x20, 0x80, 0x02, 0x88, 0x45, 0x28,
  0x00, 0x8C, 0x54, 0xA5, 0x10, 0x84, 0x00, 0x52, 0x24, 0x88, 0x60, 0x25,
  0x24, 0x92, 0x48, 0x90, 0x7F, 0xC0, 0x09, 0x24, 0x02, 0x49, 0x00, 0xE0,
  0xC0,
};

const GFXglyph RobotoCondensed_Thin12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 2, 1, -9 },
  { 3, 1, 2, 3, 1, -9 },
  { 4, 6, 9, 6, 0, -9 },
  { 11, 4, 11, 6, 1, -10 },
  { 17, 6, 9, 8, 1, -9 },
  { 24, 5, 9, 6, 1, -9 },
  { 30, 1, 2, 2, 0, -9 },
  { 31, 2, 13, 3, 1, -10 },
  { 35, 2, 13, 3, 0, -10 },
  { 39, 5, 5, 5, 0, -9 },
  { 43, 5, 6, 6, 0, -7 },
  { 47, 1, 2, 2, 0, -1 },
  { 48, 3, 1, 3, 0, -5 },
  { 49, 1, 1, 3, 1, -1 },
  { 50, 4, 10, 4, 0, -9 },
  { 55, 4, 9, 6, 1, -9 },
  { 60, 2, 9, 6, 1, -9 },
  { 63, 4, 9, 6, 1, -9 },
  { 68, 4, 9, 6, 1, -9 },
  { 73, 6, 9, 6, 0, -9 },
  { 80, 4, 9, 6, 1, -9 },
  { 85, 4, 9, 6, 1, -9 },
  { 90, 5, 9, 6, 0, -9 },
  { 96, 4, 9, 6, 1, -9 },
  { 101, 4, 9, 6, 1, -9 },
  { 106, 1, 7, 2, 1, -7 },
  { 107, 1, 8, 2, 0, -7 },
  { 108, 4, 4, 5, 1, -6 },
  { 110, 4, 2, 6, 1, -5 },
  { 111, 4, 4, 5, 1, -6 },
  { 113, 3, 9, 5, 1, -9 },
  { 117, 8, 11, 10, 1, -8 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 5, 9, 6, 1, -9 },
  { 141, 5, 9, 7, 1, -9 },
  { 147, 5, 9, 7, 1, -9 },
  { 153, 5, 9, 6, 1, -9 },
  { 159, 5, 9, 6, 1, -9 },
  { 165, 5, 9, 7, 1, -9 },
  { 171, 5, 9, 7, 1, -9 },
  { 177, 1, 9, 3, 1, -9 },
  { 179, 4, 9, 6, 1, -9 },
  { 184, 5, 9, 7, 1, -9 },
  { 190, 4, 9, 5, 1, -9 },
  { 195, 7, 9, 9, 1, -9 },
  { 203, 5, 9, 7, 1, -9 },
  { 209, 5, 9, 7, 1, -9 },
  { 215, 5, 9, 6, 1, -9 },
  { 221, 5, 11, 7, 1, -9 },
  { 228, 5, 9, 7, 1, -9 },
  { 234, 5, 9, 6, 1, -9 },
  { 240, 6, 9, 6, 0, -9 },
  { 247, 5, 9, 7, 1, -9 },
  { 253, 6, 9, 6, 0, -9 },
  { 260, 9, 9, 9, 0, -9 },
  { 271, 6, 9, 6, 0, -9 },
  { 278, 6, 9, 6, 0, -9 },
  { 285, 5, 9, 6, 1, -9 },
  { 291, 1, 12, 2, 1, -10 },
  { 293, 4, 10, 4, 0, -9 },
  { 298, 2, 12, 2, 0, -10 },
  { 301, 3, 4, 4, 1, -9 },
  { 303, 4, 1, 4, 0, 0 },
  { 304, 1, 2, 3, 1, -9 },
  { 305, 4, 7, 6, 1, -7 },
  { 309, 4, 9, 6, 1, -9 },
  { 314, 4, 7, 5, 1, -7 },
  { 318, 4, 9, 6, 1, -9 },
  { 323, 4, 7, 5, 1, -7 },
  { 327, 3, 9, 3, 0, -9 },
  { 331, 4, 9, 6, 1, -7 },
  { 336, 4, 9, 6, 1, -9 },
  { 341, 1, 10, 2, 1, -10 },
  { 343, 3, 12, 2, -1, -10 },
  { 348, 4, 9, 5, 1, -9 },
  { 353, 1, 9, 2, 1, -9 },
  { 355, 7, 7, 9, 1, -7 },
  { 362, 4, 7, 6, 1, -7 },
  { 366, 4, 7, 6, 1, -7 },
  { 370, 4, 9, 6, 1, -7 },
  { 375, 4, 9, 6, 1, -7 },
  { 380, 2, 7, 4, 1, -7 },
  { 382, 4, 7, 5, 1, -7 },
  { 386, 3, 8, 3, 0, -8 },
  { 389, 4, 7, 6, 1, -7 },
  { 393, 5, 7, 5, 0, -7 },
  { 398, 6, 7, 8, 1, -7 },
  { 404, 5, 7, 5, 0, -7 },
  { 409, 5, 9, 5, 0, -7 },
  { 415, 4, 7, 5, 1, -7 },
  { 419, 3, 12, 4, 0, -9 },
  { 424, 1, 11, 2, 1, -9 },
  { 426, 3, 12, 4, 0, -9 },
  { 431, 5, 2, 7, 1, -5 },
};

const GFXfont RobotoCondensed_Thin12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_THIN12PT7B_H_
