#ifndef _ROBOTOCONDENSED_THIN21PT7B_H_
#define _ROBOTOCONDENSED_THIN21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0xFF, 0x11, 0x08, 0x84, 0x42, 0x2F, 0xF8, 0x90, 0x88,
  0x44, 0x22, 0x11, 0x3F, 0xE4, 0x82, 0x42, 0x21, 0x10, 0x08, 0x08, 0x3C,
  0x42, 0x41, 0x81, 0x80, 0x40, 0x20, 0x18, 0x06, 0x01, 0x01, 0x81, 0x81,
  0x42, 0x3C, 0x08, 0x08, 0x70, 0x11, 0x02, 0x22, 0x44, 0x48, 0x91, 0x14,
  0x1C, 0x80, 0x20, 0x04, 0xC1, 0x24, 0x24, 0x89, 0x11, 0x12, 0x02, 0x40,
  0x30, 0x1C, 0x08, 0x84, 0x21, 0x08, 0x44, 0x0A, 0x01, 0x00, 0xC0, 0x48,
  0xA1, 0x28, 0x4A, 0x0A, 0x81, 0x10, 0xA3, 0xC8, 0xF0, 0x11, 0x22, 0x44,
  0x44, 0x88, 0x88, 0x88, 0x84, 0x44, 0x22, 0x11, 0x84, 0x22, 0x21, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x12, 0x22, 0x48, 0x08, 0x04, 0x02, 0x0D, 0xE1,
  0x80, 0xA0, 0x88, 0x44, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0xF0, 0xF0, 0x80, 0x08, 0x42, 0x21, 0x08,
  0x84, 0x22, 0x10, 0x88, 0x42, 0x10, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0x3D, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x10, 0x3C, 0x42, 0x82, 0x81, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFF, 0x3C, 0x42, 0x81, 0x81,
  0x01, 0x01, 0x02, 0x1C, 0x02, 0x01, 0x01, 0x81, 0x81, 0x42, 0x3C, 0x02,
  0x03, 0x02, 0x81, 0x41, 0x20, 0x90, 0x88, 0x44, 0x42, 0x41, 0x3F, 0xE0,
  0x40, 0x20, 0x10, 0x08, 0x7F, 0x02, 0x04, 0x08, 0x10, 0x3E, 0x42, 0x02,
  0x04, 0x0C, 0x18, 0x30, 0x5F, 0x00, 0x0E, 0x30, 0x40, 0x40, 0x40, 0xBC,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xFF, 0x01, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x42, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x3E, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43,
  0x3D, 0x01, 0x02, 0x02, 0x04, 0x38, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x16,
  0x80, 0x02, 0x18, 0xC6, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x60, 0x20, 0x30, 0x61, 0x0C, 0x60, 0x7A, 0x18, 0x61,
  0x04, 0x10, 0x42, 0x10, 0x42, 0x00, 0x00, 0x02, 0x00, 0x07, 0xE0, 0x10,
  0x20, 0xC0, 0x21, 0x00, 0x24, 0x3C, 0x48, 0x80, 0x61, 0x10, 0xC4, 0x21,
  0x88, 0x43, 0x10, 0x86, 0x21, 0x0C, 0x42, 0x28, 0x8C, 0x50, 0xE7, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0x00, 0x04, 0x00, 0x80,
  0x28, 0x05, 0x00, 0xA0, 0x22, 0x04, 0x40, 0x88, 0x20, 0x84, 0x10, 0xFE,
  0x20, 0x24, 0x04, 0x80, 0xA0, 0x08, 0xFC, 0x82, 0x82, 0x81, 0x81, 0x82,
  0x82, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x1F, 0x08, 0x24,
  0x09, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x05, 0x01,
  0x40, 0x88, 0x21, 0xF0, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x14, 0x13, 0xF0, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x87, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x04, 0xFC, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0xFF, 0xFE, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x0C, 0x18, 0x30, 0x5F, 0x00, 0x81, 0x41, 0x21, 0x10, 0x88, 0x84, 0x82,
  0x81, 0xA0, 0x90, 0x44, 0x21, 0x10, 0x88, 0x24, 0x0A, 0x02, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x80,
  0x80, 0x18, 0x03, 0xC0, 0x3C, 0x05, 0xA0, 0x5A, 0x05, 0xA0, 0x99, 0x09,
  0x90, 0x99, 0x11, 0x89, 0x18, 0x91, 0x8A, 0x18, 0x61, 0x84, 0x10, 0x80,
  0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x11, 0x84, 0xC2, 0x60, 0xB0,
  0x58, 0x1C, 0x0E, 0x02, 0x1F, 0x08, 0x24, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x88, 0x21, 0xF0, 0xFC,
  0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x1F, 0x08, 0x24, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x88, 0x21, 0xF0, 0x04, 0x00, 0x80,
  0x10, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0xFC, 0x42,
  0x21, 0x10, 0x48, 0x24, 0x0A, 0x02, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x30, 0x18, 0x0A, 0x08, 0xF8, 0xFF,
  0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E, 0x80, 0x28, 0x09, 0x01, 0x20,
  0x22, 0x08, 0x41, 0x08, 0x20, 0x88, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00,
  0xA0, 0x08, 0x01, 0x00, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x14, 0x14, 0x24,
  0x28, 0x48, 0x90, 0x91, 0x21, 0x22, 0x24, 0x44, 0x48, 0x50, 0x90, 0xA1,
  0x21, 0x41, 0x82, 0x83, 0x02, 0x06, 0x04, 0x04, 0x00, 0x80, 0xA0, 0x90,
  0x44, 0x42, 0x20, 0xA0, 0x50, 0x10, 0x14, 0x0A, 0x08, 0x84, 0x44, 0x14,
  0x06, 0x02, 0x40, 0x48, 0x08, 0x82, 0x10, 0x41, 0x10, 0x22, 0x02, 0x80,
  0x50, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xFF,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x03, 0xFE, 0xEA, 0xAA, 0xAA, 0xAA, 0xAB, 0x82, 0x08, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x81, 0xE4, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0xF0, 0x20, 0xC5, 0x12, 0x4A, 0x28, 0x40, 0xFF,
  0x48, 0x80, 0x3C, 0x86, 0x08, 0x10, 0x2F, 0xE0, 0xC1, 0x83, 0x0D, 0xE8,
  0x81, 0x02, 0x04, 0x08, 0x1F, 0x21, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x61, 0x7C, 0x3C, 0x86, 0x0C, 0x18, 0x10, 0x20, 0x41, 0x82, 0x84, 0xF0,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x3C, 0x42, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x3E, 0x3A, 0x10, 0x84, 0x79, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x3E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF8, 0x10,
  0x28, 0x4F, 0x00, 0x81, 0x02, 0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x8F, 0xFE, 0x10, 0x00, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x12, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0xA2, 0x48,
  0xA1, 0x82, 0x85, 0x09, 0x11, 0x21, 0x42, 0xFF, 0xFF, 0xF8, 0xF4, 0x28,
  0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C,
  0x10, 0x60, 0x82, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x08, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0B, 0xE4, 0x08, 0x10,
  0x20, 0x00, 0x3E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF8,
  0x10, 0x20, 0x40, 0x80, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x80, 0x7D, 0x06,
  0x0C, 0x06, 0x03, 0x01, 0x01, 0x83, 0x05, 0xF0, 0x44, 0x4F, 0x44, 0x44,
  0x44, 0x44, 0x43, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0,
  0x83, 0x06, 0x0A, 0x24, 0x48, 0x92, 0x14, 0x28, 0x60, 0x40, 0x82, 0x18,
  0x61, 0x86, 0x24, 0xA2, 0x49, 0x24, 0x92, 0x49, 0x43, 0x14, 0x30, 0xC3,
  0x0C, 0x00, 0x80, 0x82, 0x89, 0x11, 0x43, 0x02, 0x0A, 0x14, 0x45, 0x0A,
  0x08, 0x83, 0x06, 0x0A, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x20, 0x40, 0x82,
  0x04, 0x30, 0x00, 0xFE, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x03,
  0xF8, 0x08, 0x88, 0x42, 0x10, 0x84, 0x22, 0x20, 0x82, 0x10, 0x84, 0x21,
  0x08, 0x20, 0x80, 0xFF, 0xFF, 0xC0, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x20,
  0x82, 0x21, 0x10, 0x84, 0x21, 0x08, 0x4C, 0x00, 0x70, 0xC4, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_Thin21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 15, 4, 1, -15 },
  { 3, 2, 4, 5, 2, -16 },
  { 4, 9, 15, 10, 1, -15 },
  { 21, 8, 19, 10, 1, -17 },
  { 40, 11, 15, 14, 1, -15 },
  { 61, 10, 15, 11, 1, -15 },
  { 80, 1, 4, 4, 1, -16 },
  { 81, 4, 22, 6, 1, -17 },
  { 92, 4, 22, 6, 0, -17 },
  { 103, 9, 8, 9, 0, -15 },
  { 112, 9, 11, 10, 1, -13 },
  { 125, 1, 4, 4, 1, -2 },
  { 126, 4, 1, 6, 1, -8 },
  { 127, 1, 1, 5, 2, -1 },
  { 128, 5, 16, 7, 1, -15 },
  { 138, 8, 15, 10, 1, -15 },
  { 153, 4, 15, 10, 2, -15 },
  { 161, 8, 15, 10, 1, -15 },
  { 176, 8, 15, 10, 1, -15 },
  { 191, 9, 15, 10, 1, -15 },
  { 208, 7, 15, 10, 2, -15 },
  { 222, 8, 15, 10, 1, -15 },
  { 237, 8, 15, 10, 1, -15 },
  { 252, 8, 15, 10, 1, -15 },
  { 267, 8, 15, 10, 1, -15 },
  { 282, 2, 11, 4, 1, -11 },
  { 285, 2, 13, 4, 1, -11 },
  { 289, 7, 8, 10, 1, -11 },
  { 296, 8, 6, 10, 1, -10 },
  { 302, 7, 8, 10, 1, -11 },
  { 309, 6, 15, 8, 1, -15 },
  { 321, 15, 19, 17, 1, -14 },
  { 357, 11, 15, 11, 0, -15 },
  { 378, 8, 15, 11, 2, -15 },
  { 393, 10, 15, 12, 1, -15 },
  { 412, 9, 15, 12, 2, -15 },
  { 429, 8, 15, 11, 2, -15 },
  { 444, 8, 15, 11, 2, -15 },
  { 459, 9, 15, 13, 2, -15 },
  { 476, 9, 15, 13, 2, -15 },
  { 493, 1, 15, 5, 2, -15 },
  { 495, 7, 15, 10, 1, -15 },
  { 509, 9, 15, 12, 2, -15 },
  { 526, 7, 15, 10, 2, -15 },
  { 540, 12, 15, 16, 2, -15 },
  { 563, 9, 15, 13, 2, -15 },
  { 580, 10, 15, 12, 1, -15 },
  { 599, 8, 15, 11, 2, -15 },
  { 614, 10, 18, 12, 1, -15 },
  { 637, 9, 15, 12, 2, -15 },
  { 654, 9, 15, 11, 1, -15 },
  { 671, 9, 15, 11, 1, -15 },
  { 688, 8, 15, 12, 2, -15 },
  { 703, 11, 15, 11, 0, -15 },
  { 724, 15, 15, 17, 1, -15 },
  { 753, 9, 15, 11, 1, -15 },
  { 770, 11, 15, 11, 0, -15 },
  { 791, 9, 15, 11, 1, -15 },
  { 808, 2, 20, 4, 2, -17 },
  { 813, 6, 16, 7, 1, -15 },
  { 825, 3, 20, 4, 0, -17 },
  { 833, 6, 7, 8, 1, -15 },
  { 839, 8, 1, 8, 0, 0 },
  { 840, 3, 3, 6, 1, -16 },
  { 842, 7, 11, 10, 1, -11 },
  { 852, 7, 16, 10, 2, -16 },
  { 866, 7, 11, 9, 1, -11 },
  { 876, 8, 16, 10, 1, -16 },
  { 892, 8, 11, 9, 1, -11 },
  { 903, 5, 16, 6, 1, -16 },
  { 913, 7, 15, 10, 1, -11 },
  { 927, 7, 16, 10, 2, -16 },
  { 941, 1, 15, 4, 2, -15 },
  { 943, 4, 19, 4, -1, -15 },
  { 953, 7, 16, 9, 2, -16 },
  { 967, 1, 16, 4, 2, -16 },
  { 969, 13, 11, 16, 2, -11 },
  { 987, 7, 11, 10, 2, -11 },
  { 997, 8, 11, 10, 1, -11 },
  { 1008, 7, 15, 10, 2, -11 },
  { 1022, 7, 15, 10, 1, -11 },
  { 1036, 4, 11, 6, 2, -11 },
  { 1042, 7, 11, 9, 1, -11 },
  { 1052, 4, 14, 6, 1, -14 },
  { 1059, 6, 11, 10, 2, -11 },
  { 1068, 7, 11, 9, 1, -11 },
  { 1078, 12, 11, 14, 1, -11 },
  { 1095, 7, 11, 9, 1, -11 },
  { 1105, 7, 15, 9, 1, -11 },
  { 1119, 7, 11, 9, 1, -11 },
  { 1129, 5, 21, 6, 1, -16 },
  { 1143, 1, 18, 4, 2, -15 },
  { 1146, 5, 21, 6, 0, -16 },
  { 1160, 9, 3, 13, 2, -8 },
};

const GFXfont RobotoCondensed_Thin21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_THIN21PT7B_H_
