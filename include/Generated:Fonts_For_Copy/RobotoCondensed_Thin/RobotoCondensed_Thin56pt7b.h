#ifndef _ROBOTOCONDENSED_THIN56PT7B_H_
#define _ROBOTOCONDENSED_THIN56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin56pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x10, 0x00, 0x10, 0x04, 0x00,
  0x04, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x30, 0x0C,
  0x00, 0x0C, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20,
  0x18, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00,
  0x60, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00, 0x10, 0x04, 0x00,
  0x04, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x70, 0x0C, 0x00,
  0xC0, 0xC0, 0x03, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x62, 0x00, 0x03, 0x10,
  0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x02, 0x60, 0x00,
  0x31, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x30, 0x01, 0x80, 0xE0, 0x38, 0x01,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x30, 0x06, 0x00, 0x80,
  0xC0, 0x18, 0x06, 0x03, 0x00, 0x60, 0x10, 0x0C, 0x01, 0x80, 0xC0, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0x18, 0x10, 0x03, 0x00, 0x60, 0xC0, 0x04, 0x01,
  0x02, 0x00, 0x18, 0x0C, 0x18, 0x00, 0x20, 0x20, 0x40, 0x00, 0xC1, 0x83,
  0x00, 0x01, 0xFC, 0x08, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x81, 0xF8,
  0x00, 0x04, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x60, 0x00, 0x81, 0x00, 0x80,
  0x06, 0x0C, 0x03, 0x00, 0x30, 0x20, 0x04, 0x00, 0x80, 0x80, 0x10, 0x06,
  0x02, 0x00, 0x40, 0x10, 0x08, 0x01, 0x00, 0xC0, 0x20, 0x04, 0x02, 0x00,
  0x80, 0x10, 0x18, 0x02, 0x00, 0x40, 0x40, 0x08, 0x01, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x10, 0x00,
  0x60, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x00, 0x20, 0x00, 0x80, 0x20,
  0x00, 0x60, 0x30, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x30,
  0x18, 0x01, 0x10, 0x06, 0x01, 0x98, 0x01, 0x80, 0xC8, 0x00, 0x40, 0x64,
  0x00, 0x30, 0x36, 0x00, 0x0C, 0x13, 0x00, 0x03, 0x09, 0x80, 0x00, 0x8C,
  0xC0, 0x00, 0x64, 0x60, 0x00, 0x1E, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03,
  0x06, 0x00, 0x03, 0xC1, 0x80, 0x03, 0x30, 0x60, 0x03, 0x08, 0x1C, 0x07,
  0x06, 0x07, 0xFE, 0x01, 0x80, 0x10, 0x00, 0x00, 0xFF, 0xEA, 0xA8, 0x00,
  0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x0C, 0x02, 0xF0, 0x30, 0x3C,
  0xF0, 0xC7, 0x80, 0x7B, 0x70, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x20, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x18, 0xC6, 0x31, 0x08, 0xC6, 0x23, 0x10, 0xFF, 0xE0, 0xFD, 0x00, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xC1, 0xC0, 0x18, 0x03, 0x01,
  0x80, 0x0C, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x84, 0x00, 0x04, 0x20, 0x00,
  0x33, 0x00, 0x01, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00,
  0x02, 0x60, 0x00, 0x31, 0x00, 0x01, 0x88, 0x00, 0x08, 0x60, 0x00, 0xC1,
  0x00, 0x04, 0x0C, 0x00, 0x60, 0x30, 0x06, 0x00, 0xE0, 0xE0, 0x01, 0xFE,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x3C, 0x1D, 0x9E, 0x3F, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0x81, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x0C,
  0x10, 0x00, 0x21, 0x80, 0x01, 0x88, 0x00, 0x04, 0x40, 0x00, 0x26, 0x00,
  0x01, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xC0, 0xE0, 0x18, 0x01, 0x81, 0x80, 0x04,
  0x18, 0x00, 0x30, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x32, 0x00,
  0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x02,
  0x18, 0x00, 0x30, 0x60, 0x03, 0x01, 0xC0, 0x70, 0x03, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x00,
  0x80, 0x40, 0x01, 0x80, 0x40, 0x03, 0x00, 0x40, 0x03, 0x00, 0x40, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x08, 0x00, 0x40, 0x18,
  0x00, 0x40, 0x30, 0x00, 0x40, 0x30, 0x00, 0x40, 0x60, 0x00, 0x40, 0x60,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x3F, 0xFF, 0xE6, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x1F, 0xC0, 0x4F, 0x3E, 0x0B, 0x00, 0xE1, 0x80, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00,
  0x01, 0x30, 0x00, 0x63, 0x00, 0x08, 0x30, 0x03, 0x03, 0x01, 0xC0, 0x3F,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x03, 0xF0, 0x08, 0x7D, 0xE0, 0x46, 0x01,
  0xC2, 0x40, 0x06, 0x14, 0x00, 0x18, 0xE0, 0x00, 0x66, 0x00, 0x03, 0x60,
  0x00, 0x0B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x11, 0x00, 0x01, 0x8C, 0x00, 0x0C,
  0x20, 0x00, 0xC1, 0x80, 0x04, 0x06, 0x00, 0x60, 0x1C, 0x0E, 0x00, 0x3F,
  0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0x80, 0xE0, 0x38, 0x03, 0x81, 0x00, 0x06, 0x18, 0x00, 0x31, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x24, 0x00, 0x01, 0x30, 0x00, 0x09, 0x80, 0x00, 0xC4, 0x00, 0x04,
  0x30, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x60, 0x0F, 0xBE, 0x00, 0x3F,
  0xE0, 0x07, 0x01, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x33,
  0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x80, 0x00, 0x26, 0x00, 0x03, 0x18, 0x00, 0x30, 0x60, 0x03,
  0x01, 0xC0, 0x70, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0x81, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00,
  0x30, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x01, 0xB0,
  0x00, 0x05, 0x80, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x34, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0x80, 0x01, 0xE6, 0x00, 0x1B,
  0x18, 0x01, 0x90, 0x60, 0x18, 0x81, 0xE7, 0x84, 0x03, 0xF0, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x84, 0x21, 0x18, 0xC6, 0x63, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x18, 0x18, 0x30,
  0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x00, 0x41, 0x80, 0x03, 0xF0, 0x00, 0x82, 0x00, 0x0F, 0xF0,
  0x01, 0x8C, 0x00, 0x30, 0x30, 0x03, 0x18, 0x00, 0x80, 0x30, 0x02, 0x20,
  0x03, 0x00, 0x60, 0x04, 0x40, 0x0C, 0x00, 0xC0, 0x09, 0x80, 0x10, 0x01,
  0x80, 0x13, 0x00, 0x60, 0x03, 0x00, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x48,
  0x01, 0x00, 0x08, 0x00, 0xD0, 0x02, 0x00, 0x10, 0x01, 0xA0, 0x0C, 0x00,
  0x20, 0x03, 0x40, 0x18, 0x00, 0x40, 0x07, 0x80, 0x20, 0x00, 0x80, 0x0B,
  0x00, 0x40, 0x01, 0x00, 0x16, 0x00, 0x80, 0x02, 0x00, 0x2C, 0x01, 0x00,
  0x0C, 0x00, 0x48, 0x02, 0x00, 0x18, 0x00, 0x90, 0x04, 0x00, 0x30, 0x03,
  0x20, 0x08, 0x00, 0x60, 0x04, 0x40, 0x10, 0x01, 0xC0, 0x08, 0x80, 0x30,
  0x03, 0x80, 0x31, 0x80, 0x60, 0x0D, 0x00, 0x43, 0x00, 0x40, 0x12, 0x01,
  0x86, 0x00, 0xC0, 0x66, 0x06, 0x04, 0x00, 0xC1, 0x86, 0x18, 0x0C, 0x00,
  0xFC, 0x07, 0xE0, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x32, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x08, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x30, 0x02, 0x00, 0x06, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00, 0x30, 0x00, 0x20, 0x06,
  0x00, 0x04, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x07, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x0C, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x7C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x30,
  0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x01, 0xF0, 0x3F, 0xFF, 0xC0,
  0xC0, 0x01, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x04, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x0C, 0x00, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x08, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x30, 0x00, 0x06, 0x10, 0x00, 0x04, 0x18, 0x00,
  0x08, 0x0E, 0x00, 0x18, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0xFF, 0xF8, 0x01, 0x80, 0x3E, 0x03, 0x00, 0x07, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18,
  0x00, 0x38, 0x30, 0x0F, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF,
  0x8C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xCC, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x30, 0x00, 0x03, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x07,
  0x80, 0x70, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03,
  0x20, 0x00, 0x46, 0x00, 0x18, 0x60, 0x06, 0x07, 0x03, 0x80, 0x3F, 0xE0,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0xC5, 0x80, 0x00, 0xC8, 0xC0, 0x00, 0xD8, 0x60, 0x00, 0xF0, 0x60, 0x00,
  0xE0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0B, 0xD0, 0x00,
  0x00, 0x0B, 0xD8, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x13, 0xC8, 0x00,
  0x00, 0x13, 0xCC, 0x00, 0x00, 0x33, 0xC4, 0x00, 0x00, 0x23, 0xC4, 0x00,
  0x00, 0x63, 0xC6, 0x00, 0x00, 0x63, 0xC2, 0x00, 0x00, 0x43, 0xC2, 0x00,
  0x00, 0xC3, 0xC3, 0x00, 0x00, 0x83, 0xC1, 0x00, 0x00, 0x83, 0xC1, 0x80,
  0x01, 0x83, 0xC1, 0x80, 0x01, 0x03, 0xC0, 0x80, 0x03, 0x03, 0xC0, 0xC0,
  0x03, 0x03, 0xC0, 0x40, 0x02, 0x03, 0xC0, 0x40, 0x06, 0x03, 0xC0, 0x60,
  0x04, 0x03, 0xC0, 0x20, 0x04, 0x03, 0xC0, 0x20, 0x0C, 0x03, 0xC0, 0x30,
  0x08, 0x03, 0xC0, 0x10, 0x08, 0x03, 0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18,
  0x10, 0x03, 0xC0, 0x08, 0x30, 0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x04,
  0x20, 0x03, 0xC0, 0x04, 0x60, 0x03, 0xC0, 0x06, 0x40, 0x03, 0xC0, 0x02,
  0x40, 0x03, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x1E, 0xC0, 0x00,
  0x0F, 0x20, 0x00, 0x07, 0x98, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xE3, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x78, 0x20, 0x00, 0x3C, 0x18, 0x00, 0x1E, 0x04,
  0x00, 0x0F, 0x03, 0x00, 0x07, 0x80, 0xC0, 0x03, 0xC0, 0x20, 0x01, 0xE0,
  0x18, 0x00, 0xF0, 0x04, 0x00, 0x78, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x1E,
  0x00, 0x60, 0x0F, 0x00, 0x18, 0x07, 0x80, 0x04, 0x03, 0xC0, 0x03, 0x01,
  0xE0, 0x00, 0x80, 0xF0, 0x00, 0x60, 0x78, 0x00, 0x18, 0x3C, 0x00, 0x0C,
  0x1E, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x87, 0x80, 0x00, 0x63, 0xC0, 0x00,
  0x11, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x03, 0x78, 0x00, 0x00, 0xBC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x38, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x04,
  0x40, 0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x38, 0x00,
  0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFE, 0x03, 0x00, 0x3E, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x7E, 0x0F,
  0xFF, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x38, 0x01, 0x80,
  0x07, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x04, 0x40, 0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0xFF, 0xFC, 0x01, 0x00, 0x1F,
  0x02, 0x00, 0x03, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0,
  0x00, 0x03, 0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00,
  0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x10, 0x00, 0xF0, 0x3F, 0xFF,
  0x80, 0x40, 0x03, 0x00, 0x80, 0x02, 0x01, 0x00, 0x06, 0x02, 0x00, 0x04,
  0x04, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x10, 0x00, 0x18, 0x20, 0x00, 0x18,
  0x40, 0x00, 0x30, 0x80, 0x00, 0x31, 0x00, 0x00, 0x62, 0x00, 0x00, 0x64,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0x30, 0x38, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x0F,
  0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x09, 0x80, 0x00, 0x33, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x0E, 0x03, 0xC0, 0x78, 0x01, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20,
  0x08, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x30, 0x00, 0x20, 0x02, 0x00,
  0x04, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x60, 0x04, 0x00, 0x04, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x04, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x20, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x30,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00,
  0x06, 0x60, 0x00, 0x24, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00, 0x04, 0x20,
  0x00, 0x42, 0x00, 0x04, 0x30, 0x00, 0x42, 0x00, 0x0C, 0x30, 0x00, 0x43,
  0x00, 0x0C, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08,
  0x18, 0x00, 0x81, 0x00, 0x08, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x18, 0x08, 0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80,
  0x10, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x20, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x20, 0x60,
  0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x30, 0x40, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x18, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01,
  0x90, 0x00, 0x09, 0x80, 0x00, 0x90, 0x00, 0x09, 0x80, 0x00, 0x90, 0x00,
  0x0D, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x80, 0x10, 0x00, 0x60, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x20,
  0x00, 0x04, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x32, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x60, 0x0C,
  0x00, 0x08, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x10, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x08,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x10, 0x01, 0x80, 0x03, 0x00, 0x20,
  0x00, 0x20, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x34, 0x00, 0x48, 0x00, 0x98, 0x03, 0x10, 0x04, 0x20, 0x08,
  0x60, 0x30, 0x40, 0x40, 0xC0, 0x81, 0x83, 0x01, 0x04, 0x03, 0x18, 0x06,
  0x30, 0x04, 0x40, 0x0D, 0x80, 0x1B, 0x00, 0x14, 0x00, 0x30, 0xFF, 0xFF,
  0xF0, 0xC0, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x30, 0x1C, 0x1C, 0x00, 0xC2, 0x00, 0x0C, 0xC0, 0x00, 0x90, 0x00,
  0x16, 0x00, 0x02, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xFF, 0xF8, 0x7E, 0x03, 0x18, 0x00,
  0x66, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xB6, 0x00, 0x66, 0x70, 0x38, 0xC7, 0xFC, 0x08, 0x08, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x02, 0x00, 0xC3, 0xFE, 0x0C, 0xE0, 0x70, 0xD8,
  0x01, 0x8F, 0x00, 0x0C, 0xE0, 0x00, 0x4E, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x04, 0xF0,
  0x00, 0xCD, 0x80, 0x18, 0xCE, 0x07, 0x0C, 0x3F, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x38, 0x1C, 0x0C, 0x00, 0xC3, 0x00, 0x0C,
  0xC0, 0x00, 0x98, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x40, 0x00, 0x2C,
  0x00, 0x0D, 0x80, 0x01, 0x18, 0x00, 0x61, 0x80, 0x18, 0x1C, 0x0E, 0x01,
  0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x07, 0xFC,
  0x30, 0xE0, 0x73, 0x18, 0x01, 0xB3, 0x00, 0x0F, 0x20, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x32, 0x00, 0x07, 0x30, 0x00, 0xF1, 0x80, 0x1B, 0x0E, 0x07, 0x30, 0x3F,
  0xC3, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0E, 0x07, 0x01,
  0x80, 0x18, 0x30, 0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x06,
  0xC0, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0xE0, 0x38, 0x03, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF,
  0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0x0E, 0x07, 0x31,
  0x80, 0x1B, 0x30, 0x00, 0xF2, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03,
  0x40, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x73,
  0x00, 0x0F, 0x18, 0x01, 0xB0, 0xE0, 0x73, 0x07, 0xFC, 0x30, 0x04, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x63, 0x00, 0x06, 0x18, 0x00, 0xC0, 0xC0, 0x18, 0x07, 0x8F, 0x00, 0x1F,
  0xC0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x1F, 0xE1, 0x8E, 0x06, 0x33, 0x00,
  0x66, 0x40, 0x04, 0xD0, 0x00, 0xDE, 0x00, 0x0B, 0x80, 0x01, 0x70, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0C, 0xDF, 0x80, 0x00, 0x00, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00, 0xC0, 0x70,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0xCD,
  0xE1, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0D, 0x80, 0x03, 0x30,
  0x00, 0xC6, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x60,
  0x30, 0x0C, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC6,
  0x00, 0x19, 0xC0, 0x03, 0x6C, 0x00, 0x78, 0x80, 0x0E, 0x18, 0x01, 0x81,
  0x80, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x00,
  0x20, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x18, 0x3F, 0xC0, 0x3F, 0xE3, 0x18, 0x1C, 0x0C,
  0x0E, 0x66, 0x00, 0xC7, 0x00, 0x6D, 0x80, 0x08, 0x80, 0x05, 0xA0, 0x01,
  0xB0, 0x00, 0xF8, 0x00, 0x14, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x01, 0xE0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x18, 0x3F, 0xC3, 0x1C, 0x0C, 0x66,
  0x00, 0xCC, 0x80, 0x09, 0xA0, 0x01, 0xBC, 0x00, 0x17, 0x00, 0x02, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0x80, 0xE0, 0x38, 0x03, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x30, 0x80, 0x00,
  0x8C, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x48, 0x00, 0x02, 0x60, 0x00, 0x31,
  0x00, 0x01, 0x0C, 0x00, 0x18, 0x30, 0x01, 0x81, 0xC0, 0x1C, 0x03, 0x01,
  0xC0, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x20, 0x0C, 0x3F, 0xE0, 0xCE,
  0x07, 0x0D, 0x80, 0x18, 0xF0, 0x00, 0xCE, 0x00, 0x04, 0xE0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0,
  0x00, 0x4F, 0x00, 0x0C, 0xD8, 0x01, 0x8C, 0xE0, 0x70, 0xC3, 0xFE, 0x0C,
  0x02, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0x0E, 0x07, 0x31, 0x80,
  0x1B, 0x30, 0x00, 0xF2, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0x40,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x73, 0x00,
  0x0F, 0x18, 0x01, 0xB0, 0xE0, 0x73, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x0C, 0x3F, 0xC6, 0x0C, 0xC0, 0xD8, 0x0D, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01, 0x90, 0x00,
  0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0D,
  0x80, 0x02, 0x30, 0x01, 0x87, 0x01, 0xC0, 0xFF, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0xFF, 0xF0, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xFC, 0x00, 0x80, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03,
  0x60, 0x00, 0xEC, 0x00, 0x1C, 0x80, 0x07, 0x98, 0x01, 0xB1, 0xC0, 0xE6,
  0x1F, 0xF0, 0xC0, 0x20, 0x00, 0x40, 0x00, 0x0B, 0x00, 0x00, 0xD8, 0x00,
  0x04, 0x40, 0x00, 0x22, 0x00, 0x03, 0x18, 0x00, 0x18, 0x40, 0x00, 0x82,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x30, 0x18, 0x01,
  0x80, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x40, 0x20, 0x02,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x80, 0x02, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC2, 0x00, 0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x02,
  0x40, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x40, 0x01, 0x80, 0x03, 0x60, 0x01, 0xC0, 0x03,
  0x60, 0x01, 0x40, 0x03, 0x60, 0x03, 0x40, 0x02, 0x20, 0x03, 0x60, 0x06,
  0x30, 0x02, 0x60, 0x06, 0x30, 0x02, 0x60, 0x06, 0x30, 0x06, 0x20, 0x04,
  0x10, 0x06, 0x30, 0x0C, 0x18, 0x04, 0x30, 0x0C, 0x18, 0x04, 0x10, 0x0C,
  0x18, 0x0C, 0x10, 0x08, 0x08, 0x0C, 0x18, 0x18, 0x0C, 0x08, 0x18, 0x18,
  0x0C, 0x08, 0x08, 0x18, 0x0C, 0x18, 0x08, 0x10, 0x04, 0x10, 0x0C, 0x30,
  0x04, 0x10, 0x04, 0x30, 0x06, 0x30, 0x04, 0x30, 0x06, 0x30, 0x06, 0x20,
  0x02, 0x20, 0x06, 0x60, 0x02, 0x20, 0x02, 0x60, 0x03, 0x60, 0x02, 0x60,
  0x03, 0x60, 0x03, 0x40, 0x01, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x66, 0x00, 0x06, 0x20, 0x00, 0xC3, 0x00, 0x08, 0x18, 0x01,
  0x80, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x60, 0x06, 0x04, 0x00, 0x30,
  0xC0, 0x01, 0x08, 0x00, 0x19, 0x80, 0x00, 0xB0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xB0, 0x00, 0x19, 0x00, 0x01, 0x18, 0x00,
  0x30, 0xC0, 0x06, 0x04, 0x00, 0x60, 0x60, 0x0C, 0x02, 0x00, 0x80, 0x30,
  0x18, 0x01, 0x83, 0x00, 0x08, 0x30, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00,
  0x6C, 0x00, 0x03, 0x40, 0x00, 0x0B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x40,
  0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0x40, 0x00, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x40, 0x02, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x40,
  0x08, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x40, 0x20, 0x03, 0x03, 0x00,
  0x18, 0x18, 0x00, 0x40, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x42,
  0x00, 0x03, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x03, 0x40, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x70, 0x03, 0x80, 0x30, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x10, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x48, 0x0C, 0x00, 0x2C, 0x03, 0x00,
  0x14, 0x00, 0xC0, 0x1E, 0x00, 0x30, 0x0B, 0x00, 0x0C, 0x0D, 0x80, 0x03,
  0x9C, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoCondensed_Thin56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 41, 10, 4, -40 },
  { 17, 7, 11, 14, 4, -42 },
  { 27, 26, 40, 27, 2, -40 },
  { 157, 21, 52, 27, 3, -46 },
  { 294, 30, 42, 36, 3, -41 },
  { 452, 25, 42, 30, 3, -41 },
  { 584, 2, 11, 9, 4, -42 },
  { 587, 10, 57, 15, 4, -44 },
  { 659, 10, 57, 16, 1, -44 },
  { 731, 22, 22, 23, 1, -40 },
  { 792, 23, 29, 28, 2, -33 },
  { 876, 5, 11, 11, 2, -4 },
  { 883, 11, 1, 15, 2, -19 },
  { 885, 3, 3, 12, 4, -2 },
  { 887, 16, 43, 19, 1, -40 },
  { 973, 21, 42, 27, 3, -41 },
  { 1084, 11, 40, 27, 5, -40 },
  { 1139, 21, 41, 27, 3, -41 },
  { 1247, 21, 42, 27, 3, -41 },
  { 1358, 24, 40, 27, 2, -40 },
  { 1478, 19, 41, 27, 5, -40 },
  { 1576, 21, 41, 27, 3, -40 },
  { 1684, 22, 40, 27, 2, -40 },
  { 1794, 21, 42, 27, 3, -41 },
  { 1905, 21, 41, 27, 3, -41 },
  { 2013, 4, 29, 10, 3, -28 },
  { 2028, 5, 35, 10, 2, -28 },
  { 2050, 20, 22, 25, 2, -29 },
  { 2105, 19, 12, 27, 4, -24 },
  { 2134, 20, 22, 26, 3, -29 },
  { 2189, 16, 42, 22, 3, -41 },
  { 2273, 39, 51, 45, 3, -39 },
  { 2522, 27, 40, 30, 1, -40 },
  { 2657, 22, 40, 30, 5, -40 },
  { 2767, 24, 42, 32, 4, -41 },
  { 2893, 23, 40, 32, 5, -40 },
  { 3008, 21, 40, 28, 5, -40 },
  { 3113, 21, 40, 28, 5, -40 },
  { 3218, 24, 42, 34, 5, -41 },
  { 3344, 24, 40, 34, 5, -40 },
  { 3464, 1, 40, 13, 6, -40 },
  { 3469, 19, 41, 27, 3, -40 },
  { 3567, 24, 40, 31, 5, -40 },
  { 3687, 19, 40, 26, 5, -40 },
  { 3782, 32, 40, 42, 5, -40 },
  { 3942, 25, 40, 35, 5, -40 },
  { 4067, 25, 42, 33, 4, -41 },
  { 4199, 22, 40, 30, 5, -40 },
  { 4309, 25, 48, 33, 4, -41 },
  { 4459, 23, 40, 32, 5, -40 },
  { 4574, 24, 42, 29, 3, -41 },
  { 4700, 26, 40, 29, 2, -40 },
  { 4830, 23, 41, 33, 5, -40 },
  { 4948, 27, 40, 30, 1, -40 },
  { 5083, 40, 40, 44, 2, -40 },
  { 5283, 26, 40, 29, 2, -40 },
  { 5413, 27, 40, 29, 1, -40 },
  { 5548, 24, 40, 29, 3, -40 },
  { 5668, 6, 55, 11, 5, -46 },
  { 5710, 15, 43, 19, 2, -40 },
  { 5791, 7, 55, 11, 0, -46 },
  { 5840, 15, 20, 21, 3, -40 },
  { 5878, 20, 1, 21, 0, 0 },
  { 5881, 7, 7, 15, 4, -42 },
  { 5888, 19, 32, 26, 3, -31 },
  { 5964, 20, 43, 27, 4, -42 },
  { 6072, 19, 32, 25, 3, -31 },
  { 6148, 20, 43, 27, 3, -42 },
  { 6256, 20, 32, 25, 3, -31 },
  { 6336, 14, 43, 16, 2, -43 },
  { 6412, 20, 42, 27, 3, -31 },
  { 6517, 19, 42, 27, 4, -42 },
  { 6617, 3, 41, 11, 4, -41 },
  { 6633, 10, 52, 11, -3, -41 },
  { 6698, 19, 42, 24, 4, -42 },
  { 6798, 1, 42, 11, 5, -42 },
  { 6804, 35, 31, 44, 4, -31 },
  { 6940, 19, 31, 27, 4, -31 },
  { 7014, 21, 32, 27, 3, -31 },
  { 7098, 20, 42, 27, 4, -31 },
  { 7203, 20, 42, 27, 3, -31 },
  { 7308, 12, 31, 17, 4, -31 },
  { 7355, 18, 32, 25, 3, -31 },
  { 7427, 13, 39, 16, 1, -38 },
  { 7491, 19, 31, 27, 4, -30 },
  { 7565, 21, 30, 24, 1, -30 },
  { 7644, 32, 30, 37, 2, -30 },
  { 7764, 20, 30, 24, 2, -30 },
  { 7839, 21, 41, 24, 1, -30 },
  { 7947, 19, 30, 24, 3, -30 },
  { 8019, 14, 56, 16, 2, -44 },
  { 8117, 2, 47, 11, 5, -40 },
  { 8129, 13, 56, 16, 1, -44 },
  { 8220, 25, 9, 34, 4, -21 },
};

const GFXfont RobotoCondensed_Thin56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_THIN56PT7B_H_
