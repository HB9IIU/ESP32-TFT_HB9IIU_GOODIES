#ifndef _ROBOTOCONDENSED_THIN42PT7B_H_
#define _ROBOTOCONDENSED_THIN42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin42pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x00, 0xF0, 0x8E, 0x38, 0xE3,
  0x8A, 0x28, 0xA2, 0x00, 0x80, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00, 0x08,
  0x10, 0x00, 0x81, 0x00, 0x18, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x01,
  0x02, 0x03, 0xFF, 0xFF, 0x01, 0x02, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00,
  0x20, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x0F, 0xFF, 0xFC, 0x04, 0x08,
  0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x81,
  0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x03, 0xE0, 0x0C, 0x18, 0x10, 0x0C, 0x20, 0x06, 0x20, 0x02,
  0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x20, 0x02, 0x30, 0x04, 0x0C, 0x18,
  0x03, 0xE0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x1E, 0x00,
  0x00, 0x62, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x04, 0x04,
  0x10, 0x08, 0x10, 0x20, 0x10, 0x20, 0x40, 0x20, 0x80, 0x80, 0x41, 0x01,
  0x80, 0x84, 0x01, 0x02, 0x08, 0x02, 0x04, 0x20, 0x03, 0x10, 0xC0, 0x03,
  0xC1, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0xF0, 0x00,
  0x43, 0x10, 0x01, 0x0C, 0x10, 0x02, 0x10, 0x30, 0x08, 0x20, 0x20, 0x10,
  0xC0, 0x40, 0x41, 0x00, 0x81, 0x82, 0x01, 0x02, 0x02, 0x02, 0x0C, 0x04,
  0x04, 0x10, 0x08, 0x18, 0x00, 0x18, 0x20, 0x00, 0x18, 0x80, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x01, 0x86, 0x00, 0x20, 0x40, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x10, 0x10, 0x03, 0x04,
  0x00, 0x21, 0x00, 0x06, 0x40, 0x00, 0x50, 0x00, 0x04, 0x00, 0x01, 0xC0,
  0x00, 0x48, 0x00, 0x10, 0x80, 0x04, 0x08, 0x09, 0x81, 0x81, 0x20, 0x10,
  0x24, 0x01, 0x05, 0x80, 0x10, 0xA0, 0x03, 0x26, 0x00, 0x24, 0x40, 0x03,
  0x08, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x06, 0x41, 0x81, 0x84, 0x0F, 0xC0,
  0x40, 0xFF, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x60,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x06, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x60, 0x40, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x81, 0x81, 0xE1, 0x8E, 0x1D, 0x30, 0x03, 0xC0, 0x01, 0x80,
  0x02, 0x40, 0x04, 0x60, 0x0C, 0x30, 0x08, 0x10, 0x10, 0x08, 0x30, 0x0C,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xE0,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x24, 0x96, 0x94,
  0xFF, 0x80, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x30, 0xC0, 0x80, 0x43, 0x00,
  0x44, 0x00, 0x88, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x40, 0x02, 0x40, 0x04, 0x80, 0x11, 0x80, 0x21, 0x80, 0x81, 0x86, 0x00,
  0xF8, 0x00, 0x03, 0x0F, 0x31, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0xE0, 0x0C, 0x30,
  0x10, 0x08, 0x20, 0x04, 0x60, 0x04, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02,
  0x80, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x07, 0xE0, 0x0C, 0x18,
  0x10, 0x0C, 0x20, 0x04, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x30,
  0x03, 0xE0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x02,
  0x20, 0x02, 0x30, 0x04, 0x0C, 0x18, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20, 0x01,
  0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x10, 0x04, 0x18, 0x02,
  0x08, 0x01, 0x0C, 0x00, 0x87, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x3F, 0xFD, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x13, 0xF0, 0xF0, 0x63, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x24, 0x00, 0x98,
  0x04, 0x38, 0x60, 0x3F, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x1F, 0x04, 0xC1, 0x8B, 0x01, 0x98, 0x01, 0xB0, 0x01, 0x40, 0x02, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0xC0, 0x04, 0x80, 0x09, 0x80, 0x21, 0x80, 0xC1, 0x83, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x07, 0xE0, 0x1C, 0x18, 0x30, 0x0C, 0x20, 0x06, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x06, 0x10, 0x0C, 0x0C, 0x18, 0x07, 0xE0, 0x18, 0x18, 0x30, 0x04,
  0x60, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x02, 0x30, 0x04, 0x18, 0x18,
  0x07, 0xE0, 0x07, 0xE0, 0x0C, 0x30, 0x10, 0x08, 0x20, 0x04, 0x60, 0x06,
  0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40, 0x05, 0x20, 0x05,
  0x30, 0x09, 0x18, 0x32, 0x07, 0xC2, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x36, 0xDB, 0x5A, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x04, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x0F, 0x83, 0x04, 0x60, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x11, 0x80, 0x1E, 0x00, 0x88, 0x03,
  0x0C, 0x06, 0x40, 0x30, 0x20, 0x12, 0x01, 0x01, 0x00, 0xA0, 0x10, 0x08,
  0x05, 0x00, 0x80, 0x40, 0x28, 0x08, 0x02, 0x01, 0x40, 0x40, 0x10, 0x0A,
  0x02, 0x00, 0x80, 0x50, 0x10, 0x04, 0x02, 0x81, 0x80, 0x20, 0x14, 0x08,
  0x01, 0x00, 0xA0, 0x40, 0x08, 0x05, 0x02, 0x00, 0xC0, 0x68, 0x10, 0x06,
  0x02, 0x40, 0x40, 0x30, 0x12, 0x02, 0x02, 0x81, 0x10, 0x10, 0x24, 0x08,
  0xC0, 0x42, 0x11, 0x82, 0x01, 0xE0, 0x78, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x09, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x06, 0x02,
  0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x10, 0x08, 0x01, 0x00, 0x80,
  0x10, 0x08, 0x01, 0x81, 0x00, 0x08, 0x1F, 0xFF, 0x81, 0x00, 0x0C, 0x20,
  0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x30, 0x80,
  0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30, 0xFF,
  0xE0, 0x80, 0x18, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0x03, 0x81,
  0x00, 0x30, 0x80, 0x04, 0x60, 0x00, 0x90, 0x00, 0x24, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x05, 0x00,
  0x03, 0x40, 0x00, 0x88, 0x00, 0x23, 0x00, 0x10, 0x60, 0x0C, 0x0C, 0x0E,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x40, 0x18, 0x20, 0x03, 0x10, 0x00, 0xC8,
  0x00, 0x24, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x01,
  0x90, 0x01, 0x88, 0x03, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0xC0, 0x60, 0x06, 0x18,
  0x00, 0x42, 0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x12, 0x00, 0x01, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00,
  0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x40, 0x01, 0x84, 0x00, 0x60, 0x60,
  0x70, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x02, 0x80, 0x04, 0x80, 0x09, 0x00, 0x21, 0x00,
  0xC1, 0x83, 0x01, 0xF8, 0x00, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x62,
  0x00, 0x30, 0x80, 0x08, 0x20, 0x04, 0x08, 0x02, 0x02, 0x01, 0x80, 0x80,
  0xC0, 0x20, 0x20, 0x08, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x23, 0x00,
  0x09, 0xC0, 0x02, 0xC8, 0x00, 0xA1, 0x00, 0x30, 0x60, 0x08, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x60, 0x20, 0x0C, 0x08, 0x01, 0x02, 0x00, 0x20, 0x80,
  0x0C, 0x20, 0x01, 0x88, 0x00, 0x22, 0x00, 0x04, 0x80, 0x01, 0xA0, 0x00,
  0x20, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xA0, 0x00, 0x07, 0xA0, 0x00, 0x0B, 0xA0, 0x00, 0x0B,
  0x90, 0x00, 0x0B, 0x90, 0x00, 0x13, 0x90, 0x00, 0x13, 0x88, 0x00, 0x33,
  0x88, 0x00, 0x23, 0x8C, 0x00, 0x23, 0x84, 0x00, 0x43, 0x84, 0x00, 0x43,
  0x82, 0x00, 0x43, 0x82, 0x00, 0x83, 0x82, 0x00, 0x83, 0x81, 0x00, 0x83,
  0x81, 0x01, 0x03, 0x81, 0x01, 0x03, 0x80, 0x83, 0x03, 0x80, 0x82, 0x03,
  0x80, 0x42, 0x03, 0x80, 0x44, 0x03, 0x80, 0x44, 0x03, 0x80, 0x24, 0x03,
  0x80, 0x28, 0x03, 0x80, 0x28, 0x03, 0x80, 0x18, 0x03, 0x80, 0x10, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0x64,
  0x00, 0x19, 0x80, 0x06, 0x20, 0x01, 0x84, 0x00, 0x61, 0x00, 0x18, 0x20,
  0x06, 0x0C, 0x01, 0x81, 0x00, 0x60, 0x20, 0x18, 0x08, 0x06, 0x01, 0x01,
  0x80, 0x60, 0x60, 0x08, 0x18, 0x03, 0x06, 0x00, 0x41, 0x80, 0x08, 0x60,
  0x02, 0x18, 0x00, 0x46, 0x00, 0x19, 0x80, 0x02, 0x60, 0x00, 0xD8, 0x00,
  0x16, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x10, 0x03, 0xF8, 0x01, 0x81,
  0xC0, 0x40, 0x0C, 0x10, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x00, 0xB0, 0x00,
  0x14, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x4C, 0x00, 0x10, 0x80, 0x06,
  0x08, 0x01, 0x80, 0xC0, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x80, 0x18,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x01, 0x81,
  0xC0, 0x40, 0x0C, 0x10, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x00, 0xB0, 0x00,
  0x14, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x16, 0x00, 0x02, 0x40, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x06,
  0x08, 0x01, 0x80, 0xC0, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x40, 0x0C,
  0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x11, 0x00, 0x30, 0xFF, 0xE0, 0x40, 0x10, 0x20, 0x08,
  0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x31, 0x00, 0x08, 0x80,
  0x06, 0x40, 0x01, 0x20, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x04,
  0x03, 0xF8, 0x03, 0x03, 0x83, 0x00, 0x30, 0x80, 0x06, 0x40, 0x00, 0x90,
  0x00, 0x24, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x22, 0x00,
  0x18, 0xC0, 0x0C, 0x0C, 0x0E, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x60, 0x00, 0x90, 0x00, 0xC4, 0x00, 0xC1, 0x81,
  0xC0, 0x3F, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x60, 0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0x43, 0x00, 0x04, 0x10,
  0x00, 0xC1, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00,
  0x80, 0x10, 0x04, 0x03, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x20, 0x20,
  0x02, 0x04, 0x00, 0x20, 0x40, 0x03, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x01, 0x00, 0x04, 0x80, 0x03,
  0x00, 0x09, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x14, 0x00, 0x26, 0x00, 0x28,
  0x00, 0xC4, 0x00, 0x48, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10, 0x02, 0x20,
  0x04, 0x30, 0x04, 0x40, 0x18, 0x20, 0x08, 0x40, 0x20, 0x40, 0x20, 0x80,
  0x40, 0x80, 0x41, 0x00, 0x81, 0x00, 0x82, 0x01, 0x03, 0x03, 0x02, 0x06,
  0x02, 0x04, 0x04, 0x08, 0x04, 0x08, 0x08, 0x10, 0x08, 0x10, 0x10, 0x20,
  0x18, 0x60, 0x10, 0xC0, 0x10, 0x80, 0x21, 0x00, 0x21, 0x00, 0x42, 0x00,
  0x42, 0x00, 0x84, 0x00, 0x8C, 0x01, 0x88, 0x00, 0x90, 0x01, 0x30, 0x01,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x80, 0x05, 0x80, 0x0D, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x41, 0x00,
  0x08, 0x18, 0x01, 0x80, 0x80, 0x10, 0x04, 0x03, 0x00, 0x40, 0x20, 0x02,
  0x04, 0x00, 0x30, 0x40, 0x01, 0x08, 0x00, 0x19, 0x80, 0x00, 0x90, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00,
  0x01, 0x08, 0x00, 0x10, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x20, 0x04, 0x02,
  0x00, 0x80, 0x10, 0x08, 0x01, 0x81, 0x00, 0x08, 0x30, 0x00, 0xC2, 0x00,
  0x04, 0x60, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x60,
  0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x80,
  0x80, 0x10, 0x0C, 0x03, 0x00, 0x40, 0x20, 0x06, 0x06, 0x00, 0x20, 0x40,
  0x03, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x09, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x10, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x3F, 0x04, 0x00, 0xC0, 0x28, 0x05, 0x00, 0x90, 0x22, 0x04, 0x40,
  0x84, 0x20, 0x84, 0x11, 0x81, 0x20, 0x24, 0x05, 0x80, 0x60, 0x08, 0xFF,
  0xFE, 0xC3, 0x08, 0x20, 0x80, 0x07, 0xE0, 0x30, 0x60, 0x80, 0x22, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x1F, 0xF1, 0xC0, 0x26, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x1A, 0x00, 0x32, 0x00, 0xA3, 0x06, 0x43, 0xF0, 0xC0, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x1F, 0x84, 0xC1, 0x8A, 0x00, 0x9C,
  0x01, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x16, 0x00, 0x2C, 0x00, 0xD4, 0x01, 0x26, 0x0C, 0x43, 0xE0, 0x07,
  0xE0, 0x30, 0x60, 0x80, 0x23, 0x00, 0x24, 0x00, 0x48, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x40, 0x02, 0x80, 0x09, 0x80, 0x11, 0x00,
  0x41, 0x83, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x1F, 0x08, 0xC1, 0x93, 0x00, 0xA4, 0x00, 0xD0, 0x01, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x66,
  0x01, 0x46, 0x0C, 0x83, 0xF1, 0x07, 0xE0, 0x30, 0x70, 0xC0, 0x23, 0x00,
  0x24, 0x00, 0x58, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x21, 0xC1, 0x80, 0xFC, 0x00, 0x03,
  0xC3, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F,
  0xF8, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x07, 0xC2, 0x30, 0x64, 0xC0, 0x29, 0x00, 0x34, 0x00,
  0x68, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x04, 0x80, 0x19, 0x80, 0x51, 0x83, 0x20, 0xFC, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x19, 0x00, 0x23, 0x00, 0xC3, 0x03, 0x01,
  0xF8, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x3E, 0x23, 0x0C, 0x90,
  0x0A, 0x80, 0x2A, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xF0, 0x00,
  0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x18, 0x20, 0x43, 0x3C, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0xA0, 0x04, 0x80, 0x22, 0x01, 0x08, 0x08, 0x20, 0x40, 0x83, 0x02, 0x18,
  0x08, 0xC0, 0x26, 0x00, 0xBC, 0x02, 0x90, 0x0C, 0x20, 0x20, 0x40, 0x81,
  0x82, 0x02, 0x08, 0x04, 0x20, 0x18, 0x80, 0x32, 0x00, 0x48, 0x00, 0xA0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x3E, 0x11, 0x86, 0x18, 0x32,
  0x40, 0x66, 0x02, 0x50, 0x05, 0x80, 0x2A, 0x00, 0xE0, 0x05, 0x80, 0x0C,
  0x00, 0xB0, 0x01, 0x00, 0x1C, 0x00, 0x20, 0x03, 0x80, 0x04, 0x00, 0x70,
  0x00, 0x80, 0x0E, 0x00, 0x10, 0x01, 0xC0, 0x02, 0x00, 0x38, 0x00, 0x40,
  0x07, 0x00, 0x08, 0x00, 0xE0, 0x01, 0x00, 0x1C, 0x00, 0x20, 0x03, 0x80,
  0x04, 0x00, 0x70, 0x00, 0x80, 0x0E, 0x00, 0x10, 0x01, 0xC0, 0x02, 0x00,
  0x38, 0x00, 0x40, 0x07, 0x00, 0x08, 0x00, 0xC0, 0x83, 0xE2, 0x30, 0xC9,
  0x00, 0xA8, 0x02, 0xA0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x07,
  0xE0, 0x0C, 0x18, 0x10, 0x0C, 0x20, 0x04, 0x60, 0x02, 0x40, 0x02, 0x40,
  0x03, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20,
  0x04, 0x10, 0x0C, 0x0C, 0x18, 0x07, 0xE0, 0x87, 0xC1, 0x30, 0x62, 0x80,
  0x27, 0x00, 0x6C, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x05, 0x80, 0x0B, 0x00, 0x35, 0x00, 0x49, 0x83, 0x10, 0xFC,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC2, 0x30, 0x64, 0xC0, 0x29,
  0x00, 0x34, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x04, 0x80, 0x19, 0x80, 0x51, 0x83, 0x20, 0xFC, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x87, 0xC4, 0x24, 0x14, 0x0A, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0xC0, 0xC0, 0xC6, 0x01, 0x90,
  0x02, 0x40, 0x0D, 0x00, 0x14, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x14, 0x00, 0xD8, 0x02, 0x30, 0x30, 0x3F, 0x00, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC3, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x08, 0x04, 0x03, 0x00, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x05, 0x00,
  0x34, 0x00, 0xD8, 0x05, 0x30, 0x64, 0x3E, 0x10, 0x80, 0x03, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x18, 0x08, 0x10, 0x08, 0x10, 0x08, 0x30, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x80, 0x10, 0x03, 0x80, 0x18, 0x02, 0xC0, 0x18,
  0x02, 0x40, 0x28, 0x02, 0x40, 0x2C, 0x06, 0x40, 0x24, 0x04, 0x60, 0x64,
  0x04, 0x20, 0x44, 0x04, 0x20, 0x46, 0x0C, 0x20, 0x42, 0x08, 0x30, 0x82,
  0x08, 0x10, 0x82, 0x08, 0x10, 0x81, 0x18, 0x10, 0x81, 0x10, 0x19, 0x01,
  0x10, 0x09, 0x01, 0x90, 0x09, 0x00, 0xB0, 0x0A, 0x00, 0xA0, 0x0A, 0x00,
  0xA0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x40, 0x06,
  0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x10, 0x08, 0x30, 0x04, 0x20,
  0x06, 0x60, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0xC0,
  0x02, 0x40, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x10, 0x18, 0x30, 0x08,
  0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x80, 0x03, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x08,
  0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xC0, 0x60, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x60, 0x30, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x60, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1E, 0x00,
  0x24, 0x20, 0x05, 0x02, 0x00, 0xA0, 0x20, 0x38, 0x02, 0x05, 0x00, 0x31,
  0x20, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_Thin42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 30, 8, 3, -30 },
  { 9, 6, 8, 11, 3, -32 },
  { 15, 20, 30, 20, 1, -30 },
  { 90, 16, 38, 20, 2, -34 },
  { 166, 23, 30, 27, 2, -30 },
  { 253, 19, 30, 23, 2, -30 },
  { 325, 1, 8, 7, 3, -32 },
  { 326, 8, 43, 11, 3, -33 },
  { 369, 8, 43, 12, 1, -33 },
  { 412, 16, 16, 18, 1, -30 },
  { 444, 17, 21, 21, 2, -24 },
  { 489, 3, 8, 8, 2, -3 },
  { 492, 9, 1, 11, 1, -14 },
  { 494, 2, 2, 9, 3, -2 },
  { 495, 12, 33, 14, 1, -30 },
  { 545, 15, 30, 20, 3, -30 },
  { 602, 8, 30, 20, 4, -30 },
  { 632, 16, 30, 20, 2, -30 },
  { 692, 16, 30, 20, 2, -30 },
  { 752, 17, 30, 20, 2, -30 },
  { 816, 14, 30, 20, 4, -30 },
  { 869, 15, 30, 20, 3, -30 },
  { 926, 16, 30, 20, 2, -30 },
  { 986, 16, 30, 20, 2, -30 },
  { 1046, 16, 30, 20, 2, -30 },
  { 1106, 2, 22, 7, 3, -22 },
  { 1112, 3, 27, 7, 2, -22 },
  { 1123, 14, 17, 19, 2, -22 },
  { 1153, 14, 9, 21, 3, -18 },
  { 1169, 15, 17, 19, 2, -22 },
  { 1201, 12, 30, 16, 2, -30 },
  { 1246, 29, 38, 34, 2, -29 },
  { 1384, 20, 30, 22, 1, -30 },
  { 1459, 16, 30, 22, 4, -30 },
  { 1519, 18, 30, 24, 3, -30 },
  { 1587, 17, 30, 24, 4, -30 },
  { 1651, 15, 30, 21, 4, -30 },
  { 1708, 16, 30, 21, 4, -30 },
  { 1768, 19, 30, 25, 3, -30 },
  { 1840, 18, 30, 26, 4, -30 },
  { 1908, 2, 30, 10, 4, -30 },
  { 1916, 15, 30, 20, 2, -30 },
  { 1973, 18, 30, 23, 4, -30 },
  { 2041, 14, 30, 19, 4, -30 },
  { 2094, 24, 30, 31, 4, -30 },
  { 2184, 18, 30, 26, 4, -30 },
  { 2252, 19, 30, 25, 3, -30 },
  { 2324, 16, 30, 22, 4, -30 },
  { 2384, 19, 35, 25, 3, -30 },
  { 2468, 17, 30, 24, 4, -30 },
  { 2532, 18, 30, 22, 2, -30 },
  { 2600, 20, 30, 22, 1, -30 },
  { 2675, 17, 30, 24, 4, -30 },
  { 2739, 20, 30, 22, 1, -30 },
  { 2814, 31, 30, 33, 1, -30 },
  { 2931, 20, 30, 22, 1, -30 },
  { 3006, 20, 30, 22, 1, -30 },
  { 3081, 18, 30, 22, 2, -30 },
  { 3149, 6, 40, 9, 3, -34 },
  { 3179, 12, 33, 14, 1, -30 },
  { 3229, 5, 40, 9, 0, -34 },
  { 3254, 11, 15, 16, 2, -30 },
  { 3275, 15, 1, 16, 0, 0 },
  { 3277, 5, 5, 11, 3, -31 },
  { 3281, 15, 22, 20, 2, -22 },
  { 3323, 15, 32, 20, 3, -32 },
  { 3383, 15, 22, 19, 2, -22 },
  { 3425, 15, 32, 20, 2, -32 },
  { 3485, 15, 22, 19, 2, -22 },
  { 3527, 10, 32, 12, 2, -32 },
  { 3567, 15, 31, 20, 2, -22 },
  { 3626, 14, 32, 20, 3, -32 },
  { 3682, 2, 30, 8, 3, -30 },
  { 3690, 7, 39, 9, -2, -30 },
  { 3725, 14, 32, 18, 3, -32 },
  { 3781, 1, 32, 8, 4, -32 },
  { 3785, 27, 22, 33, 3, -22 },
  { 3860, 14, 22, 20, 3, -22 },
  { 3899, 16, 22, 20, 2, -22 },
  { 3943, 15, 31, 20, 3, -22 },
  { 4002, 15, 31, 20, 2, -22 },
  { 4061, 9, 22, 13, 3, -22 },
  { 4086, 14, 22, 19, 2, -22 },
  { 4125, 9, 28, 12, 1, -28 },
  { 4157, 14, 22, 20, 3, -22 },
  { 4196, 16, 22, 18, 1, -22 },
  { 4240, 24, 22, 28, 2, -22 },
  { 4306, 16, 22, 18, 1, -22 },
  { 4350, 16, 31, 18, 1, -22 },
  { 4412, 15, 22, 18, 2, -22 },
  { 4454, 10, 42, 12, 2, -33 },
  { 4507, 1, 36, 8, 4, -30 },
  { 4512, 11, 42, 12, 0, -33 },
  { 4570, 19, 7, 25, 3, -16 },
};

const GFXfont RobotoCondensed_Thin42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_THIN42PT7B_H_
