#ifndef _ROBOTOCONDENSED_THIN67PT7B_H_
#define _ROBOTOCONDENSED_THIN67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin67pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x40, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xB0, 0x58, 0x2C, 0x10, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x10, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x02, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0xC0, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0x80, 0x03, 0x80, 0xF0, 0x07, 0x00, 0x1C,
  0x03, 0x00, 0x07, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x01, 0x80,
  0xE0, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x80, 0x06, 0x00, 0x60, 0x08,
  0x00, 0x60, 0x06, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x06, 0x01, 0x80, 0x08, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x80, 0xC0,
  0x00, 0x1F, 0xF0, 0x18, 0x00, 0x00, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x7E, 0x00, 0x00, 0x10, 0x0F, 0xF8, 0x00, 0x03,
  0x01, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x60,
  0x00, 0xC0, 0x60, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x20, 0x01, 0x80, 0x40,
  0x03, 0x00, 0x18, 0x04, 0x00, 0x30, 0x03, 0x00, 0x40, 0x03, 0x00, 0x30,
  0x04, 0x00, 0x30, 0x06, 0x00, 0x40, 0x03, 0x00, 0x60, 0x04, 0x00, 0x30,
  0x0C, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x02, 0x00, 0x80, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x10, 0xC0, 0x1C, 0x00, 0x43, 0x00, 0x30, 0x03,
  0x18, 0x00, 0x60, 0x0C, 0x60, 0x00, 0xC0, 0x33, 0x00, 0x03, 0x00, 0xCC,
  0x00, 0x06, 0x03, 0x30, 0x00, 0x0C, 0x08, 0xC0, 0x00, 0x18, 0x63, 0x00,
  0x00, 0x61, 0x8C, 0x00, 0x00, 0xCC, 0x30, 0x00, 0x01, 0xB0, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01,
  0xB0, 0x70, 0x00, 0x0C, 0xE0, 0xE0, 0x00, 0x61, 0x81, 0xC0, 0x03, 0x03,
  0x03, 0xC0, 0x78, 0x06, 0x03, 0xFF, 0x80, 0x1C, 0x01, 0xF8, 0x00, 0x00,
  0x6D, 0xB6, 0xDB, 0x49, 0x6D, 0x80, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x78, 0x03, 0x00, 0x77,
  0xC0, 0xC0, 0xF8, 0x3C, 0x30, 0xF0, 0x03, 0xED, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x0C,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x66, 0x31, 0x99, 0xC4, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xF4, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x81, 0xE0,
  0x06, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x70,
  0x03, 0x81, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x03,
  0xC0, 0x7E, 0x0E, 0x33, 0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x78,
  0x01, 0x80, 0x0E, 0x01, 0x80, 0x03, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x0F, 0x01,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x83, 0xF8, 0x03, 0x3F, 0xFC, 0x06, 0xC0, 0x1C, 0x0E, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x02, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x21,
  0x80, 0x00, 0xC3, 0x80, 0x03, 0x03, 0x80, 0x0C, 0x03, 0xC0, 0x70, 0x01,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x1F,
  0xC0, 0x10, 0x7F, 0xF8, 0x08, 0x70, 0x0E, 0x0C, 0x60, 0x03, 0x86, 0x60,
  0x00, 0x63, 0x60, 0x00, 0x31, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x02, 0x70,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x02, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x38, 0x01, 0x80, 0x0F, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x07, 0x00, 0x38, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x26, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x01, 0xC0,
  0x1F, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xC4, 0x00, 0x01, 0xE3, 0x00,
  0x01, 0xB0, 0xC0, 0x01, 0x98, 0x30, 0x01, 0xCC, 0x0E, 0x03, 0x86, 0x03,
  0xFF, 0x83, 0x00, 0x7E, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6F, 0xF6, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0xFF, 0x60, 0x33, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x63, 0x18, 0xCC,
  0x63, 0x19, 0x8C, 0xC4, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x0E, 0x03, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x04, 0x18, 0x00,
  0x1C, 0x0E, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x63, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x8C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x09, 0x80, 0x06, 0x00, 0x08, 0x00, 0x26, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xD8, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x40, 0x03, 0x00, 0x02,
  0x00, 0x0D, 0x00, 0x08, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x0F, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x40, 0x00, 0x60, 0x00,
  0xF0, 0x01, 0x00, 0x01, 0x80, 0x02, 0xC0, 0x04, 0x00, 0x06, 0x00, 0x0B,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x2C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xB0,
  0x03, 0x00, 0x01, 0x00, 0x06, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x1B, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x4C, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x10, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x40, 0x06, 0x00, 0x14, 0x00, 0x21, 0x80, 0x18,
  0x00, 0xD8, 0x01, 0x86, 0x00, 0x30, 0x06, 0x60, 0x0C, 0x18, 0x00, 0xC0,
  0x30, 0xC0, 0x60, 0x30, 0x01, 0xC1, 0x81, 0x83, 0x80, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x03, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x0F, 0x03, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x78, 0x30, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0E, 0x30, 0x00, 0x0E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x0C, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0xF0, 0x0C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x0F, 0x01, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x03,
  0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x0F, 0x00, 0x00, 0x18, 0xEC, 0x00, 0x00, 0xC6, 0x30, 0x00,
  0x06, 0x61, 0x80, 0x00, 0x36, 0x06, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x60, 0x00, 0x00, 0x01, 0xBD, 0x80,
  0x00, 0x00, 0x06, 0xF2, 0x00, 0x00, 0x00, 0x13, 0xCC, 0x00, 0x00, 0x00,
  0xCF, 0x30, 0x00, 0x00, 0x03, 0x3C, 0x40, 0x00, 0x00, 0x08, 0xF1, 0x80,
  0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0x01, 0x8F, 0x08, 0x00, 0x00, 0x04,
  0x3C, 0x30, 0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x00, 0xC3, 0xC1, 0x80,
  0x00, 0x06, 0x0F, 0x06, 0x00, 0x00, 0x18, 0x3C, 0x08, 0x00, 0x00, 0x40,
  0xF0, 0x30, 0x00, 0x03, 0x03, 0xC0, 0xC0, 0x00, 0x0C, 0x0F, 0x01, 0x00,
  0x00, 0x20, 0x3C, 0x06, 0x00, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x06, 0x03,
  0xC0, 0x20, 0x00, 0x30, 0x0F, 0x00, 0xC0, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0x03, 0x00, 0xF0, 0x06, 0x00, 0x18, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x0F,
  0x00, 0x20, 0x01, 0x00, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00,
  0x30, 0x03, 0xC0, 0x04, 0x00, 0x80, 0x0F, 0x00, 0x18, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x18, 0x00, 0xF0, 0x00, 0x80, 0xC0, 0x03, 0xC0, 0x03, 0x03,
  0x00, 0x0F, 0x00, 0x0C, 0x0C, 0x00, 0x3C, 0x00, 0x18, 0x60, 0x00, 0xF0,
  0x00, 0x61, 0x80, 0x03, 0xC0, 0x00, 0x84, 0x00, 0x0F, 0x00, 0x03, 0x30,
  0x00, 0x3C, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x12, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x06,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x01, 0x80, 0x1C,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x8C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x07, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x06, 0x20, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x02, 0x20, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x08,
  0x00, 0x08, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x0C,
  0x00, 0x10, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x04, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x02, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03,
  0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x81, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0xC1, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x26, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x06, 0x80, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x31, 0x00, 0x08, 0x60, 0x06,
  0x18, 0x01, 0x82, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x0C, 0x04, 0x02, 0x01,
  0x81, 0x80, 0x60, 0x60, 0x08, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x10,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0E,
  0x06, 0x03, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xF0, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0x00, 0x06, 0x1C,
  0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0x40, 0x00, 0x1E, 0x60,
  0x00, 0x36, 0x70, 0x00, 0x66, 0x38, 0x00, 0xC6, 0x1C, 0x07, 0x86, 0x0F,
  0xFE, 0x03, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x0F, 0x80,
  0x60, 0xFF, 0xE0, 0xC7, 0x00, 0xE1, 0x98, 0x00, 0xE3, 0x60, 0x00, 0xE7,
  0x80, 0x00, 0xCF, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x01, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x17, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0xDE, 0x00, 0x03, 0x36, 0x00, 0x0E, 0x66, 0x00, 0x38, 0xC7,
  0x00, 0xE1, 0x87, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x0E,
  0x00, 0x38, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x1F, 0x01, 0x81, 0xFF, 0xC3, 0x0F, 0x01, 0xC6,
  0x38, 0x00, 0xCC, 0x60, 0x00, 0xD9, 0x80, 0x00, 0xF3, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xD8, 0x00, 0x01, 0xA0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x33, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xC6,
  0x00, 0x07, 0x86, 0x00, 0x3B, 0x07, 0x01, 0xE6, 0x07, 0xFF, 0x0C, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0xF0, 0x0E,
  0x00, 0x38, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x0C, 0x03, 0xC0, 0x78, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x0C,
  0x3C, 0x07, 0x18, 0xE0, 0x03, 0x31, 0x80, 0x03, 0x66, 0x00, 0x03, 0xCC,
  0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98,
  0x00, 0x07, 0x18, 0x00, 0x1E, 0x18, 0x00, 0xEC, 0x1C, 0x07, 0x98, 0x1F,
  0xFC, 0x30, 0x07, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x63, 0x00, 0x00, 0xC7, 0x00, 0x03, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x38,
  0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x03, 0xE0, 0x30,
  0x3F, 0xF0, 0xC3, 0x80, 0xE3, 0x1C, 0x01, 0xCC, 0xC0, 0x03, 0x33, 0x00,
  0x06, 0xD8, 0x00, 0x1B, 0x40, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x5F, 0xF0, 0x00, 0x00, 0x00, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x8F, 0xE1, 0xF0, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x0C,
  0x30, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x03, 0x01, 0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x30,
  0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x33, 0x60, 0x00,
  0xD9, 0xC0, 0x03, 0xC3, 0x00, 0x0E, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x06,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x30, 0x7F, 0xE0, 0x07, 0xFF, 0x0C, 0x38, 0x0E, 0x03, 0x80,
  0xE3, 0x18, 0x01, 0xC1, 0x80, 0x0C, 0xCC, 0x00, 0x30, 0xC0, 0x03, 0xB6,
  0x00, 0x06, 0x60, 0x00, 0x6D, 0x00, 0x01, 0xB0, 0x00, 0x0B, 0xC0, 0x00,
  0x2C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x3E, 0x03, 0x03, 0xFF, 0x0C,
  0x38, 0x0E, 0x31, 0xC0, 0x1C, 0xCC, 0x00, 0x33, 0x30, 0x00, 0x6D, 0x80,
  0x01, 0xB4, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x01,
  0x81, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02,
  0xC0, 0x00, 0x01, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x18, 0x01, 0xE0, 0x38, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0x83, 0xFF, 0x83, 0x1C,
  0x03, 0x86, 0x60, 0x03, 0x8D, 0x80, 0x03, 0x9E, 0x00, 0x03, 0x38, 0x00,
  0x03, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x5C, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x78, 0x00,
  0x0C, 0xD8, 0x00, 0x39, 0x98, 0x00, 0xE3, 0x1C, 0x07, 0x86, 0x1F, 0xFC,
  0x0C, 0x07, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x0C, 0x3C,
  0x07, 0x18, 0xE0, 0x03, 0x31, 0x80, 0x03, 0x66, 0x00, 0x03, 0xCC, 0x00,
  0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00,
  0x07, 0x18, 0x00, 0x1E, 0x18, 0x00, 0xEC, 0x1C, 0x07, 0x98, 0x1F, 0xFC,
  0x30, 0x07, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0x07, 0xFC, 0x30, 0x31, 0x80,
  0xCC, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0xFE, 0x00, 0xE0, 0x1E, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x66, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x30, 0x00, 0x18, 0x60, 0x00, 0xC0, 0xF0, 0x0E, 0x00, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x03, 0xFF, 0xF7, 0xFF,
  0xE0, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1F, 0xC0, 0x0F, 0x80, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00,
  0x1D, 0x80, 0x00, 0x73, 0x00, 0x03, 0xCC, 0x00, 0x1B, 0x18, 0x00, 0xCC,
  0x38, 0x0E, 0x30, 0x7F, 0xF0, 0xC0, 0x3E, 0x00, 0xC0, 0x00, 0x01, 0x60,
  0x00, 0x01, 0x90, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x10, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x10,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xD8, 0x00, 0x1E, 0x00, 0x06, 0x60, 0x00, 0x78, 0x00, 0x19, 0x80, 0x01,
  0x20, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x8C, 0x00, 0x33, 0x00, 0x0C,
  0x30, 0x00, 0xCC, 0x00, 0x30, 0xC0, 0x02, 0x10, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x07, 0x06, 0x00, 0x61, 0x80, 0x18, 0x18, 0x01, 0x06, 0x00, 0x60,
  0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0E, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60, 0x06, 0x0C, 0x00,
  0x81, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00,
  0xC2, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x64, 0x00, 0x09, 0x80, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x03,
  0x60, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x1C, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0x90, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x08, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x20, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x30,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x13, 0x81, 0x80, 0x00, 0xCC, 0x03, 0x00, 0x03, 0x60,
  0x06, 0x00, 0x0D, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x18, 0x01, 0xB0, 0x00,
  0x30, 0x06, 0xC0, 0x00, 0x70, 0x33, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Thin67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 49, 12, 5, -48 },
  { 20, 9, 13, 17, 5, -50 },
  { 35, 31, 48, 33, 2, -48 },
  { 221, 25, 62, 32, 4, -55 },
  { 415, 36, 50, 44, 4, -49 },
  { 640, 30, 50, 36, 4, -49 },
  { 828, 3, 14, 11, 4, -50 },
  { 834, 12, 68, 18, 5, -53 },
  { 936, 13, 68, 19, 1, -53 },
  { 1047, 26, 26, 28, 1, -48 },
  { 1132, 27, 35, 33, 3, -40 },
  { 1251, 5, 13, 13, 3, -5 },
  { 1260, 13, 2, 18, 2, -23 },
  { 1264, 4, 4, 15, 5, -3 },
  { 1266, 18, 52, 23, 2, -48 },
  { 1383, 24, 50, 32, 4, -49 },
  { 1533, 13, 48, 32, 6, -48 },
  { 1611, 25, 49, 32, 4, -49 },
  { 1765, 26, 50, 32, 3, -49 },
  { 1928, 28, 48, 32, 3, -48 },
  { 2096, 23, 49, 32, 6, -48 },
  { 2237, 25, 49, 32, 4, -48 },
  { 2391, 26, 48, 32, 3, -48 },
  { 2547, 26, 50, 32, 3, -49 },
  { 2710, 25, 49, 32, 3, -49 },
  { 2864, 4, 35, 12, 4, -34 },
  { 2882, 5, 42, 11, 3, -34 },
  { 2909, 23, 26, 30, 3, -35 },
  { 2984, 23, 16, 33, 5, -30 },
  { 3030, 23, 26, 31, 4, -35 },
  { 3105, 20, 50, 26, 3, -49 },
  { 3230, 46, 61, 54, 4, -46 },
  { 3581, 33, 48, 35, 1, -48 },
  { 3779, 26, 48, 36, 6, -48 },
  { 3935, 29, 50, 38, 5, -49 },
  { 4117, 28, 48, 38, 6, -48 },
  { 4285, 25, 48, 34, 6, -48 },
  { 4435, 25, 48, 34, 6, -48 },
  { 4585, 30, 50, 40, 5, -49 },
  { 4773, 29, 48, 41, 6, -48 },
  { 4947, 2, 48, 16, 7, -48 },
  { 4959, 24, 49, 32, 3, -48 },
  { 5106, 29, 48, 37, 6, -48 },
  { 5280, 23, 48, 31, 6, -48 },
  { 5418, 38, 48, 50, 6, -48 },
  { 5646, 29, 48, 41, 6, -48 },
  { 5820, 30, 50, 39, 5, -49 },
  { 6008, 26, 48, 35, 6, -48 },
  { 6164, 31, 58, 39, 4, -49 },
  { 6389, 28, 48, 38, 6, -48 },
  { 6557, 29, 50, 35, 3, -49 },
  { 6739, 31, 48, 35, 2, -48 },
  { 6925, 27, 49, 39, 6, -48 },
  { 7091, 32, 48, 35, 2, -48 },
  { 7283, 48, 48, 53, 2, -48 },
  { 7571, 31, 48, 35, 2, -48 },
  { 7757, 33, 48, 35, 1, -48 },
  { 7955, 29, 48, 35, 3, -48 },
  { 8129, 8, 64, 14, 6, -54 },
  { 8193, 19, 52, 23, 2, -48 },
  { 8317, 8, 64, 14, 0, -54 },
  { 8381, 18, 24, 25, 3, -48 },
  { 8435, 23, 2, 25, 1, 0 },
  { 8441, 8, 9, 18, 5, -51 },
  { 8450, 24, 37, 31, 3, -36 },
  { 8561, 23, 51, 32, 5, -50 },
  { 8708, 24, 37, 30, 3, -36 },
  { 8819, 23, 51, 32, 4, -50 },
  { 8966, 24, 37, 30, 3, -36 },
  { 9077, 17, 51, 19, 2, -51 },
  { 9186, 23, 50, 32, 4, -36 },
  { 9330, 22, 50, 32, 5, -50 },
  { 9468, 3, 48, 13, 5, -48 },
  { 9486, 11, 62, 14, -3, -48 },
  { 9572, 22, 50, 28, 5, -50 },
  { 9710, 1, 50, 13, 6, -50 },
  { 9717, 42, 36, 52, 5, -36 },
  { 9906, 22, 36, 32, 5, -36 },
  { 10005, 25, 37, 32, 4, -36 },
  { 10121, 23, 50, 32, 5, -36 },
  { 10265, 23, 50, 32, 4, -36 },
  { 10409, 14, 36, 20, 5, -36 },
  { 10472, 22, 37, 30, 3, -36 },
  { 10574, 15, 46, 19, 2, -45 },
  { 10661, 22, 36, 32, 5, -35 },
  { 10760, 25, 35, 28, 2, -35 },
  { 10870, 38, 35, 44, 3, -35 },
  { 11037, 24, 35, 28, 2, -35 },
  { 11142, 25, 49, 28, 2, -35 },
  { 11296, 24, 35, 28, 3, -35 },
  { 11401, 16, 67, 20, 3, -52 },
  { 11535, 2, 57, 13, 6, -48 },
  { 11550, 16, 67, 20, 1, -52 },
  { 11684, 30, 11, 40, 5, -26 },
};

const GFXfont RobotoCondensed_Thin67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_THIN67PT7B_H_
