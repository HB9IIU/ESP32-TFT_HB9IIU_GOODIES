#ifndef _ROBOTOCONDENSED_THIN45PT7B_H_
#define _ROBOTOCONDENSED_THIN45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin45pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x54, 0x00, 0x0F, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0x84, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x30,
  0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10,
  0x10, 0x00, 0x80, 0x81, 0xFF, 0xFF, 0xC0, 0x60, 0x40, 0x02, 0x02, 0x00,
  0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x60, 0x03, 0x02,
  0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01,
  0x01, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20,
  0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x04, 0x00, 0x20,
  0x20, 0x01, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x07, 0xE0, 0x1C, 0x18, 0x30, 0x0C, 0x20, 0x06, 0x40, 0x02, 0x40, 0x03,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x60, 0x06, 0x30, 0x04,
  0x1C, 0x18, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x0F, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x08, 0x08, 0x00,
  0x04, 0x04, 0x03, 0x02, 0x01, 0x01, 0x03, 0x00, 0x81, 0x01, 0x80, 0x40,
  0x80, 0xC0, 0x20, 0x80, 0x20, 0x30, 0x40, 0x10, 0x10, 0x40, 0x08, 0x08,
  0x60, 0x02, 0x0C, 0x20, 0x01, 0x8C, 0x30, 0x00, 0x3C, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x1E, 0x00, 0x04, 0x31, 0x80,
  0x04, 0x10, 0x60, 0x02, 0x10, 0x10, 0x02, 0x08, 0x08, 0x03, 0x04, 0x02,
  0x01, 0x02, 0x01, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x40,
  0x20, 0x40, 0x20, 0x20, 0x00, 0x10, 0x10, 0x00, 0x04, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xC3, 0x00, 0x18, 0x10, 0x01,
  0x00, 0x80, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x30, 0x10, 0x01, 0x03, 0x00, 0x10, 0x20, 0x01, 0x84, 0x00, 0x09, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x19, 0x00, 0x03, 0x08,
  0x00, 0x20, 0xC0, 0x24, 0x04, 0x06, 0xC0, 0x20, 0x68, 0x01, 0x04, 0x80,
  0x18, 0x48, 0x00, 0x84, 0x80, 0x04, 0xC8, 0x00, 0x28, 0x80, 0x03, 0x8C,
  0x00, 0x30, 0x40, 0x06, 0x86, 0x00, 0xCC, 0x38, 0x38, 0x60, 0xFE, 0x02,
  0xFF, 0x80, 0x01, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60,
  0x20, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x06,
  0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x20, 0x60, 0x40, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x07, 0x82,
  0x0E, 0x71, 0x1C, 0x07, 0xF0, 0x00, 0x40, 0x00, 0x50, 0x00, 0x44, 0x00,
  0x63, 0x00, 0x20, 0xC0, 0x20, 0x20, 0x30, 0x08, 0x10, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x24, 0x92, 0x5A, 0x80, 0xFF, 0xFC, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x0C, 0x30, 0x10, 0x08,
  0x20, 0x0C, 0x60, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x60, 0x04, 0x20, 0x0C, 0x10, 0x08, 0x0C, 0x30, 0x07, 0xE0, 0x01, 0x83,
  0x46, 0x3C, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x07, 0xC0,
  0x0C, 0x18, 0x0C, 0x02, 0x0C, 0x00, 0x84, 0x00, 0x44, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0x0E, 0x06, 0x01,
  0x86, 0x00, 0x42, 0x00, 0x13, 0x00, 0x09, 0x00, 0x04, 0x80, 0x03, 0x40,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x60, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x2C, 0x00, 0x23, 0x00, 0x10, 0xC0, 0x10, 0x38, 0x30,
  0x07, 0xE0, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x06, 0x20, 0x00, 0x84, 0x00,
  0x30, 0x80, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x08, 0x08, 0x03,
  0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x10, 0x10,
  0x02, 0x04, 0x00, 0x41, 0x80, 0x08, 0x3F, 0xFF, 0xF8, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x3F, 0xFE, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x47, 0xC0, 0x58, 0x30, 0x60, 0x08,
  0x40, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x02,
  0x40, 0x06, 0x60, 0x04, 0x30, 0x08, 0x1C, 0x30, 0x07, 0xE0, 0x00, 0x78,
  0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x83, 0xE0, 0x8C, 0x38,
  0x90, 0x0C, 0xA0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0x40, 0x02, 0x60, 0x02, 0x20, 0x04, 0x10, 0x0C, 0x0C, 0x18,
  0x03, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x03, 0xF0,
  0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x44,
  0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x26, 0x00, 0x18, 0x80,
  0x04, 0x30, 0x03, 0x06, 0x01, 0x80, 0xE1, 0xC0, 0x0F, 0xC0, 0x0C, 0x0C,
  0x04, 0x00, 0x82, 0x00, 0x11, 0x00, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x28,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x09, 0x00,
  0x06, 0x20, 0x01, 0x0C, 0x00, 0x80, 0xC0, 0xC0, 0x0F, 0xC0, 0x03, 0xE0,
  0x06, 0x0C, 0x06, 0x03, 0x06, 0x00, 0xC2, 0x00, 0x33, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x03, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x90, 0x01,
  0x4C, 0x01, 0xA3, 0x01, 0x90, 0xC1, 0x98, 0x1F, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x6C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x49, 0x2D, 0x68, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x0F, 0xC0, 0xC3, 0x08, 0x04, 0x80, 0x34, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x0F, 0x80, 0x22, 0x00, 0xE3, 0x00,
  0xD8, 0x06, 0x06, 0x01, 0x40, 0x10, 0x08, 0x05, 0x00, 0x80, 0x20, 0x14,
  0x02, 0x00, 0x80, 0x70, 0x10, 0x02, 0x01, 0x80, 0x40, 0x18, 0x06, 0x01,
  0x00, 0x60, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x20, 0x04, 0x01, 0x80, 0x80,
  0x10, 0x06, 0x02, 0x00, 0x40, 0x18, 0x08, 0x01, 0x00, 0x60, 0x20, 0x04,
  0x01, 0x80, 0x80, 0x10, 0x0E, 0x02, 0x00, 0xC0, 0x28, 0x0C, 0x03, 0x00,
  0xA0, 0x10, 0x14, 0x04, 0xC0, 0x40, 0xC8, 0x31, 0x00, 0x86, 0x31, 0x84,
  0x01, 0xE0, 0x7C, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0xC0,
  0x00, 0x21, 0x00, 0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x10, 0x20, 0x00,
  0x40, 0x80, 0x02, 0x03, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x01, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x10,
  0x08, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x06, 0x04, 0x00, 0x08, 0x30,
  0x00, 0x20, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00,
  0x19, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0xFF, 0xE0, 0x40,
  0x1C, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x68, 0x00,
  0x24, 0x00, 0x22, 0x00, 0x61, 0xFF, 0xE0, 0x80, 0x0C, 0x40, 0x01, 0x20,
  0x00, 0x50, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x14, 0x00,
  0x12, 0x00, 0x31, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x60, 0x70, 0x18, 0x01,
  0x81, 0x00, 0x0C, 0x20, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00,
  0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00,
  0x22, 0x00, 0x04, 0x10, 0x00, 0xC0, 0x80, 0x18, 0x06, 0x07, 0x00, 0x1F,
  0xC0, 0xFF, 0xE0, 0x10, 0x07, 0x02, 0x00, 0x18, 0x40, 0x01, 0x88, 0x00,
  0x19, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x1A, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00, 0x31, 0x00, 0x0C,
  0x20, 0x0E, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0xFF, 0xFC, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFC, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xC0, 0xC0, 0x60, 0x06, 0x18, 0x00, 0x46, 0x00, 0x04, 0x80, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x00, 0x90, 0x00, 0x13, 0x00, 0x06, 0x30, 0x01, 0x83, 0x81, 0xC0, 0x0F,
  0xE0, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x30,
  0x08, 0x18, 0x30, 0x07, 0xE0, 0x80, 0x00, 0xD0, 0x00, 0x12, 0x00, 0x04,
  0x40, 0x01, 0x08, 0x00, 0x61, 0x00, 0x18, 0x20, 0x06, 0x04, 0x00, 0x80,
  0x80, 0x20, 0x10, 0x08, 0x02, 0x03, 0x00, 0x40, 0xC0, 0x08, 0x30, 0x01,
  0x04, 0x00, 0x21, 0x00, 0x04, 0x50, 0x00, 0x91, 0x00, 0x14, 0x30, 0x03,
  0x02, 0x00, 0x60, 0x20, 0x08, 0x06, 0x01, 0x00, 0x60, 0x20, 0x04, 0x04,
  0x00, 0x40, 0x80, 0x0C, 0x10, 0x00, 0xC2, 0x00, 0x08, 0x40, 0x00, 0x88,
  0x00, 0x19, 0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x07, 0xA0, 0x00,
  0x02, 0xE4, 0x00, 0x00, 0xB9, 0x00, 0x00, 0x6E, 0x40, 0x00, 0x13, 0x88,
  0x00, 0x04, 0xE2, 0x00, 0x03, 0x38, 0xC0, 0x00, 0x8E, 0x10, 0x00, 0x23,
  0x84, 0x00, 0x10, 0xE0, 0x80, 0x04, 0x38, 0x20, 0x03, 0x0E, 0x08, 0x00,
  0x83, 0x81, 0x00, 0x20, 0xE0, 0x40, 0x18, 0x38, 0x18, 0x04, 0x0E, 0x02,
  0x01, 0x03, 0x80, 0x80, 0x80, 0xE0, 0x30, 0x20, 0x38, 0x04, 0x08, 0x0E,
  0x01, 0x04, 0x03, 0x80, 0x21, 0x00, 0xE0, 0x08, 0xC0, 0x38, 0x02, 0x20,
  0x0E, 0x00, 0x48, 0x03, 0x80, 0x16, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x0E, 0x00, 0x20, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1A, 0x00, 0x01, 0x90, 0x00, 0x19, 0x80, 0x01, 0x88, 0x00, 0x18, 0xC0,
  0x01, 0x84, 0x00, 0x18, 0x20, 0x01, 0x82, 0x00, 0x18, 0x10, 0x01, 0x81,
  0x80, 0x18, 0x08, 0x01, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x80, 0x20, 0x18,
  0x03, 0x01, 0x80, 0x10, 0x18, 0x01, 0x81, 0x80, 0x08, 0x18, 0x00, 0xC1,
  0x80, 0x04, 0x18, 0x00, 0x21, 0x80, 0x03, 0x18, 0x00, 0x11, 0x80, 0x01,
  0x98, 0x00, 0x09, 0x80, 0x00, 0x58, 0x00, 0x05, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x01, 0xFC, 0x00, 0x60, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x20,
  0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0x40, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x22, 0x00, 0x06, 0x30,
  0x00, 0xC1, 0x80, 0x18, 0x06, 0x07, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x40,
  0x0E, 0x20, 0x01, 0x90, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x04, 0x80, 0x1C, 0x7F, 0xF8, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x70, 0x18, 0x01,
  0x83, 0x00, 0x0C, 0x20, 0x00, 0x46, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00,
  0x22, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x06, 0x07, 0x00, 0x1F,
  0xA0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x02, 0xFF, 0xF0, 0x10, 0x03, 0x82, 0x00, 0x18, 0x40,
  0x00, 0x88, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x06, 0x80,
  0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00,
  0x03, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x0C, 0x1F, 0xFE, 0x02, 0x00,
  0x40, 0x40, 0x08, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00,
  0x30, 0x80, 0x02, 0x10, 0x00, 0x62, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00,
  0x09, 0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x03, 0xF8, 0x01, 0xC0,
  0xE0, 0x60, 0x06, 0x18, 0x00, 0x62, 0x00, 0x04, 0x80, 0x00, 0xD0, 0x00,
  0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00,
  0xB0, 0x00, 0x32, 0x00, 0x0C, 0x30, 0x03, 0x03, 0x81, 0xC0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x05, 0x00, 0x02, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0xC0, 0xE0, 0x0F, 0xE0,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x06, 0x60,
  0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x40, 0x01, 0x81, 0x80, 0x04, 0x02, 0x00, 0x10, 0x08, 0x00, 0xC0,
  0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x08,
  0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0xC0, 0x01, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x60, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00,
  0x0C, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x40, 0x02, 0xC0, 0x02,
  0x40, 0x02, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04, 0x60, 0x04, 0x40, 0x04,
  0x60, 0x04, 0x60, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x30, 0x08, 0x30, 0x08, 0x10, 0x08, 0x10, 0x08,
  0x10, 0x10, 0x10, 0x18, 0x10, 0x10, 0x10, 0x10, 0x18, 0x10, 0x18, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x30, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x0C, 0x20, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x60,
  0x04, 0x40, 0x04, 0x60, 0x04, 0x40, 0x06, 0x40, 0x06, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x02, 0x40, 0x02, 0x80, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x19, 0x00, 0x00, 0x8C, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x80,
  0x04, 0x04, 0x00, 0x60, 0x10, 0x02, 0x00, 0xC0, 0x20, 0x02, 0x01, 0x00,
  0x18, 0x10, 0x00, 0x41, 0x80, 0x01, 0x08, 0x00, 0x0C, 0x80, 0x00, 0x24,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x02, 0xC0, 0x00,
  0x32, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40, 0x00, 0x81, 0x00, 0x08, 0x0C,
  0x00, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x60, 0x04, 0x02, 0x00, 0x10, 0x20,
  0x00, 0xC3, 0x00, 0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00, 0x01,
  0xC0, 0x00, 0x09, 0x00, 0x00, 0x66, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x30,
  0x00, 0x20, 0x40, 0x01, 0x81, 0x80, 0x04, 0x02, 0x00, 0x30, 0x0C, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x60, 0x10, 0x00, 0x80, 0xC0, 0x03, 0x02, 0x00,
  0x04, 0x18, 0x00, 0x18, 0x40, 0x00, 0x23, 0x00, 0x00, 0xC8, 0x00, 0x01,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0x06, 0x00, 0x60, 0x05, 0x00, 0xD0,
  0x09, 0x00, 0x88, 0x18, 0x81, 0x08, 0x10, 0x43, 0x04, 0x20, 0x42, 0x02,
  0x60, 0x24, 0x02, 0x40, 0x18, 0x01, 0xFF, 0xFF, 0x41, 0x83, 0x04, 0x18,
  0x30, 0x07, 0xE0, 0x1C, 0x18, 0x30, 0x04, 0x20, 0x06, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x07,
  0xFE, 0x1C, 0x02, 0x30, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x06, 0x40, 0x0E, 0x60, 0x1A, 0x30, 0x73, 0x0F,
  0xC3, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x1F, 0x04, 0xC1, 0x8A,
  0x01, 0x98, 0x01, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xB0, 0x03, 0x70,
  0x0C, 0x98, 0x31, 0x1F, 0x80, 0x07, 0xE0, 0x1C, 0x18, 0x30, 0x04, 0x20,
  0x02, 0x60, 0x02, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x02, 0x20, 0x02, 0x30,
  0x04, 0x0C, 0x18, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x3F, 0x08, 0xC1, 0x92, 0x00, 0xA8, 0x00, 0xD0, 0x01, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x28,
  0x00, 0x50, 0x01, 0x90, 0x05, 0x18, 0x32, 0x1F, 0x84, 0x03, 0xF0, 0x0C,
  0x18, 0x10, 0x04, 0x20, 0x02, 0x60, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x18, 0x02, 0x0E, 0x0C, 0x03, 0xF0, 0x03, 0xE0, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x03, 0xFF,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x0F, 0xC2, 0x30, 0x64,
  0x80, 0x2A, 0x00, 0x34, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x64,
  0x01, 0x46, 0x0C, 0x87, 0xE1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x68, 0x00, 0x88, 0x03, 0x0C, 0x1C, 0x07, 0xE0, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x7E, 0x23, 0x0C, 0x90, 0x1A, 0x80, 0x2C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xC8, 0x00,
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x07, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x04, 0x18, 0xF0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0xA0, 0x04,
  0x80, 0x22, 0x01, 0x88, 0x0C, 0x20, 0x60, 0x83, 0x02, 0x18, 0x08, 0x40,
  0x22, 0x00, 0x98, 0x02, 0xA0, 0x0C, 0x40, 0x21, 0x80, 0x83, 0x02, 0x04,
  0x08, 0x08, 0x20, 0x30, 0x80, 0x42, 0x00, 0x88, 0x03, 0x20, 0x04, 0x80,
  0x0A, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0xE0, 0x1F, 0x86,
  0x60, 0xC1, 0x87, 0x36, 0x03, 0x10, 0x09, 0xA0, 0x09, 0x00, 0x2E, 0x00,
  0x70, 0x01, 0x70, 0x01, 0x80, 0x0B, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x40,
  0x01, 0xC0, 0x02, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x70, 0x00, 0x80, 0x03,
  0x80, 0x04, 0x00, 0x1C, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x00, 0x07, 0x00,
  0x08, 0x00, 0x38, 0x00, 0x40, 0x01, 0xC0, 0x02, 0x00, 0x0E, 0x00, 0x10,
  0x00, 0x70, 0x00, 0x80, 0x03, 0x80, 0x04, 0x00, 0x1C, 0x00, 0x20, 0x00,
  0xE0, 0x01, 0x00, 0x07, 0x00, 0x08, 0x00, 0x38, 0x00, 0x40, 0x01, 0x87,
  0xE2, 0x30, 0xC9, 0x01, 0xA8, 0x02, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x07, 0xE0, 0x1C, 0x38, 0x30, 0x0C, 0x60,
  0x04, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x60, 0x04, 0x30,
  0x0C, 0x1C, 0x38, 0x07, 0xE0, 0x87, 0xC1, 0x30, 0x62, 0x80, 0x66, 0x00,
  0x68, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x2C, 0x00, 0xDC, 0x03, 0x2E, 0x0C,
  0x47, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x0F, 0xC2, 0x30, 0x64, 0x80,
  0x2A, 0x00, 0x34, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x64, 0x01,
  0x46, 0x0C, 0x87, 0xE1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x87, 0xCC, 0x2C,
  0x14, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x0F, 0xE0, 0x30, 0x70, 0x80, 0x32, 0x00, 0x24, 0x00, 0x68, 0x00, 0x50,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0A,
  0x00, 0x14, 0x00, 0x64, 0x01, 0x86, 0x0E, 0x03, 0xF0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00, 0xF0, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x36, 0x00, 0xE6, 0x01, 0x46, 0x0C, 0x87, 0xE1, 0xC0, 0x00, 0xA0, 0x00,
  0x90, 0x00, 0x4C, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0xC0, 0x08, 0x20,
  0x08, 0x10, 0x04, 0x0C, 0x02, 0x02, 0x03, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x20, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x88,
  0x00, 0x2C, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x01, 0x00, 0x80,
  0x08, 0x00, 0xF0, 0x03, 0x00, 0x24, 0x00, 0xC0, 0x09, 0x00, 0x50, 0x06,
  0x40, 0x16, 0x01, 0x98, 0x04, 0x80, 0x46, 0x03, 0x20, 0x10, 0x80, 0x88,
  0x0C, 0x20, 0x23, 0x03, 0x0C, 0x08, 0x40, 0x83, 0x06, 0x10, 0x20, 0x41,
  0x04, 0x18, 0x10, 0x41, 0x86, 0x06, 0x10, 0x21, 0x01, 0x88, 0x08, 0x40,
  0x22, 0x02, 0x30, 0x08, 0x80, 0x4C, 0x02, 0x60, 0x12, 0x00, 0xD0, 0x04,
  0x80, 0x14, 0x01, 0xA0, 0x05, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0xC0, 0x60, 0x01, 0x10, 0x01, 0x0C, 0x01, 0x82,
  0x00, 0x81, 0x80, 0xC0, 0x40, 0x40, 0x10, 0x40, 0x0C, 0x60, 0x02, 0x20,
  0x00, 0xB0, 0x00, 0x50, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x08,
  0x80, 0x04, 0x60, 0x04, 0x10, 0x06, 0x0C, 0x02, 0x02, 0x02, 0x00, 0x81,
  0x00, 0x61, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x02, 0xC0, 0x00, 0xA0, 0x00,
  0xD0, 0x00, 0x4C, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0xC0, 0x08, 0x20,
  0x0C, 0x10, 0x04, 0x0C, 0x02, 0x02, 0x03, 0x01, 0x01, 0x00, 0xC0, 0x80,
  0x20, 0xC0, 0x10, 0x40, 0x0C, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x48,
  0x00, 0x2C, 0x00, 0x14, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x01,
  0xC0, 0x30, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x40, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x01, 0x80, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x10, 0x04, 0x00, 0x1F, 0x00, 0x19, 0x8C, 0x00, 0xD8, 0x10, 0x04,
  0x80, 0x40, 0x24, 0x01, 0x03, 0x60, 0x06, 0x33, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Thin45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 32, 8, 3, -32 },
  { 9, 6, 9, 12, 3, -34 },
  { 16, 21, 32, 22, 1, -32 },
  { 100, 16, 40, 22, 3, -36 },
  { 180, 25, 32, 29, 2, -32 },
  { 280, 20, 32, 24, 3, -32 },
  { 360, 1, 9, 8, 3, -34 },
  { 362, 8, 46, 12, 3, -36 },
  { 408, 8, 46, 13, 1, -36 },
  { 454, 17, 17, 19, 1, -32 },
  { 491, 18, 23, 22, 2, -26 },
  { 543, 3, 9, 8, 2, -3 },
  { 547, 8, 1, 12, 2, -15 },
  { 548, 3, 2, 10, 3, -2 },
  { 549, 13, 35, 15, 1, -32 },
  { 606, 16, 32, 22, 3, -32 },
  { 670, 9, 32, 22, 4, -32 },
  { 706, 17, 32, 22, 3, -32 },
  { 774, 17, 32, 22, 2, -32 },
  { 842, 19, 32, 22, 2, -32 },
  { 918, 16, 32, 22, 4, -32 },
  { 982, 16, 32, 22, 3, -32 },
  { 1046, 17, 32, 22, 2, -32 },
  { 1114, 18, 32, 22, 2, -32 },
  { 1186, 17, 32, 22, 2, -32 },
  { 1254, 2, 23, 8, 3, -23 },
  { 1260, 3, 29, 8, 2, -23 },
  { 1271, 16, 17, 20, 2, -23 },
  { 1305, 16, 10, 22, 3, -20 },
  { 1325, 15, 18, 21, 3, -24 },
  { 1359, 13, 32, 18, 2, -32 },
  { 1411, 30, 41, 36, 3, -31 },
  { 1565, 22, 32, 24, 1, -32 },
  { 1653, 17, 32, 24, 4, -32 },
  { 1721, 20, 32, 26, 3, -32 },
  { 1801, 19, 32, 26, 4, -32 },
  { 1877, 17, 32, 23, 4, -32 },
  { 1945, 17, 32, 23, 4, -32 },
  { 2013, 19, 32, 27, 4, -32 },
  { 2089, 20, 32, 28, 4, -32 },
  { 2169, 1, 32, 11, 5, -32 },
  { 2173, 16, 32, 22, 2, -32 },
  { 2237, 19, 32, 25, 4, -32 },
  { 2313, 15, 32, 21, 4, -32 },
  { 2373, 26, 32, 34, 4, -32 },
  { 2477, 20, 32, 28, 4, -32 },
  { 2557, 20, 32, 26, 3, -32 },
  { 2637, 17, 32, 24, 4, -32 },
  { 2705, 20, 38, 26, 3, -32 },
  { 2800, 19, 32, 26, 4, -32 },
  { 2876, 19, 32, 23, 2, -32 },
  { 2952, 21, 32, 24, 1, -32 },
  { 3036, 18, 32, 26, 4, -32 },
  { 3108, 22, 32, 24, 1, -32 },
  { 3196, 32, 32, 35, 2, -32 },
  { 3324, 21, 32, 24, 1, -32 },
  { 3408, 22, 32, 24, 1, -32 },
  { 3496, 19, 32, 24, 2, -32 },
  { 3572, 5, 44, 9, 4, -37 },
  { 3600, 13, 35, 15, 1, -32 },
  { 3657, 6, 44, 9, 0, -37 },
  { 3690, 12, 16, 17, 2, -32 },
  { 3714, 16, 1, 17, 0, 0 },
  { 3716, 6, 6, 12, 3, -34 },
  { 3721, 16, 24, 21, 2, -24 },
  { 3769, 15, 34, 22, 4, -34 },
  { 3833, 16, 24, 20, 2, -24 },
  { 3881, 15, 34, 22, 3, -34 },
  { 3945, 16, 24, 20, 2, -24 },
  { 3993, 11, 34, 13, 2, -34 },
  { 4040, 15, 33, 22, 3, -24 },
  { 4102, 14, 34, 22, 4, -34 },
  { 4162, 3, 32, 9, 3, -32 },
  { 4174, 8, 41, 9, -2, -32 },
  { 4215, 14, 34, 19, 4, -34 },
  { 4275, 1, 34, 9, 4, -34 },
  { 4280, 29, 24, 35, 3, -24 },
  { 4367, 14, 24, 22, 4, -24 },
  { 4409, 16, 24, 22, 3, -24 },
  { 4457, 15, 33, 22, 4, -24 },
  { 4519, 15, 33, 22, 3, -24 },
  { 4581, 9, 24, 14, 4, -24 },
  { 4608, 15, 24, 20, 2, -24 },
  { 4653, 10, 30, 13, 1, -30 },
  { 4691, 15, 24, 22, 3, -24 },
  { 4736, 17, 24, 19, 1, -24 },
  { 4787, 26, 24, 30, 2, -24 },
  { 4865, 17, 24, 19, 1, -24 },
  { 4916, 17, 33, 19, 1, -24 },
  { 4987, 16, 24, 19, 2, -24 },
  { 5035, 11, 45, 13, 2, -35 },
  { 5097, 1, 38, 9, 4, -32 },
  { 5102, 11, 45, 13, 0, -35 },
  { 5164, 21, 7, 27, 3, -17 },
};

const GFXfont RobotoCondensed_Thin45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_THIN45PT7B_H_
