#ifndef _ROBOTOCONDENSED_THIN60PT7B_H_
#define _ROBOTOCONDENSED_THIN60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin60pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x90, 0x00, 0x00, 0x00, 0x1F, 0xA0, 0x41, 0x41, 0x41, 0x41, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30,
  0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x60, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x08, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40, 0x10,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x18, 0x02,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x60, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x60, 0x00, 0x10, 0x04, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60,
  0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xC0, 0xE0, 0x1C,
  0x00, 0xC0, 0x60, 0x01, 0x83, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x01, 0xC1, 0x80, 0x0E, 0x03, 0xC0,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x00, 0x30,
  0x03, 0x01, 0x80, 0x18, 0x01, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x06,
  0x00, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x00,
  0xC0, 0x60, 0x06, 0x00, 0x60, 0x60, 0x01, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x10, 0x30, 0x00, 0x60, 0x18, 0x18, 0x00, 0x18, 0x08, 0x18, 0x00, 0x06,
  0x1C, 0x08, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x81, 0xC3,
  0x00, 0x00, 0xC0, 0x80, 0xC0, 0x00, 0x40, 0xC0, 0x30, 0x00, 0x60, 0x40,
  0x18, 0x00, 0x60, 0x60, 0x04, 0x00, 0x30, 0x30, 0x03, 0x00, 0x30, 0x18,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x04, 0x02, 0x00, 0x10, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x03,
  0x00, 0x10, 0x00, 0x60, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x01, 0x80, 0x18, 0x40, 0x10, 0x03, 0x18, 0x03,
  0x00, 0x62, 0x00, 0x30, 0x0C, 0xC0, 0x03, 0x01, 0x90, 0x00, 0x20, 0x22,
  0x00, 0x06, 0x04, 0xC0, 0x00, 0x61, 0x98, 0x00, 0x06, 0x33, 0x00, 0x00,
  0xCC, 0x20, 0x00, 0x0D, 0x84, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xD8, 0x38, 0x00, 0x31, 0x83, 0x80, 0x0C,
  0x18, 0x3C, 0x0F, 0x03, 0x01, 0xFF, 0x80, 0x30, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x18, 0x0E, 0xF8, 0x30, 0xF0, 0x3C,
  0x67, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x63, 0x00, 0x00, 0xC3, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x06, 0x02, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x33, 0x33, 0x33, 0x33, 0x66, 0xC8, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x01, 0xC1, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x32, 0x00, 0x00,
  0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x26, 0x00, 0x03, 0x30,
  0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C,
  0x01, 0xC1, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x0F,
  0x03, 0x90, 0xE1, 0x78, 0x1E, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x31, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x1E, 0x07, 0x00, 0x70, 0x03, 0x01, 0x80, 0x03, 0x06,
  0x00, 0x02, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x04, 0x60, 0x00, 0x08, 0xC0,
  0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x24, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x98, 0x00,
  0x02, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x1E, 0x07,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x06, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF,
  0xF8, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x21, 0xFC, 0x03, 0x3F, 0xF8, 0x1E, 0x00, 0xE0,
  0xE0, 0x01, 0x86, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x26, 0x00, 0x03, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0xC0, 0x78, 0x1C,
  0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x3F, 0x80, 0xC3, 0xFF, 0x83, 0x38, 0x07, 0x09, 0x80, 0x06, 0x2C, 0x00,
  0x08, 0xA0, 0x00, 0x33, 0x80, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x02,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x24, 0x00, 0x01, 0x90, 0x00, 0x06, 0x60, 0x00, 0x10,
  0xC0, 0x00, 0xC3, 0x00, 0x02, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x1C,
  0x0E, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0x0F,
  0x00, 0x60, 0x07, 0x01, 0x80, 0x03, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x10, 0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x13,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x08, 0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x60,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0x80,
  0xE0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x98, 0x00, 0x03, 0x18, 0x00, 0x04, 0x38,
  0x00, 0x18, 0x38, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x38, 0x03, 0x80,
  0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC3, 0x00, 0x01, 0x08, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x24, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x0D,
  0x00, 0x00, 0x36, 0x00, 0x01, 0xC8, 0x00, 0x05, 0x30, 0x00, 0x34, 0x60,
  0x01, 0x91, 0xC0, 0x0C, 0x43, 0x80, 0x63, 0x03, 0xFF, 0x0C, 0x07, 0xF0,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x5F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x05, 0xF8, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x8C, 0x63, 0x19,
  0x8C, 0xC6, 0x20, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xC0,
  0xC0, 0xC0, 0x18, 0x20, 0x03, 0x18, 0x00, 0x44, 0x00, 0x1B, 0x00, 0x02,
  0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x01, 0xF8, 0x00, 0x61, 0x80, 0x03, 0xFE, 0x00, 0x10,
  0xC0, 0x03, 0x01, 0x80, 0x0C, 0x60, 0x03, 0x00, 0x60, 0x06, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x30, 0x01, 0x00, 0x18, 0x00, 0x98, 0x01, 0x80, 0x0C,
  0x00, 0x48, 0x00, 0x80, 0x06, 0x00, 0x2C, 0x00, 0xC0, 0x03, 0x00, 0x16,
  0x00, 0x60, 0x01, 0x80, 0x0B, 0x00, 0x20, 0x00, 0xC0, 0x05, 0x80, 0x10,
  0x00, 0x40, 0x03, 0x80, 0x18, 0x00, 0x20, 0x01, 0xC0, 0x0C, 0x00, 0x10,
  0x00, 0xA0, 0x06, 0x00, 0x08, 0x00, 0x50, 0x02, 0x00, 0x04, 0x00, 0x28,
  0x01, 0x00, 0x02, 0x00, 0x14, 0x00, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x40,
  0x01, 0x80, 0x0D, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x80, 0x10, 0x00, 0x60,
  0x03, 0x40, 0x08, 0x00, 0x30, 0x01, 0x30, 0x06, 0x00, 0x38, 0x01, 0x98,
  0x03, 0x00, 0x1C, 0x00, 0x8C, 0x00, 0x80, 0x1A, 0x00, 0xC2, 0x00, 0x60,
  0x19, 0x00, 0x61, 0x00, 0x30, 0x18, 0xC0, 0x60, 0xC0, 0x0C, 0x18, 0x30,
  0xE0, 0x60, 0x03, 0xF8, 0x0F, 0xE0, 0x18, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30, 0x03, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x03, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x06, 0xFF, 0xF8, 0x01, 0x00, 0xFE, 0x02, 0x00, 0x07, 0x04, 0x00, 0x07,
  0x08, 0x00, 0x06, 0x10, 0x00, 0x06, 0x20, 0x00, 0x04, 0x40, 0x00, 0x0C,
  0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0x90, 0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00, 0x08, 0x80,
  0x00, 0x31, 0x00, 0x00, 0x42, 0x00, 0x01, 0x84, 0x00, 0x0E, 0x08, 0x03,
  0xF0, 0x1F, 0xFF, 0xE0, 0x20, 0x00, 0x70, 0x40, 0x00, 0x30, 0x80, 0x00,
  0x31, 0x00, 0x00, 0x32, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0,
  0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00, 0x18, 0x80, 0x00, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3C, 0x07, 0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x3C, 0x07,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x80,
  0x3F, 0x00, 0x80, 0x01, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x01, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x07,
  0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x07, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x86, 0x00, 0x18, 0x18, 0x01, 0x80, 0x70, 0x38, 0x01, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x06, 0x40, 0x00, 0x07, 0x20, 0x00,
  0x03, 0x10, 0x00, 0x03, 0x08, 0x00, 0x03, 0x04, 0x00, 0x03, 0x02, 0x00,
  0x03, 0x01, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80, 0x20,
  0x01, 0x80, 0x10, 0x01, 0x80, 0x08, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x02,
  0x00, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x40, 0xC0, 0x00,
  0x20, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x08, 0x78, 0x00, 0x04, 0x64, 0x00,
  0x02, 0x63, 0x00, 0x01, 0x60, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x20, 0x06, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x60, 0x04, 0x00,
  0x30, 0x02, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x40,
  0x00, 0x60, 0x20, 0x00, 0x18, 0x10, 0x00, 0x06, 0x08, 0x00, 0x03, 0x04,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06,
  0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x5A,
  0x00, 0x00, 0x00, 0x6D, 0x80, 0x00, 0x00, 0x36, 0xC0, 0x00, 0x00, 0x13,
  0x20, 0x00, 0x00, 0x19, 0x98, 0x00, 0x00, 0x0C, 0xC4, 0x00, 0x00, 0x04,
  0x62, 0x00, 0x00, 0x06, 0x31, 0x80, 0x00, 0x02, 0x18, 0x40, 0x00, 0x01,
  0x0C, 0x30, 0x00, 0x01, 0x86, 0x18, 0x00, 0x00, 0x83, 0x04, 0x00, 0x00,
  0xC1, 0x83, 0x00, 0x00, 0x60, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x40, 0x00,
  0x30, 0x30, 0x30, 0x00, 0x18, 0x18, 0x08, 0x00, 0x08, 0x0C, 0x04, 0x00,
  0x0C, 0x06, 0x03, 0x00, 0x04, 0x03, 0x00, 0x80, 0x02, 0x01, 0x80, 0x60,
  0x03, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x60, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x00, 0x10, 0x10, 0x01, 0x80, 0x08, 0x18, 0x00, 0xC0,
  0x06, 0x08, 0x00, 0x60, 0x01, 0x04, 0x00, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0x00, 0x62, 0x00, 0x0C, 0x00, 0x13, 0x00, 0x06, 0x00, 0x0D, 0x80, 0x03,
  0x00, 0x02, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0x20, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x38, 0x08, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00,
  0xE0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x40, 0x03, 0x80, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80,
  0x06, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x10, 0x0E, 0x00, 0x06, 0x03,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x04, 0x38, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x2E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x0F,
  0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0x01,
  0x00, 0x3F, 0x02, 0x00, 0x03, 0x84, 0x00, 0x03, 0x88, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x20, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x0E,
  0x20, 0x00, 0x38, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x0F,
  0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x00,
  0x60, 0x07, 0xE0, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x02, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x01, 0xC1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x40, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x08, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x38, 0x00,
  0x70, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x64, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x03, 0x80, 0x07, 0x00, 0x78, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x20, 0x02, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x00,
  0x06, 0x00, 0x10, 0x00, 0x10, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x00,
  0x00, 0x26, 0x00, 0x00, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0x88, 0x00, 0x06, 0x40, 0x00, 0x31, 0x00, 0x00, 0x88, 0x00, 0x04, 0x30,
  0x00, 0x11, 0x80, 0x00, 0x86, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC2, 0x00, 0x06, 0x08, 0x00, 0x10, 0x40, 0x00, 0xC1, 0x80, 0x02, 0x0C,
  0x00, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0x40, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00, 0x40, 0x60, 0x02, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0x40, 0x30, 0x03, 0x00, 0x80, 0x18, 0x06, 0x00,
  0x40, 0x10, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x80, 0x60, 0x04, 0x03, 0x00, 0x30, 0x08, 0x00, 0x80,
  0x60, 0x02, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x00,
  0x0C, 0x0C, 0x00, 0x20, 0x20, 0x01, 0x81, 0x00, 0x04, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0xC1, 0x80, 0x02, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80,
  0x01, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x21, 0x80, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x11, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x08, 0x80,
  0x00, 0x64, 0x00, 0x01, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80,
  0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x18,
  0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x10, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xFF, 0xFC, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0xC0,
  0x02, 0x40, 0x06, 0x60, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x30,
  0x18, 0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x08, 0x30, 0x0C, 0x20, 0x04,
  0x60, 0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0x80, 0xE0, 0x30, 0x01, 0x83, 0x00,
  0x06, 0x10, 0x00, 0x11, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x12,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xE0, 0x00, 0x8C,
  0x00, 0x04, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00,
  0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80,
  0x00, 0xEC, 0x00, 0x0D, 0x30, 0x00, 0xC9, 0xC0, 0x0C, 0x47, 0x01, 0xC3,
  0x0F, 0xF8, 0x18, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x20, 0x08, 0x3F, 0xE0, 0x8E, 0x07, 0x09, 0x80, 0x18, 0xB0, 0x00,
  0xCE, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x2C, 0x00, 0x06, 0xE0, 0x00,
  0x6B, 0x00, 0x0C, 0x98, 0x01, 0x88, 0xE0, 0x70, 0x87, 0xFE, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xC0, 0xE0, 0x38, 0x01, 0x81,
  0x00, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x40, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x23, 0x00, 0x03, 0x08, 0x00, 0x30, 0x70, 0x03, 0x01, 0xE0,
  0x70, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x7F, 0xC1, 0x0E, 0x07, 0x11, 0x80, 0x19, 0x30,
  0x00, 0xD6, 0x00, 0x05, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x16, 0x00, 0x03, 0x60,
  0x00, 0x73, 0x00, 0x05, 0x18, 0x01, 0x90, 0xE0, 0x71, 0x07, 0xFE, 0x10,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0xE0, 0x18, 0x01,
  0x81, 0x80, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x40,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x30, 0x01, 0xC0,
  0xE0, 0x38, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x3F, 0xFE,
  0x7F, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC1, 0x0E, 0x07, 0x11, 0x80, 0x19, 0x30, 0x00, 0xD6,
  0x00, 0x05, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x73,
  0x00, 0x0D, 0x18, 0x01, 0x90, 0xE0, 0x71, 0x07, 0xFE, 0x10, 0x04, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x1C, 0x01, 0x80, 0x7F,
  0xF0, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x03,
  0xFC, 0x21, 0xC0, 0xC4, 0x60, 0x0C, 0x98, 0x00, 0xD2, 0x00, 0x0A, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x7D, 0x80, 0x00, 0x00, 0x36, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x03, 0x37, 0x8F, 0x80, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x18, 0x80, 0x06, 0x10, 0x01, 0xC2,
  0x00, 0x30, 0x40, 0x0C, 0x08, 0x03, 0x01, 0x00, 0xC0, 0x20, 0x30, 0x04,
  0x0C, 0x00, 0x83, 0x00, 0x10, 0xC0, 0x02, 0x30, 0x00, 0x47, 0x00, 0x09,
  0x30, 0x01, 0x42, 0x00, 0x30, 0x60, 0x04, 0x06, 0x00, 0x80, 0x40, 0x10,
  0x0C, 0x02, 0x00, 0xC0, 0x40, 0x0C, 0x08, 0x01, 0x81, 0x00, 0x18, 0x20,
  0x01, 0x84, 0x00, 0x10, 0x80, 0x03, 0x10, 0x00, 0x32, 0x00, 0x03, 0x40,
  0x00, 0x68, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x03, 0x07, 0xFC, 0x01,
  0xFF, 0x0C, 0x38, 0x38, 0x0E, 0x06, 0x31, 0x80, 0x30, 0xE0, 0x0C, 0xCC,
  0x00, 0x63, 0x00, 0x1B, 0x60, 0x00, 0x98, 0x00, 0x2D, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00,
  0x07, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00,
  0x04, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00,
  0x1C, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00,
  0x70, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00,
  0x40, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x01,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x10, 0x3F, 0xC2, 0x1C, 0x0C,
  0x46, 0x00, 0xC9, 0x80, 0x0D, 0x20, 0x00, 0xAC, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x04, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0x80, 0x00, 0x21, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x03, 0x80, 0x38, 0x03, 0xC0, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x08, 0x3F, 0xE0, 0x8E, 0x07, 0x09, 0x80, 0x18,
  0xB0, 0x00, 0xCE, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06,
  0xE0, 0x00, 0x6B, 0x00, 0x0C, 0x98, 0x01, 0x88, 0xE0, 0x70, 0x87, 0xFE,
  0x08, 0x02, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC1,
  0x0E, 0x07, 0x11, 0x80, 0x19, 0x30, 0x00, 0xD6, 0x00, 0x07, 0x60, 0x00,
  0x34, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x40, 0x00, 0x16, 0x00, 0x03, 0x60, 0x00, 0x73, 0x00, 0x05, 0x18, 0x01,
  0x90, 0xE0, 0x71, 0x07, 0xFE, 0x10, 0x04, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x08, 0x3F, 0x8E, 0x09, 0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1C, 0x07, 0x83, 0x00, 0x1C,
  0x20, 0x00, 0xC6, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00,
  0x24, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC1, 0xE0, 0x38, 0x07, 0xFE,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x3F, 0x00, 0x20, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xB0, 0x00, 0x56, 0x00, 0x1A,
  0x60, 0x06, 0x47, 0x03, 0x88, 0x7F, 0xC1, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x90, 0x00, 0x06, 0x60, 0x00, 0x11,
  0x80, 0x00, 0xC2, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x20, 0x40,
  0x01, 0x81, 0x80, 0x04, 0x06, 0x00, 0x10, 0x08, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x06, 0x01, 0x80, 0x18, 0x04, 0x00,
  0x20, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x04, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x80,
  0x00, 0x16, 0x00, 0x00, 0x58, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x2C, 0x00,
  0x1C, 0x00, 0x1B, 0x00, 0x05, 0x00, 0x06, 0x40, 0x01, 0x60, 0x01, 0x98,
  0x00, 0xD8, 0x00, 0x46, 0x00, 0x32, 0x00, 0x31, 0x80, 0x0C, 0x80, 0x0C,
  0x20, 0x02, 0x30, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x61, 0x00,
  0x60, 0xC0, 0x10, 0x60, 0x18, 0x10, 0x04, 0x18, 0x06, 0x06, 0x03, 0x06,
  0x01, 0x81, 0x80, 0xC0, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x30, 0x08, 0x18,
  0x0C, 0x0C, 0x03, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x40, 0x80, 0x30,
  0x40, 0x18, 0x60, 0x04, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x86, 0x00,
  0x62, 0x00, 0x21, 0x00, 0x18, 0x80, 0x0C, 0xC0, 0x02, 0x60, 0x03, 0x30,
  0x00, 0x98, 0x00, 0x4C, 0x00, 0x34, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x06,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x19, 0x80, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x60, 0x02, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x60,
  0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x63,
  0x00, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x30, 0x01, 0x80, 0x40,
  0x0C, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x18, 0x30,
  0x00, 0x21, 0x80, 0x00, 0xC6, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x90, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x42, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40,
  0x01, 0x81, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x06, 0x01, 0x80, 0x08, 0x04, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x21, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x04, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x05, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x01, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF0, 0x01, 0xC0,
  0x1C, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x20, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x30, 0x38, 0x00,
  0x22, 0x00, 0xC0, 0x02, 0x60, 0x06, 0x00, 0x24, 0x00, 0x60, 0x06, 0x40,
  0x03, 0x00, 0x44, 0x00, 0x1C, 0x0C, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_Thin60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 44, 11, 4, -43 },
  { 18, 8, 12, 15, 4, -45 },
  { 30, 28, 43, 29, 2, -43 },
  { 181, 22, 55, 29, 4, -49 },
  { 333, 33, 45, 39, 3, -44 },
  { 519, 27, 45, 32, 3, -44 },
  { 671, 2, 12, 10, 4, -45 },
  { 674, 11, 62, 16, 4, -48 },
  { 760, 11, 62, 17, 1, -48 },
  { 846, 23, 23, 25, 1, -43 },
  { 913, 25, 31, 30, 2, -35 },
  { 1010, 4, 12, 11, 3, -5 },
  { 1016, 12, 1, 16, 2, -20 },
  { 1018, 4, 4, 13, 4, -3 },
  { 1020, 16, 47, 21, 2, -43 },
  { 1114, 21, 45, 29, 4, -44 },
  { 1233, 12, 43, 29, 5, -43 },
  { 1298, 23, 44, 29, 3, -44 },
  { 1425, 23, 45, 29, 3, -44 },
  { 1555, 25, 43, 29, 3, -43 },
  { 1690, 21, 44, 29, 5, -43 },
  { 1806, 22, 44, 29, 4, -43 },
  { 1927, 24, 43, 29, 2, -43 },
  { 2056, 23, 45, 29, 3, -44 },
  { 2186, 22, 44, 29, 3, -44 },
  { 2307, 3, 32, 10, 4, -31 },
  { 2319, 5, 38, 10, 2, -31 },
  { 2343, 20, 23, 27, 3, -31 },
  { 2401, 21, 15, 29, 4, -27 },
  { 2441, 21, 23, 27, 3, -31 },
  { 2502, 18, 45, 23, 3, -44 },
  { 2604, 41, 54, 48, 4, -41 },
  { 2881, 29, 43, 32, 1, -43 },
  { 3037, 23, 43, 32, 6, -43 },
  { 3161, 26, 45, 34, 4, -44 },
  { 3308, 24, 43, 34, 6, -43 },
  { 3437, 22, 43, 30, 6, -43 },
  { 3556, 22, 43, 30, 6, -43 },
  { 3675, 26, 45, 36, 5, -44 },
  { 3822, 25, 43, 37, 6, -43 },
  { 3957, 2, 43, 14, 6, -43 },
  { 3968, 21, 44, 29, 3, -43 },
  { 4084, 25, 43, 33, 6, -43 },
  { 4219, 20, 43, 27, 6, -43 },
  { 4327, 33, 43, 45, 6, -43 },
  { 4505, 26, 43, 37, 6, -43 },
  { 4645, 27, 45, 35, 4, -44 },
  { 4797, 23, 43, 32, 6, -43 },
  { 4921, 27, 52, 35, 4, -44 },
  { 5097, 25, 43, 34, 5, -43 },
  { 5232, 26, 45, 31, 3, -44 },
  { 5379, 28, 43, 32, 2, -43 },
  { 5530, 25, 44, 35, 5, -43 },
  { 5668, 29, 43, 32, 1, -43 },
  { 5824, 43, 43, 47, 2, -43 },
  { 6056, 28, 43, 32, 2, -43 },
  { 6207, 29, 43, 32, 1, -43 },
  { 6363, 26, 43, 32, 3, -43 },
  { 6503, 7, 58, 12, 5, -49 },
  { 6554, 17, 47, 20, 2, -43 },
  { 6654, 8, 58, 12, 0, -49 },
  { 6712, 16, 21, 22, 3, -43 },
  { 6754, 21, 2, 22, 1, 0 },
  { 6760, 8, 8, 16, 4, -45 },
  { 6768, 21, 34, 28, 3, -33 },
  { 6858, 20, 46, 29, 5, -45 },
  { 6973, 21, 34, 27, 3, -33 },
  { 7063, 20, 46, 29, 4, -45 },
  { 7178, 21, 34, 27, 3, -33 },
  { 7268, 15, 46, 17, 2, -46 },
  { 7355, 20, 45, 29, 4, -33 },
  { 7468, 19, 45, 29, 5, -45 },
  { 7575, 3, 43, 12, 4, -43 },
  { 7592, 10, 55, 12, -3, -43 },
  { 7661, 19, 45, 25, 5, -45 },
  { 7768, 2, 45, 12, 5, -45 },
  { 7780, 38, 33, 47, 4, -33 },
  { 7937, 19, 33, 29, 5, -33 },
  { 8016, 23, 34, 29, 3, -33 },
  { 8114, 20, 45, 29, 5, -33 },
  { 8227, 20, 45, 29, 4, -33 },
  { 8340, 12, 33, 18, 5, -33 },
  { 8390, 20, 34, 27, 3, -33 },
  { 8475, 14, 41, 17, 1, -40 },
  { 8547, 19, 33, 29, 5, -32 },
  { 8626, 22, 32, 25, 2, -32 },
  { 8714, 34, 32, 40, 3, -32 },
  { 8850, 22, 32, 25, 2, -32 },
  { 8938, 22, 44, 25, 2, -32 },
  { 9059, 21, 32, 25, 3, -32 },
  { 9143, 15, 60, 18, 2, -47 },
  { 9256, 2, 51, 12, 5, -43 },
  { 9269, 14, 60, 18, 1, -47 },
  { 9374, 28, 10, 36, 4, -23 },
};

const GFXfont RobotoCondensed_Thin60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_THIN60PT7B_H_
